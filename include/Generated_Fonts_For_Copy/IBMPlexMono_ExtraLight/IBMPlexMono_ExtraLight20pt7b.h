#ifndef _IBMPLEXMONO_EXTRALIGHT20PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x80, 0xF0, 0x99, 0x99, 0x90, 0x04, 0x80, 0x48, 0x08,
  0x80, 0x88, 0x78, 0xF0, 0x90, 0x09, 0x01, 0x10, 0x11, 0x0F, 0x1E, 0x11,
  0x01, 0x20, 0x12, 0x02, 0x20, 0x08, 0x02, 0x03, 0xE1, 0xA6, 0x48, 0xA2,
  0x08, 0x81, 0x20, 0x3C, 0x02, 0xE0, 0x88, 0x21, 0x08, 0x62, 0x26, 0x88,
  0x7C, 0x08, 0x02, 0x00, 0x70, 0x62, 0x18, 0x8A, 0x24, 0x89, 0x22, 0x87,
  0x00, 0x0E, 0x34, 0x4A, 0x14, 0x85, 0x21, 0x84, 0x60, 0xE0, 0x3C, 0x08,
  0x84, 0x21, 0x00, 0x40, 0x08, 0x03, 0x0D, 0x64, 0x8D, 0x21, 0x48, 0x32,
  0x04, 0xC2, 0x9F, 0x10, 0xF8, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x44, 0x21, 0x84, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x08,
  0x02, 0x00, 0x82, 0x21, 0x7B, 0x83, 0x00, 0xC0, 0x48, 0x21, 0x10, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x69, 0x28, 0xFC, 0xF0, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x31, 0x80, 0x60,
  0x24, 0x09, 0x02, 0x21, 0x07, 0x80, 0x18, 0x1C, 0x1A, 0x11, 0x08, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x3C, 0x21,
  0x20, 0x50, 0x20, 0x10, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x07, 0xFC, 0x1E, 0x10, 0x90, 0x20, 0x10, 0x10, 0x08, 0x78, 0x06, 0x00,
  0x80, 0x40, 0x30, 0x14, 0x11, 0xF0, 0x03, 0x01, 0x40, 0x50, 0x24, 0x11,
  0x04, 0x42, 0x11, 0x04, 0x41, 0x20, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40,
  0x7F, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x01, 0x01, 0x01, 0x01, 0x81,
  0xC2, 0x3C, 0x0C, 0x10, 0x20, 0x40, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x3C, 0xFF, 0xC0, 0x60, 0x30, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x1E, 0x18, 0x64, 0x09,
  0x02, 0x40, 0x88, 0x41, 0xE1, 0x86, 0x80, 0xA0, 0x18, 0x06, 0x02, 0x61,
  0x8F, 0xC0, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x02,
  0x02, 0x04, 0x08, 0x30, 0xF0, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x0D, 0x25,
  0x00, 0x01, 0x02, 0x0C, 0x30, 0x40, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x02,
  0x0C, 0x10, 0x60, 0x80, 0x3C, 0x43, 0x81, 0x81, 0x01, 0x02, 0x1C, 0x10,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x10, 0x3C, 0x42, 0x81, 0x81, 0x8F, 0x91,
  0xA1, 0xA1, 0xA1, 0xA1, 0x91, 0x9F, 0x80, 0x80, 0x40, 0x3E, 0x0C, 0x03,
  0x01, 0x40, 0x48, 0x12, 0x08, 0x82, 0x10, 0x84, 0x21, 0x1F, 0xE4, 0x09,
  0x02, 0x80, 0x60, 0x10, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x83,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x3C, 0x42, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x42, 0x3C, 0xFC, 0x41, 0x20, 0x50,
  0x28, 0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x28, 0x27, 0xE0,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x10, 0x90, 0x28, 0x08, 0x04, 0x02, 0x01,
  0x0F, 0x80, 0xC0, 0x50, 0x28, 0x12, 0x18, 0xF4, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x7E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x14, 0x67,
  0x80, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x84, 0x82, 0xC1, 0x90, 0x88, 0x42,
  0x20, 0x90, 0x48, 0x14, 0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x81, 0x83, 0xC3, 0xC3, 0xA5,
  0xA5, 0x99, 0x99, 0x91, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC1,
  0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x81, 0x1E,
  0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24,
  0x09, 0x02, 0x21, 0x07, 0x80, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x0A,
  0x05, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1E, 0x08, 0x44,
  0x09, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x09, 0x02,
  0x21, 0x07, 0x80, 0x80, 0x20, 0x07, 0x80, 0xFE, 0x40, 0xA0, 0x50, 0x18,
  0x0C, 0x0A, 0x05, 0xFC, 0x88, 0x42, 0x21, 0x10, 0x48, 0x14, 0x0C, 0x3E,
  0x18, 0x64, 0x0A, 0x00, 0x80, 0x10, 0x03, 0xC0, 0x0C, 0x00, 0x80, 0x10,
  0x06, 0x02, 0x60, 0x87, 0xC0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x88, 0x42, 0x10, 0x84, 0x22,
  0x04, 0x81, 0x20, 0x50, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x8C, 0x63, 0x28, 0xCA, 0x52, 0x92, 0x94, 0xA6, 0x29, 0x8A, 0x61, 0x98,
  0x60, 0x80, 0x50, 0x22, 0x10, 0x84, 0x12, 0x03, 0x00, 0xC0, 0x30, 0x12,
  0x04, 0x82, 0x11, 0x02, 0x40, 0xA0, 0x10, 0xC0, 0x34, 0x02, 0x20, 0x41,
  0x08, 0x10, 0x80, 0x90, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xF0, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x0F, 0xC0, 0x0C, 0x05, 0x01, 0x20, 0x88, 0x21, 0x10, 0x24,
  0x0A, 0x03, 0xFF, 0xC0, 0x88, 0x80, 0x3E, 0x30, 0x40, 0x10, 0x04, 0x3F,
  0x10, 0x48, 0x12, 0x04, 0x43, 0x0F, 0x30, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x05, 0xE3, 0x0D, 0x02, 0x81, 0x40, 0xA0, 0x70, 0x28, 0x16, 0x1A, 0xF0,
  0x3C, 0x42, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x42, 0x3C, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0xF5, 0x86, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x14,
  0x0B, 0x0C, 0x7A, 0x3C, 0x42, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x81, 0x42,
  0x3C, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x07, 0xFC, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x83, 0xFC, 0x03, 0x9F, 0x10, 0x90, 0x28, 0x14,
  0x09, 0x08, 0x78, 0x40, 0x40, 0x1F, 0xD0, 0x18, 0x0C, 0x0D, 0xF8, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x83, 0x84, 0x88, 0x90, 0xF0, 0x88, 0x88, 0x84, 0x82,
  0x81, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0xBB, 0xB3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18,
  0x86, 0x21, 0x88, 0x62, 0x10, 0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0xBC, 0x61, 0xA0, 0x50, 0x28, 0x14, 0x0E, 0x05, 0x02, 0xC3, 0x5E,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x1E, 0xB0, 0xD0, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x81, 0x61, 0x8F, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF7, 0x8C, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x7F, 0x80, 0x3C, 0xC3, 0x80,
  0x80, 0x78, 0x07, 0x01, 0x01, 0xC1, 0x3E, 0x10, 0x08, 0x04, 0x02, 0x0F,
  0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7C, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x81, 0x81, 0x82,
  0x42, 0x42, 0x24, 0x24, 0x28, 0x18, 0x18, 0x8C, 0x63, 0x18, 0xC6, 0x51,
  0x92, 0xA4, 0xA6, 0x29, 0x8A, 0x61, 0x98, 0x60, 0x81, 0x42, 0x44, 0x24,
  0x18, 0x18, 0x24, 0x44, 0x42, 0x81, 0x81, 0x81, 0x82, 0x42, 0x42, 0x24,
  0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x20, 0xE0, 0xFF, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xFF, 0x1F, 0x10, 0x10, 0x10, 0x10, 0x08,
  0x04, 0x08, 0xF0, 0x18, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x1F,
  0xFF, 0xFF, 0xC0, 0xF8, 0x08, 0x08, 0x08, 0x10, 0x20, 0x20, 0x10, 0x0F,
  0x18, 0x20, 0x20, 0x10, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x30, 0x52, 0x18,
  0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 4, 5, 12, 4, -15 },
  { 8, 12, 14, 12, 0, -14 },
  { 29, 10, 18, 12, 1, -16 },
  { 52, 10, 14, 12, 1, -14 },
  { 70, 10, 14, 12, 1, -14 },
  { 88, 1, 5, 12, 6, -15 },
  { 89, 4, 18, 12, 5, -15 },
  { 98, 4, 18, 12, 3, -15 },
  { 107, 10, 10, 12, 1, -11 },
  { 120, 10, 11, 12, 1, -12 },
  { 134, 3, 5, 12, 4, -2 },
  { 136, 6, 1, 12, 3, -7 },
  { 137, 2, 2, 12, 5, -2 },
  { 138, 8, 18, 12, 2, -15 },
  { 156, 10, 14, 12, 1, -14 },
  { 174, 9, 14, 12, 2, -14 },
  { 190, 9, 14, 12, 2, -14 },
  { 206, 9, 14, 12, 1, -14 },
  { 222, 10, 14, 12, 1, -14 },
  { 240, 8, 14, 12, 2, -14 },
  { 254, 8, 14, 12, 2, -14 },
  { 268, 9, 14, 12, 1, -14 },
  { 284, 10, 14, 12, 1, -14 },
  { 302, 8, 14, 12, 2, -14 },
  { 316, 2, 11, 12, 5, -11 },
  { 319, 3, 14, 12, 4, -11 },
  { 325, 8, 11, 12, 2, -12 },
  { 336, 10, 4, 12, 1, -8 },
  { 341, 8, 11, 12, 2, -12 },
  { 352, 8, 14, 12, 2, -14 },
  { 366, 8, 16, 12, 2, -14 },
  { 382, 10, 14, 12, 1, -14 },
  { 400, 8, 14, 12, 2, -14 },
  { 414, 8, 14, 12, 2, -14 },
  { 428, 9, 14, 12, 2, -14 },
  { 444, 8, 14, 12, 2, -14 },
  { 458, 8, 14, 12, 2, -14 },
  { 472, 9, 14, 12, 1, -14 },
  { 488, 8, 14, 12, 2, -14 },
  { 502, 8, 14, 12, 2, -14 },
  { 516, 7, 14, 12, 2, -14 },
  { 529, 9, 14, 12, 2, -14 },
  { 545, 8, 14, 12, 3, -14 },
  { 559, 8, 14, 12, 2, -14 },
  { 573, 8, 14, 12, 2, -14 },
  { 587, 10, 14, 12, 1, -14 },
  { 605, 9, 14, 12, 2, -14 },
  { 621, 10, 17, 12, 1, -14 },
  { 643, 9, 14, 12, 2, -14 },
  { 659, 10, 14, 12, 1, -14 },
  { 677, 10, 14, 12, 1, -14 },
  { 695, 8, 14, 12, 2, -14 },
  { 709, 10, 14, 12, 1, -14 },
  { 727, 10, 14, 12, 1, -14 },
  { 745, 10, 14, 12, 1, -14 },
  { 763, 12, 14, 12, 0, -14 },
  { 784, 10, 14, 12, 1, -14 },
  { 802, 5, 18, 12, 5, -15 },
  { 814, 8, 18, 12, 2, -15 },
  { 832, 5, 18, 12, 2, -15 },
  { 844, 10, 8, 12, 1, -14 },
  { 854, 10, 1, 12, 1, 2 },
  { 856, 3, 3, 12, 4, -15 },
  { 858, 10, 10, 12, 1, -10 },
  { 871, 9, 15, 12, 2, -15 },
  { 888, 8, 10, 12, 2, -10 },
  { 898, 9, 15, 12, 1, -15 },
  { 915, 8, 10, 12, 2, -10 },
  { 925, 9, 15, 12, 2, -15 },
  { 942, 9, 15, 12, 2, -11 },
  { 959, 8, 15, 12, 2, -15 },
  { 974, 9, 14, 12, 2, -14 },
  { 990, 7, 18, 12, 2, -14 },
  { 1006, 8, 15, 12, 3, -15 },
  { 1021, 8, 15, 12, 2, -15 },
  { 1036, 10, 10, 12, 1, -10 },
  { 1049, 8, 10, 12, 2, -10 },
  { 1059, 8, 10, 12, 2, -10 },
  { 1069, 9, 14, 12, 2, -10 },
  { 1085, 9, 14, 12, 1, -10 },
  { 1101, 9, 10, 12, 2, -10 },
  { 1113, 8, 10, 12, 2, -10 },
  { 1123, 9, 14, 12, 1, -14 },
  { 1139, 8, 10, 12, 2, -10 },
  { 1149, 8, 10, 12, 2, -10 },
  { 1159, 10, 10, 12, 1, -10 },
  { 1172, 8, 10, 12, 2, -10 },
  { 1182, 8, 14, 12, 2, -10 },
  { 1196, 8, 10, 12, 2, -10 },
  { 1206, 8, 18, 12, 2, -15 },
  { 1224, 1, 18, 12, 6, -15 },
  { 1227, 8, 18, 12, 2, -15 },
  { 1245, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_EXTRALIGHT20PT7B_H_
