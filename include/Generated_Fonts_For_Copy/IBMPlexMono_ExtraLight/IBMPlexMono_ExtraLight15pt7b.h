#ifndef _IBMPLEXMONO_EXTRALIGHT15PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x8E, 0x71, 0x41, 0x23,
  0x9C, 0x48, 0x28, 0x14, 0x00, 0x10, 0x21, 0xE4, 0xA9, 0x32, 0x1C, 0x0E,
  0x13, 0x26, 0x4B, 0xE1, 0x02, 0x00, 0x71, 0xC4, 0xA2, 0x91, 0x47, 0x40,
  0xB8, 0xA4, 0x91, 0x49, 0x43, 0x80, 0x71, 0x12, 0x02, 0x06, 0x36, 0xA7,
  0x46, 0x8C, 0xE4, 0xF0, 0x32, 0x48, 0x88, 0x88, 0x88, 0x42, 0x30, 0x84,
  0x22, 0x22, 0x12, 0x22, 0x24, 0x80, 0x10, 0x20, 0x47, 0xF3, 0x05, 0x11,
  0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x68, 0xF8, 0x80, 0x08,
  0x44, 0x21, 0x10, 0x88, 0x44, 0x21, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18,
  0x32, 0x60, 0xC1, 0x44, 0x70, 0x10, 0x61, 0x44, 0x81, 0x02, 0x04, 0x08,
  0x11, 0xFC, 0x38, 0x8A, 0x10, 0x20, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x39,
  0x18, 0x41, 0x38, 0x30, 0x41, 0x85, 0xE0, 0x0C, 0x28, 0x51, 0x24, 0x50,
  0xA1, 0x7F, 0x04, 0x08, 0x7D, 0x02, 0x05, 0xC4, 0x40, 0x40, 0x81, 0xC4,
  0x70, 0x18, 0x41, 0x02, 0x0B, 0xD8, 0xA0, 0xC1, 0x44, 0x70, 0xFF, 0x0A,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0x7D, 0x0A, 0x0C, 0x27, 0x98,
  0xA0, 0xC1, 0x82, 0xF8, 0x38, 0x8A, 0x0C, 0x14, 0x67, 0x41, 0x02, 0x08,
  0x60, 0x81, 0x40, 0x01, 0xA0, 0x02, 0x18, 0xC2, 0x0C, 0x04, 0x06, 0x03,
  0xFE, 0x03, 0xF8, 0x80, 0xC0, 0x60, 0x20, 0x61, 0x0C, 0x60, 0x3C, 0x8A,
  0x18, 0x20, 0x86, 0x08, 0x00, 0x00, 0x20, 0x38, 0x8A, 0x14, 0xEA, 0x34,
  0x68, 0xD1, 0x9F, 0x01, 0x01, 0xE0, 0x10, 0x60, 0xA2, 0x44, 0x88, 0x9F,
  0x42, 0x83, 0x04, 0xFD, 0x0A, 0x14, 0x2F, 0x90, 0xA0, 0xC1, 0x83, 0xF8,
  0x38, 0x8A, 0x0C, 0x08, 0x10, 0x20, 0x41, 0x44, 0x70, 0xF2, 0x28, 0x61,
  0x86, 0x18, 0x61, 0x8B, 0xC0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83,
  0xF0, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x82, 0x00, 0x38, 0x8A, 0x0C,
  0x08, 0x11, 0xE0, 0xC1, 0x46, 0x74, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60,
  0xC1, 0x83, 0x04, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC,
  0x7C, 0x10, 0x41, 0x04, 0x10, 0x61, 0x44, 0xE0, 0x86, 0x29, 0x28, 0xE2,
  0x89, 0x22, 0x8A, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0,
  0x83, 0x8F, 0x2D, 0x5B, 0x32, 0x60, 0xC1, 0x83, 0x04, 0x83, 0x87, 0x0D,
  0x19, 0x32, 0x62, 0xC5, 0x87, 0x04, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x44, 0x70, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x00, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0x70, 0x40, 0x81, 0xC0, 0xFA,
  0x18, 0x61, 0x87, 0xEA, 0x24, 0x8A, 0x10, 0x79, 0x0A, 0x0C, 0x07, 0x01,
  0x80, 0xC1, 0x42, 0x78, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0xF8, 0x83, 0x06,
  0x12, 0x24, 0x49, 0x0A, 0x14, 0x30, 0x20, 0x83, 0x06, 0x0C, 0x9B, 0x35,
  0x6A, 0xE6, 0xCC, 0x88, 0x83, 0x09, 0x21, 0x41, 0x06, 0x0A, 0x22, 0x85,
  0x04, 0x81, 0xA0, 0x88, 0x84, 0x81, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0xFE, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x81, 0xFC, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0x84, 0x21, 0x04, 0x20, 0x84, 0x10, 0x84,
  0x10, 0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x30, 0x51, 0x22,
  0x28, 0x50, 0x40, 0xFE, 0xA4, 0x79, 0x08, 0x13, 0xE8, 0x50, 0xA1, 0x3F,
  0x82, 0x08, 0x3E, 0x8A, 0x18, 0x61, 0x86, 0x2F, 0x80, 0x72, 0x28, 0x20,
  0x82, 0x28, 0xDC, 0x04, 0x10, 0x5F, 0x46, 0x18, 0x61, 0x85, 0x17, 0xC0,
  0x38, 0x8A, 0x0F, 0xF8, 0x10, 0x11, 0x9E, 0x1E, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x08, 0x10, 0x23, 0xF8, 0x06, 0x79, 0x14, 0x28, 0x48, 0x9E, 0x40,
  0x7F, 0x06, 0x0B, 0xE0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x62, 0x30,
  0x00, 0x38, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0x04, 0x00, 0x3E, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x09, 0xE0, 0x82, 0x08, 0x21, 0x9A, 0x8A,
  0x34, 0x92, 0x28, 0x40, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x23, 0xF8, 0xEF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xF4, 0x63, 0x18,
  0xC6, 0x31, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x51, 0x1C, 0xFA, 0x28, 0x61,
  0x86, 0x18, 0xBE, 0x82, 0x08, 0x00, 0x7D, 0x18, 0x61, 0x86, 0x14, 0x5F,
  0x04, 0x10, 0x40, 0xEE, 0x60, 0x81, 0x02, 0x04, 0x08, 0x7F, 0x39, 0x8E,
  0x03, 0x80, 0xC0, 0x60, 0xBE, 0x20, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x7C, 0x8C, 0x63, 0x18, 0xC6, 0x6F, 0x83, 0x09, 0x12, 0x44, 0x85,
  0x0C, 0x08, 0x93, 0x66, 0xCD, 0x5A, 0xB9, 0xB3, 0x22, 0x86, 0x88, 0xA1,
  0x81, 0x05, 0x11, 0x43, 0x83, 0x09, 0x12, 0x44, 0x85, 0x0C, 0x08, 0x20,
  0x43, 0x80, 0x7C, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7F, 0x3A, 0x10, 0x42,
  0x0B, 0x86, 0x21, 0x10, 0x83, 0x80, 0xFF, 0xF8, 0xE1, 0x08, 0x44, 0x20,
  0xEC, 0x41, 0x08, 0x4E, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph IBMPlexMono_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 10, 9, 4, -10 },
  { 3, 3, 4, 9, 3, -11 },
  { 5, 9, 10, 9, 0, -10 },
  { 17, 7, 14, 9, 1, -12 },
  { 30, 9, 10, 9, 0, -10 },
  { 42, 7, 10, 9, 1, -10 },
  { 51, 1, 4, 9, 4, -11 },
  { 52, 4, 13, 9, 3, -11 },
  { 59, 4, 13, 9, 2, -11 },
  { 66, 7, 7, 9, 1, -8 },
  { 73, 7, 7, 9, 1, -8 },
  { 80, 2, 3, 9, 3, -1 },
  { 81, 5, 1, 9, 2, -5 },
  { 82, 1, 1, 9, 4, -1 },
  { 83, 5, 13, 9, 2, -11 },
  { 92, 7, 10, 9, 1, -10 },
  { 101, 7, 10, 9, 1, -10 },
  { 110, 7, 10, 9, 1, -10 },
  { 119, 6, 10, 9, 1, -10 },
  { 127, 7, 10, 9, 1, -10 },
  { 136, 7, 10, 9, 1, -10 },
  { 145, 7, 10, 9, 1, -10 },
  { 154, 7, 10, 9, 1, -10 },
  { 163, 7, 10, 9, 1, -10 },
  { 172, 7, 10, 9, 1, -10 },
  { 181, 1, 8, 9, 4, -8 },
  { 182, 2, 10, 9, 3, -8 },
  { 185, 7, 8, 9, 1, -9 },
  { 192, 7, 3, 9, 1, -6 },
  { 195, 7, 8, 9, 1, -9 },
  { 202, 7, 10, 9, 1, -10 },
  { 211, 7, 12, 9, 1, -10 },
  { 222, 7, 10, 9, 1, -10 },
  { 231, 7, 10, 9, 1, -10 },
  { 240, 7, 10, 9, 1, -10 },
  { 249, 6, 10, 9, 2, -10 },
  { 257, 6, 10, 9, 2, -10 },
  { 265, 6, 10, 9, 2, -10 },
  { 273, 7, 10, 9, 1, -10 },
  { 282, 7, 10, 9, 1, -10 },
  { 291, 7, 10, 9, 1, -10 },
  { 300, 6, 10, 9, 1, -10 },
  { 308, 6, 10, 9, 2, -10 },
  { 316, 6, 10, 9, 2, -10 },
  { 324, 7, 10, 9, 1, -10 },
  { 333, 7, 10, 9, 1, -10 },
  { 342, 7, 10, 9, 1, -10 },
  { 351, 6, 10, 9, 2, -10 },
  { 359, 7, 13, 9, 1, -10 },
  { 371, 6, 10, 9, 2, -10 },
  { 379, 7, 10, 9, 1, -10 },
  { 388, 7, 10, 9, 1, -10 },
  { 397, 7, 10, 9, 1, -10 },
  { 406, 7, 10, 9, 1, -10 },
  { 415, 7, 10, 9, 1, -10 },
  { 424, 7, 10, 9, 1, -10 },
  { 433, 9, 10, 9, 0, -10 },
  { 445, 7, 10, 9, 1, -10 },
  { 454, 4, 13, 9, 4, -11 },
  { 461, 5, 13, 9, 2, -11 },
  { 470, 4, 13, 9, 1, -11 },
  { 477, 7, 6, 9, 1, -10 },
  { 483, 7, 1, 9, 1, 1 },
  { 484, 2, 3, 9, 3, -13 },
  { 485, 7, 8, 9, 1, -8 },
  { 492, 6, 11, 9, 2, -11 },
  { 501, 6, 8, 9, 2, -8 },
  { 507, 6, 11, 9, 1, -11 },
  { 516, 7, 8, 9, 1, -8 },
  { 523, 7, 11, 9, 1, -11 },
  { 533, 7, 12, 9, 1, -9 },
  { 544, 5, 11, 9, 2, -11 },
  { 551, 6, 11, 9, 2, -11 },
  { 560, 6, 14, 9, 1, -11 },
  { 571, 6, 11, 9, 2, -11 },
  { 580, 7, 11, 9, 1, -11 },
  { 590, 7, 8, 9, 1, -8 },
  { 597, 5, 8, 9, 2, -8 },
  { 602, 7, 8, 9, 1, -8 },
  { 609, 6, 11, 9, 2, -8 },
  { 618, 6, 11, 9, 1, -8 },
  { 627, 7, 8, 9, 1, -8 },
  { 634, 7, 8, 9, 1, -8 },
  { 641, 7, 10, 9, 1, -10 },
  { 650, 5, 8, 9, 2, -8 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 8, 9, 1, -8 },
  { 669, 7, 8, 9, 1, -8 },
  { 676, 7, 11, 9, 1, -8 },
  { 686, 7, 8, 9, 1, -8 },
  { 693, 5, 13, 9, 2, -11 },
  { 702, 1, 13, 9, 4, -11 },
  { 704, 5, 13, 9, 2, -11 },
  { 713, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_EXTRALIGHT15PT7B_H_
