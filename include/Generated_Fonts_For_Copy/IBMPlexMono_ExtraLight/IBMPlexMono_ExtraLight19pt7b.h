#ifndef _IBMPLEXMONO_EXTRALIGHT19PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x02, 0xC0, 0xB6, 0xDA, 0x0C, 0x81, 0x10, 0x24, 0x04,
  0x87, 0x9E, 0x12, 0x04, 0x40, 0x88, 0xF1, 0xC2, 0x40, 0x48, 0x11, 0x02,
  0x20, 0x08, 0x04, 0x0F, 0x89, 0x28, 0x8C, 0x41, 0x20, 0xD0, 0x1E, 0x04,
  0xC2, 0x21, 0x18, 0x8A, 0x4C, 0xF8, 0x10, 0x08, 0x00, 0x38, 0x28, 0x8A,
  0x12, 0x42, 0x44, 0x50, 0x72, 0x00, 0x00, 0x9E, 0x12, 0x24, 0x84, 0x90,
  0xA1, 0x18, 0x3C, 0x3C, 0x21, 0x10, 0x88, 0x04, 0x01, 0x01, 0xC7, 0x12,
  0x85, 0x41, 0xA0, 0x90, 0xA7, 0x88, 0xF8, 0x19, 0x08, 0x84, 0x42, 0x10,
  0x84, 0x21, 0x04, 0x20, 0x84, 0x18, 0xC1, 0x08, 0x21, 0x04, 0x21, 0x08,
  0x42, 0x11, 0x08, 0x84, 0xC0, 0x08, 0x02, 0x00, 0x82, 0x22, 0x7F, 0x42,
  0x01, 0x40, 0x88, 0x61, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x56, 0x80, 0xF8, 0xB0, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x80, 0x1E,
  0x30, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x23, 0x01, 0x80, 0xC0, 0x50, 0x2C,
  0x21, 0xE0, 0x0C, 0x0A, 0x09, 0x08, 0x88, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x87, 0xF8, 0x3C, 0x42, 0x82, 0x82, 0x02, 0x02, 0x04,
  0x0C, 0x18, 0x20, 0x40, 0x80, 0xFF, 0x3E, 0x41, 0x81, 0x01, 0x02, 0x1C,
  0x03, 0x01, 0x01, 0x01, 0x81, 0x43, 0x3E, 0x02, 0x01, 0x80, 0xA0, 0x28,
  0x12, 0x08, 0x84, 0x21, 0x08, 0x82, 0x3F, 0xF0, 0x20, 0x08, 0x02, 0x00,
  0x7E, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x01, 0x01, 0x01, 0x82, 0x82,
  0x7C, 0x0C, 0x10, 0x20, 0x40, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0x3C, 0xFF, 0xC0, 0xA0, 0x50, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x00, 0x3E, 0x30, 0x90, 0x30, 0x14, 0x13, 0x08,
  0x78, 0xC6, 0x80, 0xC0, 0x60, 0x28, 0x33, 0xE0, 0x3C, 0xC2, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x7E, 0x02, 0x04, 0x04, 0x08, 0x30, 0xB0, 0x00, 0x2C,
  0x4C, 0x00, 0x00, 0x09, 0x29, 0x00, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x80,
  0x60, 0x18, 0x04, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x03, 0x04, 0x18, 0x60, 0x80, 0x3C, 0x42, 0x82, 0x83, 0x02,
  0x0C, 0x10, 0x10, 0x00, 0x00, 0x00, 0x10, 0x30, 0x3C, 0x42, 0x82, 0x82,
  0x9D, 0xA3, 0xA1, 0xA1, 0xA1, 0xA1, 0x9F, 0x80, 0x80, 0x40, 0x3E, 0x08,
  0x05, 0x01, 0x40, 0x50, 0x22, 0x08, 0x82, 0x21, 0x04, 0x7F, 0x10, 0x48,
  0x0A, 0x02, 0x80, 0xC0, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x82, 0xFC, 0x82,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x1E, 0x10, 0x90, 0x28, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x24, 0x21, 0xE0, 0xFC, 0x82, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x10, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x50, 0x24,
  0x31, 0xE8, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x7E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x06, 0x0C, 0x27, 0x80, 0x81, 0x41, 0x21, 0x11, 0x09, 0x04, 0x82, 0xC1,
  0x90, 0x84, 0x42, 0x20, 0x90, 0x28, 0x18, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x81, 0x83, 0xC5, 0xC5, 0xC5,
  0xA9, 0xA9, 0x91, 0x91, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC1, 0xA1,
  0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x1E, 0x30, 0x90,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x2C, 0x21, 0xE0,
  0xFE, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x50, 0x2C, 0x21, 0xE0, 0x40, 0x20, 0x1E, 0xFE, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFE, 0x88, 0x88, 0x84, 0x82, 0x81, 0x3E, 0x20, 0xA0, 0x30,
  0x04, 0x03, 0x00, 0x78, 0x03, 0x00, 0x80, 0x60, 0x28, 0x33, 0xE0, 0xFF,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xC2, 0x7C, 0x80, 0xC0, 0x50, 0x28, 0x24, 0x12, 0x08,
  0x88, 0x44, 0x22, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x8C, 0xA6, 0x53, 0x29, 0x94, 0xB1, 0x58, 0xCC, 0x64, 0x10, 0x80,
  0x90, 0x42, 0x10, 0x88, 0x14, 0x05, 0x00, 0x80, 0x50, 0x12, 0x08, 0x84,
  0x11, 0x02, 0x80, 0xC0, 0xC0, 0x28, 0x08, 0x82, 0x10, 0x41, 0x10, 0x14,
  0x02, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0xFF, 0x80,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x0F,
  0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8,
  0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x81, 0x01, 0x02, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF8, 0x08, 0x0A, 0x04, 0x84, 0x44, 0x12, 0x0A, 0x02, 0xFF, 0x80,
  0x94, 0x3C, 0x61, 0x00, 0x40, 0x23, 0xF2, 0x0A, 0x05, 0x02, 0x47, 0x1C,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC2, 0xBC, 0x3C, 0x42, 0x82, 0x80, 0x80, 0x80, 0x80, 0x81, 0x42,
  0x3C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x63, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x63, 0x3D, 0x3C, 0x42, 0x82, 0x81, 0xFF, 0x80, 0x80, 0x81, 0x42,
  0x3C, 0x1F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x03, 0x9E, 0x10, 0x90, 0x48, 0x24, 0x11, 0x08, 0x78,
  0xC0, 0x40, 0x1F, 0x90, 0x28, 0x14, 0x09, 0xF8, 0x81, 0x02, 0x04, 0x0B,
  0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x08, 0x00, 0x00,
  0x00, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x06,
  0x00, 0x00, 0x0F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x05, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x14, 0x12, 0x31, 0x20,
  0xB0, 0x64, 0x21, 0x10, 0x48, 0x14, 0x0C, 0xF0, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xB3, 0x66, 0x62,
  0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0xBD, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x42, 0x3C, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x63, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x63, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xF3, 0xC5, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xE0, 0x7C, 0x82, 0x81,
  0x80, 0x78, 0x06, 0x01, 0x01, 0x82, 0x7C, 0x10, 0x08, 0x04, 0x1F, 0xF1,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0xF4, 0x81, 0x82, 0x82, 0x44, 0x44,
  0x44, 0x28, 0x28, 0x28, 0x10, 0x88, 0x65, 0x29, 0x4A, 0x52, 0x94, 0xA4,
  0xAA, 0x29, 0x8C, 0x63, 0x18, 0x40, 0x83, 0x42, 0x44, 0x28, 0x10, 0x10,
  0x28, 0x44, 0x82, 0x83, 0x80, 0xA0, 0x90, 0x44, 0x22, 0x21, 0x10, 0x50,
  0x28, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x03, 0x80, 0xFE, 0x02, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x80, 0xFF, 0x1E, 0x20, 0x40, 0x81, 0x01, 0x02,
  0x04, 0xF0, 0x30, 0x20, 0x41, 0x02, 0x04, 0x08, 0x1E, 0xFF, 0xFF, 0x80,
  0xF0, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x1E, 0x60, 0x81, 0x01, 0x02,
  0x02, 0x04, 0xF0, 0x70, 0xA4, 0x61, 0x30, 0x60,
};

const GFXglyph IBMPlexMono_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 13, 11, 5, -13 },
  { 5, 3, 5, 11, 4, -14 },
  { 7, 11, 13, 11, 0, -13 },
  { 25, 9, 17, 11, 1, -15 },
  { 45, 11, 13, 11, 0, -13 },
  { 63, 9, 13, 11, 1, -13 },
  { 78, 1, 5, 11, 5, -14 },
  { 79, 5, 17, 11, 4, -14 },
  { 90, 5, 17, 11, 2, -14 },
  { 101, 10, 9, 11, 1, -10 },
  { 113, 9, 9, 11, 1, -10 },
  { 124, 2, 5, 11, 4, -2 },
  { 126, 5, 1, 11, 3, -6 },
  { 127, 2, 2, 11, 5, -2 },
  { 128, 7, 17, 11, 2, -14 },
  { 143, 9, 13, 11, 1, -13 },
  { 158, 9, 13, 11, 1, -13 },
  { 173, 8, 13, 11, 2, -13 },
  { 186, 8, 13, 11, 1, -13 },
  { 199, 10, 13, 11, 1, -13 },
  { 216, 8, 13, 11, 2, -13 },
  { 229, 8, 13, 11, 2, -13 },
  { 242, 9, 13, 11, 1, -13 },
  { 257, 9, 13, 11, 1, -13 },
  { 272, 8, 13, 11, 2, -13 },
  { 285, 2, 11, 11, 5, -11 },
  { 288, 3, 14, 11, 4, -11 },
  { 294, 8, 10, 11, 2, -11 },
  { 304, 9, 4, 11, 1, -8 },
  { 309, 8, 10, 11, 2, -11 },
  { 319, 8, 13, 11, 2, -13 },
  { 332, 8, 15, 11, 2, -13 },
  { 347, 10, 13, 11, 1, -13 },
  { 364, 8, 13, 11, 2, -13 },
  { 377, 9, 13, 11, 1, -13 },
  { 392, 8, 13, 11, 2, -13 },
  { 405, 8, 13, 11, 2, -13 },
  { 418, 8, 13, 11, 2, -13 },
  { 431, 9, 13, 11, 1, -13 },
  { 446, 8, 13, 11, 2, -13 },
  { 459, 8, 13, 11, 2, -13 },
  { 472, 7, 13, 11, 2, -13 },
  { 484, 9, 13, 11, 2, -13 },
  { 499, 7, 13, 11, 3, -13 },
  { 511, 8, 13, 11, 2, -13 },
  { 524, 8, 13, 11, 2, -13 },
  { 537, 9, 13, 11, 1, -13 },
  { 552, 8, 13, 11, 2, -13 },
  { 565, 9, 16, 11, 1, -13 },
  { 583, 8, 13, 11, 2, -13 },
  { 596, 9, 13, 11, 1, -13 },
  { 611, 10, 13, 11, 1, -13 },
  { 628, 8, 13, 11, 2, -13 },
  { 641, 9, 13, 11, 1, -13 },
  { 656, 9, 13, 11, 1, -13 },
  { 671, 10, 13, 11, 1, -13 },
  { 688, 11, 13, 11, 0, -13 },
  { 706, 9, 13, 11, 1, -13 },
  { 721, 5, 17, 11, 5, -14 },
  { 732, 7, 17, 11, 2, -14 },
  { 747, 5, 17, 11, 2, -14 },
  { 758, 9, 7, 11, 1, -13 },
  { 766, 9, 1, 11, 1, 2 },
  { 768, 2, 3, 11, 4, -15 },
  { 769, 9, 10, 11, 1, -10 },
  { 781, 8, 14, 11, 2, -14 },
  { 795, 8, 10, 11, 2, -10 },
  { 805, 8, 14, 11, 1, -14 },
  { 819, 8, 10, 11, 2, -10 },
  { 829, 8, 14, 11, 2, -14 },
  { 843, 9, 15, 11, 2, -11 },
  { 860, 7, 14, 11, 2, -14 },
  { 873, 8, 14, 11, 2, -14 },
  { 887, 7, 18, 11, 2, -14 },
  { 903, 9, 14, 11, 2, -14 },
  { 919, 8, 14, 11, 2, -14 },
  { 933, 9, 10, 11, 1, -10 },
  { 945, 7, 10, 11, 2, -10 },
  { 954, 8, 10, 11, 2, -10 },
  { 964, 8, 14, 11, 2, -10 },
  { 978, 8, 14, 11, 1, -10 },
  { 992, 10, 10, 11, 1, -10 },
  { 1005, 8, 10, 11, 2, -10 },
  { 1015, 9, 13, 11, 1, -13 },
  { 1030, 7, 10, 11, 2, -10 },
  { 1039, 8, 10, 11, 2, -10 },
  { 1049, 10, 10, 11, 1, -10 },
  { 1062, 8, 10, 11, 2, -10 },
  { 1072, 9, 14, 11, 1, -10 },
  { 1088, 8, 10, 11, 2, -10 },
  { 1098, 7, 17, 11, 2, -14 },
  { 1113, 1, 17, 11, 5, -14 },
  { 1116, 7, 17, 11, 2, -14 },
  { 1131, 9, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_EXTRALIGHT19PT7B_H_
