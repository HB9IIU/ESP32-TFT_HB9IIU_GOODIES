#ifndef _IBMPLEXMONO_EXTRALIGHT22PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0x2C, 0x99, 0x99, 0x99, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x48, 0x3C, 0x3C, 0x22, 0x01, 0x10, 0x08, 0x87, 0xC7,
  0x84, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x00, 0x04, 0x00, 0x80,
  0x7C, 0x12, 0x64, 0x42, 0x88, 0x11, 0x02, 0x20, 0x34, 0x01, 0xF0, 0x13,
  0x02, 0x10, 0x42, 0x08, 0x71, 0x11, 0x26, 0x1F, 0x00, 0x80, 0x10, 0x00,
  0x78, 0x38, 0x82, 0x84, 0x48, 0x44, 0x84, 0x88, 0x90, 0x79, 0x00, 0x00,
  0x11, 0xC2, 0x22, 0x24, 0x24, 0x41, 0x44, 0x28, 0x22, 0x81, 0xC0, 0x1E,
  0x04, 0x21, 0x04, 0x20, 0x04, 0x00, 0x40, 0x04, 0x01, 0xC3, 0x4C, 0x90,
  0x92, 0x0A, 0x40, 0xC8, 0x18, 0x84, 0x8F, 0x08, 0xFC, 0x08, 0x88, 0x84,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x84, 0x42, 0x11, 0x11, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x0E, 0x46, 0x3F, 0x01, 0x80, 0x50, 0x11, 0x04,
  0x10, 0x83, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x56, 0xA0, 0xFC, 0xB0, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x00, 0x1F, 0x04,
  0x11, 0x01, 0x20, 0x24, 0x05, 0x00, 0x61, 0x0C, 0x21, 0x80, 0x30, 0x05,
  0x01, 0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x0C, 0x05, 0x02, 0x43, 0x10,
  0x84, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x0F, 0xFC, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x0F, 0xFC, 0x1F, 0x08, 0x24,
  0x04, 0x01, 0x00, 0x80, 0x61, 0xE0, 0x06, 0x00, 0x40, 0x10, 0x04, 0x01,
  0xC0, 0x58, 0x61, 0xF0, 0x01, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x88, 0x11,
  0x04, 0x21, 0x04, 0x40, 0x88, 0x12, 0x02, 0x7F, 0xF0, 0x08, 0x01, 0x00,
  0x20, 0x7F, 0xA0, 0x10, 0x10, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x00, 0x80,
  0x40, 0x20, 0x18, 0x0A, 0x08, 0xF8, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x02, 0xF9, 0x82, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x08, 0xF8, 0xFF,
  0xC0, 0x60, 0x30, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24, 0x04, 0x80,
  0x88, 0x20, 0xF8, 0x31, 0xC8, 0x0A, 0x00, 0xC0, 0x14, 0x04, 0xC1, 0x87,
  0xC0, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x3E, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0xE0, 0xB0, 0x00, 0x0B, 0x4C, 0x00, 0x00,
  0x01, 0x25, 0x24, 0x00, 0x80, 0x81, 0x83, 0x02, 0x06, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x02, 0x06, 0x0C, 0x08, 0x18,
  0x10, 0x00, 0x3E, 0x30, 0xA0, 0x30, 0x10, 0x08, 0x08, 0x08, 0x18, 0x08,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x3E, 0x30, 0x90, 0x30, 0x18,
  0xEC, 0xCE, 0x43, 0x21, 0x90, 0xC8, 0x64, 0x32, 0x18, 0xFC, 0x01, 0x00,
  0xC0, 0x1F, 0x00, 0x04, 0x01, 0x40, 0x28, 0x05, 0x01, 0x10, 0x22, 0x04,
  0x41, 0x04, 0x20, 0x87, 0xF1, 0x01, 0x20, 0x24, 0x05, 0x00, 0x60, 0x08,
  0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x05, 0xFC, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0F, 0xFC, 0x1E, 0x18, 0x44, 0x0A, 0x03, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02, 0x40, 0xD8, 0x41, 0xE0,
  0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0A, 0x02, 0x80, 0xA0, 0x4F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x3E, 0x30, 0xB0, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x87, 0xC0, 0x60, 0x30, 0x1C, 0x1B, 0x0C, 0xFA, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x7F, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x42, 0x3C, 0x80,
  0x60, 0x28, 0x12, 0x08, 0x84, 0x22, 0x09, 0x82, 0xA0, 0xC4, 0x20, 0x88,
  0x22, 0x04, 0x80, 0xA0, 0x28, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0x80,
  0xE0, 0xF0, 0x78, 0x5A, 0x2D, 0x16, 0x53, 0x29, 0x88, 0xC4, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x80, 0xE0, 0x70, 0x34, 0x19, 0x0C, 0x86, 0x23,
  0x11, 0x84, 0xC2, 0x60, 0xB0, 0x58, 0x1C, 0x0E, 0x02, 0x1F, 0x04, 0x11,
  0x01, 0x20, 0x24, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0xFF, 0x20, 0x28, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x0A, 0x02, 0xFF, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24, 0x05, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x20, 0x04,
  0x00, 0xF8, 0xFF, 0x20, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0xFF, 0x21, 0x08, 0x42, 0x08, 0x81, 0x20, 0x28, 0x0C, 0x1F, 0x0C, 0x19,
  0x01, 0x20, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x1C, 0x04, 0x41, 0x87, 0xC0, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x08, 0xF8, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x24, 0x04, 0x41, 0x08, 0x21, 0x04, 0x11, 0x02, 0x20, 0x44, 0x05,
  0x00, 0xA0, 0x14, 0x01, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x43,
  0x18, 0x52, 0x92, 0x52, 0x4A, 0x4A, 0x29, 0x45, 0x28, 0xA5, 0x14, 0xC1,
  0x88, 0x30, 0x80, 0x28, 0x08, 0x82, 0x10, 0x41, 0x10, 0x14, 0x02, 0x80,
  0x20, 0x0A, 0x01, 0x20, 0x44, 0x10, 0x42, 0x04, 0x80, 0xA0, 0x08, 0x80,
  0x38, 0x02, 0x40, 0x42, 0x08, 0x20, 0x81, 0x10, 0x0A, 0x00, 0xA0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x3F, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x80, 0x20, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0xFC, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x04, 0x01,
  0x40, 0x28, 0x08, 0x82, 0x08, 0x41, 0x10, 0x16, 0x03, 0xFF, 0xE0, 0x88,
  0x90, 0x3C, 0x30, 0x80, 0x10, 0x04, 0x01, 0x1F, 0xC8, 0x12, 0x04, 0x81,
  0x21, 0xC7, 0x9C, 0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xE3, 0x09, 0x02,
  0x81, 0x40, 0x60, 0x30, 0x18, 0x14, 0x0B, 0x09, 0x78, 0x1E, 0x30, 0x90,
  0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0xB0, 0x87, 0x80, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x09, 0xE5, 0x0B, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x05, 0x0E, 0x79, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0F, 0xFE, 0x01,
  0x00, 0x80, 0x20, 0x4F, 0xC0, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x3F,
  0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x83,
  0xFE, 0x01, 0xCF, 0xC6, 0x11, 0x04, 0x40, 0x90, 0x26, 0x10, 0xF8, 0x40,
  0x10, 0x07, 0xF9, 0x01, 0x80, 0x60, 0x1C, 0x09, 0xFC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x03, 0x03, 0x00, 0x00, 0x00,
  0xFE, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0E, 0x09, 0x08,
  0x88, 0x48, 0x3A, 0x10, 0x88, 0x44, 0x12, 0x05, 0x01, 0xF8, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x21, 0xFF, 0xF3, 0xA5, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86,
  0x21, 0x88, 0x62, 0x18, 0x84, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0x8F, 0x80, 0xBC, 0x61, 0x20, 0x50, 0x28, 0x0C, 0x06,
  0x03, 0x02, 0x81, 0x61, 0x2F, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3C, 0xA1,
  0x60, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA1, 0xCF, 0x20, 0x10,
  0x08, 0x04, 0x02, 0xF3, 0xC5, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x0F, 0xF8, 0x3E, 0x20, 0xE0, 0x10, 0x06, 0x00, 0xF8,
  0x02, 0x01, 0x80, 0xA0, 0x4F, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F,
  0xFE, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0xF8, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x40, 0xA1, 0xCF, 0x20, 0x80, 0xC0, 0x50, 0x48, 0x24, 0x11, 0x10, 0x88,
  0x28, 0x14, 0x0A, 0x02, 0x00, 0x84, 0x31, 0x46, 0x28, 0xC5, 0x18, 0xA2,
  0xA2, 0x94, 0x52, 0x8A, 0x51, 0x4C, 0x18, 0x82, 0x00, 0x80, 0xA0, 0x88,
  0x82, 0x41, 0x40, 0x40, 0x50, 0x44, 0x22, 0x20, 0xA0, 0x20, 0x80, 0xE0,
  0x24, 0x11, 0x04, 0x41, 0x08, 0x82, 0x20, 0x50, 0x14, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x0E, 0x00, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x3F, 0xE0, 0x0F, 0x88, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x7C, 0x03, 0x00, 0x80, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x01, 0xF0, 0xFF, 0xFF, 0xF0, 0xF8, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x07, 0xC6, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x1F, 0x00, 0x38, 0x29, 0x86, 0x19, 0x40,
  0xC0,
};

const GFXglyph IBMPlexMono_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 15, 13, 6, -15 },
  { 5, 4, 6, 13, 5, -16 },
  { 8, 13, 15, 13, 0, -15 },
  { 33, 11, 19, 13, 1, -17 },
  { 60, 12, 15, 13, 1, -15 },
  { 83, 11, 15, 13, 1, -15 },
  { 104, 1, 6, 13, 6, -16 },
  { 105, 5, 20, 13, 5, -17 },
  { 118, 5, 20, 13, 3, -17 },
  { 131, 11, 11, 13, 1, -12 },
  { 147, 11, 11, 13, 1, -12 },
  { 163, 2, 6, 13, 5, -2 },
  { 165, 6, 1, 13, 4, -7 },
  { 166, 2, 2, 13, 6, -2 },
  { 167, 9, 20, 13, 2, -17 },
  { 190, 11, 15, 13, 1, -15 },
  { 211, 10, 15, 13, 2, -15 },
  { 230, 10, 15, 13, 2, -15 },
  { 249, 10, 15, 13, 1, -15 },
  { 268, 11, 15, 13, 1, -15 },
  { 289, 9, 15, 13, 2, -15 },
  { 306, 9, 15, 13, 2, -15 },
  { 323, 9, 15, 13, 2, -15 },
  { 340, 11, 15, 13, 1, -15 },
  { 361, 9, 15, 13, 2, -15 },
  { 378, 2, 12, 13, 6, -12 },
  { 381, 3, 16, 13, 5, -12 },
  { 387, 9, 12, 13, 2, -13 },
  { 401, 11, 5, 13, 1, -9 },
  { 408, 9, 12, 13, 2, -13 },
  { 422, 9, 15, 13, 2, -15 },
  { 439, 9, 17, 13, 2, -15 },
  { 459, 11, 15, 13, 1, -15 },
  { 480, 9, 15, 13, 2, -15 },
  { 497, 10, 15, 13, 2, -15 },
  { 516, 10, 15, 13, 2, -15 },
  { 535, 9, 15, 13, 2, -15 },
  { 552, 9, 15, 13, 2, -15 },
  { 569, 9, 15, 13, 2, -15 },
  { 586, 9, 15, 13, 2, -15 },
  { 603, 9, 15, 13, 2, -15 },
  { 620, 8, 15, 13, 2, -15 },
  { 635, 10, 15, 13, 2, -15 },
  { 654, 9, 15, 13, 3, -15 },
  { 671, 9, 15, 13, 2, -15 },
  { 688, 9, 15, 13, 2, -15 },
  { 705, 11, 15, 13, 1, -15 },
  { 726, 10, 15, 13, 2, -15 },
  { 745, 11, 18, 13, 1, -15 },
  { 770, 10, 15, 13, 2, -15 },
  { 789, 11, 15, 13, 1, -15 },
  { 810, 11, 15, 13, 1, -15 },
  { 831, 9, 15, 13, 2, -15 },
  { 848, 11, 15, 13, 1, -15 },
  { 869, 11, 15, 13, 1, -15 },
  { 890, 11, 15, 13, 1, -15 },
  { 911, 12, 15, 13, 1, -15 },
  { 934, 11, 15, 13, 1, -15 },
  { 955, 5, 20, 13, 6, -17 },
  { 968, 9, 20, 13, 2, -17 },
  { 991, 6, 20, 13, 2, -17 },
  { 1006, 11, 8, 13, 1, -15 },
  { 1017, 11, 1, 13, 1, 2 },
  { 1019, 3, 4, 13, 4, -17 },
  { 1021, 10, 11, 13, 2, -11 },
  { 1035, 9, 16, 13, 3, -16 },
  { 1053, 9, 11, 13, 2, -11 },
  { 1066, 9, 16, 13, 2, -16 },
  { 1084, 9, 11, 13, 2, -11 },
  { 1097, 10, 16, 13, 2, -16 },
  { 1117, 10, 16, 13, 2, -12 },
  { 1137, 8, 16, 13, 3, -16 },
  { 1153, 9, 16, 13, 3, -16 },
  { 1171, 8, 20, 13, 2, -16 },
  { 1191, 9, 16, 13, 3, -16 },
  { 1209, 9, 16, 13, 2, -16 },
  { 1227, 10, 11, 13, 2, -11 },
  { 1241, 8, 11, 13, 3, -11 },
  { 1252, 9, 11, 13, 2, -11 },
  { 1265, 9, 15, 13, 3, -11 },
  { 1282, 9, 15, 13, 2, -11 },
  { 1299, 10, 11, 13, 2, -11 },
  { 1313, 9, 11, 13, 2, -11 },
  { 1326, 11, 15, 13, 1, -15 },
  { 1347, 9, 11, 13, 2, -11 },
  { 1360, 9, 11, 13, 2, -11 },
  { 1373, 11, 11, 13, 1, -11 },
  { 1389, 9, 11, 13, 2, -11 },
  { 1402, 10, 15, 13, 2, -11 },
  { 1421, 9, 11, 13, 2, -11 },
  { 1434, 9, 20, 13, 2, -17 },
  { 1457, 1, 20, 13, 6, -17 },
  { 1460, 9, 20, 13, 2, -17 },
  { 1483, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_EXTRALIGHT22PT7B_H_
