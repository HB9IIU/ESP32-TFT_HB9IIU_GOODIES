#ifndef _IBMPLEXMONO_EXTRALIGHT11PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x28, 0xA6, 0xCA, 0x53, 0x35, 0x14, 0x23, 0xAB, 0x4E,
  0x1C, 0xB5, 0x71, 0x00, 0x66, 0xAA, 0x98, 0x0D, 0xD5, 0x63, 0x31, 0x24,
  0x09, 0xFA, 0x68, 0x9D, 0xE0, 0x6A, 0xAA, 0x90, 0x88, 0x92, 0x49, 0x50,
  0x42, 0x36, 0xC9, 0x00, 0x42, 0x11, 0xF4, 0x21, 0x00, 0x68, 0xE0, 0x80,
  0x11, 0x22, 0x24, 0x48, 0x88, 0x74, 0xA3, 0x1A, 0xC6, 0x4E, 0x23, 0x28,
  0x42, 0x10, 0x9F, 0x74, 0x84, 0x21, 0x13, 0x1F, 0x79, 0x16, 0x11, 0x97,
  0x08, 0x62, 0x92, 0x89, 0xF8, 0x82, 0xF4, 0x21, 0xE8, 0x86, 0x4E, 0x22,
  0x21, 0xE8, 0xC6, 0x2E, 0xFC, 0xA4, 0x42, 0x11, 0x08, 0x74, 0x64, 0xC9,
  0xC6, 0x2E, 0x74, 0x63, 0x17, 0x08, 0x88, 0x84, 0x40, 0x1A, 0x09, 0xB1,
  0x06, 0x0C, 0xF8, 0x3E, 0x82, 0x0C, 0x36, 0x40, 0x74, 0x86, 0x26, 0x20,
  0x04, 0x74, 0xAD, 0x9C, 0xE6, 0xF0, 0x70, 0x23, 0x19, 0x29, 0x7A, 0x31,
  0xF4, 0xA5, 0xE8, 0xC6, 0x3E, 0x74, 0xA3, 0x08, 0x42, 0x6E, 0xF4, 0xA3,
  0x18, 0xC6, 0x5E, 0xFC, 0x21, 0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xE8, 0x42,
  0x10, 0x74, 0xA3, 0x0B, 0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9,
  0x08, 0x42, 0x10, 0x9F, 0x71, 0x11, 0x11, 0x96, 0x8C, 0xA9, 0x8A, 0x4A,
  0x51, 0x88, 0x88, 0x88, 0x8F, 0x8C, 0x67, 0xDA, 0xC6, 0x31, 0x8C, 0x73,
  0x9A, 0xD6, 0x71, 0x74, 0xA3, 0x18, 0xC6, 0x4E, 0xF4, 0x63, 0x1F, 0x42,
  0x10, 0x74, 0xA3, 0x18, 0xC6, 0x4E, 0x21, 0x80, 0xF4, 0x63, 0x1F, 0x52,
  0x53, 0x74, 0x61, 0xC1, 0x86, 0x2E, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x8C, 0x63, 0x18, 0xC6, 0x4E, 0x8C, 0x65, 0x29, 0x31, 0x84, 0x8C, 0x6B,
  0xDE, 0xF6, 0x52, 0x85, 0x23, 0x04, 0x10, 0xA4, 0xA1, 0x85, 0x24, 0x8C,
  0x10, 0x41, 0x04, 0xF8, 0x84, 0x44, 0x42, 0x1F, 0xF2, 0x49, 0x24, 0x9C,
  0x88, 0x84, 0x42, 0x22, 0x11, 0xE4, 0x92, 0x49, 0x3C, 0x23, 0x25, 0x10,
  0xF8, 0xB0, 0x74, 0x85, 0xE9, 0x74, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74,
  0xA1, 0x09, 0xB0, 0x11, 0x79, 0x99, 0x97, 0x74, 0xBF, 0x09, 0xB8, 0x3A,
  0x3E, 0x84, 0x21, 0x1F, 0x0B, 0xA5, 0x27, 0x41, 0xF1, 0xF0, 0x88, 0xF9,
  0x99, 0x99, 0x20, 0x38, 0x42, 0x10, 0x9F, 0x10, 0xF1, 0x11, 0x11, 0x1F,
  0x84, 0x27, 0x4A, 0x72, 0x51, 0xE1, 0x08, 0x42, 0x10, 0x9F, 0xDF, 0x73,
  0x9C, 0xE4, 0xF9, 0x99, 0x99, 0x74, 0xA3, 0x19, 0x38, 0xF4, 0x63, 0x18,
  0xFA, 0x10, 0x79, 0x99, 0x97, 0x11, 0xD9, 0x10, 0x84, 0x7C, 0x74, 0x78,
  0x38, 0xB8, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x07, 0x99, 0x99, 0x97, 0x9C,
  0xA4, 0xC6, 0x10, 0x96, 0xDB, 0x6D, 0xC9, 0x20, 0x9C, 0x98, 0x4D, 0x4C,
  0x8C, 0xA4, 0xC6, 0x11, 0x18, 0xF0, 0x88, 0x88, 0x7C, 0x34, 0x42, 0xC2,
  0x24, 0x43, 0xFF, 0xC0, 0xE2, 0x44, 0x36, 0x42, 0x2E, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 3, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 6, 8, 7, 0, -8 },
  { 28, 1, 3, 7, 3, -8 },
  { 29, 2, 10, 7, 3, -8 },
  { 32, 3, 10, 7, 1, -8 },
  { 36, 5, 5, 7, 1, -6 },
  { 40, 5, 7, 7, 1, -7 },
  { 45, 2, 3, 7, 2, -1 },
  { 46, 3, 1, 7, 2, -4 },
  { 47, 1, 1, 7, 3, -1 },
  { 48, 4, 10, 7, 1, -8 },
  { 53, 5, 8, 7, 1, -8 },
  { 58, 5, 8, 7, 1, -8 },
  { 63, 5, 8, 7, 1, -8 },
  { 68, 4, 8, 7, 1, -8 },
  { 72, 6, 8, 7, 0, -8 },
  { 78, 5, 8, 7, 1, -8 },
  { 83, 5, 8, 7, 1, -8 },
  { 88, 5, 8, 7, 1, -8 },
  { 93, 5, 8, 7, 1, -8 },
  { 98, 5, 8, 7, 1, -8 },
  { 103, 1, 6, 7, 3, -6 },
  { 104, 2, 8, 7, 2, -6 },
  { 106, 5, 6, 7, 1, -6 },
  { 110, 5, 3, 7, 1, -5 },
  { 112, 5, 6, 7, 1, -6 },
  { 116, 5, 8, 7, 1, -8 },
  { 121, 5, 9, 7, 1, -8 },
  { 127, 5, 8, 7, 1, -8 },
  { 132, 5, 8, 7, 1, -8 },
  { 137, 5, 8, 7, 1, -8 },
  { 142, 5, 8, 7, 1, -8 },
  { 147, 5, 8, 7, 1, -8 },
  { 152, 5, 8, 7, 1, -8 },
  { 157, 5, 8, 7, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 5, 8, 7, 1, -8 },
  { 172, 4, 8, 7, 1, -8 },
  { 176, 5, 8, 7, 1, -8 },
  { 181, 4, 8, 7, 2, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 5, 8, 7, 1, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 5, 10, 7, 1, -8 },
  { 212, 5, 8, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 6, 8, 7, 0, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 5, 8, 7, 1, -8 },
  { 243, 6, 8, 7, 0, -8 },
  { 249, 6, 8, 7, 0, -8 },
  { 255, 5, 8, 7, 1, -8 },
  { 260, 3, 10, 7, 3, -8 },
  { 264, 4, 10, 7, 1, -8 },
  { 269, 3, 10, 7, 1, -8 },
  { 273, 5, 4, 7, 1, -8 },
  { 276, 5, 1, 7, 1, 1 },
  { 277, 2, 2, 7, 2, -10 },
  { 278, 5, 6, 7, 1, -6 },
  { 282, 5, 8, 7, 1, -8 },
  { 287, 5, 6, 7, 1, -6 },
  { 291, 4, 8, 7, 1, -8 },
  { 295, 5, 6, 7, 1, -6 },
  { 299, 5, 8, 7, 1, -8 },
  { 304, 5, 9, 7, 1, -7 },
  { 310, 4, 8, 7, 1, -8 },
  { 314, 5, 8, 7, 1, -8 },
  { 319, 4, 10, 7, 1, -8 },
  { 324, 5, 8, 7, 1, -8 },
  { 329, 5, 8, 7, 1, -8 },
  { 334, 5, 6, 7, 1, -6 },
  { 338, 4, 6, 7, 1, -6 },
  { 341, 5, 6, 7, 1, -6 },
  { 345, 5, 8, 7, 1, -6 },
  { 350, 4, 8, 7, 1, -6 },
  { 354, 5, 6, 7, 1, -6 },
  { 358, 5, 6, 7, 1, -6 },
  { 362, 6, 8, 7, 0, -8 },
  { 368, 4, 6, 7, 1, -6 },
  { 371, 5, 6, 7, 1, -6 },
  { 375, 6, 6, 7, 0, -6 },
  { 380, 5, 6, 7, 1, -6 },
  { 384, 5, 8, 7, 1, -6 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 4, 10, 7, 1, -8 },
  { 398, 1, 10, 7, 3, -8 },
  { 400, 4, 10, 7, 1, -8 },
  { 405, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_EXTRALIGHT11PT7B_H_
