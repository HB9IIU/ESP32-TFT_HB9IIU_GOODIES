#ifndef _IBMPLEXMONO_EXTRALIGHT32PT7B_H_
#define _IBMPLEXMONO_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x7F, 0xC0, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x20,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x81, 0xF8, 0x3F, 0x02, 0x10, 0x01,
  0x84, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x0C, 0x0F, 0xC3,
  0xF0, 0x30, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x21, 0x80,
  0x08, 0x40, 0x04, 0x10, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F,
  0x03, 0x91, 0x8C, 0x20, 0x90, 0x41, 0xA0, 0x80, 0x41, 0x00, 0x82, 0x01,
  0x04, 0x03, 0x08, 0x03, 0x90, 0x01, 0xF8, 0x00, 0x5E, 0x00, 0x86, 0x01,
  0x04, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x38, 0x20, 0xD8, 0x41,
  0x1C, 0x8C, 0x0F, 0xE0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x3E, 0x00,
  0xB1, 0x80, 0xF0, 0x60, 0x50, 0x10, 0x48, 0x08, 0x24, 0x04, 0x22, 0x02,
  0x11, 0x83, 0x10, 0x63, 0x10, 0x1F, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x46, 0x30, 0x22, 0x04, 0x22, 0x02, 0x11, 0x01, 0x10, 0x80, 0x98, 0x40,
  0x48, 0x20, 0x28, 0x08, 0x14, 0x06, 0x34, 0x00, 0xF0, 0x07, 0xC0, 0x04,
  0x10, 0x04, 0x04, 0x02, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x07, 0x80, 0x06, 0x40, 0xF6, 0x10,
  0x42, 0x04, 0x23, 0x01, 0x11, 0x00, 0x48, 0x80, 0x38, 0x40, 0x0C, 0x10,
  0x07, 0x0C, 0x06, 0x83, 0x06, 0x20, 0x7C, 0x0C, 0xFF, 0x03, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x03, 0xC0, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x04, 0x04, 0x09, 0xC2, 0x1E, 0x1D, 0x70, 0x01, 0xC0,
  0x00, 0xA0, 0x00, 0xD8, 0x00, 0x44, 0x00, 0x41, 0x00, 0x60, 0x40, 0x20,
  0x30, 0x20, 0x08, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x32, 0x66, 0x44, 0xC8,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x64, 0x00, 0x48,
  0x00, 0xB0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xA0, 0x03, 0x40, 0x04, 0x80, 0x08,
  0x80, 0x31, 0x80, 0x41, 0x83, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x06, 0x80,
  0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x7F, 0xFF, 0x0F, 0x80, 0xC1, 0x84, 0x03, 0x20, 0x04, 0x80,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0xC0, 0xC6, 0x01,
  0x90, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x01,
  0x80, 0xF8, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x38, 0x00, 0x90, 0x06, 0x30, 0x30, 0x3F, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x04,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01,
  0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x7F, 0xFA, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x7E, 0x1C, 0x18, 0x80, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x07, 0x80, 0x27, 0x06, 0x0F, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x3F, 0x0B, 0x06, 0x30, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x03, 0x80, 0x0A, 0x00, 0x2C, 0x00, 0x90, 0x04, 0x30, 0x60, 0x3F, 0x00,
  0xFF, 0xFF, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x90, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x30, 0x70, 0x80, 0x23,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x20, 0x08, 0x30,
  0x60, 0x1F, 0x00, 0xC1, 0xC6, 0x00, 0xC8, 0x00, 0xB0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x05, 0x00, 0x1B, 0x00, 0x63, 0x81, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0xC1, 0x84, 0x01, 0x30, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x34, 0x01, 0x8C, 0x1A, 0x0F, 0x88, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x77, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x66, 0x44, 0xC8, 0x00, 0x08, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x08, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0x83, 0x18, 0x04,
  0x80, 0x38, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x03, 0x01,
  0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0x81, 0x83, 0x08, 0x04,
  0x80, 0x24, 0x00, 0xC0, 0x06, 0x0F, 0x30, 0xC5, 0x84, 0x1C, 0x40, 0x62,
  0x03, 0x10, 0x18, 0x80, 0xC4, 0x06, 0x20, 0x31, 0x01, 0x84, 0x0C, 0x20,
  0xE0, 0xFB, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x2C, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x08, 0xC0, 0x08, 0x20, 0x04, 0x10, 0x02, 0x0C, 0x03, 0x02, 0x01,
  0x01, 0x00, 0x80, 0xC0, 0xC0, 0x20, 0x7F, 0xF0, 0x20, 0x0C, 0x30, 0x02,
  0x10, 0x01, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0C, 0xFF,
  0xC2, 0x01, 0x88, 0x01, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x68, 0x01, 0xA0,
  0x04, 0x80, 0x12, 0x01, 0x8F, 0xFC, 0x20, 0x0C, 0x80, 0x1A, 0x00, 0x28,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x06, 0x80, 0x33,
  0xFF, 0x80, 0x07, 0xE0, 0x18, 0x30, 0x40, 0x31, 0x00, 0x26, 0x00, 0x28,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x04,
  0x80, 0x10, 0x80, 0x60, 0xC1, 0x80, 0xFC, 0x00, 0xFF, 0x83, 0x01, 0x8C,
  0x03, 0x30, 0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0B, 0x00, 0x2C, 0x01, 0xB0, 0x0C, 0xC0, 0x63, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFC, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xA0, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x07, 0xE0, 0x60, 0xC3, 0x00, 0x88, 0x01, 0x40, 0x05, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xFF, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x12, 0x00, 0x4C,
  0x03, 0x18, 0x34, 0x1F, 0x10, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x7F, 0xFC, 0x3F, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x24, 0x02, 0x60,
  0xC1, 0xF8, 0x80, 0x07, 0x00, 0x12, 0x00, 0x44, 0x01, 0x88, 0x06, 0x10,
  0x18, 0x20, 0x60, 0x41, 0x80, 0x82, 0x01, 0x08, 0x02, 0x28, 0x04, 0x98,
  0x0A, 0x10, 0x18, 0x10, 0x30, 0x30, 0x40, 0x20, 0x80, 0x21, 0x00, 0x62,
  0x00, 0x44, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0x80, 0x0F, 0x00, 0x7C,
  0x01, 0x68, 0x09, 0xA0, 0x26, 0x41, 0x19, 0x04, 0x62, 0x11, 0x88, 0x86,
  0x32, 0x18, 0x50, 0x61, 0xC1, 0x82, 0x06, 0x08, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xC0,
  0x0E, 0x00, 0x68, 0x03, 0x40, 0x19, 0x00, 0xC8, 0x06, 0x20, 0x31, 0x01,
  0x84, 0x0C, 0x20, 0x60, 0x83, 0x04, 0x18, 0x10, 0xC0, 0x86, 0x02, 0x30,
  0x11, 0x80, 0x4C, 0x02, 0x60, 0x0B, 0x00, 0x78, 0x01, 0xC0, 0x0C, 0x07,
  0xC0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x64, 0x00, 0x48, 0x00, 0xB0, 0x01,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xA0, 0x03, 0x40, 0x04, 0x80, 0x08, 0x80, 0x31, 0x80,
  0x41, 0x83, 0x00, 0xFC, 0x00, 0xFF, 0xE2, 0x00, 0xC8, 0x00, 0xA0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x03,
  0x3F, 0xF8, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x60,
  0xC0, 0x21, 0x00, 0x64, 0x00, 0x48, 0x00, 0xB0, 0x01, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xA0, 0x03, 0x40, 0x04, 0x80, 0x09, 0x80, 0x31, 0x80, 0x41, 0x83, 0x00,
  0xFC, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xF0, 0xFF, 0xE2, 0x00,
  0xC8, 0x00, 0xA0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x28, 0x03, 0x3F, 0xF8, 0x81, 0x02, 0x04, 0x08, 0x08, 0x20,
  0x30, 0x80, 0x42, 0x00, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x30,
  0x0F, 0xE0, 0x60, 0x31, 0x80, 0x32, 0x00, 0x34, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0x00, 0x1B,
  0x00, 0x63, 0x01, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50, 0x06,
  0x80, 0x23, 0x06, 0x0F, 0xE0, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x60, 0x04, 0x20, 0x08, 0x20, 0x08, 0x30, 0x08, 0x10,
  0x18, 0x10, 0x10, 0x18, 0x10, 0x08, 0x30, 0x08, 0x20, 0x0C, 0x20, 0x04,
  0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x81, 0x02, 0x83, 0x82, 0xC2, 0x82, 0x42, 0x82, 0x42, 0xC6, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x24, 0x48, 0x24, 0x48, 0x24, 0x48,
  0x24, 0x58, 0x14, 0x30, 0x14, 0x30, 0x14, 0x30, 0x1C, 0x40, 0x01, 0x90,
  0x01, 0x8C, 0x00, 0x82, 0x00, 0x80, 0x80, 0xC0, 0x60, 0x40, 0x10, 0x40,
  0x04, 0x60, 0x03, 0x20, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x16,
  0x00, 0x11, 0x00, 0x18, 0xC0, 0x08, 0x30, 0x08, 0x08, 0x0C, 0x06, 0x04,
  0x01, 0x84, 0x00, 0x46, 0x00, 0x36, 0x00, 0x0C, 0x80, 0x00, 0xA0, 0x00,
  0x98, 0x00, 0x44, 0x00, 0x41, 0x00, 0x60, 0xC0, 0x20, 0x20, 0x20, 0x18,
  0x30, 0x04, 0x10, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x28, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x01, 0x80, 0x05,
  0x00, 0x1B, 0x00, 0x22, 0x00, 0xC2, 0x01, 0x04, 0x04, 0x04, 0x08, 0x0C,
  0x20, 0x08, 0xC0, 0x09, 0x00, 0x14, 0x00, 0x10, 0xFF, 0xFE, 0xC3, 0x08,
  0x20, 0x80, 0x0F, 0xC0, 0x60, 0xC1, 0x80, 0xC2, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x1F, 0xF8, 0x60, 0x31, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x98, 0x03, 0x10, 0x0E, 0x30, 0x2C, 0x1F, 0x8E, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x11, 0xF0, 0xB0,
  0xC6, 0x01, 0x20, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x28, 0x01, 0x60, 0x12, 0x83, 0x13,
  0xF0, 0x0F, 0xC0, 0xC1, 0x88, 0x04, 0x80, 0x14, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x04,
  0x80, 0x63, 0x06, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x21, 0xF9, 0x18, 0x29, 0x00, 0xD8, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x16, 0x00, 0x90, 0x0C, 0x60, 0xA1, 0xF9, 0x0F, 0x80, 0xC1, 0x86,
  0x01, 0x10, 0x04, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0xFF, 0xFE,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x26, 0x01, 0x8C, 0x0C,
  0x0F, 0xC0, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFE, 0x00, 0x3E, 0x1F, 0x40,
  0xC1, 0x81, 0x01, 0x84, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x10, 0x40, 0x60, 0x41, 0x80, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x3F, 0xF0, 0xC0, 0x1A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x70,
  0x00, 0x98, 0x06, 0x0F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0, 0xCC, 0x06, 0x80, 0x28, 0x02, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03,
  0xFF, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x06, 0x80, 0x32, 0x01, 0x08, 0x08, 0x20, 0x40, 0x82,
  0x02, 0x10, 0x09, 0xE0, 0x2C, 0x80, 0xE1, 0x03, 0x06, 0x08, 0x0C, 0x20,
  0x18, 0x80, 0x22, 0x00, 0x48, 0x01, 0xA0, 0x03, 0xFE, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x9E,
  0x3D, 0x44, 0x8B, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x9F, 0x8A, 0x0C, 0xC0, 0x68,
  0x02, 0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F, 0x80, 0xC1,
  0x86, 0x01, 0x10, 0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x0E, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x09, 0x00, 0x66, 0x01, 0x0C,
  0x18, 0x0F, 0x80, 0x8F, 0x85, 0x86, 0x30, 0x09, 0x00, 0x28, 0x01, 0x40,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x40, 0x0B, 0x00, 0x94, 0x18, 0x9F, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x0F, 0xC8, 0xC1, 0x48, 0x06, 0xC0, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x00, 0xB0, 0x04, 0x80, 0x63, 0x05, 0x0F, 0xC8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0xFC, 0x7E, 0x09, 0x00, 0x14,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0xC0, 0xC4, 0x01, 0x90, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x2C, 0x00, 0x8C, 0x0C, 0x0F, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x1B, 0x05, 0x3F, 0x20, 0x80, 0x0C, 0x00, 0x50, 0x06, 0x80, 0x26,
  0x01, 0x10, 0x10, 0x80, 0x86, 0x04, 0x10, 0x40, 0x82, 0x02, 0x10, 0x11,
  0x00, 0x88, 0x02, 0xC0, 0x14, 0x00, 0xA0, 0x02, 0x00, 0x80, 0x80, 0xC0,
  0xA0, 0x50, 0x50, 0x28, 0x28, 0x24, 0x14, 0x12, 0x09, 0x09, 0x08, 0x84,
  0x84, 0x42, 0x22, 0x21, 0x11, 0x09, 0x09, 0x04, 0x84, 0x82, 0x42, 0x41,
  0x20, 0xA0, 0x50, 0x60, 0x28, 0x30, 0x18, 0x18, 0x0C, 0x00, 0x80, 0x09,
  0x00, 0x42, 0x03, 0x0C, 0x08, 0x10, 0x40, 0x22, 0x00, 0xD8, 0x01, 0xC0,
  0x02, 0x00, 0x1C, 0x00, 0xD8, 0x02, 0x20, 0x10, 0x40, 0xC0, 0x86, 0x03,
  0x10, 0x04, 0x80, 0x0C, 0xC0, 0x06, 0x80, 0x09, 0x80, 0x11, 0x00, 0x42,
  0x00, 0x82, 0x03, 0x04, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xE0, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x1E, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0xFF, 0xF8, 0x0F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x06, 0x0F,
  0x80, 0x0E, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0C, 0x00, 0x3F, 0x0E,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xE0, 0x3C, 0x02, 0xCC, 0x05,
  0x0C, 0x0C, 0x0C, 0x28, 0x0C, 0x50, 0x07, 0x00,
};

const GFXglyph IBMPlexMono_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 22, 19, 8, -22 },
  { 10, 5, 8, 19, 7, -24 },
  { 15, 18, 22, 19, 1, -22 },
  { 65, 15, 28, 19, 2, -25 },
  { 118, 17, 22, 19, 1, -22 },
  { 165, 17, 22, 19, 1, -22 },
  { 212, 1, 8, 19, 9, -24 },
  { 213, 8, 28, 19, 7, -24 },
  { 241, 8, 28, 19, 4, -24 },
  { 269, 17, 16, 19, 1, -18 },
  { 303, 15, 15, 19, 2, -17 },
  { 332, 4, 8, 19, 7, -3 },
  { 336, 9, 1, 19, 5, -10 },
  { 338, 3, 3, 19, 8, -3 },
  { 340, 13, 28, 19, 3, -24 },
  { 386, 15, 22, 19, 2, -22 },
  { 428, 16, 22, 19, 2, -22 },
  { 472, 14, 22, 19, 3, -22 },
  { 511, 14, 22, 19, 2, -22 },
  { 550, 17, 22, 19, 1, -22 },
  { 597, 13, 22, 19, 3, -22 },
  { 633, 14, 22, 19, 3, -22 },
  { 672, 15, 22, 19, 2, -22 },
  { 714, 15, 22, 19, 2, -22 },
  { 756, 14, 22, 19, 3, -22 },
  { 795, 3, 17, 19, 8, -17 },
  { 802, 4, 22, 19, 7, -17 },
  { 813, 13, 17, 19, 3, -18 },
  { 841, 15, 7, 19, 2, -13 },
  { 855, 13, 17, 19, 3, -18 },
  { 883, 13, 22, 19, 3, -22 },
  { 919, 13, 25, 19, 3, -22 },
  { 960, 17, 22, 19, 1, -22 },
  { 1007, 14, 22, 19, 3, -22 },
  { 1046, 15, 22, 19, 2, -22 },
  { 1088, 14, 22, 19, 3, -22 },
  { 1127, 13, 22, 19, 3, -22 },
  { 1163, 14, 22, 19, 3, -22 },
  { 1202, 14, 22, 19, 2, -22 },
  { 1241, 13, 22, 19, 3, -22 },
  { 1277, 13, 22, 19, 3, -22 },
  { 1313, 12, 22, 19, 3, -22 },
  { 1346, 15, 22, 19, 3, -22 },
  { 1388, 13, 22, 19, 4, -22 },
  { 1424, 14, 22, 19, 3, -22 },
  { 1463, 13, 22, 19, 3, -22 },
  { 1499, 15, 22, 19, 2, -22 },
  { 1541, 14, 22, 19, 3, -22 },
  { 1580, 15, 26, 19, 2, -22 },
  { 1629, 14, 22, 19, 3, -22 },
  { 1668, 15, 22, 19, 2, -22 },
  { 1710, 17, 22, 19, 1, -22 },
  { 1757, 13, 22, 19, 3, -22 },
  { 1793, 16, 22, 19, 2, -22 },
  { 1837, 16, 22, 19, 2, -22 },
  { 1881, 17, 22, 19, 1, -22 },
  { 1928, 17, 22, 19, 1, -22 },
  { 1975, 16, 22, 19, 2, -22 },
  { 2019, 8, 28, 19, 8, -24 },
  { 2047, 13, 28, 19, 3, -24 },
  { 2093, 8, 28, 19, 3, -24 },
  { 2121, 15, 12, 19, 2, -22 },
  { 2144, 15, 1, 19, 2, 4 },
  { 2146, 5, 5, 19, 6, -24 },
  { 2150, 15, 17, 19, 2, -17 },
  { 2182, 13, 24, 19, 4, -24 },
  { 2221, 13, 17, 19, 3, -17 },
  { 2249, 13, 24, 19, 2, -24 },
  { 2288, 14, 17, 19, 3, -17 },
  { 2318, 14, 24, 19, 3, -24 },
  { 2360, 15, 24, 19, 3, -18 },
  { 2405, 12, 24, 19, 4, -24 },
  { 2441, 13, 24, 19, 4, -24 },
  { 2480, 11, 30, 19, 3, -24 },
  { 2522, 14, 24, 19, 4, -24 },
  { 2564, 13, 24, 19, 3, -24 },
  { 2603, 15, 17, 19, 2, -17 },
  { 2635, 12, 17, 19, 4, -17 },
  { 2661, 14, 17, 19, 3, -17 },
  { 2691, 13, 23, 19, 4, -17 },
  { 2729, 13, 23, 19, 2, -17 },
  { 2767, 15, 17, 19, 3, -17 },
  { 2799, 14, 17, 19, 3, -17 },
  { 2829, 16, 22, 19, 1, -22 },
  { 2873, 11, 17, 19, 4, -17 },
  { 2897, 13, 17, 19, 3, -17 },
  { 2925, 17, 17, 19, 1, -17 },
  { 2962, 14, 17, 19, 3, -17 },
  { 2992, 15, 23, 19, 2, -17 },
  { 3036, 13, 17, 19, 3, -17 },
  { 3064, 12, 28, 19, 4, -24 },
  { 3106, 1, 28, 19, 9, -24 },
  { 3110, 12, 28, 19, 4, -24 },
  { 3152, 15, 6, 19, 2, -13 },
};

const GFXfont IBMPlexMono_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ExtraLight32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_EXTRALIGHT32PT7B_H_
