#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x04, 0x3E, 0xFD, 0xFF,
  0xFF, 0xE7, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF0,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x7C, 0xF0,
  0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03,
  0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0xCE,
  0xF9, 0x85, 0xF3, 0x03, 0xE6, 0x07, 0xEC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0D, 0xF0, 0x1B,
  0xF0, 0x37, 0xF0, 0x6F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1,
  0xFF, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xF8, 0x1F, 0x00,
  0x79, 0xE0, 0x78, 0x03, 0xE7, 0xC3, 0xE0, 0x0F, 0x9F, 0x0F, 0x00, 0x3E,
  0x3C, 0x3C, 0x00, 0xF8, 0xF1, 0xF0, 0x03, 0xE3, 0xC7, 0x80, 0x0F, 0x8F,
  0x1E, 0x00, 0x3E, 0x7C, 0xF0, 0x60, 0xF9, 0xF3, 0xC7, 0xE1, 0xE7, 0x9F,
  0x3F, 0xC7, 0xFE, 0x79, 0xFF, 0x8F, 0xF9, 0xE7, 0xFE, 0x3F, 0xCF, 0x3E,
  0x7C, 0x3C, 0x3C, 0xF9, 0xF0, 0x01, 0xF3, 0xE7, 0xC0, 0x07, 0x8F, 0x9F,
  0x00, 0x1E, 0x3E, 0x7C, 0x00, 0xF0, 0xF9, 0xF0, 0x03, 0xC3, 0xE7, 0xC0,
  0x1F, 0x0F, 0x9F, 0x00, 0x78, 0x1E, 0x7C, 0x01, 0xE0, 0x7F, 0xE0, 0x0F,
  0x01, 0xFF, 0x80, 0x3C, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x1F, 0xFC, 0x7E, 0x7F, 0xFD, 0xF8, 0xFD,
  0xFB, 0xF3, 0xF3, 0xFF, 0xE7, 0xE3, 0xFF, 0x8F, 0xC3, 0xFF, 0x1F, 0x87,
  0xFE, 0x3F, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0x80, 0x07, 0xC3, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x04, 0x3C, 0x13, 0x9E, 0x7B, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF3, 0xE1, 0xF9, 0xF8,
  0x38, 0x78, 0x0C, 0x30, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFB, 0xF1, 0xF8, 0xFC, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3F, 0x0F, 0x9F, 0x07, 0xDF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xEF, 0x83, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xDE, 0x7E, 0x63, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0x7C, 0x7E, 0x30, 0x7F,
  0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x38, 0x7F, 0x20, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xF7, 0xE0, 0x7D, 0xF8, 0x1E, 0x7E, 0x0F,
  0x9F, 0x83, 0xC7, 0xE1, 0xF1, 0xF8, 0x78, 0x7E, 0x3E, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x9F, 0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x1E, 0x0F, 0xBF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFE, 0x7E, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xFD, 0xF8, 0xFE, 0xFC, 0x7E, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9,
  0xF8, 0xFC, 0xF8, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xDF, 0x87, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFE, 0x3F,
  0xBF, 0x9F, 0x8F, 0xDF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3,
  0xF3, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x9F, 0xEF, 0x87, 0xE7, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x7D, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x3E,
  0x7E, 0x7F, 0x7F, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xF8, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xCF, 0x1F, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0xF0,
  0x18, 0x3E, 0x3C, 0x1F, 0xF3, 0xC7, 0x87, 0xFE, 0x7D, 0xF1, 0xFF, 0xC7,
  0xBC, 0x7C, 0x78, 0xF7, 0x8F, 0x8F, 0x1E, 0xF1, 0xE1, 0xE3, 0xDE, 0x7C,
  0x3C, 0x7B, 0xCF, 0x8F, 0x8F, 0xF9, 0xF1, 0xF1, 0xFF, 0x3E, 0x3E, 0x3D,
  0xE7, 0xC7, 0xC7, 0xBC, 0x78, 0xF9, 0xF7, 0x8F, 0xBF, 0x3C, 0xF1, 0xFF,
  0xFF, 0x9E, 0x1F, 0xDF, 0xE3, 0xE1, 0xF1, 0xF8, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0xFF, 0xDF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xDF, 0x80,
  0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x9F, 0xEF, 0xE1, 0xFB, 0xF8,
  0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFB, 0xF8, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFC, 0x79, 0xFC, 0x08, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x04, 0xFF, 0x06, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x8F, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x87, 0xF7, 0xF3, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0x87, 0x1F, 0xE0, 0x23, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xF8, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xCF, 0xF0, 0xF0, 0x00,
  0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1,
  0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x83,
  0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x9F,
  0x87, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xEF, 0xC0, 0xFE, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xBC, 0x1F, 0xFF,
  0xEF, 0x87, 0xFF, 0xFB, 0xE3, 0xEF, 0xFE, 0xF8, 0xFB, 0xFF, 0x9E, 0x3E,
  0xFF, 0xE7, 0xCF, 0x3F, 0xF9, 0xF7, 0xCF, 0xFE, 0x7D, 0xF3, 0xFF, 0x8F,
  0x7C, 0xFF, 0xE3, 0xFE, 0x3F, 0xF8, 0xFF, 0x8F, 0xFE, 0x3F, 0xE3, 0xFF,
  0x87, 0xF8, 0xFF, 0xE1, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F, 0xC3,
  0xFF, 0x83, 0xE0, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xC0, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFF, 0xBE, 0x3F, 0xFB, 0xF3, 0xFF, 0x9F, 0x3F, 0xF9, 0xF9,
  0xFF, 0x9F, 0x9F, 0xF8, 0xFD, 0xFF, 0x8F, 0xDF, 0xF8, 0x7D, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xCF, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFE, 0xFE, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x03, 0xF9, 0xF8, 0x1F,
  0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xCF, 0xF1, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0x7F, 0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x8F, 0xE7, 0xF0,
  0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F,
  0xC7, 0xF1, 0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x07,
  0xEF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xBF, 0x83, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xDF, 0x83, 0xFB, 0xF8, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00,
  0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F,
  0x81, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F,
  0xCF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x07,
  0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x01, 0xFF, 0xE0, 0x7F,
  0x03, 0xF7, 0xC0, 0xFE, 0x0F, 0xEF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8,
  0x3F, 0x3F, 0x07, 0xF0, 0x7E, 0x7E, 0x1F, 0xF0, 0xFC, 0xFC, 0x3F, 0xE1,
  0xF8, 0xF8, 0x7B, 0xC7, 0xE1, 0xF8, 0xF7, 0x8F, 0xC3, 0xF1, 0xEF, 0x1F,
  0x87, 0xE7, 0xDF, 0x3F, 0x0F, 0xCF, 0xBE, 0x7E, 0x0F, 0x9F, 0x7C, 0xF8,
  0x1F, 0x3E, 0xFB, 0xF0, 0x3F, 0x78, 0xF7, 0xE0, 0x7F, 0xF1, 0xEF, 0xC0,
  0xFF, 0xE3, 0xDF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x01, 0xFB, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0x9F,
  0x83, 0xF9, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xE7, 0xE0,
  0x7E, 0xFE, 0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8,
  0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFB, 0xE0,
  0x1F, 0x9F, 0x01, 0xF1, 0xF0, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x1E, 0x7F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xDF, 0x7F, 0xDF, 0x3F, 0x8F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xFC, 0x7E, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF,
  0x9F, 0xE7, 0xC7, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3,
  0xFF, 0xCF, 0xE1, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x04,
  0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7,
  0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8,
  0x7E, 0x7C, 0x07, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF3,
  0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0x3F, 0xC7, 0x8F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xE0, 0x00, 0xC0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x41,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xCF, 0x8F, 0xF7,
  0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFD, 0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0xA0, 0x0F, 0xDF, 0x3F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x02, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x3B, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x08,
  0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xFF, 0xFF, 0xFB, 0xFD,
  0xFC, 0x70, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xFF,
  0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xEF, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFC,
  0x3F, 0x1F, 0x7F, 0xCF, 0xF3, 0xEF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFC, 0x7F, 0x1F, 0xBF, 0x0F, 0xE3, 0xFF, 0xE1, 0xF8,
  0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE,
  0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0xC1,
  0xFF, 0xE1, 0xF8, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0,
  0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F,
  0xC0, 0xF9, 0xFC, 0xFB, 0xFE, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x07, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xF8,
  0xFC, 0x7C, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFB,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xDF, 0xE7, 0xE7, 0xE3, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF,
  0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFD, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFD, 0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x1F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xEF, 0x7E, 0x0B, 0xF0, 0x1F,
  0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07,
  0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xCF, 0x1F, 0x8F, 0xFC, 0x0F, 0xFF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0xF8, 0x3F,
  0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC3,
  0xF7, 0xC1, 0xFC, 0x3F, 0x7C, 0x3F, 0xC3, 0xE7, 0xE3, 0xFC, 0x3E, 0x7E,
  0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7E, 0x3E, 0x3F, 0xE7, 0xE3, 0xE7, 0xDE,
  0x7C, 0x3F, 0x79, 0xE7, 0xC3, 0xF7, 0x9E, 0xFC, 0x3F, 0x79, 0xEF, 0xC1,
  0xF7, 0x9E, 0xFC, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x8F, 0xF8, 0x1F, 0x78,
  0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x07, 0xE0, 0xFE, 0x1F, 0xDF, 0x87, 0xE7, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFE, 0x7E,
  0x1F, 0xBF, 0x07, 0xF0, 0xFC, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x87,
  0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0x01, 0x00, 0x00, 0x08, 0x00, 0xBF, 0xC0, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 11, 18, 2, -29 },
  { 48, 19, 29, 21, 1, -29 },
  { 117, 15, 32, 19, 2, -30 },
  { 177, 30, 29, 32, 1, -29 },
  { 286, 23, 29, 24, 1, -29 },
  { 370, 6, 11, 10, 2, -29 },
  { 379, 10, 35, 13, 2, -29 },
  { 423, 11, 35, 13, 0, -29 },
  { 472, 17, 17, 18, 1, -31 },
  { 509, 17, 19, 19, 1, -24 },
  { 550, 8, 10, 10, 1, -5 },
  { 560, 10, 5, 13, 1, -13 },
  { 567, 7, 7, 11, 2, -7 },
  { 574, 16, 29, 17, 0, -29 },
  { 632, 17, 29, 19, 1, -29 },
  { 694, 13, 29, 19, 2, -29 },
  { 742, 16, 29, 19, 1, -29 },
  { 800, 16, 29, 19, 1, -29 },
  { 858, 18, 29, 19, 1, -29 },
  { 924, 15, 29, 19, 2, -29 },
  { 979, 17, 29, 19, 1, -29 },
  { 1041, 17, 29, 19, 1, -29 },
  { 1103, 17, 29, 19, 1, -29 },
  { 1165, 17, 29, 19, 1, -29 },
  { 1227, 7, 22, 11, 2, -22 },
  { 1247, 8, 27, 11, 1, -22 },
  { 1274, 17, 19, 19, 1, -24 },
  { 1315, 17, 13, 19, 1, -21 },
  { 1343, 17, 19, 19, 1, -24 },
  { 1384, 15, 29, 15, 0, -29 },
  { 1439, 27, 32, 30, 1, -29 },
  { 1547, 22, 29, 22, 0, -29 },
  { 1627, 18, 29, 22, 2, -29 },
  { 1693, 17, 29, 20, 2, -29 },
  { 1755, 19, 29, 23, 2, -29 },
  { 1824, 13, 29, 18, 3, -29 },
  { 1872, 13, 29, 17, 3, -29 },
  { 1920, 19, 29, 23, 2, -29 },
  { 1989, 18, 29, 24, 3, -29 },
  { 2055, 11, 29, 13, 1, -29 },
  { 2095, 11, 38, 11, -2, -29 },
  { 2148, 19, 29, 21, 3, -29 },
  { 2217, 14, 29, 17, 2, -29 },
  { 2268, 26, 29, 32, 3, -29 },
  { 2363, 20, 29, 26, 3, -29 },
  { 2436, 21, 29, 24, 2, -29 },
  { 2513, 17, 29, 20, 2, -29 },
  { 2575, 21, 36, 24, 2, -29 },
  { 2670, 19, 29, 21, 2, -29 },
  { 2739, 15, 29, 17, 1, -29 },
  { 2794, 16, 29, 18, 1, -29 },
  { 2852, 19, 29, 23, 2, -29 },
  { 2921, 21, 29, 21, 0, -29 },
  { 2998, 31, 29, 31, 0, -29 },
  { 3111, 20, 29, 20, 0, -29 },
  { 3184, 20, 29, 20, 0, -29 },
  { 3257, 16, 29, 18, 1, -29 },
  { 3315, 9, 36, 12, 2, -29 },
  { 3356, 16, 29, 17, 0, -29 },
  { 3414, 9, 36, 12, 1, -29 },
  { 3455, 20, 19, 21, 1, -29 },
  { 3503, 18, 4, 18, 0, 3 },
  { 3512, 9, 7, 13, 2, -31 },
  { 3520, 16, 22, 19, 1, -22 },
  { 3564, 17, 30, 20, 2, -30 },
  { 3628, 15, 22, 17, 1, -22 },
  { 3670, 17, 30, 20, 1, -30 },
  { 3734, 17, 22, 19, 1, -22 },
  { 3781, 14, 31, 12, 0, -31 },
  { 3836, 17, 32, 20, 1, -22 },
  { 3904, 16, 30, 21, 2, -30 },
  { 3964, 6, 31, 10, 2, -31 },
  { 3988, 9, 41, 10, -1, -31 },
  { 4035, 18, 30, 20, 2, -30 },
  { 4103, 6, 30, 10, 2, -30 },
  { 4126, 27, 22, 31, 2, -22 },
  { 4201, 16, 22, 21, 2, -22 },
  { 4245, 18, 22, 20, 1, -22 },
  { 4295, 17, 32, 20, 2, -22 },
  { 4363, 17, 32, 20, 1, -22 },
  { 4431, 12, 22, 14, 2, -22 },
  { 4464, 13, 22, 15, 1, -22 },
  { 4500, 13, 27, 14, 0, -27 },
  { 4544, 16, 22, 21, 2, -22 },
  { 4588, 19, 22, 19, 0, -22 },
  { 4641, 28, 22, 28, 0, -22 },
  { 4718, 18, 22, 18, 0, -22 },
  { 4768, 19, 32, 19, 0, -22 },
  { 4844, 13, 22, 15, 1, -22 },
  { 4880, 13, 36, 14, 0, -29 },
  { 4939, 5, 40, 17, 6, -31 },
  { 4964, 13, 36, 14, 1, -29 },
  { 5023, 17, 7, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD40PT7B_H_
