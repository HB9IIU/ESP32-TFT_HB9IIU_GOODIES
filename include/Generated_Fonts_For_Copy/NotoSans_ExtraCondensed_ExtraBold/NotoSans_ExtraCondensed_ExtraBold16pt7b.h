#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xFC, 0xDF, 0x7D, 0xB6, 0x1E, 0x16, 0x36, 0x7F, 0x36,
  0x34, 0xFF, 0xFF, 0x2C, 0x6C, 0x6C, 0x21, 0xEF, 0xF8, 0xE3, 0xC3, 0x8F,
  0x2F, 0xFF, 0x88, 0x20, 0x20, 0x47, 0x98, 0x59, 0x8D, 0x90, 0xDB, 0x05,
  0xB6, 0x7E, 0xF2, 0x69, 0x04, 0x90, 0xC9, 0x0C, 0xF1, 0x87, 0x18, 0x0F,
  0x07, 0x61, 0x98, 0x7C, 0x0F, 0x07, 0x99, 0xBE, 0xEF, 0x39, 0xC7, 0xF1,
  0xFF, 0xFF, 0x36, 0x6C, 0xCC, 0xCC, 0xCC, 0xCE, 0x66, 0x30, 0xC6, 0x63,
  0x33, 0x33, 0x33, 0x33, 0x66, 0xC0, 0x19, 0x37, 0xF9, 0xE3, 0xCD, 0xCA,
  0x00, 0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06, 0x0C, 0x6D, 0xF0, 0xFF, 0xC0,
  0xFC, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x00,
  0x21, 0xEF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x7F, 0x9E, 0x3B, 0xFF, 0xB1,
  0x8C, 0x63, 0x18, 0xC6, 0x10, 0xFB, 0xFA, 0x70, 0xE1, 0x87, 0x0C, 0x30,
  0xE3, 0xFF, 0xF0, 0x11, 0xF9, 0xB8, 0x70, 0xE7, 0x8F, 0x07, 0x0F, 0x1D,
  0xFB, 0xE0, 0x0C, 0x38, 0x71, 0xE6, 0xCD, 0xB3, 0x7F, 0xFE, 0x18, 0x30,
  0xFB, 0xEC, 0x30, 0xFB, 0xF1, 0xC3, 0x9F, 0xEF, 0x80, 0x0C, 0x7D, 0xEB,
  0x06, 0x8F, 0x9F, 0xF3, 0x66, 0xCD, 0xF9, 0xE0, 0xFF, 0xFC, 0x38, 0x60,
  0xC3, 0x86, 0x0C, 0x38, 0x61, 0xC0, 0x18, 0xF9, 0xBB, 0x36, 0xE7, 0x8F,
  0x37, 0x67, 0xCD, 0xF9, 0xE0, 0x10, 0xF9, 0xFB, 0x3E, 0x6C, 0xDF, 0xBB,
  0x06, 0x19, 0xF3, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x03, 0xFC, 0x02, 0x0C,
  0x7B, 0xCF, 0x07, 0x83, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC1,
  0xE0, 0xF0, 0xE7, 0xBC, 0x60, 0x33, 0xEF, 0xC3, 0x1C, 0xE3, 0x0C, 0x00,
  0x87, 0x1C, 0x0C, 0x0F, 0xC6, 0x1B, 0x33, 0xDE, 0xE4, 0x9B, 0x26, 0xC9,
  0x96, 0xF7, 0xEC, 0x01, 0x84, 0x3F, 0x00, 0x1C, 0x1E, 0x0D, 0x86, 0xC3,
  0x63, 0xB1, 0xFC, 0xFE, 0x63, 0x71, 0xB8, 0xE0, 0xFD, 0xFF, 0x3E, 0x7F,
  0xDF, 0xB3, 0xE7, 0xCF, 0xFF, 0xF0, 0x18, 0xFF, 0xF7, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xC5, 0xF1, 0xE0, 0xFC, 0xFE, 0xCE, 0xC6, 0xC6, 0xC7, 0xC6,
  0xC6, 0xCE, 0xFC, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC7, 0xFE, 0xFF,
  0xF1, 0x8F, 0xFF, 0xF8, 0xC6, 0x30, 0x08, 0xFD, 0xFF, 0x0C, 0x19, 0xF3,
  0xE7, 0xC7, 0xCD, 0xF9, 0xF0, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFE, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0xC7, 0xCE, 0xDC, 0xDC, 0xF8, 0xF8,
  0xFC, 0xCC, 0xCE, 0xCE, 0xC7, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE,
  0xF1, 0xFE, 0x3F, 0xCF, 0xF9, 0xFD, 0xBF, 0xB7, 0xF7, 0xBE, 0xF7, 0xCE,
  0xF9, 0xDF, 0x33, 0x80, 0xE3, 0xF3, 0xF3, 0xFB, 0xDB, 0xDB, 0xCF, 0xCF,
  0xCF, 0xC7, 0xC7, 0x18, 0x7E, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xE7, 0x7E, 0x3C, 0xFD, 0xFB, 0x3E, 0x7C, 0xDF, 0xBE, 0x60, 0xC1, 0x83,
  0x00, 0x18, 0x7E, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0x7E,
  0x3C, 0x0E, 0x06, 0x07, 0xFD, 0xFB, 0x3E, 0x7C, 0xDF, 0xBE, 0x6E, 0xCD,
  0x9F, 0x18, 0x18, 0xFD, 0xF3, 0x06, 0x0F, 0x0F, 0x0E, 0x0F, 0x1B, 0xF3,
  0xC0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xFD, 0xF0, 0xE3, 0xF1, 0x99,
  0xCC, 0xE6, 0x63, 0xB0, 0xD8, 0x78, 0x3C, 0x1E, 0x07, 0x00, 0xC6, 0x3F,
  0x39, 0xB9, 0xCC, 0xDE, 0xE6, 0xF7, 0x36, 0xB1, 0xB7, 0x8F, 0xBC, 0x39,
  0xE1, 0xCF, 0x0E, 0x70, 0xE7, 0x6E, 0x7C, 0x3C, 0x3C, 0x38, 0x3C, 0x3C,
  0x7E, 0x66, 0xE7, 0xE7, 0x66, 0x7E, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xFF, 0xF8,
  0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0xC1, 0x83, 0x03,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3F, 0xF0, 0x18, 0x1C, 0x3C, 0x36, 0x66, 0x63, 0xC3, 0xFF, 0xFC,
  0xE7, 0x3C, 0xFD, 0x38, 0x77, 0xED, 0xFB, 0xBF, 0x76, 0xC1, 0x83, 0x06,
  0xCF, 0xD9, 0xB3, 0xE7, 0xCF, 0x9B, 0xF6, 0xE0, 0x7F, 0xF3, 0x8C, 0x63,
  0x3F, 0x78, 0x0C, 0x30, 0xDB, 0xFF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDF, 0x7B,
  0xEC, 0xF3, 0xFF, 0x0C, 0x3F, 0x7C, 0x3B, 0xD8, 0xFF, 0xB1, 0x8C, 0x63,
  0x18, 0xC0, 0x6F, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x38, 0xFF, 0x70,
  0xC3, 0x0C, 0x36, 0xFF, 0xBC, 0xF3, 0xCF, 0x3C, 0xF3, 0xF3, 0xFF, 0xFF,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC1, 0x83, 0x06, 0x7C,
  0xDB, 0x3E, 0x7C, 0xF9, 0xBB, 0x36, 0x70, 0xFF, 0xFF, 0xFF, 0xD9, 0xFF,
  0xFE, 0xEF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xC0, 0xDB, 0xFE,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x78,
  0xD9, 0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0x7E, 0xDD, 0x83, 0x06, 0x0C, 0x00,
  0x6F, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x30, 0xC3, 0x0C, 0xDF, 0xFD,
  0x8C, 0x63, 0x18, 0xC0, 0x7D, 0xEE, 0x5C, 0x78, 0x79, 0xFF, 0xF8, 0x23,
  0x1F, 0xF6, 0x31, 0x8C, 0x63, 0xCE, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0x7C, 0xE7, 0xCD, 0x9B, 0x66, 0xC7, 0x8F, 0x1C, 0x38, 0xCE, 0x7D, 0xCD,
  0xBB, 0xB5, 0xE6, 0xBC, 0xF7, 0x9E, 0xF1, 0xDE, 0x39, 0x80, 0xEE, 0xD9,
  0xF1, 0xE3, 0x87, 0x1B, 0x36, 0xEE, 0xE7, 0xCD, 0xBB, 0x67, 0xC7, 0x8F,
  0x1C, 0x18, 0x70, 0xE3, 0x86, 0x00, 0xFF, 0xF1, 0x8E, 0x31, 0xC6, 0x3F,
  0xFC, 0x09, 0xCC, 0x63, 0x19, 0xDC, 0xF1, 0x8C, 0x63, 0x1C, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xC7, 0x0C, 0x30, 0xC3, 0x87, 0x38, 0xC3, 0x0C,
  0x73, 0xCC, 0x00, 0x73, 0xFE, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 6, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 13, 8, 1, -12 },
  { 28, 12, 12, 13, 0, -12 },
  { 46, 10, 12, 10, 0, -12 },
  { 61, 2, 4, 4, 1, -11 },
  { 62, 4, 15, 5, 1, -12 },
  { 70, 4, 15, 5, 0, -12 },
  { 78, 7, 7, 7, 0, -12 },
  { 85, 7, 8, 8, 0, -10 },
  { 92, 3, 4, 4, 0, -2 },
  { 94, 5, 2, 5, 0, -5 },
  { 96, 2, 3, 4, 1, -3 },
  { 97, 7, 12, 7, 0, -12 },
  { 108, 6, 12, 8, 1, -12 },
  { 117, 5, 11, 8, 1, -11 },
  { 124, 7, 12, 8, 0, -12 },
  { 135, 7, 12, 8, 0, -12 },
  { 146, 7, 11, 8, 0, -11 },
  { 156, 6, 11, 8, 1, -11 },
  { 165, 7, 12, 8, 0, -12 },
  { 176, 7, 11, 8, 0, -11 },
  { 186, 7, 12, 8, 0, -12 },
  { 197, 7, 12, 8, 0, -12 },
  { 208, 2, 9, 4, 1, -9 },
  { 211, 2, 11, 4, 1, -9 },
  { 214, 7, 8, 8, 0, -10 },
  { 221, 7, 5, 8, 0, -8 },
  { 226, 7, 8, 8, 0, -10 },
  { 233, 6, 12, 6, 0, -12 },
  { 242, 10, 13, 12, 1, -12 },
  { 259, 9, 11, 9, 0, -11 },
  { 272, 7, 11, 9, 1, -11 },
  { 282, 7, 12, 8, 1, -12 },
  { 293, 8, 11, 9, 1, -11 },
  { 304, 5, 11, 7, 1, -11 },
  { 311, 5, 11, 7, 1, -11 },
  { 318, 7, 12, 9, 1, -12 },
  { 329, 8, 11, 10, 1, -11 },
  { 340, 5, 11, 5, 0, -11 },
  { 347, 4, 14, 5, -1, -11 },
  { 354, 8, 11, 9, 1, -11 },
  { 365, 5, 11, 7, 1, -11 },
  { 372, 11, 11, 13, 1, -11 },
  { 388, 8, 11, 10, 1, -11 },
  { 399, 8, 12, 10, 1, -12 },
  { 411, 7, 11, 8, 1, -11 },
  { 421, 8, 15, 10, 1, -12 },
  { 436, 7, 11, 8, 1, -11 },
  { 446, 7, 12, 7, 0, -12 },
  { 457, 7, 11, 7, 0, -11 },
  { 467, 7, 11, 9, 1, -11 },
  { 477, 9, 11, 9, 0, -11 },
  { 490, 13, 11, 12, 0, -11 },
  { 508, 8, 11, 8, 0, -11 },
  { 519, 8, 11, 8, 0, -11 },
  { 530, 7, 11, 7, 0, -11 },
  { 540, 4, 15, 5, 1, -12 },
  { 548, 7, 12, 7, 0, -12 },
  { 559, 4, 15, 5, 0, -12 },
  { 567, 8, 7, 9, 0, -11 },
  { 574, 7, 2, 7, 0, 1 },
  { 576, 4, 2, 5, 1, -12 },
  { 577, 7, 9, 8, 0, -9 },
  { 585, 7, 12, 8, 1, -12 },
  { 596, 5, 9, 7, 1, -9 },
  { 602, 6, 12, 8, 1, -12 },
  { 611, 6, 9, 8, 1, -9 },
  { 618, 5, 12, 5, 0, -12 },
  { 626, 6, 13, 8, 1, -9 },
  { 636, 6, 12, 8, 1, -12 },
  { 645, 2, 12, 4, 1, -12 },
  { 648, 4, 16, 4, -1, -12 },
  { 656, 7, 12, 8, 1, -12 },
  { 667, 2, 12, 4, 1, -12 },
  { 670, 10, 9, 12, 1, -9 },
  { 682, 6, 9, 8, 1, -9 },
  { 689, 6, 9, 8, 1, -9 },
  { 696, 7, 13, 8, 1, -9 },
  { 708, 6, 13, 8, 1, -9 },
  { 718, 5, 9, 6, 1, -9 },
  { 724, 6, 9, 6, 0, -9 },
  { 731, 5, 11, 5, 0, -11 },
  { 738, 6, 9, 8, 1, -9 },
  { 745, 7, 9, 7, 0, -9 },
  { 753, 11, 9, 11, 0, -9 },
  { 766, 7, 9, 7, 0, -9 },
  { 774, 7, 13, 7, 0, -9 },
  { 786, 6, 9, 6, 0, -9 },
  { 793, 5, 15, 6, 0, -12 },
  { 803, 2, 16, 7, 2, -12 },
  { 807, 6, 15, 6, 0, -12 },
  { 819, 7, 3, 8, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD16PT7B_H_
