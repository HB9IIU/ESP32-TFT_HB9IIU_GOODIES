#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFC, 0x7F, 0x03, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFE,
  0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFC, 0xF0, 0xE3, 0xFC, 0x78, 0x11,
  0xFE, 0x3C, 0x00, 0xFF, 0x1E, 0x00, 0x7F, 0x8F, 0x00, 0x3F, 0xE7, 0x80,
  0x1F, 0xFB, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0xFF, 0x80, 0x0F, 0x3F, 0xC0,
  0x07, 0x9F, 0xF0, 0x03, 0xCF, 0xFC, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0xFB,
  0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE,
  0x1F, 0xE3, 0xF8, 0x1F, 0x80, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xE0, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFF, 0xF0, 0x7F, 0x3F, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xE3, 0xFD, 0xFC, 0x1F, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x0F,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF9, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0xEF,
  0xFC, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x08,
  0x0F, 0xE0, 0x21, 0xC1, 0xFC, 0x1E, 0x3F, 0x3F, 0x9F, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0xBF, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x07, 0xF8,
  0x07, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8,
  0x7F, 0xE7, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x03,
  0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF,
  0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xEF, 0xF1, 0xFF, 0x3F, 0x0F, 0xF8, 0xF0,
  0x7F, 0xC3, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0x87, 0xFF, 0x0F, 0x80, 0x7F, 0xE1,
  0xC0, 0x1F, 0xF8, 0x60, 0x07, 0xFE, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0x03, 0xFF, 0x87, 0x00, 0x7F, 0xE1, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xBF, 0xE0, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xCF, 0xF8, 0x00,
  0xFE, 0x7F, 0xC0, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0x1F, 0xF0, 0x07, 0xF0,
  0xFF, 0x80, 0x3F, 0x87, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xC1, 0xFF,
  0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xFE, 0x07,
  0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC4, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x08,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xEC, 0x00, 0x3F,
  0xF7, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF1, 0xFF, 0x83, 0xFE, 0x7F, 0xF8,
  0x7F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xDF, 0xFC, 0x1F, 0xFB,
  0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x0F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF3, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0xBF, 0xF0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x80,
  0xFF, 0xBF, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3,
  0xFF, 0x9F, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFD, 0xFF, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x02, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x83,
  0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xF8, 0xFE, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0x1F, 0xC0, 0xE0, 0x03, 0x01, 0xFC, 0x3F,
  0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x1F,
  0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0x07, 0xFE, 0x1C, 0x03, 0xFF, 0x10, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xC3, 0xF8, 0x3F, 0x80,
  0xFF, 0xFE, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xC7, 0xF1, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7E, 0x3F, 0x83, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0x0F, 0xE1,
  0xFD, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xBF, 0x87, 0xF8, 0x3F, 0x87, 0xF7,
  0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xDF, 0x83,
  0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFE, 0x1F, 0xC0,
  0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x03, 0xF8,
  0x3F, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x83, 0xF3, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF1, 0xFF, 0x1F, 0x8F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0x7F, 0xFC, 0x3F, 0x81, 0xFF, 0xE7,
  0xFF, 0x83, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0x87, 0xFF, 0x80, 0x70,
  0xFF, 0xE0, 0x02, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0C, 0x7F, 0xFC, 0x0F, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01,
  0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01,
  0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xF0, 0xFF, 0xF8,
  0x00, 0xC3, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xCF,
  0xFC, 0x01, 0xFF, 0x3F, 0xF8, 0x07, 0xFC, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x7F,
  0xE7, 0xFE, 0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F,
  0xFF, 0xEF, 0xF0, 0x1F, 0xDF, 0xFF, 0xFB, 0xFC, 0x0F, 0xF7, 0xFF, 0xFE,
  0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8,
  0x7F, 0x9F, 0xFF, 0xF9, 0xFE, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0x87, 0xF9,
  0xFF, 0xFF, 0x8F, 0xF1, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xCF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFB, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF,
  0xEF, 0xF8, 0x3F, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF,
  0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xBF,
  0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x03,
  0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xE0, 0x3C, 0xFF, 0xC0,
  0x0C, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x3F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xF7, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC1, 0xFD, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x7F, 0x87,
  0xFC, 0x03, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x00, 0xFF, 0x8F, 0xF3, 0xF8,
  0xFF, 0xC0, 0x3F, 0xE3, 0xFC, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x3F,
  0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0x8F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xE3,
  0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x7F, 0x3F, 0xE0, 0x07, 0xFD, 0xFE,
  0x1F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0x87, 0xF7, 0xFC, 0x00, 0x7F, 0xDF,
  0xE1, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0xC0, 0x03, 0xFD,
  0xFC, 0x0F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xDF, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x01, 0xFF, 0x82, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x9F, 0xFF,
  0x1F, 0xC7, 0xFF, 0x0F, 0xE1, 0xFF, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0x00,
  0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x0F, 0xFB,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF,
  0x8F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFB, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x78, 0xFF, 0xE0, 0x11, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x13,
  0xFF, 0x80, 0x63, 0xFF, 0xC7, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x01, 0xF0, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF9, 0xFF, 0x0F,
  0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF,
  0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xDF, 0xF0, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xEF,
  0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xBF, 0xC3, 0xFF, 0xE7, 0xF8, 0x3F, 0xF8, 0xFF, 0x03,
  0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFF, 0x9F,
  0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x04, 0x3F, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFC, 0x20, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x1F,
  0xFC, 0x7F, 0x87, 0xFF, 0xCF, 0xF1, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xEF, 0xFC,
  0x1F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF,
  0xF0, 0x7F, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xE1, 0xFF, 0xF7, 0xFC, 0x1F,
  0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE4, 0x00,
  0x0F, 0xF8, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF3, 0xFF, 0x07,
  0xFC, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x1F, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF8, 0x3F, 0xF7, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC,
  0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8,
  0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE7, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8,
  0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0x9F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFB, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xDF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xE1, 0xFF, 0x83,
  0xFC, 0x7F, 0xF8, 0x7F, 0x9F, 0xFF, 0x8F, 0xFB, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xDF,
  0xFC, 0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC,
  0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x0F, 0xFE, 0x0F, 0xF9, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF,
  0xCF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF,
  0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xF9, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF,
  0x0F, 0xF9, 0xFF, 0xF0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFC, 0x7F, 0x80, 0xFF,
  0xC0, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x1F,
  0xFC, 0x7F, 0x87, 0xFF, 0xCF, 0xF1, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xEF, 0xFC,
  0x1F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF,
  0xF0, 0x7F, 0xF7, 0xFF, 0xBF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xE1, 0xFF, 0xF7, 0xFC, 0x1F,
  0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x7E, 0xFF, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0x3F, 0xEF, 0xFB, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x2F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0x81, 0xE7, 0xFC, 0x02, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x2E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0x1F, 0xFC, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0x87, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0x1F, 0xE1, 0xFF, 0xE3, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFB, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFD, 0xF8, 0x3F, 0xE1, 0xFF, 0x07,
  0xEF, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0x7F, 0x0F, 0xF8, 0x3F, 0xE3, 0xFB,
  0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xDF, 0xC7, 0xFC, 0x0F, 0xF8, 0xFE, 0x7E,
  0x3F, 0xE0, 0x7F, 0xC7, 0xE3, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0x1F, 0xCF,
  0xF0, 0x0F, 0xFB, 0xF8, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xC7, 0xF7, 0xFC,
  0x03, 0xFE, 0xFE, 0x3F, 0xBF, 0xE0, 0x0F, 0xF7, 0xF0, 0xFD, 0xFF, 0x00,
  0x7F, 0xBF, 0x07, 0xEF, 0xF0, 0x03, 0xFD, 0xF8, 0x3F, 0x7F, 0x80, 0x1F,
  0xEF, 0xC1, 0xFB, 0xFC, 0x00, 0xFF, 0x7E, 0x0F, 0xDF, 0xE0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x9F, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF,
  0x9F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFE,
  0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x27,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xD0, 0x00, 0xFF, 0xF2, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 47, 17, 3, -46 },
  { 66, 24, 17, 30, 3, -46 },
  { 117, 32, 46, 33, 1, -46 },
  { 301, 25, 53, 31, 3, -49 },
  { 467, 48, 47, 51, 2, -46 },
  { 749, 37, 47, 38, 1, -46 },
  { 967, 10, 17, 16, 3, -46 },
  { 989, 17, 56, 20, 3, -46 },
  { 1108, 17, 56, 20, 1, -46 },
  { 1227, 27, 27, 29, 1, -49 },
  { 1319, 27, 31, 31, 2, -38 },
  { 1424, 12, 17, 17, 2, -8 },
  { 1450, 16, 9, 20, 2, -22 },
  { 1468, 11, 11, 17, 3, -10 },
  { 1484, 26, 47, 27, 0, -46 },
  { 1637, 26, 47, 31, 2, -46 },
  { 1790, 21, 46, 31, 3, -46 },
  { 1911, 26, 46, 31, 2, -46 },
  { 2061, 26, 47, 31, 2, -46 },
  { 2214, 29, 46, 31, 1, -46 },
  { 2381, 25, 47, 31, 3, -46 },
  { 2528, 27, 47, 31, 2, -46 },
  { 2687, 26, 46, 31, 2, -46 },
  { 2837, 27, 47, 31, 2, -46 },
  { 2996, 26, 47, 31, 2, -46 },
  { 3149, 11, 37, 17, 3, -36 },
  { 3200, 12, 45, 17, 2, -36 },
  { 3268, 27, 32, 31, 2, -39 },
  { 3376, 27, 21, 31, 2, -33 },
  { 3447, 27, 32, 31, 2, -39 },
  { 3555, 24, 47, 25, 0, -46 },
  { 3696, 43, 51, 48, 2, -46 },
  { 3971, 35, 46, 35, 0, -46 },
  { 4173, 28, 46, 35, 4, -46 },
  { 4334, 27, 47, 32, 3, -46 },
  { 4493, 30, 46, 37, 4, -46 },
  { 4666, 21, 46, 28, 4, -46 },
  { 4787, 21, 46, 28, 4, -46 },
  { 4908, 30, 47, 37, 3, -46 },
  { 5085, 30, 46, 38, 4, -46 },
  { 5258, 18, 46, 21, 2, -46 },
  { 5362, 18, 60, 18, -4, -46 },
  { 5497, 31, 46, 34, 4, -46 },
  { 5676, 22, 46, 27, 4, -46 },
  { 5803, 42, 46, 50, 4, -46 },
  { 6045, 33, 46, 41, 4, -46 },
  { 6235, 33, 47, 39, 3, -46 },
  { 6429, 26, 46, 32, 4, -46 },
  { 6579, 33, 57, 39, 3, -46 },
  { 6815, 30, 46, 34, 4, -46 },
  { 6988, 24, 47, 28, 2, -46 },
  { 7129, 26, 46, 28, 1, -46 },
  { 7279, 29, 47, 37, 4, -46 },
  { 7450, 34, 46, 34, 0, -46 },
  { 7646, 50, 46, 50, 0, -46 },
  { 7934, 32, 46, 32, 0, -46 },
  { 8118, 32, 46, 32, 0, -46 },
  { 8302, 26, 46, 28, 1, -46 },
  { 8452, 15, 56, 20, 3, -46 },
  { 8557, 26, 47, 27, 0, -46 },
  { 8710, 16, 56, 20, 1, -46 },
  { 8822, 32, 29, 34, 1, -46 },
  { 8938, 29, 6, 29, 0, 5 },
  { 8960, 15, 10, 21, 3, -49 },
  { 8979, 25, 37, 31, 2, -36 },
  { 9095, 28, 50, 33, 3, -49 },
  { 9270, 23, 37, 27, 2, -36 },
  { 9377, 27, 50, 33, 2, -49 },
  { 9546, 26, 37, 30, 2, -36 },
  { 9667, 21, 49, 20, 1, -49 },
  { 9796, 27, 51, 33, 2, -36 },
  { 9969, 27, 49, 33, 3, -49 },
  { 10135, 10, 49, 16, 3, -49 },
  { 10197, 15, 64, 16, -2, -49 },
  { 10317, 28, 49, 32, 4, -49 },
  { 10489, 10, 49, 16, 3, -49 },
  { 10551, 43, 36, 49, 3, -36 },
  { 10745, 27, 36, 33, 3, -36 },
  { 10867, 28, 37, 32, 2, -36 },
  { 10997, 28, 51, 33, 3, -36 },
  { 11176, 27, 51, 33, 2, -36 },
  { 11349, 20, 36, 23, 3, -36 },
  { 11439, 21, 37, 25, 2, -36 },
  { 11537, 20, 43, 22, 1, -42 },
  { 11645, 27, 36, 33, 3, -35 },
  { 11767, 30, 35, 30, 0, -35 },
  { 11899, 45, 35, 45, 0, -35 },
  { 12096, 28, 35, 29, 0, -35 },
  { 12219, 30, 50, 30, 0, -35 },
  { 12407, 22, 35, 24, 1, -35 },
  { 12504, 20, 56, 23, 1, -46 },
  { 12644, 8, 64, 28, 10, -49 },
  { 12708, 20, 56, 23, 2, -46 },
  { 12848, 27, 11, 31, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD64PT7B_H_
