#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF,
  0x87, 0xEF, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC1, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xB9, 0xEF, 0xCE, 0x13, 0xF3, 0x80, 0xFC,
  0xE0, 0x3F, 0xB8, 0x07, 0xEE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xBF, 0x00, 0xEF, 0xC0, 0x39, 0xF8, 0x0E, 0x7F, 0x83, 0xBF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFE,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0xF9, 0xF8,
  0x1F, 0x00, 0x1F, 0x1F, 0x03, 0xE0, 0x07, 0xE3, 0xE0, 0xF8, 0x00, 0xFC,
  0x7C, 0x1F, 0x00, 0x1F, 0x8F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0xF8, 0x00,
  0x7E, 0x3E, 0x1F, 0x00, 0x0F, 0xC7, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0xF8,
  0x38, 0x1F, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xE7, 0xC7, 0xFC, 0x7F, 0xF8,
  0xF9, 0xFF, 0xC7, 0xFF, 0x3E, 0x7F, 0xF8, 0xFF, 0xC7, 0xCF, 0xDF, 0x8F,
  0xF1, 0xF1, 0xF1, 0xF0, 0x7C, 0x3E, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC7,
  0xC0, 0x01, 0xF1, 0xF8, 0xF8, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x0F, 0x87,
  0xE3, 0xE0, 0x01, 0xF0, 0xFC, 0x7C, 0x00, 0x3E, 0x0F, 0x8F, 0x80, 0x0F,
  0x81, 0xF1, 0xF0, 0x01, 0xF0, 0x3E, 0x3E, 0x00, 0x7C, 0x07, 0xEF, 0xC0,
  0x0F, 0x80, 0x7F, 0xF0, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0x9F,
  0xC7, 0xF7, 0xFB, 0xF9, 0xFE, 0x7F, 0xFF, 0x3F, 0x87, 0xFF, 0xC7, 0xF0,
  0xFF, 0xF8, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0xC0, 0xFF, 0xC7, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0,
  0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x07, 0x1F, 0x0E, 0x7D, 0xF7, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xBF, 0x03, 0xF9, 0xF8, 0x7F, 0x1F, 0xC1, 0xF0, 0xF8, 0x0E,
  0x0E, 0x00, 0x20, 0x40, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E,
  0x3F, 0x1F, 0x9F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xCF, 0xE3, 0xF8, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x07, 0xEF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0xFE, 0x1F, 0xDF, 0xC3, 0xF9, 0xF8,
  0x7F, 0x3F, 0x8F, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x8F, 0xF1, 0xC0, 0xFF, 0x10, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3C, 0x1F, 0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x80, 0x0F, 0xEE, 0x01, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0x7D, 0xFC, 0x07, 0xCF,
  0xE0, 0x3E, 0x7F, 0x03, 0xE3, 0xF8, 0x1F, 0x1F, 0xC1, 0xF0, 0xFE, 0x1F,
  0x87, 0xF0, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7C, 0x0F, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0x8F,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x3E, 0x07, 0xE7, 0xF8, 0x7E, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF3, 0xF8, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xE7,
  0xF0, 0x7E, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0xDF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x0F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0xFE, 0x7E, 0x01, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x31, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x1F, 0x1F, 0xCF, 0xEF, 0xF3, 0xF9,
  0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x9F,
  0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xF0, 0xFE, 0x60, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xF8, 0xF9, 0xF8, 0x7F,
  0xF9, 0xF3, 0xE1, 0xFF, 0xF1, 0xF7, 0xC3, 0xFF, 0xE3, 0xFF, 0x0F, 0xC7,
  0xC7, 0xFE, 0x1F, 0x0F, 0x8F, 0xFC, 0x7E, 0x1F, 0x1F, 0xF8, 0xF8, 0x7E,
  0x3F, 0xF1, 0xF0, 0xF8, 0x7F, 0xE3, 0xE1, 0xF0, 0xFF, 0xC7, 0xC3, 0xE1,
  0xFF, 0x8F, 0x87, 0xC3, 0xFF, 0x1F, 0x0F, 0x87, 0xFE, 0x3E, 0x1F, 0x0F,
  0x7C, 0x7E, 0x7E, 0x3E, 0xF8, 0x7F, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xF3,
  0xF0, 0xFF, 0x3F, 0xC3, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x70, 0x18, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x40, 0x1F,
  0xE0, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F,
  0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF, 0xC1, 0xFE, 0xFE,
  0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE,
  0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x7F, 0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xE1, 0xE3, 0xFC, 0x04, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x23, 0xFE, 0x06, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x1F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F,
  0x8F, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFC, 0x1E, 0x1F, 0xF0, 0x04, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07,
  0xF9, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x9F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF,
  0x81, 0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE1, 0xFE, 0x3F, 0x87,
  0xF8, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0,
  0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFD, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF7, 0xC0, 0x7F, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0xDF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xDF, 0xFF, 0xBE, 0x0F, 0xBF, 0xFF, 0x7E, 0x3F, 0x7F, 0xFE,
  0xFC, 0x7E, 0xFF, 0xFD, 0xF8, 0xF9, 0xFF, 0xF9, 0xF3, 0xF3, 0xFF, 0xF3,
  0xF7, 0xE7, 0xFF, 0xE7, 0xEF, 0xCF, 0xFF, 0xCF, 0xDF, 0x1F, 0xFF, 0x8F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFC, 0x7F,
  0xE1, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xE1, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC0, 0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x7F,
  0xFD, 0xFC, 0x7F, 0xFC, 0xFC, 0x7F, 0xFE, 0xFE, 0x3F, 0xFE, 0xFE, 0x3F,
  0xFE, 0x7F, 0x3F, 0xFE, 0x7F, 0x3F, 0xFE, 0x3F, 0x3F, 0xFE, 0x3F, 0xBF,
  0xFE, 0x1F, 0xBF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF8, 0x03, 0xFB,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x7F,
  0x9F, 0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F,
  0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x87,
  0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xEF, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0xBF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF,
  0x3F, 0x81, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFC, 0x0E, 0x7F, 0x00, 0x9F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xF8, 0x0F, 0xEF, 0xE0,
  0x1F, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF0, 0x1F,
  0xCF, 0xE0, 0x7F, 0xC1, 0xFC, 0x7F, 0x03, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0xF0, 0x7F, 0x0F, 0xC1, 0xFF, 0x83, 0xF8, 0x7F, 0x0F, 0xFC, 0x1F, 0xC3,
  0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0xC3, 0xEF, 0x8F, 0xE0, 0xFE, 0x3F, 0x7C,
  0x7F, 0x03, 0xF1, 0xFB, 0xE3, 0xF8, 0x1F, 0x8F, 0xDF, 0x1F, 0xC0, 0xFE,
  0x7C, 0xF8, 0xFC, 0x07, 0xF3, 0xE7, 0xEF, 0xE0, 0x3F, 0xBF, 0x3F, 0x7F,
  0x00, 0xFD, 0xF8, 0xFB, 0xF8, 0x07, 0xEF, 0xC7, 0xDF, 0xC0, 0x3F, 0x7E,
  0x3E, 0xFC, 0x01, 0xFB, 0xE1, 0xF7, 0xE0, 0x0F, 0xFF, 0x0F, 0xBF, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF9,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x83, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x83, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x9F, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1E, 0x3F, 0xC2, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xF3, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xF1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xBF, 0x3F,
  0xE3, 0xE3, 0xF8, 0x7C, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x0F, 0xE7, 0xF8, 0xFE, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xC7, 0xF0, 0x03, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0x02,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x03, 0x7F, 0xCF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x0F, 0xC7, 0xF1, 0xFE, 0x7F, 0x3F, 0xF7, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0xBF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xF3, 0xF0, 0xFE, 0x3F, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0xBF, 0x83,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x47, 0xF8, 0x38, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC3,
  0xF1, 0xFE, 0x7F, 0x3F, 0xF7, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0xBF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x7F, 0x1F, 0xF7,
  0xF0, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE8, 0x00,
  0xFE, 0x60, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x0F, 0xEF,
  0xF8, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xFD, 0xF8, 0x1F, 0xEF, 0xC0, 0xFE, 0x7E, 0x0F,
  0xE3, 0xF0, 0xFF, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F,
  0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xC1, 0xFC,
  0xFF, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xFC,
  0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0xFF, 0xCF, 0xF8, 0xFD, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF8, 0xFE, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7F, 0xFC, 0x3F, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x9F,
  0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF8, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFD, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xEF,
  0xFC, 0xFE, 0x7F, 0x8F, 0xE3, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC3,
  0xF1, 0xFE, 0x7F, 0x3F, 0xF7, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0xBF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x7F, 0x1F, 0xE7,
  0xF0, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xF8, 0x7F, 0xE3, 0xEF, 0x9F,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xE0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0x1C, 0xFE, 0x04, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xDC, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xBF, 0x07, 0xFC, 0x1F, 0xDF, 0x83, 0xFE,
  0x0F, 0xCF, 0xE1, 0xFF, 0x07, 0xE7, 0xF0, 0xFF, 0x87, 0xF3, 0xF8, 0x7F,
  0xC3, 0xF8, 0xFC, 0x3D, 0xF1, 0xFC, 0x7E, 0x3E, 0xF8, 0xFC, 0x3F, 0x9F,
  0x7C, 0x7E, 0x1F, 0xCF, 0xBE, 0x7F, 0x0F, 0xE7, 0xDF, 0x3F, 0x83, 0xF3,
  0xEF, 0x9F, 0x81, 0xF9, 0xE3, 0xEF, 0xC0, 0xFD, 0xF1, 0xF7, 0xE0, 0x7E,
  0xF8, 0xFB, 0xF0, 0x1F, 0xFC, 0x7D, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07,
  0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x8F, 0xE1, 0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xC0, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7F,
  0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x13, 0xFE, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x03,
  0xFE, 0x80, 0x01, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 35, 12, 2, -34 },
  { 36, 18, 13, 22, 2, -34 },
  { 66, 23, 34, 25, 1, -34 },
  { 164, 18, 39, 23, 2, -36 },
  { 252, 35, 34, 38, 1, -34 },
  { 401, 27, 34, 28, 1, -34 },
  { 516, 7, 13, 11, 2, -34 },
  { 528, 13, 41, 15, 2, -34 },
  { 595, 13, 41, 15, 0, -34 },
  { 662, 20, 20, 22, 1, -36 },
  { 712, 20, 23, 23, 1, -28 },
  { 770, 9, 12, 12, 1, -6 },
  { 784, 12, 7, 15, 1, -16 },
  { 795, 8, 9, 12, 2, -8 },
  { 804, 19, 34, 19, 0, -34 },
  { 885, 19, 34, 22, 2, -34 },
  { 966, 16, 34, 22, 2, -34 },
  { 1034, 19, 34, 22, 1, -34 },
  { 1115, 20, 34, 22, 1, -34 },
  { 1200, 21, 34, 22, 1, -34 },
  { 1290, 18, 34, 22, 2, -34 },
  { 1367, 20, 34, 22, 1, -34 },
  { 1452, 20, 34, 22, 1, -34 },
  { 1537, 20, 34, 22, 1, -34 },
  { 1622, 20, 34, 22, 1, -34 },
  { 1707, 8, 27, 13, 2, -26 },
  { 1734, 9, 32, 13, 1, -26 },
  { 1770, 20, 23, 23, 1, -28 },
  { 1828, 20, 15, 23, 1, -24 },
  { 1866, 20, 23, 23, 1, -28 },
  { 1924, 17, 35, 18, 0, -34 },
  { 1999, 31, 38, 35, 2, -34 },
  { 2147, 26, 34, 26, 0, -34 },
  { 2258, 21, 34, 25, 3, -34 },
  { 2348, 20, 34, 23, 2, -34 },
  { 2433, 22, 34, 27, 3, -34 },
  { 2527, 16, 34, 21, 3, -34 },
  { 2595, 15, 34, 20, 3, -34 },
  { 2659, 23, 34, 27, 2, -34 },
  { 2757, 22, 34, 28, 3, -34 },
  { 2851, 13, 34, 16, 1, -34 },
  { 2907, 13, 44, 13, -3, -34 },
  { 2979, 22, 34, 25, 3, -34 },
  { 3073, 16, 34, 20, 3, -34 },
  { 3141, 31, 34, 37, 3, -34 },
  { 3273, 24, 34, 30, 3, -34 },
  { 3375, 25, 34, 28, 2, -34 },
  { 3482, 19, 34, 24, 3, -34 },
  { 3563, 25, 42, 28, 2, -34 },
  { 3695, 22, 34, 25, 3, -34 },
  { 3789, 18, 34, 21, 1, -34 },
  { 3866, 19, 34, 21, 1, -34 },
  { 3947, 21, 34, 27, 3, -34 },
  { 4037, 25, 34, 25, 0, -34 },
  { 4144, 37, 34, 36, 0, -34 },
  { 4302, 23, 34, 23, 0, -34 },
  { 4400, 23, 34, 23, 0, -34 },
  { 4498, 19, 34, 21, 1, -34 },
  { 4579, 11, 42, 14, 2, -34 },
  { 4637, 19, 34, 19, 0, -34 },
  { 4718, 11, 42, 14, 1, -34 },
  { 4776, 23, 22, 25, 1, -34 },
  { 4840, 21, 4, 21, 0, 4 },
  { 4851, 11, 8, 15, 2, -36 },
  { 4862, 19, 26, 22, 1, -26 },
  { 4924, 20, 36, 24, 2, -36 },
  { 5014, 16, 26, 20, 2, -26 },
  { 5066, 20, 36, 24, 2, -36 },
  { 5156, 19, 26, 22, 2, -26 },
  { 5218, 16, 36, 15, 0, -36 },
  { 5290, 20, 37, 24, 2, -26 },
  { 5383, 20, 36, 24, 2, -36 },
  { 5473, 8, 36, 12, 2, -36 },
  { 5509, 12, 47, 12, -2, -36 },
  { 5580, 21, 36, 24, 3, -36 },
  { 5675, 7, 36, 12, 2, -36 },
  { 5707, 32, 26, 36, 2, -26 },
  { 5811, 20, 26, 24, 2, -26 },
  { 5876, 20, 26, 24, 2, -26 },
  { 5941, 20, 37, 24, 2, -26 },
  { 6034, 20, 37, 24, 2, -26 },
  { 6127, 14, 26, 17, 3, -26 },
  { 6173, 16, 26, 18, 1, -26 },
  { 6225, 15, 31, 16, 0, -31 },
  { 6284, 20, 26, 24, 2, -26 },
  { 6349, 22, 26, 22, 0, -26 },
  { 6421, 33, 26, 33, 0, -26 },
  { 6529, 21, 26, 21, 0, -26 },
  { 6598, 22, 37, 22, 0, -26 },
  { 6700, 16, 26, 18, 1, -26 },
  { 6752, 14, 42, 17, 1, -34 },
  { 6826, 6, 47, 20, 7, -36 },
  { 6862, 15, 42, 17, 1, -34 },
  { 6941, 20, 9, 23, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD47PT7B_H_
