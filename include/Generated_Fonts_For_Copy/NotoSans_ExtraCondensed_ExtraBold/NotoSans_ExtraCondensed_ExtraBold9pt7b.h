#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF5, 0x77, 0xD5, 0xE6, 0x30, 0x27, 0xC6, 0x3B, 0x62,
  0x41, 0x52, 0xA5, 0xB5, 0xA5, 0x49, 0x80, 0x23, 0x9C, 0xCF, 0xED, 0xE0,
  0xD0, 0x29, 0x6D, 0x93, 0x95, 0x57, 0x6F, 0x6F, 0x2F, 0x22, 0x70, 0xE0,
  0xC0, 0x12, 0x26, 0x44, 0x80, 0x27, 0xDD, 0xDD, 0x60, 0x7C, 0x92, 0x40,
  0x4F, 0x32, 0x64, 0xF0, 0x2F, 0x36, 0x33, 0xE0, 0x37, 0x7B, 0xF3, 0x74,
  0xF3, 0x3E, 0x27, 0xCF, 0xDD, 0x70, 0xF3, 0x22, 0x64, 0x2F, 0xD6, 0xFD,
  0x70, 0x2F, 0xDF, 0x53, 0x60, 0xD0, 0xC0, 0xD0, 0x70, 0x3C, 0x61, 0xF0,
  0xF0, 0xC3, 0x68, 0x5C, 0xB4, 0x10, 0x11, 0xB5, 0xEB, 0xAE, 0xF4, 0x4E,
  0x72, 0x94, 0xEF, 0xEC, 0xEA, 0xEA, 0xBE, 0x27, 0x4C, 0xC4, 0x70, 0xEB,
  0xBB, 0xAE, 0xF3, 0x49, 0xC0, 0xF3, 0x49, 0x00, 0x13, 0xD1, 0xBD, 0xAD,
  0xE0, 0xBB, 0xFB, 0xBB, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x5E, 0xBE, 0xCE,
  0xAB, 0x92, 0x49, 0xC0, 0xDF, 0x7D, 0xF7, 0xAE, 0xB0, 0xDD, 0xDB, 0xBB,
  0x23, 0xF3, 0x9C, 0xAD, 0xC0, 0xF6, 0xE9, 0x00, 0x23, 0xF3, 0x9C, 0xAD,
  0xC2, 0x18, 0xEA, 0xEE, 0xAB, 0x2F, 0xC6, 0x3B, 0xE0, 0xF6, 0x66, 0x66,
  0xBB, 0xBB, 0xBE, 0xDE, 0x94, 0xA7, 0x30, 0x93, 0xAD, 0xB3, 0x66, 0xCD,
  0x80, 0xD6, 0x66, 0x7D, 0xD7, 0x62, 0x22, 0xF2, 0x64, 0xCF, 0xFB, 0x6D,
  0xB7, 0x8C, 0x44, 0x22, 0x30, 0xD5, 0x57, 0x23, 0x95, 0x30, 0xF0, 0xC4,
  0x71, 0x7F, 0xF0, 0xCC, 0xFD, 0xDD, 0xF0, 0x7C, 0xCC, 0x60, 0x11, 0x7D,
  0xDD, 0x70, 0x6D, 0xFC, 0x70, 0x6B, 0xA4, 0x90, 0x7D, 0xDD, 0x71, 0x70,
  0xCC, 0xFD, 0xDD, 0xD0, 0xDF, 0xFC, 0xDF, 0xFF, 0xC0, 0xC6, 0x35, 0xEE,
  0x7B, 0x60, 0xFF, 0xFC, 0xFF, 0x5D, 0x75, 0xD4, 0xFD, 0xDD, 0xD0, 0x7D,
  0xDD, 0x70, 0xFD, 0xDD, 0xFC, 0xC0, 0x7D, 0xDD, 0x71, 0x10, 0xFB, 0x6C,
  0x79, 0x9E, 0x5D, 0x24, 0xC0, 0xDD, 0xDD, 0x70, 0x9F, 0x66, 0x60, 0xB7,
  0xD7, 0x5B, 0x68, 0xF6, 0x66, 0xF0, 0x9F, 0x66, 0x66, 0xC0, 0xE5, 0x2E,
  0x69, 0x44, 0x98, 0xFF, 0xFF, 0xC0, 0xC9, 0x14, 0xB0, 0xFB,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 7, 7, 7, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 2, 2, 2, 0, -6 },
  { 25, 3, 8, 3, 0, -7 },
  { 28, 2, 8, 3, 0, -7 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 4, 4, 0, -5 },
  { 34, 2, 2, 2, 0, -1 },
  { 35, 3, 1, 3, 0, -3 },
  { 36, 2, 1, 2, 0, -1 },
  { 37, 4, 7, 4, 0, -7 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 6, 4, 0, -6 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 4, 7, 4, 0, -7 },
  { 77, 2, 5, 2, 0, -5 },
  { 79, 2, 6, 2, 0, -5 },
  { 81, 4, 4, 4, 0, -5 },
  { 83, 4, 3, 4, 0, -5 },
  { 85, 4, 4, 4, 0, -5 },
  { 87, 3, 7, 3, 0, -7 },
  { 90, 6, 8, 7, 0, -7 },
  { 96, 5, 6, 5, 0, -6 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 4, 7, 4, 0, -7 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 3, 6, 4, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 3, 8, 3, -1, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 3, 6, 4, 1, -6 },
  { 136, 6, 6, 7, 1, -6 },
  { 141, 4, 6, 6, 1, -6 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 3, 6, 5, 1, -6 },
  { 152, 5, 9, 5, 0, -7 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 4, 7, 4, 0, -7 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 4, 6, 5, 1, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 7, 6, 7, 0, -6 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 4, 6, 4, 0, -6 },
  { 187, 4, 6, 4, 0, -6 },
  { 190, 3, 8, 3, 0, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 2, 8, 3, 0, -7 },
  { 199, 5, 4, 5, 0, -6 },
  { 202, 4, 1, 4, 0, 1 },
  { 203, 3, 2, 3, 0, -7 },
  { 204, 4, 5, 4, 0, -5 },
  { 207, 4, 7, 5, 0, -7 },
  { 211, 4, 5, 4, 0, -5 },
  { 214, 4, 7, 5, 0, -7 },
  { 218, 4, 5, 4, 0, -5 },
  { 221, 3, 7, 3, 0, -7 },
  { 224, 4, 7, 5, 0, -5 },
  { 228, 4, 7, 5, 0, -7 },
  { 232, 2, 7, 2, 0, -7 },
  { 234, 2, 9, 2, 0, -7 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 2, 7, 2, 0, -7 },
  { 244, 6, 5, 7, 0, -5 },
  { 248, 4, 5, 5, 0, -5 },
  { 251, 4, 5, 5, 0, -5 },
  { 254, 4, 7, 5, 0, -5 },
  { 258, 4, 7, 5, 0, -5 },
  { 262, 3, 5, 3, 0, -5 },
  { 264, 3, 5, 3, 0, -5 },
  { 266, 3, 6, 3, 0, -6 },
  { 269, 4, 5, 5, 0, -5 },
  { 272, 4, 5, 4, 0, -5 },
  { 275, 6, 5, 6, 0, -5 },
  { 279, 4, 5, 4, 0, -5 },
  { 282, 4, 7, 4, 0, -5 },
  { 286, 3, 5, 3, 0, -5 },
  { 288, 3, 7, 3, 0, -6 },
  { 291, 2, 9, 4, 1, -7 },
  { 294, 3, 7, 3, 0, -6 },
  { 297, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD9PT7B_H_
