#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF,
  0x9E, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0xE3,
  0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8,
  0xF8, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x71, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x79, 0xE0, 0x1E, 0x78,
  0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFC, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF,
  0xBE, 0xC6, 0xF3, 0x03, 0xCC, 0x0F, 0xB0, 0x3F, 0xC0, 0x7F, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x37, 0xC0, 0xCF, 0x83,
  0x7F, 0x0D, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x07, 0x80,
  0x7F, 0xC0, 0xF0, 0x07, 0xFC, 0x0F, 0x00, 0xFB, 0xE1, 0xF0, 0x0F, 0x1E,
  0x1E, 0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE3, 0xC0,
  0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE7, 0x80, 0x0F, 0x1E, 0x79, 0xF8, 0xFB,
  0xEF, 0x3F, 0xC7, 0xFC, 0xF3, 0xFE, 0x7F, 0xCF, 0x7F, 0xE3, 0xF9, 0xE7,
  0x9E, 0x0E, 0x1E, 0x79, 0xE0, 0x03, 0xC7, 0x9F, 0x00, 0x3C, 0x78, 0xF0,
  0x03, 0xC7, 0x8F, 0x00, 0x78, 0x79, 0xF0, 0x07, 0x87, 0x9E, 0x00, 0xF0,
  0x79, 0xE0, 0x0F, 0x07, 0xFE, 0x00, 0xF0, 0x3F, 0xE0, 0x1E, 0x03, 0xFC,
  0x01, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0xF8, 0xFF, 0xCF, 0xCF, 0xFE, 0x7E, 0xFD, 0xFB,
  0xE7, 0xE7, 0xFF, 0x3E, 0x1F, 0xF9, 0xF0, 0xFF, 0x8F, 0x83, 0xFC, 0x7E,
  0x0F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xDF,
  0x87, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x02, 0x3E, 0x2F, 0x39, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xEF, 0xC7, 0x8F, 0x06,
  0x0C, 0x04, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF,
  0xCF, 0xCF, 0x9F, 0x1F, 0xBE, 0x3F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xEF, 0xCF, 0xDF, 0xFF, 0x1F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7B, 0xF3, 0x3F, 0x23, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x3F,
  0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF, 0x1F, 0x8C, 0x1F, 0x10, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC6, 0x1F, 0x88,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0xFF, 0xC1, 0xFE,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF1, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1E, 0xFC, 0x1E,
  0xFC, 0x3C, 0xFC, 0x3C, 0xFC, 0x78, 0xFC, 0x78, 0xFC, 0xF0, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF,
  0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x3F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7E, 0xFE, 0xFC, 0x7E,
  0xFC, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFC, 0x7E, 0x7F, 0xFE,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0xCF, 0xCF, 0xBF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x3F, 0xBE, 0x3E, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x90,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x00, 0x33, 0xEF, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0x78, 0x18, 0x79, 0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF0,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x0F, 0x80, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x7F, 0xF9, 0xC3, 0xF4, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x78, 0x3F,
  0x1E, 0x3C, 0x7F, 0xEF, 0x3C, 0x7F, 0xE3, 0xDE, 0x3E, 0xF1, 0xEF, 0x3E,
  0x78, 0xF7, 0x9E, 0x3C, 0x7F, 0x8F, 0x1E, 0x3F, 0xC7, 0x8F, 0x1F, 0xE3,
  0xC7, 0x8F, 0xF1, 0xE3, 0xC7, 0xF8, 0xF1, 0xE3, 0xFC, 0x78, 0xF1, 0xCF,
  0x3E, 0xFD, 0xE7, 0x8F, 0xEF, 0xE3, 0xC3, 0xF7, 0xE1, 0xF0, 0x60, 0xE0,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x03, 0xFC, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xDE, 0x00, 0xFD, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xC7, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F,
  0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8,
  0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBF, 0x07, 0xFF, 0x87, 0xEF, 0xC3, 0xF7,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x01,
  0xE0, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xE1, 0x9F, 0x81,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x5F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFD,
  0xFF, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03,
  0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC,
  0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFC, 0x19, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFB,
  0xF0, 0x7D, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xEF, 0xFB,
  0xFE, 0xFF, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0x83, 0xDF, 0xFB,
  0xC1, 0xEF, 0xFD, 0xF1, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xBC, 0x7B, 0xFF,
  0xDE, 0x3D, 0xFF, 0xEF, 0xBE, 0xFF, 0xF7, 0xDF, 0x7F, 0xF9, 0xEF, 0x3F,
  0xFC, 0xF7, 0x9F, 0xFE, 0x7F, 0xCF, 0xFF, 0x3F, 0xC7, 0xFF, 0x8F, 0xE3,
  0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1, 0xF8, 0x7F, 0xF8, 0x7C,
  0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xC0, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0x7C, 0x7F, 0xEF, 0xCF, 0xFC, 0xF9,
  0xFF, 0xDF, 0x3F, 0xF9, 0xF7, 0xFF, 0x3E, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFC, 0x01, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x3F,
  0x1F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xEF, 0xC0, 0xFC,
  0xFC, 0x3F, 0x9F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0xFE, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83, 0xF7,
  0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x3F, 0x9F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC,
  0xFE, 0x3F, 0x1F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07,
  0xF0, 0x07, 0xC0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xF9, 0xEF,
  0xC0, 0xBF, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xE1, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xF8, 0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x07,
  0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xE7, 0xC1, 0xFC, 0x3F, 0x3E, 0x0F, 0xE1,
  0xF9, 0xF0, 0x7F, 0x0F, 0xCF, 0xC7, 0xF8, 0x7C, 0x7E, 0x3F, 0xC3, 0xE1,
  0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x79, 0xF8, 0x7C, 0x7B, 0xCF, 0xC3, 0xE7,
  0xDE, 0x7C, 0x1F, 0xBE, 0xF3, 0xE0, 0x7D, 0xE7, 0x9F, 0x03, 0xEF, 0x3E,
  0xF8, 0x1F, 0x78, 0xFF, 0xC0, 0xFB, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFE, 0x1F, 0xDF, 0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x3F,
  0x3F, 0x07, 0xCF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7C, 0xF8, 0x3F,
  0x3F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x0F, 0xFF, 0x03,
  0xF0, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F,
  0x8F, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C,
  0x0F, 0x1F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x01,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC2, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x07, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFD,
  0xF3, 0xF1, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xE0, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFE, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF1, 0xF0, 0x01,
  0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF9, 0xF8, 0x47, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x82, 0x7F, 0x39, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x06, 0x1F, 0x1F, 0x9F, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x7F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x7F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x03, 0x80, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0x87, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x0C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xF9, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xC1, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x00,
  0x1F, 0x9F, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0x7C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x60, 0x7E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x70, 0xFB, 0xF9, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF0, 0xFB, 0xEF, 0xFE, 0xF8, 0x00, 0x00, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0x1F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0xFF, 0x7F, 0xBF, 0x9F, 0xCF, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x3F, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0xC3,
  0xEF, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x87, 0xE7, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7E, 0x7C,
  0x1F, 0x3E, 0x0F, 0xDF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x70, 0x30, 0xF3, 0xF8, 0xFE, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x3F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0x00, 0xE1, 0xE7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x01, 0xC0, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF0, 0x00, 0xE0, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFE, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x1F, 0x9F, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x7F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0x82, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0xE3, 0xFE,
  0x0F, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x7F, 0x80, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x11, 0xFF, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFD, 0xFE, 0xF9, 0xF8, 0xF0, 0xFC, 0x1F, 0xBE, 0x0F, 0xDF, 0x07,
  0xCF, 0x83, 0xE7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F,
  0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x3F, 0x07, 0xDF, 0x0F, 0xC3, 0xF7, 0xC7, 0xF8, 0xF9, 0xF1,
  0xFE, 0x3E, 0x7C, 0x7F, 0x8F, 0x9F, 0x9F, 0xE3, 0xE3, 0xE7, 0xF9, 0xF0,
  0xF9, 0xCE, 0x7C, 0x3E, 0xF3, 0xDF, 0x0F, 0xBC, 0xF7, 0xC1, 0xEF, 0x3D,
  0xF0, 0x7B, 0xCF, 0x78, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x7E, 0x3E, 0x3E, 0x7E,
  0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8,
  0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x3F, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x3F, 0x8F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFF, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xA0, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 14, 9, 17, 2, -26 },
  { 37, 18, 26, 19, 1, -26 },
  { 96, 14, 30, 18, 2, -28 },
  { 149, 28, 27, 30, 1, -27 },
  { 244, 21, 27, 22, 1, -27 },
  { 315, 5, 9, 9, 2, -26 },
  { 321, 10, 33, 12, 2, -27 },
  { 363, 10, 33, 12, 0, -27 },
  { 405, 15, 16, 17, 1, -28 },
  { 435, 16, 18, 18, 1, -22 },
  { 471, 7, 10, 10, 1, -5 },
  { 480, 10, 5, 12, 1, -12 },
  { 487, 6, 6, 10, 2, -6 },
  { 492, 15, 27, 15, 0, -27 },
  { 543, 15, 27, 18, 1, -27 },
  { 594, 12, 26, 18, 2, -26 },
  { 633, 15, 27, 18, 1, -27 },
  { 684, 15, 27, 18, 1, -27 },
  { 735, 16, 26, 18, 1, -26 },
  { 787, 14, 26, 18, 2, -26 },
  { 833, 16, 27, 18, 1, -27 },
  { 887, 15, 26, 18, 1, -26 },
  { 936, 16, 27, 18, 1, -27 },
  { 990, 15, 27, 18, 1, -27 },
  { 1041, 6, 21, 10, 2, -21 },
  { 1057, 7, 26, 10, 1, -21 },
  { 1080, 16, 18, 18, 1, -22 },
  { 1116, 16, 12, 18, 1, -19 },
  { 1140, 16, 18, 18, 1, -22 },
  { 1176, 14, 27, 14, 0, -27 },
  { 1224, 25, 30, 27, 1, -27 },
  { 1318, 20, 26, 20, 0, -26 },
  { 1383, 17, 26, 20, 2, -26 },
  { 1439, 15, 27, 18, 2, -27 },
  { 1490, 18, 26, 21, 2, -26 },
  { 1549, 13, 26, 16, 2, -26 },
  { 1592, 13, 26, 16, 2, -26 },
  { 1635, 17, 27, 21, 2, -27 },
  { 1693, 18, 26, 22, 2, -26 },
  { 1752, 10, 26, 12, 1, -26 },
  { 1785, 10, 34, 10, -2, -26 },
  { 1828, 18, 26, 20, 2, -26 },
  { 1887, 13, 26, 15, 2, -26 },
  { 1930, 25, 26, 29, 2, -26 },
  { 2012, 19, 26, 24, 2, -26 },
  { 2074, 19, 27, 22, 2, -27 },
  { 2139, 16, 26, 19, 2, -26 },
  { 2191, 19, 33, 22, 2, -27 },
  { 2270, 18, 26, 20, 2, -26 },
  { 2329, 14, 27, 16, 1, -27 },
  { 2377, 15, 26, 16, 1, -26 },
  { 2426, 17, 26, 21, 2, -26 },
  { 2482, 20, 26, 20, 0, -26 },
  { 2547, 29, 26, 29, 0, -26 },
  { 2642, 18, 26, 18, 0, -26 },
  { 2701, 18, 26, 18, 0, -26 },
  { 2760, 15, 26, 16, 1, -26 },
  { 2809, 9, 33, 11, 2, -27 },
  { 2847, 15, 27, 15, 0, -27 },
  { 2898, 9, 33, 11, 1, -27 },
  { 2936, 18, 16, 20, 1, -26 },
  { 2972, 17, 3, 17, 0, 3 },
  { 2979, 10, 6, 12, 1, -28 },
  { 2987, 15, 21, 18, 1, -21 },
  { 3027, 16, 28, 19, 2, -28 },
  { 3083, 14, 21, 15, 1, -21 },
  { 3120, 16, 28, 19, 1, -28 },
  { 3176, 15, 21, 17, 1, -21 },
  { 3216, 13, 28, 12, 0, -28 },
  { 3262, 16, 30, 19, 1, -21 },
  { 3322, 15, 28, 19, 2, -28 },
  { 3375, 6, 28, 9, 2, -28 },
  { 3396, 9, 37, 9, -1, -28 },
  { 3438, 17, 28, 19, 2, -28 },
  { 3498, 5, 28, 9, 2, -28 },
  { 3516, 24, 21, 28, 2, -21 },
  { 3579, 15, 21, 19, 2, -21 },
  { 3619, 16, 21, 19, 1, -21 },
  { 3661, 16, 30, 19, 2, -21 },
  { 3721, 16, 30, 19, 1, -21 },
  { 3781, 11, 21, 13, 2, -21 },
  { 3810, 12, 21, 14, 1, -21 },
  { 3842, 12, 25, 13, 0, -25 },
  { 3880, 15, 20, 19, 2, -20 },
  { 3918, 17, 20, 17, 0, -20 },
  { 3961, 26, 20, 26, 0, -20 },
  { 4026, 16, 20, 17, 0, -20 },
  { 4066, 17, 29, 17, 0, -20 },
  { 4128, 12, 20, 14, 1, -20 },
  { 4158, 12, 33, 13, 0, -27 },
  { 4208, 4, 37, 16, 6, -28 },
  { 4227, 12, 33, 13, 1, -27 },
  { 4277, 16, 6, 18, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD37PT7B_H_
