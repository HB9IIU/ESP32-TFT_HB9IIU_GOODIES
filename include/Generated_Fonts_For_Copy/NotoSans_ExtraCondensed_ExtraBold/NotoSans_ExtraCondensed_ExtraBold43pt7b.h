#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0,
  0x07, 0xC7, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x83, 0xC7, 0xC0, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF8, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC3, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFF, 0xE1,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7E, 0xE1, 0x3E, 0x70,
  0x1F, 0x38, 0x0F, 0xDC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0E, 0xFC,
  0x07, 0x7E, 0x03, 0xBF, 0x81, 0xDF, 0xF0, 0xEF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xE0,
  0x1F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x7D, 0xF0,
  0x3E, 0x00, 0x78, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3C, 0x00, 0xF8, 0xF8,
  0x7C, 0x00, 0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0xF0, 0x00, 0xF8, 0xF9, 0xF0, 0xF0, 0x78, 0xF9,
  0xE3, 0xFC, 0x7D, 0xF3, 0xE7, 0xFC, 0x7F, 0xF3, 0xE7, 0xFE, 0x3F, 0xE3,
  0xCF, 0xFF, 0x1F, 0xE7, 0xCF, 0x9F, 0x0F, 0x87, 0x8F, 0x9F, 0x00, 0x0F,
  0x8F, 0x1F, 0x00, 0x0F, 0x8F, 0x1F, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x1F,
  0x0F, 0x1F, 0x00, 0x1E, 0x0F, 0x1F, 0x00, 0x3E, 0x0F, 0x1F, 0x00, 0x3E,
  0x0F, 0x9F, 0x00, 0x3C, 0x0F, 0x9F, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x78,
  0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFC, 0x3F, 0xF0, 0xFE,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x9F, 0xCF, 0xFF,
  0xCF, 0xE3, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3, 0xF0, 0x7F, 0xE1, 0xFC, 0x1F,
  0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xF8, 0x3F, 0xE1, 0xFE, 0xFF,
  0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF0, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x41, 0xE0, 0x9C, 0x79,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x83, 0xF3, 0xF1, 0xF8, 0xFE, 0x1E,
  0x1E, 0x03, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE7, 0xF1, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F,
  0x9F, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x1F, 0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E, 0x7F, 0x1F,
  0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF7, 0xCF, 0xCE, 0x3F, 0x10,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE,
  0x60, 0x3F, 0x10, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0x9F, 0xE3, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFC,
  0x1F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1E, 0xFC, 0x07, 0xDF, 0x80, 0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F,
  0xC1, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x78, 0x7F, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xF8, 0x23, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF9, 0xF0,
  0x7C, 0xFF, 0x1F, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7F, 0x1F, 0xDF, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFB, 0xF9,
  0xFC, 0x7E, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE3,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFE, 0xFC, 0x7F, 0x3F,
  0x03, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x88, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x1E, 0x3F,
  0x7F, 0x7F, 0x7F, 0x3F, 0x3F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE,
  0x7C, 0xFF, 0x30, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3C, 0x0F, 0xE1, 0xE7,
  0xC3, 0xFF, 0x9F, 0x78, 0x7F, 0xF9, 0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0xF8,
  0xF8, 0xFF, 0x8F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F,
  0xF1, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0, 0xFF, 0x1F,
  0x1F, 0x0F, 0xF1, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0x1E, 0xF8, 0xFF, 0xFF,
  0xEF, 0x8F, 0xFB, 0xFC, 0xF8, 0x7F, 0x3F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xE0, 0x0F, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xBF, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xFB,
  0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xCF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF,
  0x8F, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x19, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x8F, 0xF0,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFC, 0x3F, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFC, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xC0, 0x67, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0x7F, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x83, 0xF3, 0xFC,
  0x3F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF,
  0xE7, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0, 0xFC, 0x7F,
  0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xBF, 0xFD, 0xF0, 0xFB,
  0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF1, 0xFB, 0xFF, 0xDF, 0x9F, 0x3F, 0xFC,
  0xF9, 0xF3, 0xFF, 0xCF, 0x9F, 0x3F, 0xFC, 0xFB, 0xF3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x7F, 0xC3, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F,
  0x83, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x03, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xF7, 0xE3, 0xFF, 0xDF, 0x8F, 0xFF, 0x3F, 0x3F,
  0xFC, 0xFC, 0xFF, 0xF1, 0xFB, 0xFF, 0xC7, 0xEF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8,
  0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFE,
  0x7F, 0x83, 0xF8, 0xFF, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0xFF,
  0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xEF,
  0xC0, 0xFE, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFC, 0x38, 0xFC, 0x04, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE7, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0x01, 0xFB, 0xF8, 0x1F, 0xC0, 0x7E, 0x7E, 0x07, 0xF0, 0x3F, 0x9F, 0x81,
  0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x83, 0xF1, 0xF8, 0x1F, 0xE0, 0xFC, 0x7F,
  0x0F, 0xF8, 0x3F, 0x0F, 0xC3, 0xFE, 0x1F, 0xC3, 0xF0, 0xFF, 0x87, 0xF0,
  0xFC, 0x3F, 0xF1, 0xF8, 0x3F, 0x0F, 0x7C, 0x7E, 0x0F, 0xC7, 0xDF, 0x1F,
  0x83, 0xF9, 0xF7, 0xC7, 0xE0, 0x7E, 0x7D, 0xF3, 0xF8, 0x1F, 0x9F, 0x3C,
  0xFC, 0x07, 0xE7, 0xCF, 0xBF, 0x01, 0xFB, 0xF3, 0xEF, 0xC0, 0x7E, 0xF8,
  0xFB, 0xF0, 0x0F, 0xBE, 0x3E, 0xFC, 0x03, 0xFF, 0x8F, 0xBF, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0,
  0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x7E, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x7E, 0x1F, 0xC3,
  0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xE3, 0xF0, 0x7F,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xE0, 0x0F,
  0xBF, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0,
  0x7C, 0x03, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8,
  0xE1, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0x7C,
  0xFF, 0x3E, 0x3F, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x8F, 0x83, 0xF3, 0xF8, 0x7E, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xCF, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8,
  0x3F, 0x7F, 0x07, 0xEF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF7, 0xF0,
  0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x7F, 0x7F, 0x8F, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xEF, 0xF8, 0xFC, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x8E, 0x7F,
  0x02, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0x7F,
  0x86, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xF9, 0xFC, 0x7F,
  0x9F, 0x8F, 0xFB, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xEF, 0xFB, 0xF8,
  0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1,
  0xFD, 0xF8, 0x3F, 0xBF, 0x8F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xBF, 0x0F, 0xE3, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3F,
  0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x18, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8,
  0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFB, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xC7, 0xE1, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0x7F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x7F, 0xBF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xEF, 0xC7, 0xF9, 0xF8, 0x7E, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x20, 0x07, 0xE3, 0x83, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x1F, 0x0F, 0xCF, 0xF3,
  0xF7, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFB, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xC0, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xEF, 0xFB, 0xFE, 0xFF, 0x3F, 0xCF,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8,
  0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0x7E, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x0F, 0x87, 0xCF, 0xF9, 0xFF,
  0x3F, 0x7F, 0xEF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFE, 0x1F,
  0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0xFC, 0x3F, 0x83,
  0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x07, 0xFF,
  0xC3, 0xF8, 0x3F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x87,
  0xF0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0,
  0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xC3, 0xF8, 0x3F, 0xF8, 0x7C, 0x3E, 0x7F,
  0xCF, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0xF8,
  0x7C, 0x1F, 0x9F, 0xC3, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFE,
  0x7F, 0xBF, 0x87, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8,
  0x3F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xF0,
  0x7E, 0xFE, 0x0F, 0xDF, 0xC3, 0xFB, 0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFB, 0xFE, 0x3F, 0x3F, 0xC7, 0xE3, 0xF0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC7, 0xE1, 0xFC,
  0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x7F, 0xDF, 0xC3,
  0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F,
  0xEF, 0xE1, 0xFD, 0xFC, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xEF,
  0xC7, 0xF9, 0xF8, 0x7E, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0xF8, 0x7F, 0xC7, 0xFF, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0xE7,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xF0, 0xEF, 0xC0, 0xBF, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x1F, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0x1F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0x7C, 0x7F, 0x1F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8,
  0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x83, 0xF7, 0xE1, 0xFE, 0x0F, 0xDF, 0x87,
  0xF8, 0x7E, 0x7E, 0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0xC7, 0xE3, 0xF1, 0xFF,
  0x1F, 0x8F, 0xCF, 0xFC, 0x7E, 0x3F, 0x3E, 0xF3, 0xF0, 0xFC, 0xF3, 0xCF,
  0xC3, 0xF3, 0xCF, 0x3F, 0x07, 0xCF, 0x3E, 0xFC, 0x1F, 0xBC, 0xFB, 0xE0,
  0x7F, 0xF3, 0xEF, 0x81, 0xFF, 0xC7, 0xBE, 0x07, 0xFF, 0x1F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF9, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xF7, 0xE0,
  0x7E, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x9F, 0x83, 0xF7,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x3F, 0xC3, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xA0, 0x1F, 0xE4, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 31, 11, 2, -31 },
  { 29, 16, 11, 20, 2, -31 },
  { 51, 21, 31, 22, 1, -31 },
  { 133, 17, 36, 21, 2, -33 },
  { 210, 32, 31, 35, 1, -31 },
  { 334, 25, 31, 26, 1, -31 },
  { 431, 7, 11, 10, 2, -31 },
  { 441, 11, 38, 14, 2, -31 },
  { 494, 12, 38, 14, 0, -31 },
  { 551, 18, 18, 20, 1, -33 },
  { 592, 18, 21, 21, 1, -26 },
  { 640, 8, 12, 11, 1, -6 },
  { 652, 11, 5, 14, 1, -14 },
  { 659, 7, 7, 11, 2, -7 },
  { 666, 18, 31, 18, 0, -31 },
  { 736, 18, 31, 21, 1, -31 },
  { 806, 14, 31, 21, 2, -31 },
  { 861, 17, 31, 21, 1, -31 },
  { 927, 18, 31, 21, 1, -31 },
  { 997, 19, 31, 21, 1, -31 },
  { 1071, 17, 31, 21, 2, -31 },
  { 1137, 18, 31, 21, 1, -31 },
  { 1207, 18, 31, 21, 1, -31 },
  { 1277, 18, 31, 21, 1, -31 },
  { 1347, 18, 31, 21, 1, -31 },
  { 1417, 7, 24, 12, 2, -24 },
  { 1438, 8, 30, 12, 1, -24 },
  { 1468, 18, 21, 21, 1, -26 },
  { 1516, 18, 14, 21, 1, -22 },
  { 1548, 19, 21, 21, 1, -26 },
  { 1598, 16, 31, 17, 0, -31 },
  { 1660, 28, 34, 32, 2, -31 },
  { 1779, 24, 31, 24, 0, -31 },
  { 1872, 19, 31, 23, 3, -31 },
  { 1946, 18, 31, 21, 2, -31 },
  { 2016, 20, 31, 25, 3, -31 },
  { 2094, 14, 31, 19, 3, -31 },
  { 2149, 14, 31, 19, 3, -31 },
  { 2204, 20, 31, 25, 2, -31 },
  { 2282, 20, 31, 26, 3, -31 },
  { 2360, 12, 31, 14, 1, -31 },
  { 2407, 11, 40, 12, -2, -31 },
  { 2462, 20, 31, 23, 3, -31 },
  { 2540, 14, 31, 18, 3, -31 },
  { 2595, 28, 31, 34, 3, -31 },
  { 2704, 22, 31, 28, 3, -31 },
  { 2790, 22, 31, 26, 2, -31 },
  { 2876, 17, 31, 22, 3, -31 },
  { 2942, 22, 38, 26, 2, -31 },
  { 3047, 20, 31, 23, 3, -31 },
  { 3125, 17, 31, 19, 1, -31 },
  { 3191, 17, 31, 19, 1, -31 },
  { 3257, 19, 31, 25, 3, -31 },
  { 3331, 23, 31, 23, 0, -31 },
  { 3421, 34, 31, 33, 0, -31 },
  { 3553, 21, 31, 21, 0, -31 },
  { 3635, 21, 31, 21, 0, -31 },
  { 3717, 17, 31, 19, 1, -31 },
  { 3783, 10, 38, 13, 2, -31 },
  { 3831, 18, 31, 18, 0, -31 },
  { 3901, 10, 38, 13, 1, -31 },
  { 3949, 21, 20, 23, 1, -31 },
  { 4002, 19, 4, 19, 0, 3 },
  { 4012, 10, 7, 14, 2, -33 },
  { 4021, 17, 24, 21, 1, -24 },
  { 4072, 19, 33, 22, 2, -33 },
  { 4151, 16, 24, 18, 1, -24 },
  { 4199, 19, 33, 22, 1, -33 },
  { 4278, 18, 24, 20, 1, -24 },
  { 4332, 15, 33, 13, 0, -33 },
  { 4394, 19, 34, 22, 1, -24 },
  { 4475, 18, 33, 22, 2, -33 },
  { 4550, 7, 33, 11, 2, -33 },
  { 4579, 10, 43, 11, -1, -33 },
  { 4633, 20, 33, 22, 2, -33 },
  { 4716, 7, 33, 11, 2, -33 },
  { 4745, 29, 24, 33, 2, -24 },
  { 4832, 18, 24, 22, 2, -24 },
  { 4886, 19, 24, 22, 1, -24 },
  { 4943, 19, 34, 22, 2, -24 },
  { 5024, 19, 34, 22, 1, -24 },
  { 5105, 13, 24, 15, 2, -24 },
  { 5144, 14, 24, 17, 1, -24 },
  { 5186, 14, 29, 15, 0, -29 },
  { 5237, 18, 24, 22, 2, -24 },
  { 5291, 20, 24, 20, 0, -24 },
  { 5351, 30, 24, 30, 0, -24 },
  { 5441, 19, 24, 19, 0, -24 },
  { 5498, 20, 34, 20, 0, -24 },
  { 5583, 14, 24, 16, 1, -24 },
  { 5625, 14, 38, 15, 0, -31 },
  { 5692, 5, 43, 18, 7, -33 },
  { 5719, 14, 38, 15, 1, -31 },
  { 5786, 19, 8, 21, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD43PT7B_H_
