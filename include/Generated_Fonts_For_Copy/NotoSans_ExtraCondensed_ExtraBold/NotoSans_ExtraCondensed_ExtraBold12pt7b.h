#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xA2, 0xC0, 0xBB, 0xBB, 0x28, 0xA2, 0x9F, 0x2B, 0xFF, 0xD4,
  0x50, 0x4F, 0xDC, 0xE3, 0xDF, 0x44, 0x62, 0x3B, 0x35, 0x1A, 0x87, 0xFB,
  0x54, 0x6A, 0x25, 0x33, 0x80, 0x30, 0xF1, 0xA3, 0xC7, 0x7B, 0xF7, 0x7E,
  0x7E, 0xF0, 0x7B, 0x49, 0x24, 0xD9, 0x80, 0xC9, 0xB2, 0x4B, 0x6B, 0x00,
  0x37, 0x7E, 0xF5, 0x00, 0x31, 0xBE, 0x63, 0x18, 0x69, 0x60, 0xFC, 0xB0,
  0x18, 0x84, 0x62, 0x31, 0x88, 0xC0, 0x33, 0xD7, 0xBC, 0xE5, 0x6F, 0x70,
  0x2F, 0xD2, 0x49, 0x20, 0x37, 0xD6, 0x31, 0x99, 0x8F, 0xF8, 0x77, 0xC6,
  0x37, 0x0C, 0x73, 0xF0, 0x18, 0xE3, 0x9E, 0x5B, 0x6F, 0xC6, 0x18, 0xFF,
  0x8A, 0xF3, 0x3B, 0xE0, 0x1B, 0xD0, 0xAF, 0xE7, 0x2F, 0x78, 0xFF, 0xC6,
  0x31, 0x18, 0xC4, 0x60, 0x33, 0xD6, 0xF3, 0x3F, 0x3B, 0x78, 0x33, 0xF7,
  0x9D, 0xB4, 0x73, 0x70, 0xB0, 0x2C, 0x4C, 0x00, 0xD2, 0xC0, 0x09, 0xF8,
  0xE1, 0x84, 0xF8, 0x3F, 0xF0, 0xC3, 0x86, 0x7E, 0x40, 0x6F, 0x13, 0x36,
  0x06, 0x60, 0x1C, 0x36, 0x41, 0x5D, 0xD5, 0xD5, 0x55, 0x4A, 0x62, 0x1E,
  0x30, 0x70, 0xE3, 0x46, 0x8D, 0x9F, 0x66, 0xC6, 0xE7, 0xF7, 0xBF, 0x6F,
  0x7F, 0xF0, 0x19, 0xF6, 0x10, 0xC1, 0x06, 0x1E, 0x38, 0xE7, 0xB7, 0xBD,
  0xEF, 0x7F, 0xF0, 0xFF, 0xCC, 0xFC, 0xCF, 0xF0, 0xFF, 0xCC, 0xFF, 0xCC,
  0xC0, 0x37, 0xF1, 0x8B, 0xDF, 0x7B, 0x78, 0xCE, 0x73, 0x9F, 0xE7, 0x39,
  0xC8, 0xFF, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xEC,
  0xDE, 0xFD, 0xEE, 0x7B, 0xDB, 0xD8, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC7,
  0xE7, 0xE7, 0xAF, 0xAF, 0xBB, 0xBB, 0x9B, 0x93, 0xCF, 0x3E, 0xEB, 0xBE,
  0xF9, 0xE7, 0x8C, 0x38, 0xF9, 0x92, 0x3C, 0x68, 0xD9, 0xB6, 0x3C, 0xE7,
  0xB7, 0xBF, 0x7B, 0x18, 0xC0, 0x38, 0xF9, 0x9A, 0x3C, 0x68, 0xD9, 0xB6,
  0x3C, 0x18, 0x38, 0xE7, 0xB7, 0xBF, 0x7B, 0xDB, 0xD8, 0x33, 0xF3, 0xC7,
  0x1C, 0x7F, 0xF0, 0xFF, 0xCC, 0x63, 0x18, 0xC6, 0x30, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0x70, 0xC7, 0x34, 0xD3, 0x69, 0xE3, 0x8E, 0x30, 0xC8, 0xE6,
  0xF7, 0x6B, 0xB5, 0x5B, 0xA9, 0xD4, 0xEE, 0x73, 0x00, 0xCD, 0x67, 0x9C,
  0x30, 0xC7, 0x9E, 0xCC, 0xCF, 0x37, 0x9E, 0x30, 0xC3, 0x0C, 0x30, 0xFF,
  0xC6, 0x63, 0x31, 0x9F, 0xF8, 0xFA, 0xAA, 0xAC, 0xC2, 0x10, 0xC2, 0x18,
  0xC2, 0x18, 0xFD, 0xB6, 0xDB, 0x6F, 0x80, 0x10, 0xC3, 0x9A, 0x4F, 0x30,
  0xF8, 0xE4, 0x33, 0xC6, 0xFD, 0xED, 0xA0, 0x84, 0x2D, 0xE9, 0xCE, 0x7A,
  0xB0, 0x3B, 0x91, 0x8C, 0x35, 0xE0, 0x0C, 0x32, 0xDF, 0xCF, 0x3C, 0xDF,
  0x7C, 0x33, 0xD3, 0xFC, 0x35, 0xE0, 0x76, 0x7F, 0x66, 0x66, 0x60, 0x2D,
  0xFC, 0xF3, 0xCD, 0xF7, 0xC2, 0x79, 0xC0, 0x84, 0x2D, 0xE9, 0xCE, 0x73,
  0x98, 0xFF, 0x80, 0x55, 0x55, 0x5F, 0x84, 0x27, 0x6B, 0x73, 0xD6, 0x98,
  0xFF, 0x80, 0xB6, 0xFE, 0x9B, 0x93, 0x93, 0x93, 0x93, 0xB7, 0xA7, 0x39,
  0xCE, 0x60, 0x31, 0xE4, 0xB3, 0xCD, 0xE7, 0x80, 0xB7, 0xA7, 0x39, 0xEE,
  0xD0, 0x84, 0x00, 0x2D, 0xFC, 0xF3, 0xCD, 0xF7, 0xC3, 0x0C, 0x30, 0xBF,
  0x49, 0x20, 0x7F, 0xC7, 0x3B, 0xF0, 0x67, 0xF6, 0x66, 0x77, 0x9C, 0xE7,
  0x39, 0xFF, 0xE0, 0xCF, 0x25, 0x96, 0x71, 0xC3, 0x00, 0xD9, 0xDB, 0x5F,
  0x57, 0x57, 0x76, 0x76, 0xDA, 0xDC, 0x67, 0x2F, 0x60, 0xCF, 0x25, 0x9E,
  0x70, 0xC3, 0x0C, 0x61, 0x80, 0xFF, 0x36, 0x6C, 0xF0, 0x17, 0x66, 0x6C,
  0x66, 0x66, 0x30, 0xFF, 0xF0, 0xCE, 0x66, 0x63, 0x66, 0x66, 0xC0, 0xFC,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 6, 1, -9 },
  { 6, 6, 9, 6, 0, -9 },
  { 13, 4, 10, 6, 1, -9 },
  { 18, 9, 9, 10, 0, -9 },
  { 29, 7, 9, 7, 0, -9 },
  { 37, 1, 4, 3, 1, -9 },
  { 38, 3, 11, 4, 1, -9 },
  { 43, 3, 11, 4, 0, -9 },
  { 48, 5, 5, 6, 0, -9 },
  { 52, 5, 6, 6, 0, -7 },
  { 56, 3, 4, 3, 0, -2 },
  { 58, 3, 2, 4, 0, -4 },
  { 59, 2, 2, 3, 1, -2 },
  { 60, 5, 9, 5, 0, -9 },
  { 66, 5, 9, 6, 0, -9 },
  { 72, 3, 9, 6, 1, -9 },
  { 76, 5, 9, 6, 0, -9 },
  { 82, 5, 9, 6, 0, -9 },
  { 88, 6, 9, 6, 0, -9 },
  { 95, 4, 9, 6, 1, -9 },
  { 100, 5, 9, 6, 0, -9 },
  { 106, 5, 9, 6, 0, -9 },
  { 112, 5, 9, 6, 0, -9 },
  { 118, 5, 9, 6, 0, -9 },
  { 124, 2, 7, 3, 1, -7 },
  { 126, 3, 9, 3, 0, -7 },
  { 130, 5, 6, 6, 0, -7 },
  { 134, 5, 4, 6, 0, -6 },
  { 137, 5, 6, 6, 0, -7 },
  { 141, 4, 9, 5, 0, -9 },
  { 146, 8, 10, 9, 0, -9 },
  { 156, 7, 9, 7, 0, -9 },
  { 164, 5, 9, 6, 1, -9 },
  { 170, 6, 9, 6, 0, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 4, 9, 5, 1, -9 },
  { 188, 4, 9, 5, 1, -9 },
  { 193, 5, 9, 7, 1, -9 },
  { 199, 5, 9, 7, 1, -9 },
  { 205, 4, 9, 4, 0, -9 },
  { 210, 4, 12, 3, -1, -9 },
  { 216, 5, 9, 6, 1, -9 },
  { 222, 4, 9, 5, 1, -9 },
  { 227, 8, 9, 9, 1, -9 },
  { 236, 6, 9, 8, 1, -9 },
  { 243, 7, 9, 7, 0, -9 },
  { 251, 5, 9, 6, 1, -9 },
  { 257, 7, 11, 7, 0, -9 },
  { 267, 5, 9, 6, 1, -9 },
  { 273, 5, 9, 5, 0, -9 },
  { 279, 5, 9, 5, 0, -9 },
  { 285, 5, 9, 7, 1, -9 },
  { 291, 6, 9, 6, 0, -9 },
  { 298, 9, 9, 9, 0, -9 },
  { 309, 6, 9, 6, 0, -9 },
  { 316, 6, 9, 6, 0, -9 },
  { 323, 5, 9, 5, 0, -9 },
  { 329, 2, 11, 4, 1, -9 },
  { 332, 5, 9, 5, 0, -9 },
  { 338, 3, 11, 4, 0, -9 },
  { 343, 6, 6, 6, 0, -9 },
  { 348, 5, 1, 5, 0, 1 },
  { 349, 3, 2, 4, 0, -9 },
  { 350, 5, 7, 6, 0, -7 },
  { 355, 5, 9, 6, 1, -9 },
  { 361, 5, 7, 5, 0, -7 },
  { 366, 6, 9, 6, 0, -9 },
  { 373, 5, 7, 6, 0, -7 },
  { 378, 4, 9, 4, 0, -9 },
  { 383, 6, 10, 6, 0, -7 },
  { 391, 5, 9, 6, 1, -9 },
  { 397, 1, 9, 3, 1, -9 },
  { 399, 2, 12, 3, 0, -9 },
  { 402, 5, 9, 6, 1, -9 },
  { 408, 1, 9, 3, 1, -9 },
  { 410, 8, 7, 9, 1, -7 },
  { 417, 5, 7, 6, 1, -7 },
  { 422, 6, 7, 6, 0, -7 },
  { 428, 5, 10, 6, 1, -7 },
  { 435, 6, 10, 6, 0, -7 },
  { 443, 3, 7, 4, 1, -7 },
  { 446, 4, 7, 5, 0, -7 },
  { 450, 4, 8, 4, 0, -8 },
  { 454, 5, 7, 6, 1, -7 },
  { 459, 6, 7, 6, 0, -7 },
  { 465, 8, 7, 8, 0, -7 },
  { 472, 5, 7, 5, 0, -7 },
  { 477, 6, 10, 6, 0, -7 },
  { 485, 4, 7, 5, 0, -7 },
  { 489, 4, 11, 4, 0, -9 },
  { 495, 1, 12, 5, 2, -9 },
  { 497, 4, 11, 4, 0, -9 },
  { 503, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD12PT7B_H_
