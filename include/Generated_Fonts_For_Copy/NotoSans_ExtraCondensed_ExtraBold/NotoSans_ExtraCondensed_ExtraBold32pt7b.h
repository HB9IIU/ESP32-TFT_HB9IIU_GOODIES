#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x00, 0x07, 0x9F, 0xFD, 0xF7, 0x80, 0xF9, 0xFF, 0x9F, 0x78, 0xF7,
  0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x07, 0x38, 0x1E, 0x70, 0x3C,
  0xE0, 0x79, 0xC0, 0xE7, 0x81, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x79, 0xC0, 0xE7, 0x81, 0xCF, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFC, 0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38,
  0x1E, 0x70, 0x00, 0x03, 0x00, 0x18, 0x03, 0xF8, 0x7F, 0xF7, 0xFF, 0x3F,
  0xF9, 0xEC, 0x5F, 0x60, 0x7B, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0x7C, 0x1B, 0xF8, 0xFF, 0xFF, 0xEF,
  0xFF, 0x3F, 0xF0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3E, 0x03,
  0xC0, 0x7F, 0x03, 0xC0, 0x7F, 0x83, 0x80, 0xF7, 0x87, 0x80, 0xF3, 0x87,
  0x00, 0xF3, 0x8F, 0x00, 0xE3, 0x8F, 0x00, 0xF3, 0x8E, 0x00, 0xE3, 0x9E,
  0x00, 0xF3, 0x9C, 0x78, 0xF7, 0xBC, 0xFC, 0x7F, 0xBD, 0xFE, 0x7F, 0x39,
  0xCE, 0x3E, 0x7B, 0xCF, 0x00, 0x73, 0xCF, 0x00, 0x73, 0xCF, 0x00, 0xF3,
  0xCF, 0x00, 0xE3, 0xCF, 0x01, 0xE3, 0xCF, 0x01, 0xC1, 0xCE, 0x01, 0xC1,
  0xFE, 0x03, 0xC0, 0xFC, 0x03, 0x80, 0x78, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF7,
  0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x3E, 0x7F, 0xCF,
  0xBF, 0xFB, 0xEF, 0xBF, 0xF3, 0xE7, 0xFC, 0xF8, 0xFF, 0x3E, 0x1F, 0x8F,
  0x87, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE1, 0xFC, 0xFC, 0xFF,
  0xDE, 0xF7, 0xBD, 0xEF, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x01,
  0xC1, 0xCE, 0x6F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF,
  0x1F, 0x7C, 0x71, 0xC1, 0x0C, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0xDF, 0x3C, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFB, 0xC7, 0xDF, 0x3C, 0xFF, 0xE3, 0xFF, 0x1F, 0xF0,
  0x3F, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF,
  0xDF, 0x33, 0xE2, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83,
  0xFF, 0x3F, 0xF9, 0xFF, 0xE7, 0x1F, 0x10, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC3, 0xFF, 0x3F, 0xFC, 0xFF, 0xE6, 0x1F, 0x00, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0x01, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xEF, 0xFF, 0x7F, 0xF1,
  0xFE, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0E, 0xF8, 0x3D, 0xF0, 0x73, 0xE1, 0xE7,
  0xC3, 0x8F, 0x8F, 0x1F, 0x1C, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F,
  0xFC, 0xFF, 0xEF, 0xFE, 0x67, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x83, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x03, 0xF0, 0x7F,
  0x87, 0xFC, 0x7F, 0xE3, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xFB, 0xC7,
  0xBF, 0xBD, 0xFD, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8,
  0xFF, 0xC7, 0xDF, 0x3E, 0xFF, 0xF3, 0xFF, 0x1F, 0xF0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x7D, 0xE3,
  0xEF, 0x9E, 0x7D, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x3E, 0xFB,
  0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xFB, 0xF7, 0xFF, 0x3F,
  0xF8, 0x7F, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0x9F, 0x7C,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF,
  0xBF, 0xBC, 0xF9, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x80, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0xC0, 0x00, 0x08,
  0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x3F, 0xE3, 0xFC, 0x1F, 0x00, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xC7, 0xFC, 0x3F,
  0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0xFF, 0xE7,
  0xFF, 0x61, 0xF4, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x87,
  0xF7, 0x9E, 0x3F, 0xCE, 0x71, 0xFF, 0x39, 0xCF, 0x3C, 0xEF, 0x3C, 0xF3,
  0xFC, 0xE3, 0xCF, 0xF3, 0x8F, 0x3F, 0xCE, 0x3C, 0xEF, 0x38, 0xF3, 0xBC,
  0xE3, 0xCE, 0xF3, 0xDF, 0x79, 0xC7, 0xEF, 0xC7, 0x0F, 0x3E, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x02, 0x01, 0xFC, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x7C, 0x07,
  0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xC1, 0xF1, 0xF0, 0x3E,
  0x7C, 0x0F, 0xBF, 0x03, 0xEF, 0x80, 0xFC, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0xFB, 0xFF,
  0xEF, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xE3, 0xEF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0x19, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x8F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF,
  0xCF, 0x9F, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8,
  0x7D, 0xF1, 0xFB, 0xE7, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x04, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x3E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFC, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xEF, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xCF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xCF, 0xFF, 0xDF, 0xEF, 0xE7, 0xC0, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7C,
  0x7D, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xFC, 0x7C, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7,
  0xEF, 0x87, 0xDF, 0x0F, 0xFE, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFE, 0xF0, 0xEF,
  0xF7, 0x8F, 0x7F, 0xFC, 0x7B, 0xFF, 0xE3, 0xDF, 0xF7, 0x9C, 0xFF, 0xBD,
  0xE7, 0xFD, 0xEF, 0x3F, 0xEF, 0x79, 0xFF, 0x3F, 0x8F, 0xF9, 0xFC, 0x7F,
  0xCF, 0xE3, 0xFE, 0x7E, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x7C,
  0x3F, 0xE3, 0xC1, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F, 0xF7, 0xCF,
  0xF3, 0xCF, 0xFB, 0xEF, 0xFB, 0xEF, 0xF9, 0xEF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0x7F, 0xF3, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF,
  0xCF, 0x9F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3E, 0xF8, 0x7D, 0xF0, 0xF9,
  0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xDF, 0x0F, 0xBE, 0x1F,
  0x80, 0x1F, 0xC3, 0xFF, 0x7F, 0xF7, 0xFE, 0xFC, 0xEF, 0x82, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0xE3, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFB,
  0xF1, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x0F,
  0xFC, 0x07, 0xDE, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0xF8,
  0x3C, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xE7,
  0x83, 0xE1, 0xF3, 0xC3, 0xF0, 0xF9, 0xF1, 0xFC, 0x7C, 0xF8, 0xFE, 0x3E,
  0x7C, 0x77, 0x1E, 0x1E, 0x3B, 0x8F, 0x0F, 0x3D, 0xCF, 0x87, 0x9E, 0xF7,
  0xC3, 0xEF, 0x7B, 0xE1, 0xF7, 0xBD, 0xE0, 0x7B, 0x9E, 0xF0, 0x3F, 0xC7,
  0x78, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0xFC,
  0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0x78, 0x3E,
  0x7C, 0x3C, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xF0, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x87,
  0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x0F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE3, 0x0F, 0x00, 0x7C, 0x03, 0xE3, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0x7F,
  0x79, 0xF3, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xCF, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBE, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDF, 0xDE, 0x7C, 0x07, 0xC1, 0xFF, 0x3F, 0xE7, 0xFE,
  0x7C, 0x47, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC2, 0x7F, 0xE7, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xE7, 0xCF, 0xDF, 0x7F,
  0xFD, 0xFF, 0xF7, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3,
  0xFF, 0xC7, 0xCF, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC,
  0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x3C, 0x05, 0xF9, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xFC,
  0x7F, 0x1F, 0xE3, 0xE0, 0x7C, 0x0F, 0xF3, 0xFE, 0xFF, 0xDF, 0xF8, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x3C, 0xFD, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC,
  0x7D, 0xF0, 0x07, 0xC0, 0x1E, 0x40, 0x79, 0xC7, 0xE7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xCF, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0x7F, 0xF1, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0x67, 0xBF, 0xFF, 0x00, 0x1E,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x0C,
  0x1E, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0xBE, 0xFE, 0xFE, 0xFC, 0xF0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFC, 0x3E, 0xF0, 0xFB,
  0xC7, 0xCF, 0x3E, 0x3C, 0xF8, 0xF7, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xEF, 0x0F,
  0xBC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC3, 0xC7, 0xBF, 0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xDF, 0xDF, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFE, 0x1F, 0x1F, 0xF0,
  0xF8, 0xFF, 0x87, 0xC7, 0xFC, 0x3E, 0x3F, 0xE1, 0xF1, 0xFF, 0x0F, 0x8F,
  0xF8, 0x7C, 0x7F, 0xC3, 0xE3, 0xFE, 0x1F, 0x1F, 0xF0, 0xF8, 0xFF, 0x87,
  0xC7, 0xC0, 0xE3, 0xC7, 0xBF, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0xFC, 0x7F,
  0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xC0, 0x0F, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xF1, 0xE7, 0xFF, 0x8F, 0xFC,
  0x3F, 0xF0, 0x3F, 0x00, 0xE3, 0xC7, 0xBF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F,
  0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0xF7, 0xF7, 0x9F, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E,
  0x3C, 0xFD, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xF7,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xE3, 0xFB, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xBC, 0x0F, 0xC3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x1E, 0x07, 0x81, 0xE0, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x79,
  0xF3, 0xC0, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x8F, 0x0F, 0x1E, 0x1E, 0x7C, 0x3E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x7C, 0x3F, 0xE3, 0xF0, 0xF7, 0x8F, 0xC7, 0xDE, 0x3F, 0x1F, 0x7C,
  0xFE, 0x7D, 0xF3, 0xF9, 0xE7, 0xCE, 0xE7, 0x8F, 0x7B, 0xBE, 0x3D, 0xEE,
  0xF8, 0xF7, 0x3B, 0xC3, 0xDC, 0xFF, 0x07, 0xF3, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0x7D, 0xF1, 0xF7, 0xCF, 0x8F, 0x3E, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC3, 0xCF, 0x9F, 0x3E, 0x7C, 0x7B, 0xE1, 0xF0, 0xF8, 0x3F,
  0xF0, 0x7D, 0xE0, 0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1F,
  0x7C, 0x3E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x0B, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0xFF, 0x3F, 0x8F, 0xC3, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0xC3, 0xF0, 0xFC, 0x7F, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xE0,
  0x7C, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFA, 0x01, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 23, 8, 1, -23 },
  { 19, 12, 8, 15, 1, -23 },
  { 31, 15, 23, 17, 1, -23 },
  { 75, 13, 26, 15, 1, -24 },
  { 118, 24, 23, 26, 1, -23 },
  { 187, 18, 23, 19, 1, -23 },
  { 239, 5, 8, 8, 1, -23 },
  { 244, 9, 28, 10, 1, -23 },
  { 276, 9, 28, 10, 0, -23 },
  { 308, 13, 13, 15, 1, -24 },
  { 330, 13, 15, 15, 1, -19 },
  { 355, 6, 8, 8, 1, -4 },
  { 361, 8, 5, 10, 1, -11 },
  { 366, 5, 5, 8, 2, -5 },
  { 370, 13, 23, 13, 0, -23 },
  { 408, 13, 23, 15, 1, -23 },
  { 446, 11, 23, 15, 1, -23 },
  { 478, 13, 23, 15, 1, -23 },
  { 516, 13, 23, 15, 1, -23 },
  { 554, 15, 23, 15, 0, -23 },
  { 598, 12, 23, 15, 2, -23 },
  { 633, 13, 23, 15, 1, -23 },
  { 671, 13, 23, 15, 1, -23 },
  { 709, 13, 23, 15, 1, -23 },
  { 747, 13, 23, 15, 1, -23 },
  { 785, 5, 18, 9, 2, -18 },
  { 797, 6, 22, 9, 1, -18 },
  { 814, 13, 15, 15, 1, -19 },
  { 839, 13, 10, 15, 1, -16 },
  { 856, 14, 15, 15, 1, -19 },
  { 883, 12, 23, 12, 0, -23 },
  { 918, 22, 25, 24, 1, -23 },
  { 987, 18, 23, 18, 0, -23 },
  { 1039, 14, 23, 17, 2, -23 },
  { 1080, 14, 23, 16, 1, -23 },
  { 1121, 15, 23, 18, 2, -23 },
  { 1165, 11, 23, 14, 2, -23 },
  { 1197, 11, 23, 14, 2, -23 },
  { 1229, 16, 23, 18, 1, -23 },
  { 1275, 15, 23, 19, 2, -23 },
  { 1319, 9, 23, 11, 1, -23 },
  { 1345, 9, 30, 9, -2, -23 },
  { 1379, 15, 23, 17, 2, -23 },
  { 1423, 11, 23, 13, 2, -23 },
  { 1455, 21, 23, 25, 2, -23 },
  { 1516, 16, 23, 21, 2, -23 },
  { 1562, 17, 23, 19, 1, -23 },
  { 1611, 13, 23, 16, 2, -23 },
  { 1649, 17, 28, 19, 1, -23 },
  { 1709, 15, 23, 17, 2, -23 },
  { 1753, 12, 23, 14, 1, -23 },
  { 1788, 13, 23, 14, 1, -23 },
  { 1826, 15, 23, 19, 2, -23 },
  { 1870, 17, 23, 17, 0, -23 },
  { 1919, 25, 23, 25, 0, -23 },
  { 1991, 16, 23, 16, 0, -23 },
  { 2037, 16, 23, 16, 0, -23 },
  { 2083, 13, 23, 14, 1, -23 },
  { 2121, 7, 28, 10, 2, -23 },
  { 2146, 13, 23, 13, 0, -23 },
  { 2184, 7, 28, 10, 1, -23 },
  { 2209, 17, 15, 17, 0, -23 },
  { 2241, 15, 3, 14, 0, 2 },
  { 2247, 8, 6, 10, 1, -25 },
  { 2253, 13, 18, 15, 1, -18 },
  { 2283, 13, 24, 16, 2, -24 },
  { 2322, 12, 18, 13, 1, -18 },
  { 2349, 14, 24, 16, 1, -24 },
  { 2391, 13, 18, 15, 1, -18 },
  { 2421, 11, 24, 10, 0, -24 },
  { 2454, 14, 26, 16, 1, -18 },
  { 2500, 13, 24, 16, 2, -24 },
  { 2539, 5, 25, 8, 2, -25 },
  { 2555, 8, 33, 8, -1, -25 },
  { 2588, 14, 24, 16, 2, -24 },
  { 2630, 4, 24, 8, 2, -24 },
  { 2642, 21, 18, 25, 2, -18 },
  { 2690, 13, 18, 16, 2, -18 },
  { 2720, 14, 18, 16, 1, -18 },
  { 2752, 13, 26, 16, 2, -18 },
  { 2795, 14, 26, 16, 1, -18 },
  { 2841, 9, 18, 12, 2, -18 },
  { 2862, 10, 18, 12, 1, -18 },
  { 2885, 10, 21, 11, 0, -21 },
  { 2912, 13, 18, 16, 2, -18 },
  { 2942, 15, 18, 15, 0, -18 },
  { 2976, 22, 18, 23, 0, -18 },
  { 3026, 14, 18, 14, 0, -18 },
  { 3058, 15, 26, 15, 0, -18 },
  { 3107, 10, 18, 12, 1, -18 },
  { 3130, 10, 28, 11, 0, -23 },
  { 3165, 4, 32, 14, 5, -25 },
  { 3181, 10, 28, 11, 1, -23 },
  { 3216, 14, 6, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD32PT7B_H_
