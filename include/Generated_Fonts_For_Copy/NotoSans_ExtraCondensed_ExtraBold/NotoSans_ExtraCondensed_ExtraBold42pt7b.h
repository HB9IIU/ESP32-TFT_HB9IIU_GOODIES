#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x1C, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFD, 0xCE, 0xF9,
  0xC2, 0xF9, 0xC0, 0xF9, 0xC0, 0xFD, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xDF, 0x01, 0xDF, 0x81, 0xDF, 0xE1, 0xDF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x7F, 0xE0, 0x3E,
  0x00, 0x7F, 0xF0, 0x3E, 0x00, 0x7D, 0xF0, 0x3C, 0x00, 0xF8, 0xF0, 0x7C,
  0x00, 0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0xF0, 0x00, 0xF8, 0xF9, 0xF0, 0x00, 0xF8, 0xF9, 0xE0,
  0x00, 0xF8, 0xF1, 0xE3, 0xF0, 0x79, 0xF3, 0xE7, 0xF8, 0x7F, 0xF3, 0xCF,
  0xFC, 0x3F, 0xE7, 0xCF, 0xFE, 0x3F, 0xE7, 0x8F, 0x3E, 0x1F, 0xC7, 0x9F,
  0x1E, 0x00, 0x0F, 0x9F, 0x1E, 0x00, 0x0F, 0x1F, 0x1E, 0x00, 0x1F, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x1E, 0x00, 0x3E, 0x1F,
  0x1E, 0x00, 0x3C, 0x1F, 0x1E, 0x00, 0x7C, 0x0F, 0x3E, 0x00, 0x7C, 0x0F,
  0xFE, 0x00, 0x78, 0x0F, 0xFC, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xBF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x7E, 0x3F, 0xF8,
  0xFE, 0x7F, 0xFC, 0xFE, 0x7F, 0xFE, 0xFC, 0xFE, 0xFE, 0xFC, 0xFC, 0x7F,
  0xFC, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFE, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xC0, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0xFC, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x63, 0xE1, 0x1E, 0xFB, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFF, 0xD0, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x87, 0xE3,
  0xF0, 0xF8, 0xF8, 0x0C, 0x18, 0x01, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xCF, 0xC7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xF3, 0xF7, 0x8F, 0xCC, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3,
  0xE3, 0xF8, 0xE0, 0xFE, 0x20, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xFC, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xEF, 0xC0, 0xFB, 0xF0, 0x3D, 0xFC,
  0x1F, 0x7F, 0x07, 0x9F, 0xC3, 0xE7, 0xF0, 0xF1, 0xFC, 0x7C, 0x7F, 0x1E,
  0x1F, 0xCF, 0x87, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x20, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC3, 0x81, 0xF3, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E, 0x7F,
  0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xF3, 0xF9, 0xF8, 0x7E, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xFB, 0xE1, 0xFC, 0xF8,
  0x1E, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x3E, 0x3F,
  0x7F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFE, 0x78, 0x7E, 0x20, 0x7F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x70, 0x3C, 0x7C, 0x3F, 0xF3,
  0xE7, 0x87, 0xFF, 0x1E, 0xF8, 0x7F, 0xF1, 0xEF, 0x8F, 0x8F, 0x1E, 0xF1,
  0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0x1F, 0xF1, 0xF1, 0xF1, 0xFF, 0x1E, 0x1F,
  0x1F, 0xF1, 0xE1, 0xF1, 0xFF, 0x1E, 0x1F, 0x1E, 0xF1, 0xE1, 0xF1, 0xEF,
  0x1F, 0x1F, 0x1E, 0xF1, 0xF1, 0xF3, 0xEF, 0x1F, 0xFF, 0xFC, 0xF8, 0xFF,
  0xFF, 0xCF, 0x87, 0xF3, 0xF8, 0x78, 0x3E, 0x1F, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x3E, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0xFC, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x1F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xF1, 0xC7, 0xF0, 0x11, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x02, 0x7F, 0xC3, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x0F,
  0xF7, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xBF, 0x07, 0xF7, 0xE1, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFC, 0x1C, 0x7F, 0x80, 0x47, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF7,
  0xF0, 0x3F, 0x3F, 0x83, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xF7,
  0xFF, 0xFF, 0x7F, 0xEF, 0xF9, 0xFE, 0x3F, 0x80, 0xFC, 0x07, 0xFF, 0xC0,
  0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC,
  0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFD, 0xFC, 0x0F,
  0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC1,
  0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7C,
  0x1F, 0xFF, 0xEF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0x7F,
  0xFB, 0xE3, 0xEF, 0xFF, 0x7C, 0x7D, 0xFF, 0xEF, 0x8F, 0xBF, 0xFD, 0xFB,
  0xE7, 0xFF, 0x9F, 0x7C, 0xFF, 0xF3, 0xEF, 0x9F, 0xFE, 0x7D, 0xF3, 0xFF,
  0xC7, 0xFC, 0x7F, 0xF8, 0xFF, 0x8F, 0xFF, 0x1F, 0xF1, 0xFF, 0xE3, 0xFC,
  0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE,
  0x1F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xC0, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFE, 0xFC, 0x7F, 0xF7, 0xE3, 0xFF, 0x9F, 0x1F, 0xFC, 0xFC, 0xFF, 0xF7,
  0xE7, 0xFF, 0x9F, 0xBF, 0xFC, 0xFD, 0xFF, 0xE3, 0xF7, 0xFF, 0x1F, 0xBF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F,
  0x1F, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E,
  0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F,
  0x8F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xE7, 0xFB, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0x7F, 0x9F, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF,
  0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F,
  0xC1, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xF9, 0xFF, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xF7, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC,
  0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xC0, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xBE, 0x7E, 0x06, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7E, 0xFF, 0x3F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0xFE, 0x03, 0xF0,
  0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F,
  0x03, 0xF3, 0xF0, 0x3F, 0x83, 0xF9, 0xF8, 0x3F, 0xC1, 0xFC, 0xFC, 0x1F,
  0xE0, 0xFC, 0x7E, 0x0F, 0xF8, 0x7E, 0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xC3,
  0xFE, 0x1F, 0x87, 0xE3, 0xEF, 0x1F, 0xC3, 0xF1, 0xF7, 0x8F, 0xC1, 0xF8,
  0xFB, 0xC7, 0xE0, 0x7C, 0x7D, 0xF3, 0xF0, 0x3F, 0x3E, 0xF9, 0xF8, 0x1F,
  0xBE, 0x7C, 0xFC, 0x0F, 0xDF, 0x3E, 0xFC, 0x07, 0xEF, 0x8F, 0x7E, 0x01,
  0xF7, 0xC7, 0xBF, 0x00, 0xFB, 0xE3, 0xFF, 0x80, 0x7D, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF3,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF,
  0xE0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF8,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0,
  0x7F, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x81, 0xFC,
  0xFE, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F,
  0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C,
  0x03, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x00, 0x40, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFB, 0xF8, 0x40, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC3,
  0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFE, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0x7C, 0xFF, 0x3E, 0x3F, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x3F, 0x0F, 0xDF, 0xE3, 0xF7, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xDF, 0xE3, 0xE3, 0xF0, 0x00, 0x40, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0xC1, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x05, 0xFC, 0x1B, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0x0F, 0xC3, 0xF3,
  0xF1, 0xFE, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF1, 0xFD,
  0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83,
  0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0x7C,
  0x3F, 0x1F, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xF3,
  0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x8F, 0xF7, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8,
  0x7F, 0x21, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0x00, 0x03, 0xF1, 0xF1, 0xFE, 0x7C, 0xFF, 0xDF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xF1, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFD,
  0x00, 0x7F, 0x78, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x10, 0x7E,
  0x7F, 0x3F, 0x7F, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0x0F, 0x87, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0xBF, 0xBF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xF0, 0x7F, 0x7E,
  0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC,
  0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFB, 0xF0, 0xFE, 0x7E, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x02, 0x0F, 0x8F, 0xE1, 0xF8, 0xF9, 0xFF, 0x3F, 0xCF,
  0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC7, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0x00, 0x10, 0x7C, 0x7F, 0x3E, 0x7F, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xC7, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC,
  0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x10, 0x3E, 0x3F, 0x0F, 0xDF, 0xE3, 0xF7, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x7F, 0xCF, 0xDF, 0xE3, 0xF3, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x00, 0x03, 0xF1, 0xF1, 0xFE,
  0x7C, 0xFF, 0xDF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF1, 0xFD, 0xF8, 0x3F,
  0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xF1,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x3F, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x27, 0xC7, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0xDF, 0xFE, 0x7F, 0xFB, 0xFB,
  0xEF, 0xC1, 0x3F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x23, 0xFF, 0x1F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFE, 0xF9, 0xFF, 0x7C, 0x7F, 0x3E, 0xFE, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0x80,
  0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0, 0xFF, 0x0F, 0xDF, 0x87, 0xF8,
  0x7E, 0xFC, 0x3F, 0xC3, 0xF7, 0xE1, 0xFE, 0x1F, 0x3F, 0x1F, 0xF1, 0xF8,
  0xFC, 0xFF, 0x8F, 0xC7, 0xE7, 0xBE, 0x7E, 0x3F, 0x3D, 0xF3, 0xF1, 0xF9,
  0xE7, 0x9F, 0x0F, 0xDF, 0x3D, 0xF8, 0x3E, 0xF9, 0xEF, 0xC1, 0xF7, 0xCF,
  0x7E, 0x0F, 0xFC, 0x7B, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x00, 0xFE, 0x0F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xFC, 0xFE, 0x1F,
  0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0xBF, 0x83, 0xF8, 0xFE, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x07,
  0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x17, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x87, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFC, 0x0F, 0xFA, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 30, 11, 2, -30 },
  { 28, 16, 11, 19, 2, -30 },
  { 50, 20, 30, 22, 1, -30 },
  { 125, 16, 34, 20, 2, -32 },
  { 193, 32, 30, 34, 1, -30 },
  { 313, 24, 30, 25, 1, -30 },
  { 403, 6, 11, 10, 2, -30 },
  { 412, 11, 37, 13, 2, -30 },
  { 463, 12, 37, 13, 0, -30 },
  { 519, 18, 18, 19, 1, -32 },
  { 560, 18, 20, 20, 1, -25 },
  { 605, 8, 11, 11, 1, -5 },
  { 616, 11, 6, 13, 1, -14 },
  { 625, 7, 7, 11, 2, -7 },
  { 632, 17, 30, 17, 0, -30 },
  { 696, 18, 30, 20, 1, -30 },
  { 764, 14, 30, 20, 2, -30 },
  { 817, 17, 30, 20, 1, -30 },
  { 881, 17, 30, 20, 1, -30 },
  { 945, 18, 30, 20, 1, -30 },
  { 1013, 16, 30, 20, 2, -30 },
  { 1073, 18, 30, 20, 1, -30 },
  { 1141, 18, 30, 20, 1, -30 },
  { 1209, 18, 30, 20, 1, -30 },
  { 1277, 18, 30, 20, 1, -30 },
  { 1345, 7, 23, 11, 2, -23 },
  { 1366, 8, 29, 11, 1, -23 },
  { 1395, 18, 20, 20, 1, -25 },
  { 1440, 18, 14, 20, 1, -22 },
  { 1472, 18, 20, 20, 1, -25 },
  { 1517, 16, 30, 16, 0, -30 },
  { 1577, 28, 33, 31, 2, -30 },
  { 1693, 23, 30, 23, 0, -30 },
  { 1780, 18, 30, 23, 3, -30 },
  { 1848, 18, 30, 21, 2, -30 },
  { 1916, 19, 30, 24, 3, -30 },
  { 1988, 14, 30, 18, 3, -30 },
  { 2041, 13, 30, 18, 3, -30 },
  { 2090, 20, 30, 24, 2, -30 },
  { 2165, 19, 30, 25, 3, -30 },
  { 2237, 12, 30, 14, 1, -30 },
  { 2282, 11, 39, 12, -2, -30 },
  { 2336, 20, 30, 22, 3, -30 },
  { 2411, 14, 30, 17, 3, -30 },
  { 2464, 27, 30, 33, 3, -30 },
  { 2566, 21, 30, 27, 3, -30 },
  { 2645, 22, 30, 25, 2, -30 },
  { 2728, 17, 30, 21, 3, -30 },
  { 2792, 22, 37, 25, 2, -30 },
  { 2894, 19, 30, 22, 3, -30 },
  { 2966, 16, 30, 18, 1, -30 },
  { 3026, 17, 30, 19, 1, -30 },
  { 3090, 19, 30, 24, 3, -30 },
  { 3162, 22, 30, 22, 0, -30 },
  { 3245, 33, 30, 33, 0, -30 },
  { 3369, 21, 30, 21, 0, -30 },
  { 3448, 21, 30, 21, 0, -30 },
  { 3527, 17, 30, 18, 1, -30 },
  { 3591, 10, 37, 13, 2, -30 },
  { 3638, 17, 30, 17, 0, -30 },
  { 3702, 10, 37, 13, 1, -30 },
  { 3749, 21, 19, 23, 1, -30 },
  { 3799, 19, 4, 19, 0, 3 },
  { 3809, 10, 7, 14, 2, -32 },
  { 3818, 17, 24, 20, 1, -24 },
  { 3869, 18, 32, 21, 2, -32 },
  { 3941, 15, 24, 17, 1, -24 },
  { 3986, 18, 32, 21, 1, -32 },
  { 4058, 17, 23, 20, 1, -23 },
  { 4107, 14, 32, 13, 0, -32 },
  { 4163, 18, 34, 21, 1, -24 },
  { 4240, 17, 32, 22, 2, -32 },
  { 4308, 7, 32, 11, 2, -32 },
  { 4336, 10, 42, 11, -1, -32 },
  { 4389, 19, 32, 21, 2, -32 },
  { 4465, 6, 32, 11, 2, -32 },
  { 4489, 28, 24, 32, 2, -24 },
  { 4573, 17, 24, 22, 2, -24 },
  { 4624, 19, 24, 21, 1, -24 },
  { 4681, 18, 34, 21, 2, -24 },
  { 4758, 18, 34, 21, 1, -24 },
  { 4835, 13, 24, 15, 2, -24 },
  { 4874, 14, 24, 16, 1, -24 },
  { 4916, 13, 28, 14, 0, -28 },
  { 4962, 17, 23, 22, 2, -23 },
  { 5011, 19, 23, 20, 0, -23 },
  { 5066, 29, 23, 30, 0, -23 },
  { 5150, 19, 23, 19, 0, -23 },
  { 5205, 19, 33, 20, 0, -23 },
  { 5284, 14, 23, 16, 1, -23 },
  { 5325, 14, 37, 15, 0, -30 },
  { 5390, 6, 42, 18, 6, -32 },
  { 5422, 13, 37, 15, 1, -30 },
  { 5483, 18, 8, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD42PT7B_H_
