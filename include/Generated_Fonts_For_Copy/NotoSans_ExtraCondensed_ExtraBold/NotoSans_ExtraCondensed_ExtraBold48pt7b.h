#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08,
  0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xF0, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xDC, 0x33, 0xF3, 0x80, 0x7E, 0x70, 0x0F, 0xCE, 0x01,
  0xFD, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0x7F, 0x00, 0xE7, 0xE0, 0x1C, 0xFF, 0x03, 0x9F, 0xF0, 0x77, 0xFF,
  0xCF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F,
  0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xF8, 0x07, 0xC0,
  0x07, 0xEF, 0xC0, 0x7C, 0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0xF8, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE1, 0xF0, 0x00, 0xFC,
  0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x3E, 0x00,
  0x0F, 0xC7, 0xE7, 0xE0, 0x00, 0x7C, 0x7C, 0x7C, 0x3F, 0x07, 0xC7, 0xC7,
  0xC7, 0xF8, 0x7E, 0xFC, 0xF8, 0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F,
  0xF9, 0xF9, 0xFF, 0xE1, 0xFF, 0x1F, 0x3F, 0x3F, 0x0F, 0xE1, 0xF3, 0xF3,
  0xF0, 0x38, 0x3E, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE1, 0xF0, 0x00, 0x7E,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x83, 0xF1,
  0xF0, 0x01, 0xF0, 0x3F, 0x3F, 0x00, 0x1F, 0x01, 0xFF, 0xE0, 0x03, 0xE0,
  0x1F, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x07, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x1F, 0xE0, 0xFF, 0xE1, 0xFE, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF,
  0xF1, 0xFC, 0x7F, 0xFF, 0xBF, 0xC7, 0xF3, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF,
  0x8F, 0xE1, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE,
  0x07, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFB, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x06, 0x1F, 0x86, 0x78, 0xF1, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3F, 0x9F, 0xC7, 0xF0, 0xFE,
  0x1F, 0x0F, 0x80, 0x60, 0x60, 0x02, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x9F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xDF, 0xC1, 0xFB,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x3E, 0x7F,
  0x1C, 0x7F, 0x08, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xC1, 0xFE, 0x18, 0x0F, 0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0x7F, 0xE1, 0x80, 0xFE, 0x10, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x60, 0x1F,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xBF, 0x80,
  0xFD, 0xFC, 0x07, 0xCF, 0xE0, 0x7E, 0x7F, 0x03, 0xE3, 0xF8, 0x3F, 0x1F,
  0xC1, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x41, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xF8,
  0x61, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x0C, 0x07, 0xE7, 0xF8, 0x7E, 0xFF, 0xC7, 0xEF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xDF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF8, 0x7F, 0x3F, 0x8F, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF9, 0xFE, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x07,
  0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xFB, 0xF1, 0xFF, 0x7F, 0x07,
  0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1C, 0x7F, 0x7F, 0x7F,
  0xFF, 0x7F, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x08,
  0x1C, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3F, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xEF, 0xF8, 0xC0, 0xFF, 0x20,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x7C, 0x3E, 0x0F, 0xFE, 0x3E, 0x7C, 0x1F,
  0xFE, 0x3E, 0x7C, 0x3F, 0xFE, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0xF8, 0x7E,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF8, 0xFC,
  0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8,
  0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0xFC,
  0x7E, 0x3E, 0xF8, 0x7C, 0x7E, 0x3E, 0xF8, 0x7F, 0xFF, 0xFC, 0xFC, 0x7F,
  0xEF, 0xFC, 0x7C, 0x3F, 0xEF, 0xF8, 0x7C, 0x1F, 0xC7, 0xF0, 0x7E, 0x02,
  0x00, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x40, 0x0F, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFC, 0x3F, 0xEF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFC, 0x0C, 0x3F, 0xC0, 0x23, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x23, 0xFE, 0x06, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xE1, 0xFF, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0xBF, 0x9F, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF0, 0x0C, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0x01, 0xFD,
  0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF,
  0x3F, 0xF1, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8,
  0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF9, 0xFE, 0x07,
  0xF3, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0x8F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFE,
  0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0x7F, 0xFF, 0xF8, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC,
  0x3F, 0x7F, 0xFE, 0xFC, 0x3E, 0x7F, 0xFE, 0xFC, 0x7E, 0x7F, 0xFE, 0x7E,
  0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7C, 0x7F, 0xFE, 0x7E,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F,
  0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xF7,
  0xE1, 0xFF, 0xFB, 0xF8, 0xFF, 0xFD, 0xFC, 0x7F, 0xFE, 0x7F, 0x3F, 0xFF,
  0x3F, 0x9F, 0xFF, 0x8F, 0xEF, 0xFF, 0xC7, 0xF7, 0xFF, 0xE1, 0xFB, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F,
  0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF,
  0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x1F, 0xE1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F,
  0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE3, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE3,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8,
  0x3F, 0xCF, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF9, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0x7F,
  0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFC, 0x1C, 0x7F, 0x00, 0x8F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xEF, 0xC7, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03,
  0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x7F, 0x03, 0xFE,
  0x07, 0xF0, 0xFC, 0x0F, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xDF, 0x0F, 0xE0, 0xFE, 0x1F, 0x7C,
  0x3F, 0x81, 0xF8, 0x7D, 0xF0, 0xFE, 0x07, 0xF3, 0xF7, 0xE7, 0xF8, 0x1F,
  0xCF, 0xDF, 0x9F, 0xC0, 0x7F, 0x3F, 0x7E, 0x7F, 0x01, 0xFC, 0xFC, 0xF9,
  0xFC, 0x03, 0xF3, 0xE3, 0xE7, 0xF0, 0x0F, 0xCF, 0x8F, 0x9F, 0xC0, 0x3F,
  0x7E, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xE1, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE7, 0xF0, 0x1F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3,
  0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3,
  0x03, 0xF8, 0x40, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFC, 0x7F, 0x7F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFE,
  0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xF3, 0xE7, 0xFE, 0x7C, 0x7F,
  0x0F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC3, 0xC0, 0xFC, 0xFF, 0x0F, 0xDF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xF1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0xBF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xDF, 0xF8, 0xFD, 0xFF, 0x8F, 0x87, 0xF0, 0x01, 0xF8, 0x03, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFE, 0x19, 0xFE,
  0x04, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x13, 0xFE, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x78, 0x7F, 0x1F, 0xE7, 0xF3, 0xFF, 0x7F,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0xBF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF3, 0xF0, 0xFE, 0x3F,
  0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x9F, 0xC3, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x04, 0xFF, 0x07, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xE2, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0xFE, 0x3F,
  0x1F, 0xF3, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x9F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1, 0xFF, 0x7F,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE6, 0x00, 0xFE, 0x7F, 0x7F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x87, 0x83, 0xF3, 0xFC, 0x7E,
  0xFF, 0xCF, 0xDF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0x08, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x9F,
  0xC1, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x03,
  0xE1, 0xF1, 0xFF, 0x1F, 0xF3, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xF8, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83,
  0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F,
  0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x3C, 0x1F, 0x1F, 0xE3, 0xE7,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x7F, 0x0F, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x0F, 0x8F, 0xF0,
  0xFD, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x1F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFF, 0x0F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFD, 0xFF, 0x8F, 0xCF, 0xF8,
  0xFC, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFE, 0x3F, 0x1F, 0xF3, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0x9F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1,
  0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE,
  0x0C, 0xFE, 0x02, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE, 0x1F, 0xFF, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E,
  0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x83, 0xF9, 0xFC,
  0x3F, 0xF0, 0xFE, 0x7F, 0x0F, 0xFC, 0x3F, 0x9F, 0xC3, 0xFF, 0x0F, 0xC3,
  0xF0, 0xFF, 0xC7, 0xF0, 0xFE, 0x3F, 0xF1, 0xFC, 0x3F, 0x9F, 0x7C, 0x7F,
  0x0F, 0xE7, 0xCF, 0x9F, 0x81, 0xF9, 0xF3, 0xE7, 0xE0, 0x7E, 0x7C, 0xF9,
  0xF8, 0x1F, 0x9F, 0x3E, 0xFE, 0x07, 0xF7, 0xCF, 0xBF, 0x81, 0xFF, 0xE3,
  0xEF, 0xC0, 0x3F, 0xF8, 0x7B, 0xF0, 0x0F, 0xFE, 0x1E, 0xFC, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC1,
  0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x1F, 0x81, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x02, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xD0, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 35, 13, 2, -34 },
  { 36, 18, 12, 22, 2, -34 },
  { 63, 23, 34, 25, 1, -34 },
  { 161, 19, 39, 23, 2, -36 },
  { 254, 36, 35, 39, 1, -35 },
  { 412, 28, 35, 29, 1, -35 },
  { 535, 8, 12, 12, 2, -34 },
  { 547, 13, 43, 15, 2, -35 },
  { 617, 13, 43, 15, 0, -35 },
  { 687, 20, 21, 22, 1, -37 },
  { 740, 21, 24, 23, 1, -29 },
  { 803, 9, 12, 12, 1, -6 },
  { 817, 13, 6, 15, 1, -16 },
  { 827, 8, 9, 13, 2, -8 },
  { 836, 20, 35, 20, 0, -35 },
  { 924, 19, 35, 23, 2, -35 },
  { 1008, 16, 34, 23, 2, -34 },
  { 1076, 20, 35, 23, 1, -35 },
  { 1164, 20, 35, 23, 1, -35 },
  { 1252, 21, 34, 23, 1, -34 },
  { 1342, 19, 34, 23, 2, -34 },
  { 1423, 20, 35, 23, 1, -35 },
  { 1511, 20, 34, 23, 1, -34 },
  { 1596, 20, 35, 23, 1, -35 },
  { 1684, 20, 35, 23, 1, -35 },
  { 1772, 8, 28, 13, 2, -27 },
  { 1800, 8, 33, 13, 2, -27 },
  { 1833, 21, 23, 23, 1, -29 },
  { 1894, 21, 16, 23, 1, -25 },
  { 1936, 21, 23, 23, 1, -29 },
  { 1997, 18, 36, 18, 0, -35 },
  { 2078, 32, 39, 36, 2, -35 },
  { 2234, 26, 34, 26, 0, -34 },
  { 2345, 21, 34, 26, 3, -34 },
  { 2435, 21, 35, 24, 2, -35 },
  { 2527, 22, 34, 27, 3, -34 },
  { 2621, 16, 34, 21, 3, -34 },
  { 2689, 16, 34, 21, 3, -34 },
  { 2757, 23, 35, 28, 2, -35 },
  { 2858, 23, 34, 29, 3, -34 },
  { 2956, 14, 34, 16, 1, -34 },
  { 3016, 13, 44, 13, -3, -34 },
  { 3088, 23, 34, 26, 3, -34 },
  { 3186, 16, 34, 20, 3, -34 },
  { 3254, 32, 34, 38, 3, -34 },
  { 3390, 25, 34, 31, 3, -34 },
  { 3497, 25, 35, 29, 2, -35 },
  { 3607, 20, 34, 24, 3, -34 },
  { 3692, 25, 43, 29, 2, -35 },
  { 3827, 22, 34, 25, 3, -34 },
  { 3921, 19, 35, 21, 1, -35 },
  { 4005, 20, 34, 21, 1, -34 },
  { 4090, 22, 34, 28, 3, -34 },
  { 4184, 25, 34, 25, 0, -34 },
  { 4291, 38, 34, 37, 0, -34 },
  { 4453, 24, 34, 24, 0, -34 },
  { 4555, 24, 34, 24, 0, -34 },
  { 4657, 19, 34, 21, 1, -34 },
  { 4738, 12, 43, 15, 2, -35 },
  { 4803, 20, 35, 20, 0, -35 },
  { 4891, 11, 43, 15, 1, -35 },
  { 4951, 24, 21, 26, 1, -34 },
  { 5014, 22, 4, 22, 0, 4 },
  { 5025, 12, 8, 16, 2, -37 },
  { 5037, 19, 27, 23, 1, -27 },
  { 5102, 20, 36, 25, 3, -36 },
  { 5192, 17, 27, 20, 2, -27 },
  { 5250, 20, 36, 25, 2, -36 },
  { 5340, 19, 27, 23, 2, -27 },
  { 5405, 16, 37, 15, 0, -37 },
  { 5479, 20, 39, 25, 2, -27 },
  { 5577, 19, 36, 25, 3, -36 },
  { 5663, 8, 37, 12, 2, -37 },
  { 5700, 12, 49, 12, -2, -37 },
  { 5774, 21, 36, 24, 3, -36 },
  { 5869, 7, 36, 12, 3, -36 },
  { 5901, 31, 27, 37, 3, -27 },
  { 6006, 19, 27, 25, 3, -27 },
  { 6071, 20, 27, 24, 2, -27 },
  { 6139, 20, 39, 25, 3, -27 },
  { 6237, 20, 39, 25, 2, -27 },
  { 6335, 14, 27, 17, 3, -27 },
  { 6383, 16, 27, 18, 1, -27 },
  { 6437, 15, 32, 16, 0, -32 },
  { 6497, 20, 26, 25, 2, -26 },
  { 6562, 22, 26, 22, 0, -26 },
  { 6634, 34, 26, 34, 0, -26 },
  { 6745, 21, 26, 21, 0, -26 },
  { 6814, 22, 38, 22, 0, -26 },
  { 6919, 16, 26, 18, 1, -26 },
  { 6971, 15, 43, 17, 1, -35 },
  { 7052, 6, 48, 21, 7, -37 },
  { 7088, 16, 43, 17, 1, -35 },
  { 7174, 21, 8, 23, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD48PT7B_H_
