#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xC7, 0xE0, 0x80, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFE, 0xFE, 0x3F, 0xDF, 0xC3, 0xFB,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x01,
  0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xC0, 0x0F,
  0x87, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F,
  0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFE, 0x70, 0xCF, 0xE7, 0x00, 0xFE, 0x70, 0x0F, 0xE7,
  0x00, 0x7E, 0x70, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0x7F, 0x00, 0x73, 0xF8, 0x07, 0x3F,
  0xC0, 0x77, 0xFF, 0x07, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x01, 0xF9, 0xF8, 0x1F,
  0x80, 0x07, 0xC7, 0xE0, 0x7C, 0x00, 0x1F, 0x1F, 0x81, 0xF0, 0x00, 0xFC,
  0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE3, 0xE0, 0xF8, 0x1F, 0x1F, 0x9F, 0x8F,
  0xF0, 0x7E, 0x7E, 0x7C, 0x7F, 0xE1, 0xFF, 0xF1, 0xF3, 0xFF, 0xC3, 0xFF,
  0xCF, 0xCF, 0xFF, 0x87, 0xFE, 0x3E, 0x3E, 0x7E, 0x1F, 0xF1, 0xF9, 0xF8,
  0xF8, 0x1F, 0x87, 0xC7, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC3,
  0xF0, 0x00, 0x7C, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0xFC, 0x00, 0x3E, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0x1F, 0x9F,
  0x80, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x7F, 0x87, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0x1F,
  0xC7, 0xFF, 0xF9, 0xFE, 0x3F, 0xDF, 0xEF, 0xF1, 0xFC, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xC7, 0xF8, 0x3F, 0xFC, 0x3F, 0xC1,
  0xFF, 0xE1, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x38, 0x7C, 0x39, 0xF3, 0xE7, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x07, 0xC1, 0xF0, 0x0E, 0x0E, 0x00, 0x20, 0x20, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0xBF,
  0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x08, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xBF, 0xC7,
  0xF1, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xEF, 0xF3, 0xE7, 0xF8, 0xE3, 0xFC, 0x21, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1,
  0xFC, 0x7F, 0xC7, 0x81, 0xFE, 0x18, 0x0F, 0xF0, 0x80, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7C, 0x3F,
  0xE3, 0x01, 0xFE, 0x20, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0xFE, 0x00, 0xFB,
  0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0x7F, 0x80, 0xFD, 0xFE, 0x03, 0xE7, 0xF8,
  0x1F, 0x9F, 0xE0, 0x7C, 0x7F, 0x83, 0xF1, 0xFE, 0x0F, 0x87, 0xF8, 0x7E,
  0x1F, 0xE1, 0xF0, 0x7F, 0x8F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xC7, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xEF, 0x03, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xF0, 0x23, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x08,
  0x0F, 0xE7, 0xF0, 0xFE, 0xFF, 0x8F, 0xFF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF9, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF9, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF9, 0xFE, 0x3F,
  0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFF, 0x7F, 0xEF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x7F, 0xCF, 0xF0, 0xFE, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x87, 0xFB, 0xFE,
  0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFD, 0xFC,
  0x3F, 0xCF, 0xE0, 0x78, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x1E, 0x1F, 0x9F,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xE3,
  0xFC, 0xC0, 0x7F, 0x20, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0xFE, 0x1F, 0x8F, 0x81, 0xFF, 0xC7, 0xCF, 0xC1, 0xFF, 0xE3, 0xE7, 0xC1,
  0xFF, 0xF0, 0xFB, 0xE1, 0xFC, 0xF8, 0x7D, 0xF0, 0xF8, 0x7C, 0x3F, 0xF8,
  0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F, 0xFC, 0x3E, 0x0F, 0x87, 0xFE,
  0x1F, 0x07, 0xC3, 0xFF, 0x1F, 0x83, 0xE1, 0xFF, 0x8F, 0xC1, 0xF0, 0xFF,
  0xC7, 0xE1, 0xF8, 0x7F, 0xE1, 0xF0, 0xFC, 0x3F, 0xF0, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7C, 0x3F, 0x1F, 0x7C, 0x3F, 0x3F, 0x8F, 0xBF, 0x0F, 0xFF, 0xFF,
  0x8F, 0x87, 0xFE, 0xFF, 0xC7, 0xC1, 0xFE, 0x3F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xEF,
  0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x9F, 0x0F, 0xF8, 0x0C, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x10, 0xFF, 0xC1, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFC, 0x7C,
  0x3F, 0xF0, 0x0C, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xF0, 0x7F, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFC, 0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xF7, 0xE0, 0xFD, 0xFF, 0xFB,
  0xF0, 0x7E, 0xFF, 0xFD, 0xF8, 0x3F, 0x7F, 0xFE, 0x7E, 0x1F, 0xBF, 0xFF,
  0x3F, 0x1F, 0x9F, 0xFF, 0x9F, 0x8F, 0xCF, 0xFF, 0xCF, 0xC7, 0xE7, 0xFF,
  0xE3, 0xF7, 0xE3, 0xFF, 0xF1, 0xFB, 0xF1, 0xFF, 0xF8, 0xFD, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xBF, 0x87, 0xFF, 0xEF, 0xE1, 0xFF, 0xFB, 0xFC, 0x7F, 0xFE, 0x7F,
  0x1F, 0xFF, 0x9F, 0xC7, 0xFF, 0xE3, 0xF9, 0xFF, 0xF8, 0xFE, 0x7F, 0xFE,
  0x1F, 0xDF, 0xFF, 0x87, 0xF7, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1,
  0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0xFF, 0x1F,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC,
  0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC3,
  0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFC, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFC, 0x0E, 0x7F, 0x80, 0x4F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF,
  0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xC0, 0xFF, 0x3F,
  0x80, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0xF8, 0x7F, 0x87, 0xF0, 0x7D, 0xF0, 0xFF, 0x0F, 0xF1, 0xFB,
  0xE1, 0xFC, 0x0F, 0xE3, 0xF7, 0xC3, 0xF8, 0x1F, 0xC7, 0xEF, 0xC7, 0xF0,
  0x3F, 0x8F, 0xDF, 0x9F, 0xE0, 0x7F, 0x1F, 0xBF, 0x3F, 0xC0, 0xFE, 0x7E,
  0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x7C, 0xFE, 0x01, 0xFD, 0xF8, 0xF9, 0xFC,
  0x03, 0xFB, 0xF1, 0xFB, 0xF8, 0x07, 0xF7, 0xE3, 0xF7, 0xF0, 0x0F, 0xEF,
  0x87, 0xFF, 0xC0, 0x0F, 0xDF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0xFF,
  0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x9F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x0F,
  0xF0, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0x7F, 0x7F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF,
  0x3F, 0xF3, 0xF1, 0xFE, 0x1F, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x87,
  0x81, 0xFC, 0xFF, 0x0F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0xFF, 0x9F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFB, 0xFF, 0x8F, 0xCF, 0xF8, 0x7E, 0x3F, 0x80,
  0x00, 0x20, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFC, 0x71, 0xFE, 0x04, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x9F, 0xE0, 0x67, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC1,
  0xF0, 0xFE, 0x1F, 0xE7, 0xF1, 0xFF, 0xBF, 0x9F, 0xFD, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xEF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xF7, 0xF1, 0xFF, 0x9F, 0x87, 0xF0,
  0xFC, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x06, 0x7F,
  0xE3, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x84, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xC1, 0xF8, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xF7,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xDF, 0xC7, 0xFC,
  0xFE, 0x1F, 0xC7, 0xF0, 0x10, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x60, 0x0F, 0xF3, 0xE0, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x3E, 0x0F, 0xEF, 0xF8, 0xFE, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x7F,
  0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x87, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE,
  0xFE, 0x07, 0xFB, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE,
  0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xE0, 0xFF, 0x3F, 0xC3, 0xF8,
  0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F,
  0xCF, 0xE0, 0x7F, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F,
  0x01, 0xF0, 0x7E, 0x7F, 0xC3, 0xFE, 0x3F, 0x7F, 0xF3, 0xFF, 0x9F, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0x03, 0xF8, 0x3F,
  0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x07,
  0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0x81, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xCF, 0xF8, 0xFD,
  0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE0,
  0xFE, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x3F,
  0xC3, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x3E, 0x07,
  0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFE, 0x3F, 0xDF, 0xE1, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x87, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xF7, 0xFE, 0x3F, 0xBF, 0xE1, 0xFC, 0xFE, 0x0F, 0xE0,
  0x80, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x7F, 0x9F, 0xC7,
  0xFE, 0xFE, 0x7F, 0xF7, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xDF, 0xC7, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0x10, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3, 0xF7, 0xEF, 0xEF, 0xDF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFC, 0x39, 0xFC,
  0x04, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE1, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFE, 0x00, 0x20, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xBF, 0x3F,
  0xF3, 0xF1, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03,
  0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x81,
  0xFD, 0xFC, 0x1F, 0xF0, 0x7F, 0x3F, 0x83, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0xE1, 0xFC, 0x7F, 0x1F, 0xFC, 0x3F, 0x8F, 0xE3, 0xEF, 0x87, 0xF1, 0xFC,
  0x7D, 0xF1, 0xFC, 0x3F, 0x8F, 0xBE, 0x3F, 0x87, 0xF1, 0xF7, 0xE7, 0xF0,
  0x7F, 0x3E, 0xFC, 0xFE, 0x0F, 0xEF, 0xCF, 0x9F, 0x81, 0xFD, 0xF1, 0xF7,
  0xF0, 0x3F, 0xBE, 0x3E, 0xFE, 0x07, 0xF7, 0xC7, 0xDF, 0xC0, 0x7E, 0xF8,
  0xFB, 0xF8, 0x0F, 0xDF, 0x1F, 0x7E, 0x01, 0xFB, 0xE1, 0xFF, 0xC0, 0x3F,
  0x7C, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9,
  0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD,
  0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x5F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xB0, 0x07, 0xFC, 0x80, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 37, 13, 2, -36 },
  { 43, 19, 13, 23, 2, -36 },
  { 74, 24, 36, 26, 1, -36 },
  { 182, 20, 41, 24, 2, -38 },
  { 285, 38, 36, 40, 1, -36 },
  { 456, 29, 37, 30, 1, -36 },
  { 591, 8, 13, 12, 2, -36 },
  { 604, 14, 44, 16, 2, -36 },
  { 681, 14, 44, 16, 0, -36 },
  { 758, 21, 21, 23, 1, -38 },
  { 814, 20, 24, 24, 2, -30 },
  { 874, 9, 13, 13, 2, -6 },
  { 889, 13, 7, 16, 1, -17 },
  { 901, 9, 9, 13, 2, -8 },
  { 912, 20, 36, 21, 0, -36 },
  { 1002, 20, 37, 24, 2, -36 },
  { 1095, 17, 36, 24, 2, -36 },
  { 1172, 21, 36, 24, 1, -36 },
  { 1267, 20, 37, 24, 2, -36 },
  { 1360, 22, 36, 24, 1, -36 },
  { 1459, 20, 37, 24, 2, -36 },
  { 1552, 20, 37, 24, 2, -36 },
  { 1645, 21, 36, 24, 1, -36 },
  { 1740, 21, 37, 24, 1, -36 },
  { 1838, 21, 37, 24, 1, -36 },
  { 1936, 8, 29, 13, 3, -28 },
  { 1965, 9, 35, 13, 2, -28 },
  { 2005, 22, 24, 24, 1, -30 },
  { 2071, 22, 17, 24, 1, -26 },
  { 2118, 21, 24, 24, 2, -30 },
  { 2181, 18, 37, 19, 0, -36 },
  { 2265, 33, 40, 37, 2, -36 },
  { 2430, 27, 36, 27, 0, -36 },
  { 2552, 22, 36, 27, 3, -36 },
  { 2651, 22, 37, 25, 2, -36 },
  { 2753, 24, 36, 29, 3, -36 },
  { 2861, 17, 36, 22, 3, -36 },
  { 2938, 17, 36, 22, 3, -36 },
  { 3015, 24, 37, 29, 2, -36 },
  { 3126, 24, 36, 30, 3, -36 },
  { 3234, 14, 36, 17, 1, -36 },
  { 3297, 14, 47, 14, -3, -36 },
  { 3380, 24, 36, 27, 3, -36 },
  { 3488, 17, 36, 21, 3, -36 },
  { 3565, 33, 36, 39, 3, -36 },
  { 3714, 26, 36, 32, 3, -36 },
  { 3831, 26, 37, 30, 2, -36 },
  { 3952, 21, 36, 25, 3, -36 },
  { 4047, 26, 45, 30, 2, -36 },
  { 4194, 23, 36, 26, 3, -36 },
  { 4298, 19, 37, 22, 1, -36 },
  { 4386, 20, 36, 22, 1, -36 },
  { 4476, 23, 37, 29, 3, -36 },
  { 4583, 27, 36, 27, 0, -36 },
  { 4705, 39, 36, 39, 0, -36 },
  { 4881, 25, 36, 25, 0, -36 },
  { 4994, 25, 36, 25, 0, -36 },
  { 5107, 20, 36, 22, 1, -36 },
  { 5197, 12, 44, 15, 2, -36 },
  { 5263, 20, 36, 21, 0, -36 },
  { 5353, 12, 44, 15, 1, -36 },
  { 5419, 25, 23, 27, 1, -36 },
  { 5491, 23, 4, 23, 0, 4 },
  { 5503, 12, 8, 16, 2, -38 },
  { 5515, 20, 29, 24, 1, -28 },
  { 5588, 21, 39, 26, 3, -38 },
  { 5691, 18, 29, 21, 2, -28 },
  { 5757, 21, 39, 26, 2, -38 },
  { 5860, 20, 29, 23, 2, -28 },
  { 5933, 17, 38, 16, 0, -38 },
  { 6014, 21, 40, 26, 2, -28 },
  { 6119, 20, 38, 26, 3, -38 },
  { 6214, 8, 38, 13, 2, -38 },
  { 6252, 12, 50, 13, -2, -38 },
  { 6327, 22, 38, 25, 3, -38 },
  { 6432, 7, 38, 13, 3, -38 },
  { 6466, 33, 28, 38, 3, -28 },
  { 6582, 20, 28, 26, 3, -28 },
  { 6652, 21, 29, 25, 2, -28 },
  { 6729, 21, 40, 26, 3, -28 },
  { 6834, 21, 40, 26, 2, -28 },
  { 6939, 15, 28, 18, 3, -28 },
  { 6992, 17, 29, 19, 1, -28 },
  { 7054, 16, 34, 17, 0, -33 },
  { 7122, 20, 29, 26, 3, -28 },
  { 7195, 23, 28, 23, 0, -28 },
  { 7276, 35, 27, 35, 0, -27 },
  { 7395, 22, 27, 22, 0, -27 },
  { 7470, 23, 40, 23, 0, -28 },
  { 7585, 17, 28, 19, 1, -28 },
  { 7645, 15, 44, 18, 1, -36 },
  { 7728, 6, 50, 22, 8, -38 },
  { 7766, 16, 44, 18, 1, -36 },
  { 7854, 22, 9, 24, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD50PT7B_H_
