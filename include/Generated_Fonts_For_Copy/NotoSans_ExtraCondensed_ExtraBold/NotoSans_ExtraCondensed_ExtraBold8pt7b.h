#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x30, 0xFC, 0x55, 0xF6, 0xF6, 0x3F, 0x1A, 0xC0, 0x4A, 0xCB,
  0x97, 0x2C, 0xB0, 0x63, 0x19, 0xFB, 0x7C, 0xF0, 0x6B, 0x48, 0x90, 0x95,
  0x5C, 0x4F, 0xE0, 0x44, 0xF4, 0xE0, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x6E,
  0xBB, 0xE6, 0x3D, 0x92, 0x40, 0x74, 0xB5, 0xC0, 0x6A, 0x26, 0x3E, 0x26,
  0x6A, 0xF2, 0x6B, 0x93, 0xC0, 0x64, 0xAF, 0xF6, 0xF2, 0x22, 0x44, 0x6E,
  0x66, 0xB6, 0x6E, 0xB7, 0x2E, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF, 0x86,
  0x78, 0xD5, 0xA0, 0x80, 0x31, 0x2B, 0x6D, 0xB9, 0x23, 0x00, 0x66, 0x75,
  0xF9, 0xED, 0xFF, 0xDF, 0x75, 0xCC, 0xC7, 0xEF, 0xDD, 0xDE, 0xEB, 0xB0,
  0xEB, 0xA0, 0x35, 0xCF, 0x57, 0xB7, 0xFB, 0x40, 0xD5, 0x70, 0x55, 0x5E,
  0xBF, 0x6F, 0x40, 0xDB, 0x6D, 0xC0, 0x9C, 0xF7, 0xDE, 0xD4, 0xBB, 0xFD,
  0xBB, 0x72, 0xB5, 0xBD, 0x38, 0xEF, 0xDE, 0xCC, 0x72, 0xB5, 0xBD, 0x38,
  0x40, 0xEF, 0xDE, 0xFD, 0x7F, 0x3B, 0xC0, 0xE9, 0x24, 0x80, 0xDD, 0xDD,
  0xD7, 0x99, 0x56, 0x66, 0x96, 0xDF, 0x5F, 0x79, 0xA0, 0xB6, 0x66, 0x6B,
  0x9F, 0x66, 0x66, 0xE5, 0xAD, 0xC0, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5,
  0x5C, 0x26, 0x69, 0xF0, 0xC0, 0x6E, 0xF0, 0xCC, 0xFD, 0xDE, 0x73, 0x30,
  0x31, 0xFB, 0xF7, 0xEF, 0x86, 0x6B, 0x24, 0x80, 0xFB, 0xF5, 0x3E, 0xCC,
  0xFD, 0xDD, 0xCF, 0xF0, 0xCF, 0xFE, 0xCD, 0xEE, 0xED, 0xFF, 0xF0, 0xFF,
  0xDF, 0x7D, 0xFD, 0xDD, 0xE9, 0xD6, 0xFD, 0xDE, 0xCC, 0xFB, 0xF5, 0x33,
  0xFB, 0x60, 0xF8, 0xF0, 0x5D, 0x26, 0xDD, 0xF7, 0xB6, 0x66, 0xBF, 0xE7,
  0x96, 0xF6, 0x6B, 0xB6, 0x66, 0x4C, 0xE9, 0x70, 0x69, 0x64, 0x98, 0xFF,
  0xC9, 0x34, 0xB0, 0x5F,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 2, 2, 2, 0, -6 },
  { 20, 3, 7, 3, 0, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 4, 3, 4, 0, -6 },
  { 27, 4, 4, 4, 0, -5 },
  { 29, 2, 2, 2, 0, -1 },
  { 30, 2, 1, 3, 0, -3 },
  { 31, 2, 1, 2, 0, -1 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 4, 6, 4, 0, -6 },
  { 38, 3, 6, 4, 0, -6 },
  { 41, 3, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 3, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 5, 2, 0, -4 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 4, 2, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 3, 6, 3, 0, -6 },
  { 76, 6, 7, 6, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 5, 0, -6 },
  { 94, 2, 6, 4, 1, -6 },
  { 96, 2, 6, 3, 1, -6 },
  { 98, 4, 6, 5, 0, -6 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 8, 2, 0, -6 },
  { 108, 3, 6, 4, 1, -6 },
  { 111, 3, 6, 3, 0, -6 },
  { 114, 5, 6, 6, 1, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 4, 6, 4, 0, -6 },
  { 128, 5, 7, 5, 0, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 3, 6, 4, 0, -6 },
  { 139, 3, 6, 4, 0, -6 },
  { 142, 4, 6, 5, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 6, 6, 6, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 3, 6, 4, 0, -6 },
  { 162, 2, 7, 2, 0, -6 },
  { 164, 3, 6, 3, 0, -6 },
  { 167, 2, 7, 2, 0, -6 },
  { 169, 4, 4, 4, 0, -6 },
  { 171, 4, 1, 4, 0, 0 },
  { 172, 2, 1, 3, 0, -6 },
  { 173, 3, 4, 4, 0, -4 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 3, 0, -6 },
  { 188, 4, 6, 4, 0, -4 },
  { 191, 4, 6, 4, 0, -6 },
  { 194, 2, 6, 2, 0, -6 },
  { 196, 2, 8, 2, 0, -6 },
  { 198, 4, 6, 4, 0, -6 },
  { 201, 2, 6, 2, 0, -6 },
  { 203, 6, 4, 6, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 5, 3, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 6, 4, 6, 0, -4 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 4, 6, 4, 0, -4 },
  { 234, 3, 4, 3, 0, -4 },
  { 236, 3, 7, 3, 0, -6 },
  { 239, 1, 8, 3, 1, -6 },
  { 240, 3, 7, 3, 0, -6 },
  { 243, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD8PT7B_H_
