#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83,
  0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7,
  0xFE, 0x3F, 0xC0, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xEF,
  0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0x9E, 0x1E, 0x3F, 0xE3, 0xC0, 0xC7, 0xFC,
  0x78, 0x00, 0xFF, 0x8F, 0x00, 0x1F, 0xF1, 0xE0, 0x03, 0xFE, 0x3C, 0x00,
  0x7F, 0xE7, 0x80, 0x07, 0xFE, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xEF, 0xFC, 0x00, 0x3C, 0xFF, 0x80, 0x07, 0x9F, 0xF0, 0x00, 0xF1,
  0xFF, 0x00, 0x1E, 0x3F, 0xF0, 0x03, 0xCF, 0xFF, 0x80, 0x79, 0xFF, 0xFE,
  0x0F, 0x7F, 0xDF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F,
  0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFC, 0x7F, 0x8F, 0xE0, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x0F, 0xFC,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC0, 0x7E, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFE, 0x1F, 0xF9, 0xFF,
  0xEF, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xBF,
  0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xBF, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x0C, 0x07, 0xF8, 0x0C, 0x3C, 0x1F, 0xC1, 0xF0, 0xFE, 0x7F,
  0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF,
  0xCF, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xE0, 0x18,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFE, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F,
  0xC0, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0x07, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFB, 0xFF, 0x80, 0xFF,
  0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xF0,
  0x1F, 0xFB, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0x87, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xBF, 0xE3, 0xFF, 0x3F, 0xC7, 0xFE, 0x3F, 0x0F, 0xFC, 0x3C, 0x1F,
  0xF8, 0x30, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFC,
  0x1F, 0xFC, 0x3F, 0x00, 0xFF, 0xE1, 0xE0, 0x0F, 0xFE, 0x0C, 0x00, 0x7F,
  0xE0, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0xFE, 0x1E, 0x00, 0xFF,
  0xE0, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFE, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0x00, 0x1F,
  0xE7, 0xFE, 0x00, 0x3F, 0x8F, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFC,
  0x3F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x70,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0x80, 0x1F, 0xFE, 0xFF, 0x0F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x02,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x9F, 0xFE, 0x07, 0xFC, 0xFF, 0xF8,
  0x3F, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xFD, 0xFF, 0xE0,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF0,
  0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0,
  0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xE0,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xCF,
  0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFD,
  0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFE, 0x7F, 0xC0, 0xFF, 0xE3, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xFB,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0xC7,
  0x00, 0x7F, 0xE3, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x3F, 0xF0, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0x0F, 0xE0,
  0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0x87, 0xF9, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF,
  0x0F, 0xE0, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFB, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x3F, 0x80, 0xFE,
  0x07, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x87, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xBF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE,
  0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFB, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xCF,
  0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x3F, 0x83, 0xFE, 0x3F, 0xE3, 0xFC, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xF0,
  0x3F, 0xFE, 0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x7F, 0x80,
  0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFE,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF,
  0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF,
  0xBF, 0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x9F, 0xFC,
  0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0x07, 0xFF, 0x80, 0x38, 0x7F, 0xF8, 0x00, 0x43,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x06, 0x3F, 0xFF, 0x00, 0xF0, 0xFF, 0xFF, 0x7F,
  0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0,
  0x7F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xCF, 0xFE,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFD, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF,
  0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01,
  0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x81,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0xC0, 0x03, 0x07,
  0xFF, 0xC0, 0x00, 0x83, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0x1F,
  0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0xA0, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x03,
  0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xFB, 0xFF,
  0x80, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xDF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xFF, 0xFD,
  0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF,
  0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0x83, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xF8,
  0x7F, 0x8F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xFD,
  0xFF, 0x83, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFB, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x07, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xFB,
  0xFF, 0x87, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFC,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC7, 0xFF, 0x01, 0xF1, 0xFF, 0x80, 0x1C, 0xFF, 0xE0, 0x01, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFD,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xDF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x7F, 0x83, 0xFF, 0x00,
  0xFF, 0xC3, 0xFC, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xCF, 0xF1, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x87, 0xF3, 0xFF, 0x00, 0x1F,
  0xF9, 0xFE, 0x1F, 0xEF, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x7F, 0xBF, 0xF0,
  0x00, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x07, 0xFB,
  0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x0F, 0xEF, 0xF8, 0x00, 0x3F, 0xEF, 0xF0,
  0x3F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x03, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xDF,
  0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xF3,
  0xFF, 0xE0, 0xF0, 0x1F, 0xFC, 0x18, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xCF, 0xF3, 0xFF, 0xF1, 0xFE,
  0x3F, 0xFC, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0x07, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x30,
  0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xF9, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x87,
  0xFC, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0xFF,
  0xC0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xE1,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0x87, 0xFC, 0xFF, 0xFC, 0x3F,
  0xC3, 0xFF, 0xC1, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0x0F, 0xFE, 0x01, 0x8F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x13, 0xFF, 0xC0, 0x18, 0xFF, 0xF0, 0x3C,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xBF, 0xF1,
  0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0,
  0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0,
  0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xCF, 0xFE, 0x1F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0x1F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xE0,
  0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x06, 0x3F, 0xF8, 0x01, 0xE3,
  0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x20, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xF1, 0xFF,
  0x0F, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF,
  0x03, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80,
  0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFE,
  0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0,
  0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF,
  0x07, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x0E, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x20, 0x00, 0x3F, 0xF8, 0xE0, 0x00,
  0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x0F, 0x00, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0xF0, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF9, 0xFF, 0xEF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x8F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF,
  0xC7, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9,
  0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x07, 0xF8,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC3, 0xFF, 0xC1, 0xFF, 0xF1, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF1, 0xFF, 0xF8, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD,
  0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x81, 0xFE, 0x3F, 0xFE, 0x0F, 0xF9,
  0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0xC3, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xEF, 0xFF, 0xF1, 0xFF, 0x3F, 0xFF, 0x0F, 0xF9, 0xFF, 0xF8, 0x7F, 0xE7,
  0xFF, 0x83, 0xFF, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF,
  0xEF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF, 0x03, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7,
  0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF,
  0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xF3,
  0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF, 0x07, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0E, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xEF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xF7, 0xF9, 0xFF, 0x80, 0xE3, 0xFE, 0x00, 0x47, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x0C, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x3C, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0x3F, 0xFF, 0xDF, 0xF1, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x3F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x7F, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0x7F, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0x7F, 0x0F, 0xFC, 0x1F, 0xF8, 0xFE,
  0x7F, 0x0F, 0xF8, 0x1F, 0xF8, 0xFE, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFE,
  0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFE, 0x3F, 0x9F, 0xF8, 0x0F, 0xF8, 0xFE,
  0x3F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE, 0x3F, 0x9F, 0xF0, 0x07, 0xFD, 0xFC,
  0x3F, 0x9F, 0xF0, 0x07, 0xFD, 0xFC, 0x3F, 0x9F, 0xF0, 0x07, 0xFD, 0xFC,
  0x3F, 0x9F, 0xF0, 0x07, 0xFD, 0xFC, 0x1F, 0xDF, 0xE0, 0x07, 0xFD, 0xFC,
  0x1F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC,
  0x1F, 0xFF, 0xE0, 0x03, 0xFD, 0xF8, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xFC, 0x03,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x13, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xD0,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x09, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xA0,
  0x00, 0x3F, 0xF9, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 50, 18, 3, -49 },
  { 76, 26, 18, 32, 3, -49 },
  { 135, 34, 49, 36, 1, -49 },
  { 344, 27, 56, 33, 3, -52 },
  { 533, 51, 51, 55, 2, -50 },
  { 859, 39, 51, 41, 2, -50 },
  { 1108, 11, 18, 17, 3, -49 },
  { 1133, 19, 61, 22, 3, -50 },
  { 1278, 18, 61, 22, 1, -50 },
  { 1416, 30, 30, 32, 1, -53 },
  { 1529, 29, 33, 33, 2, -41 },
  { 1649, 13, 18, 18, 2, -9 },
  { 1679, 18, 9, 22, 2, -23 },
  { 1700, 12, 12, 18, 3, -11 },
  { 1718, 28, 51, 29, 0, -50 },
  { 1897, 29, 51, 33, 2, -50 },
  { 2082, 23, 49, 33, 3, -49 },
  { 2223, 28, 50, 33, 2, -50 },
  { 2398, 28, 51, 33, 2, -50 },
  { 2577, 31, 49, 33, 1, -49 },
  { 2767, 27, 50, 33, 3, -49 },
  { 2936, 29, 51, 33, 2, -50 },
  { 3121, 29, 49, 33, 2, -49 },
  { 3299, 29, 51, 33, 2, -50 },
  { 3484, 29, 51, 33, 2, -50 },
  { 3669, 11, 39, 19, 4, -38 },
  { 3723, 13, 47, 19, 2, -38 },
  { 3800, 29, 34, 33, 2, -42 },
  { 3924, 29, 23, 33, 2, -36 },
  { 4008, 29, 34, 33, 2, -42 },
  { 4132, 25, 51, 27, 0, -50 },
  { 4292, 46, 55, 51, 3, -50 },
  { 4609, 38, 49, 38, 0, -49 },
  { 4842, 31, 49, 37, 4, -49 },
  { 5032, 29, 51, 34, 3, -50 },
  { 5217, 33, 49, 39, 4, -49 },
  { 5420, 23, 49, 30, 4, -49 },
  { 5561, 23, 49, 30, 4, -49 },
  { 5702, 33, 51, 40, 3, -50 },
  { 5913, 33, 49, 41, 4, -49 },
  { 6116, 19, 49, 23, 2, -49 },
  { 6233, 19, 64, 19, -4, -49 },
  { 6385, 33, 49, 37, 4, -49 },
  { 6588, 24, 49, 29, 4, -49 },
  { 6735, 46, 49, 54, 4, -49 },
  { 7017, 36, 49, 44, 4, -49 },
  { 7238, 36, 51, 42, 3, -50 },
  { 7468, 29, 49, 35, 4, -49 },
  { 7646, 36, 62, 42, 3, -50 },
  { 7925, 33, 49, 36, 4, -49 },
  { 8128, 26, 51, 30, 2, -50 },
  { 8294, 29, 49, 31, 1, -49 },
  { 8472, 32, 50, 40, 4, -49 },
  { 8672, 37, 49, 37, 0, -49 },
  { 8899, 54, 49, 53, 0, -49 },
  { 9230, 34, 49, 34, 0, -49 },
  { 9439, 34, 49, 34, 0, -49 },
  { 9648, 28, 49, 30, 1, -49 },
  { 9820, 17, 61, 21, 3, -50 },
  { 9950, 28, 51, 29, 0, -50 },
  { 10129, 17, 61, 21, 1, -50 },
  { 10259, 35, 31, 37, 1, -49 },
  { 10395, 31, 7, 31, 0, 5 },
  { 10423, 17, 11, 22, 3, -53 },
  { 10447, 27, 40, 33, 2, -39 },
  { 10582, 29, 53, 35, 4, -52 },
  { 10775, 25, 40, 29, 2, -39 },
  { 10900, 30, 53, 35, 2, -52 },
  { 11099, 28, 40, 32, 2, -39 },
  { 11239, 22, 53, 22, 1, -53 },
  { 11385, 30, 56, 35, 2, -39 },
  { 11595, 28, 52, 35, 4, -52 },
  { 11777, 11, 53, 18, 3, -53 },
  { 11850, 16, 70, 18, -2, -53 },
  { 11990, 31, 52, 35, 4, -52 },
  { 12192, 10, 52, 17, 4, -52 },
  { 12257, 45, 39, 53, 4, -39 },
  { 12477, 28, 39, 35, 4, -39 },
  { 12614, 30, 40, 35, 2, -39 },
  { 12764, 29, 56, 35, 4, -39 },
  { 12967, 30, 56, 35, 2, -39 },
  { 13177, 20, 39, 25, 4, -39 },
  { 13275, 23, 40, 27, 2, -39 },
  { 13390, 21, 47, 24, 1, -46 },
  { 13514, 28, 39, 35, 4, -38 },
  { 13651, 32, 38, 32, 0, -38 },
  { 13803, 48, 38, 49, 0, -38 },
  { 14031, 31, 38, 31, 0, -38 },
  { 14179, 32, 55, 32, 0, -38 },
  { 14399, 24, 38, 26, 1, -38 },
  { 14513, 22, 61, 25, 1, -50 },
  { 14681, 9, 69, 30, 10, -53 },
  { 14759, 22, 61, 25, 2, -50 },
  { 14927, 29, 12, 33, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD69PT7B_H_
