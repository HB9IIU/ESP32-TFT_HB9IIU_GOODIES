#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00,
  0x01, 0xEF, 0xFF, 0xFE, 0xFC, 0xFF, 0xE7, 0xDE, 0x3E, 0xF1, 0xF7, 0x8F,
  0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF0, 0x07, 0x3C, 0x07, 0x3C, 0x07,
  0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0xE0, 0x3C, 0xE0, 0x38,
  0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x06, 0x00, 0x60, 0x0F, 0x83,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x6F, 0x60, 0xF6, 0x0F, 0x60, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x06, 0xF0, 0x6F, 0x86, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x1C, 0x01, 0xE0, 0x1F, 0x80, 0xE0, 0x1F, 0xE0, 0xF0, 0x1F, 0xF0, 0x70,
  0x0F, 0x38, 0x78, 0x07, 0x9E, 0x3C, 0x03, 0xCF, 0x1C, 0x01, 0xE7, 0x9E,
  0x00, 0xF3, 0xCE, 0x00, 0x79, 0xEF, 0x08, 0x3C, 0xF7, 0x9F, 0x1F, 0xF3,
  0x9F, 0xC7, 0xFB, 0xDF, 0xF1, 0xF9, 0xCF, 0x78, 0x78, 0xE7, 0x9C, 0x00,
  0xF3, 0x8F, 0x00, 0x71, 0xC7, 0x80, 0x78, 0xE3, 0xC0, 0x38, 0x71, 0xE0,
  0x1C, 0x3C, 0xE0, 0x1E, 0x1E, 0xF0, 0x0E, 0x07, 0xF8, 0x0F, 0x03, 0xF8,
  0x07, 0x80, 0xF8, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xCF, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE3, 0xE3, 0xFC, 0x7C, 0xFF, 0xCF,
  0xBF, 0xFF, 0xE7, 0xCF, 0xFC, 0xF8, 0xFF, 0x9F, 0x1F, 0xE3, 0xE1, 0xFC,
  0x7E, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFE, 0x3F,
  0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F,
  0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x8F, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x70, 0x31, 0xC6, 0xFF, 0x7B, 0xFF, 0xEF, 0xFF, 0xCF, 0xF8, 0x1F,
  0xC0, 0xFF, 0x87, 0xDF, 0x1F, 0x3C, 0x38, 0xE0, 0x21, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0xBC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80,
  0x7F, 0x83, 0xFE, 0x0F, 0xFC, 0x7F, 0xF1, 0xF3, 0xE7, 0x8F, 0xBE, 0x3E,
  0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1E, 0xF8, 0x79, 0xE3, 0xE7, 0x8F, 0x9F, 0x3E, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFE, 0x03, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F,
  0xDF, 0xFF, 0xEF, 0x79, 0xE6, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xE7, 0xBF, 0xB0, 0x7C, 0x83,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7, 0x9F,
  0x90, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x87, 0xF8, 0x3F, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x1D, 0xF0, 0x7B, 0xE0, 0xE7, 0xC3, 0xCF, 0x87, 0x1F, 0x1E, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xF8, 0xFF, 0xEF, 0xFE, 0xFF, 0xF4,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F,
  0x89, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x83, 0xEF, 0x8F, 0xFF, 0x3F,
  0xFE, 0xFF, 0xFB, 0xF3, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7,
  0x87, 0x9F, 0x3E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x7C,
  0xF9, 0xE3, 0xE7, 0x87, 0x9E, 0x3E, 0x7C, 0xF8, 0xFF, 0xC3, 0xFE, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xDF, 0xBE, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0x80,
  0x7F, 0x83, 0xFE, 0x1F, 0xFC, 0xFD, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x1E,
  0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xF7,
  0x87, 0x9E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x7F, 0xF1, 0xFF,
  0x87, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xDF, 0x7D, 0xF7, 0x9E, 0xFB, 0xC0, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFC, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x1F, 0x87, 0xFC, 0xFF, 0xE7, 0xFF, 0x7B, 0xF4, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0xF8,
  0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC3, 0xE3, 0x9E, 0x3F, 0xCF, 0x79,
  0xFF, 0x3D, 0xC7, 0x9C, 0x77, 0x3C, 0x71, 0xFC, 0xF1, 0xC7, 0xF3, 0xC7,
  0x1F, 0xCF, 0x1C, 0x7F, 0x3C, 0xF1, 0xFC, 0xF3, 0xC7, 0xF3, 0xCF, 0x3F,
  0xCF, 0xFF, 0xE7, 0x1F, 0xBF, 0x1E, 0x3C, 0x78, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x04, 0x07, 0xF1, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x87, 0x83,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7D, 0xF1, 0xF3, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF,
  0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xF7, 0xC7, 0xEF,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x7F,
  0xF0, 0xFF, 0xE3, 0xFB, 0xC7, 0xC1, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x63, 0xFF, 0xC3, 0xFF,
  0x83, 0xFF, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xFB, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xDE, 0x3F, 0x02, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0x7C, 0xFF, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F,
  0x3F, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xF7, 0xFF, 0xFF,
  0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE7, 0xFF, 0xEF, 0xF7, 0xF3, 0xF0,
  0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xBC, 0xF7, 0xFE, 0xF3, 0xDF, 0xFB, 0xCF, 0x7F, 0xEF, 0x3D, 0xFF,
  0x9F, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFE, 0x7F, 0xE7, 0xF1, 0xFF, 0x8F,
  0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xE1, 0xFF, 0x87, 0x87,
  0xFE, 0x1E, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFE, 0xF3, 0xFF, 0x7D, 0xFF, 0xBE, 0xFF, 0xCF, 0xBF, 0xE7, 0xDF, 0xF1,
  0xEF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE1,
  0xF8, 0xFC, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFB, 0xE3, 0xEF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0xFE, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFE, 0x3F, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE1,
  0xF8, 0xFC, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0x9F,
  0x1F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xE7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7D, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x1F, 0x0F,
  0xC1, 0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0xFF, 0x7C, 0x13, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xE0, 0x7D, 0xE7, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0x8F, 0xFE,
  0x0F, 0xF8, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x07, 0xC3, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x87,
  0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x00, 0xF7, 0xC0,
  0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0xF8, 0x1E, 0x07, 0xFE,
  0x07, 0x81, 0xFF, 0x83, 0xE0, 0xFB, 0xE0, 0xF8, 0x3E, 0x78, 0x3F, 0x0F,
  0x9F, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF9, 0xF1, 0xFC, 0x3C, 0x7C, 0x7F,
  0x1F, 0x0F, 0x1F, 0xE7, 0xC3, 0xC7, 0x79, 0xF0, 0xFB, 0xDE, 0x7C, 0x3E,
  0xF7, 0x9E, 0x0F, 0xBC, 0xEF, 0x81, 0xEF, 0x3B, 0xE0, 0x7B, 0xCF, 0xF8,
  0x1E, 0xF3, 0xFE, 0x07, 0xB8, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xFF, 0xE0, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x3C, 0x0F, 0x9E,
  0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xF3, 0xE0, 0x7B, 0xE0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3E, 0x3E, 0x1F, 0x0F, 0x1F, 0xE3,
  0xFF, 0x8F, 0xFC, 0x7B, 0xF2, 0x0F, 0x80, 0x7C, 0x03, 0xE3, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x79, 0xF3, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0xF8, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE,
  0x3E, 0xF8, 0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1E, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0xBD, 0xFC, 0xF3, 0xE0,
  0x0F, 0xE3, 0xFF, 0x3F, 0xE7, 0xFE, 0x7C, 0x2F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC3, 0x7F, 0xF7, 0xFF,
  0x3F, 0xF1, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC7, 0xDF, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0x7C, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x1F,
  0xC1, 0xFF, 0x9F, 0xFC, 0xF9, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x05, 0xFF, 0xE7,
  0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x7F, 0x9F, 0xE3, 0xE0,
  0x7C, 0x0F, 0x83, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7D, 0xF1, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0,
  0x07, 0xC0, 0x1F, 0x40, 0x7D, 0xC3, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0,
  0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x7C, 0xF7, 0xF7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF8, 0xF7, 0xFF, 0xF7, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0xBE, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1E, 0xF8, 0x3D, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xCF, 0x8F, 0x9F, 0x1F,
  0x1F, 0x3E, 0x3E, 0x7C, 0x3E, 0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF3,
  0xE3, 0xF3, 0xDF, 0xDF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0xFC,
  0xFF, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F,
  0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3,
  0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3, 0xE1,
  0xF0, 0xF3, 0xE7, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xC0, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x7D, 0xF1, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFB,
  0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0xBF, 0xFE, 0xF7, 0xF3, 0xCF, 0x8F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D,
  0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF3,
  0xFD, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x3F, 0xCF,
  0xFF, 0xFF, 0x7D, 0xEF, 0x85, 0xF0, 0x3F, 0x07, 0xF8, 0x7F, 0x87, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xE0, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0x80, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0,
  0xF8, 0x3E, 0xF0, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F,
  0x1E, 0x1F, 0x3C, 0x3E, 0xF8, 0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x7E,
  0x3E, 0xF0, 0xFC, 0x7D, 0xE3, 0xF8, 0xFB, 0xE7, 0xF1, 0xE7, 0xCF, 0xE3,
  0xCF, 0x9D, 0xCF, 0x8F, 0x3B, 0xDF, 0x1E, 0x77, 0xBC, 0x3D, 0xEF, 0x78,
  0x7F, 0xCE, 0xF0, 0xFF, 0x9D, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x87, 0xC0, 0xFC, 0x7C, 0xF8, 0xF9, 0xF3, 0xE1, 0xF7, 0xC3, 0xEF, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x81, 0xFF, 0x07, 0xDF, 0x0F, 0xBE, 0x3E, 0x7C, 0x7C, 0x7D, 0xF0, 0xFC,
  0xF8, 0x3E, 0xF0, 0x7D, 0xF0, 0xFB, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F,
  0x9E, 0x1F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x0B, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x60, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF1, 0xFE, 0x3F, 0x07, 0xF0,
  0xFF, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x3F, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x3F, 0x8F, 0xE3, 0xF0, 0xF8, 0x00,
  0x10, 0x05, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 13, 9, 15, 1, -24 },
  { 31, 16, 24, 17, 1, -24 },
  { 79, 12, 27, 16, 2, -25 },
  { 120, 25, 24, 27, 1, -24 },
  { 195, 19, 24, 20, 1, -24 },
  { 252, 6, 9, 8, 1, -24 },
  { 259, 8, 29, 11, 2, -24 },
  { 288, 9, 29, 11, 0, -24 },
  { 321, 14, 14, 15, 1, -25 },
  { 346, 14, 16, 16, 1, -20 },
  { 374, 6, 8, 9, 1, -4 },
  { 380, 8, 4, 10, 1, -11 },
  { 384, 5, 5, 9, 2, -5 },
  { 388, 14, 24, 14, 0, -24 },
  { 430, 14, 24, 16, 1, -24 },
  { 472, 11, 24, 16, 1, -24 },
  { 505, 13, 24, 16, 1, -24 },
  { 544, 13, 24, 16, 1, -24 },
  { 583, 15, 24, 16, 0, -24 },
  { 628, 12, 24, 16, 2, -24 },
  { 664, 14, 24, 16, 1, -24 },
  { 706, 14, 24, 16, 1, -24 },
  { 748, 14, 24, 16, 1, -24 },
  { 790, 14, 24, 16, 1, -24 },
  { 832, 5, 18, 9, 2, -18 },
  { 844, 6, 22, 9, 1, -18 },
  { 861, 14, 16, 16, 1, -20 },
  { 889, 14, 11, 16, 1, -17 },
  { 909, 14, 16, 16, 1, -20 },
  { 937, 12, 24, 13, 0, -24 },
  { 973, 22, 27, 25, 1, -24 },
  { 1048, 18, 24, 18, 0, -24 },
  { 1102, 15, 24, 18, 2, -24 },
  { 1147, 15, 24, 16, 1, -24 },
  { 1192, 16, 24, 19, 2, -24 },
  { 1240, 11, 24, 14, 2, -24 },
  { 1273, 11, 24, 14, 2, -24 },
  { 1306, 16, 24, 19, 1, -24 },
  { 1354, 16, 24, 20, 2, -24 },
  { 1402, 9, 24, 11, 1, -24 },
  { 1429, 9, 31, 9, -2, -24 },
  { 1464, 16, 24, 18, 2, -24 },
  { 1512, 11, 24, 14, 2, -24 },
  { 1545, 22, 24, 26, 2, -24 },
  { 1611, 17, 24, 21, 2, -24 },
  { 1662, 18, 24, 20, 1, -24 },
  { 1716, 14, 24, 17, 2, -24 },
  { 1758, 18, 30, 20, 1, -24 },
  { 1826, 15, 24, 17, 2, -24 },
  { 1871, 13, 24, 14, 1, -24 },
  { 1910, 13, 24, 15, 1, -24 },
  { 1949, 15, 24, 19, 2, -24 },
  { 1994, 18, 24, 18, 0, -24 },
  { 2048, 26, 24, 26, 0, -24 },
  { 2126, 16, 24, 16, 0, -24 },
  { 2174, 16, 24, 16, 0, -24 },
  { 2222, 13, 24, 14, 1, -24 },
  { 2261, 7, 29, 10, 2, -24 },
  { 2287, 13, 24, 14, 0, -24 },
  { 2326, 8, 29, 10, 1, -24 },
  { 2355, 17, 15, 18, 0, -24 },
  { 2387, 15, 3, 15, 0, 3 },
  { 2393, 8, 5, 11, 1, -25 },
  { 2398, 13, 18, 16, 1, -18 },
  { 2428, 14, 25, 17, 2, -25 },
  { 2472, 12, 18, 14, 1, -18 },
  { 2499, 14, 25, 17, 1, -25 },
  { 2543, 13, 18, 15, 1, -18 },
  { 2573, 11, 25, 10, 0, -25 },
  { 2608, 14, 26, 17, 1, -18 },
  { 2654, 13, 25, 17, 2, -25 },
  { 2695, 5, 25, 8, 2, -25 },
  { 2711, 8, 33, 8, -1, -25 },
  { 2744, 15, 25, 17, 2, -25 },
  { 2791, 5, 25, 8, 2, -25 },
  { 2807, 22, 18, 25, 2, -18 },
  { 2857, 13, 18, 17, 2, -18 },
  { 2887, 14, 18, 17, 1, -18 },
  { 2919, 14, 26, 17, 2, -18 },
  { 2965, 14, 26, 17, 1, -18 },
  { 3011, 10, 18, 12, 2, -18 },
  { 3034, 11, 18, 13, 1, -18 },
  { 3059, 11, 22, 11, 0, -22 },
  { 3090, 13, 18, 17, 2, -18 },
  { 3120, 15, 18, 15, 0, -18 },
  { 3154, 23, 18, 23, 0, -18 },
  { 3206, 15, 18, 15, 0, -18 },
  { 3240, 15, 26, 15, 0, -18 },
  { 3289, 11, 18, 12, 1, -18 },
  { 3314, 11, 29, 12, 0, -24 },
  { 3354, 4, 33, 14, 5, -25 },
  { 3371, 10, 29, 12, 1, -24 },
  { 3408, 14, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD33PT7B_H_
