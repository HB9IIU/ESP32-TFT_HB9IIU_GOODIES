#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x06, 0xFF, 0xF0, 0xF7, 0xFB,
  0xFD, 0xFE, 0x7E, 0x3F, 0x1C, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF1, 0xDC, 0x1D, 0xC1, 0x98, 0xFF, 0xFF, 0xFF, 0x39,
  0x83, 0xB8, 0x3B, 0x83, 0xB8, 0x33, 0x80, 0x0C, 0x06, 0x0F, 0xEF, 0xFF,
  0xDF, 0x63, 0xB1, 0xF8, 0x7E, 0x1F, 0x83, 0xE1, 0xF0, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7E, 0x06, 0x03, 0x00, 0x78, 0x38, 0x3F, 0x0E, 0x0E, 0xE3, 0x03,
  0x39, 0xC0, 0xCE, 0x60, 0x33, 0xB8, 0x0C, 0xEE, 0x43, 0xBB, 0x3C, 0xFD,
  0xDF, 0x9E, 0x66, 0x60, 0x3B, 0x9C, 0x0E, 0xE7, 0x03, 0x39, 0xC1, 0xC6,
  0x60, 0x61, 0xD8, 0x38, 0x7E, 0x0E, 0x0F, 0x00, 0x3F, 0x03, 0xFC, 0x1F,
  0xE0, 0xE7, 0x07, 0x38, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x7F, 0xFB,
  0xBB, 0xFD, 0xCF, 0xEE, 0x3E, 0x79, 0xF3, 0xFF, 0x9F, 0xFE, 0x7F, 0x78,
  0xFF, 0xFF, 0xEE, 0x1C, 0xE3, 0x9C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x38,
  0xE3, 0xC7, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0xF0, 0xE0, 0xE1, 0xC3, 0xC3,
  0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x71, 0xE3,
  0x8E, 0x00, 0x0E, 0x01, 0xC1, 0xBB, 0x3F, 0xEF, 0xFE, 0x1C, 0x07, 0xC1,
  0xDC, 0x7B, 0xC2, 0x20, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xEE, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF7, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x00,
  0x3E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xB8, 0xEE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8E, 0xF3, 0xBC, 0xE7, 0xF9, 0xFC, 0x3E, 0x00, 0x0F, 0x1F,
  0x3F, 0x7F, 0xFF, 0x7F, 0x2F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x7E, 0x7F, 0xBF, 0xE8, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x0F, 0x0F, 0x07, 0x07, 0x87, 0x87, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x7F, 0xFF, 0xE8, 0xF0, 0x38, 0x3C, 0x3C, 0x7C, 0x3F, 0x1F, 0xC1, 0xE0,
  0x70, 0x3C, 0x3F, 0xFF, 0xFE, 0xFE, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0x8E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xBF, 0xDF, 0xEE, 0x07,
  0x03, 0x83, 0xF9, 0xFE, 0xFF, 0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x3F, 0xFF,
  0xFE, 0xFE, 0x00, 0x1F, 0x8F, 0xE7, 0xF9, 0xC0, 0xF0, 0x38, 0x0E, 0xF3,
  0xFE, 0xFF, 0xBC, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xE7, 0xF9, 0xFC, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x00, 0x3F,
  0x1F, 0xEF, 0xFB, 0xCE, 0xF3, 0xBD, 0xE7, 0xF8, 0xFC, 0x3F, 0x1F, 0xEF,
  0x7B, 0x8F, 0xE3, 0xF8, 0xFF, 0xF9, 0xFE, 0x3F, 0x00, 0x3E, 0x1F, 0xCF,
  0xFB, 0xCE, 0xE3, 0xB8, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF, 0xF7, 0xB8, 0x0E,
  0x03, 0x81, 0xE7, 0xF1, 0xF8, 0x7C, 0x00, 0xFF, 0xF6, 0x00, 0x00, 0x07,
  0xFF, 0x70, 0x7F, 0xF6, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xEE, 0x00, 0xC0,
  0xF0, 0xFC, 0xFC, 0xFC, 0x3C, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xF0, 0x0C,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF1, 0xF9, 0xF8, 0xF8, 0x38, 0x08, 0x00, 0x7E,
  0x7F, 0x9F, 0xE8, 0xF0, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x38,
  0x1C, 0x70, 0x0E, 0x71, 0xE6, 0x67, 0xF7, 0xE7, 0x77, 0xEE, 0x77, 0xCE,
  0x77, 0xCE, 0x67, 0xCE, 0x67, 0xEE, 0xE6, 0xE7, 0xFE, 0xE7, 0xBC, 0x70,
  0x00, 0x70, 0x00, 0x3C, 0x38, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x87, 0xBC, 0x3C, 0xE1,
  0xC7, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3C, 0x39, 0xC1, 0xFE, 0x0F, 0xF0,
  0x78, 0xFF, 0x9F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0xF7, 0xFC,
  0xFF, 0x9F, 0xFB, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xF7, 0xFE, 0xFF,
  0x00, 0x1F, 0xCF, 0xF7, 0xFD, 0xE1, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x17, 0xFC, 0xFF, 0x1F, 0x80, 0xFF,
  0x0F, 0xFC, 0xFF, 0xCF, 0x3E, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x3E, 0xFF, 0xCF, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x87, 0x0E,
  0x1C, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x7F, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x0F, 0xE3, 0xFE, 0x3F, 0xE7,
  0x82, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0xFF,
  0x0F, 0x70, 0xF7, 0x8F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xE0, 0xFF, 0xF7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBF, 0xFC, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xF3,
  0xFF, 0xFB, 0xC0, 0xE1, 0xFC, 0x7B, 0x8F, 0x73, 0xCE, 0xF1, 0xDE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x73, 0xCE, 0x79, 0xC7, 0x38, 0xF7,
  0x1E, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F,
  0xF6, 0x77, 0xEE, 0xEF, 0xDD, 0xDF, 0xBB, 0x3F, 0x3E, 0x7E, 0x7C, 0xFC,
  0xF9, 0xF9, 0xE3, 0xF1, 0xC7, 0xE3, 0x8E, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x8F, 0xFC, 0xFF, 0xCF, 0xFE, 0xFE, 0xEF, 0xEE, 0x7E, 0xF7, 0xE7, 0x7E,
  0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xF0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xF8, 0xF1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xDE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0F, 0x3C, 0x79, 0xFF, 0x87, 0xFC, 0x1F,
  0x80, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF,
  0xFF, 0xEF, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F,
  0xC1, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xDE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0F, 0x3C, 0x79, 0xFF, 0x87,
  0xFC, 0x1F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0x0F,
  0xF8, 0xFF, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x7C, 0xFF, 0x8F,
  0xF0, 0xF7, 0x8F, 0x78, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF1, 0xF0,
  0x3F, 0x3F, 0xFF, 0xDE, 0x2E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x3F, 0xFD, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E,
  0xF3, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xE1,
  0xE7, 0x8F, 0x3C, 0x70, 0xE3, 0x87, 0x3C, 0x3D, 0xE1, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xE1,
  0xFE, 0x3C, 0x3B, 0xC7, 0x87, 0x38, 0xF9, 0xE7, 0x1F, 0x3C, 0xE3, 0xE7,
  0x9E, 0xFC, 0xE3, 0xDD, 0x9C, 0x3B, 0xB3, 0x87, 0x77, 0xF0, 0xEE, 0xFE,
  0x1D, 0x9F, 0xC3, 0xF3, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1E, 0x1F, 0x00, 0xF1, 0xE7, 0x9E, 0x79, 0xC3, 0xBC, 0x3F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0xC3, 0x9C,
  0x79, 0xE7, 0x1E, 0xF0, 0xF0, 0xF0, 0xF7, 0x0E, 0x79, 0xE7, 0x9E, 0x39,
  0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xF0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xFF, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFC, 0x07,
  0x00, 0x70, 0x0F, 0x80, 0xF8, 0x1F, 0xC1, 0xDC, 0x3D, 0xC3, 0x8E, 0x78,
  0xE7, 0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0xC0, 0x7F, 0x3F,
  0xDD, 0xE0, 0x70, 0x3B, 0xFF, 0xFF, 0xE7, 0xE3, 0xF3, 0xFF, 0xFF, 0xF7,
  0x98, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFB, 0xFF, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xFF, 0xFF, 0xB9, 0xE0,
  0x3F, 0x7F, 0x7F, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF1, 0xFF, 0x7F,
  0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xDF, 0x77, 0xFF, 0xFF, 0xF3,
  0xF8, 0xFE, 0x3F, 0x87, 0xE3, 0xF8, 0xFF, 0x3F, 0xFF, 0x7F, 0xCF, 0x70,
  0x3F, 0x1F, 0xEF, 0x7B, 0x8E, 0xE3, 0xBF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C,
  0x2F, 0xF9, 0xFE, 0x3F, 0x00, 0x1F, 0x3F, 0x3F, 0x38, 0x38, 0x7E, 0xFE,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D,
  0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xFC, 0xFF,
  0xFD, 0xF7, 0x3D, 0xC0, 0xF0, 0x3F, 0x1E, 0xFF, 0xBF, 0xC3, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xC0, 0x00, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xEF,
  0xB8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE3, 0xFC, 0xF7, 0x9C,
  0xF7, 0x9F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF1, 0xEF, 0x3C, 0xE7, 0x9E, 0xF1,
  0xDE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3,
  0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3,
  0xC7, 0xEF, 0xBF, 0xFF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0xEF,
  0xBF, 0xEF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF,
  0xFF, 0xFE, 0xF7, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x3D,
  0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xFC, 0xFF,
  0xFD, 0xF7, 0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xEF,
  0xDF, 0xFF, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x7E,
  0xFE, 0xF6, 0xE0, 0xF0, 0xFC, 0x7E, 0x3E, 0x0F, 0x8F, 0xFE, 0xFE, 0xFC,
  0x18, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0xF1, 0xEE, 0x3D,
  0xC7, 0x38, 0xE7, 0xBC, 0x77, 0x8E, 0xE1, 0xDC, 0x3B, 0x83, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0xF3, 0xE7, 0xF9, 0xF3, 0x9C, 0xF9, 0xCE, 0x6C, 0xE7,
  0x36, 0xF3, 0xFB, 0x78, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xEF, 0x79, 0xEE, 0x1F,
  0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x87, 0xF1, 0xEE, 0x39, 0xEF,
  0x1E, 0xF1, 0xEE, 0x3D, 0xC7, 0x3C, 0xE7, 0xBC, 0x77, 0x8E, 0xE1, 0xDC,
  0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x7C,
  0x0F, 0x81, 0xC0, 0x00, 0x7F, 0x3F, 0x9F, 0xC1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x3C, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x1F, 0x1F, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF0, 0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xE3, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7C, 0x79, 0xF3,
  0x87, 0x0E, 0x1C, 0x38, 0xF3, 0xE7, 0x8E, 0x00, 0x20, 0x7F, 0x3F, 0xFE,
  0x7F, 0x83, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 9, 6, 11, 1, -17 },
  { 17, 12, 17, 13, 0, -17 },
  { 43, 9, 19, 12, 1, -18 },
  { 65, 18, 17, 19, 1, -17 },
  { 104, 13, 17, 14, 1, -17 },
  { 132, 4, 6, 6, 1, -17 },
  { 135, 6, 21, 8, 1, -17 },
  { 151, 7, 21, 8, 0, -17 },
  { 170, 11, 10, 11, 0, -18 },
  { 184, 10, 11, 12, 1, -14 },
  { 198, 4, 6, 6, 1, -3 },
  { 201, 6, 3, 8, 1, -8 },
  { 204, 4, 4, 6, 1, -4 },
  { 206, 10, 17, 10, 0, -17 },
  { 228, 10, 17, 11, 1, -17 },
  { 250, 8, 17, 11, 1, -17 },
  { 267, 9, 17, 11, 1, -17 },
  { 287, 9, 17, 11, 1, -17 },
  { 307, 11, 17, 11, 0, -17 },
  { 331, 9, 17, 11, 1, -17 },
  { 351, 10, 17, 11, 1, -17 },
  { 373, 10, 17, 11, 1, -17 },
  { 395, 10, 17, 11, 1, -17 },
  { 417, 10, 17, 11, 1, -17 },
  { 439, 4, 13, 6, 1, -13 },
  { 446, 4, 16, 6, 1, -13 },
  { 454, 10, 11, 12, 1, -14 },
  { 468, 10, 7, 12, 1, -12 },
  { 477, 10, 11, 12, 1, -14 },
  { 491, 9, 17, 9, 0, -17 },
  { 511, 16, 19, 18, 1, -17 },
  { 549, 13, 17, 13, 0, -17 },
  { 577, 11, 17, 13, 1, -17 },
  { 601, 10, 17, 12, 1, -17 },
  { 623, 12, 17, 14, 1, -17 },
  { 649, 7, 17, 11, 2, -17 },
  { 664, 7, 17, 10, 2, -17 },
  { 679, 12, 17, 14, 1, -17 },
  { 705, 11, 17, 14, 2, -17 },
  { 729, 6, 17, 8, 1, -17 },
  { 742, 6, 22, 7, -1, -17 },
  { 759, 11, 17, 13, 2, -17 },
  { 783, 9, 17, 10, 1, -17 },
  { 803, 15, 17, 19, 2, -17 },
  { 835, 12, 17, 15, 2, -17 },
  { 861, 13, 17, 15, 1, -17 },
  { 889, 10, 17, 12, 1, -17 },
  { 911, 13, 21, 15, 1, -17 },
  { 946, 12, 17, 13, 1, -17 },
  { 972, 9, 17, 10, 1, -17 },
  { 992, 10, 17, 11, 0, -17 },
  { 1014, 11, 17, 14, 1, -17 },
  { 1038, 13, 17, 13, 0, -17 },
  { 1066, 19, 17, 19, 0, -17 },
  { 1107, 12, 17, 12, 0, -17 },
  { 1133, 12, 17, 12, 0, -17 },
  { 1159, 10, 17, 11, 0, -17 },
  { 1181, 6, 21, 7, 1, -17 },
  { 1197, 10, 17, 10, 0, -17 },
  { 1219, 6, 21, 7, 0, -17 },
  { 1235, 12, 11, 13, 0, -17 },
  { 1252, 11, 2, 11, 0, 2 },
  { 1255, 6, 3, 8, 1, -18 },
  { 1258, 9, 13, 11, 1, -13 },
  { 1273, 10, 18, 12, 1, -18 },
  { 1296, 8, 13, 10, 1, -13 },
  { 1309, 10, 18, 12, 1, -18 },
  { 1332, 10, 13, 11, 1, -13 },
  { 1349, 8, 18, 7, 0, -18 },
  { 1367, 10, 19, 12, 1, -13 },
  { 1391, 10, 18, 12, 1, -18 },
  { 1414, 4, 18, 6, 1, -18 },
  { 1423, 6, 24, 6, -1, -18 },
  { 1441, 11, 18, 12, 1, -18 },
  { 1466, 4, 18, 6, 1, -18 },
  { 1475, 16, 13, 18, 1, -13 },
  { 1501, 10, 13, 12, 1, -13 },
  { 1518, 10, 13, 12, 1, -13 },
  { 1535, 10, 19, 12, 1, -13 },
  { 1559, 10, 19, 12, 1, -13 },
  { 1583, 7, 13, 9, 1, -13 },
  { 1595, 8, 13, 9, 1, -13 },
  { 1608, 8, 16, 8, 0, -16 },
  { 1624, 10, 13, 12, 1, -13 },
  { 1641, 11, 13, 11, 0, -13 },
  { 1659, 17, 13, 17, 0, -13 },
  { 1687, 11, 13, 11, 0, -13 },
  { 1705, 11, 19, 11, 0, -13 },
  { 1732, 9, 13, 9, 0, -13 },
  { 1747, 8, 21, 9, 0, -17 },
  { 1768, 3, 24, 10, 4, -18 },
  { 1777, 7, 21, 9, 1, -17 },
  { 1796, 10, 5, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD24PT7B_H_
