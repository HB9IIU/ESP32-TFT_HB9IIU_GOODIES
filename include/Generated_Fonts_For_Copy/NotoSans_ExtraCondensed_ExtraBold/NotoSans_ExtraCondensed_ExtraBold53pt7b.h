#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xFC,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xF7, 0xF9, 0xF8, 0x20, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF,
  0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07,
  0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xDE, 0x39, 0xFC, 0xF0, 0x4F, 0xE7, 0x80, 0x7F, 0x3C,
  0x01, 0xFD, 0xE0, 0x0F, 0xEF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1E, 0xFE, 0x00,
  0xF7, 0xF0, 0x07, 0x9F, 0xE0, 0x3D, 0xFF, 0xC1, 0xEF, 0xFF, 0x8F, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x7E, 0x01, 0xF0, 0x00, 0x7E,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0x03,
  0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xC0, 0x00,
  0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x1F, 0x07,
  0xE0, 0x7E, 0x3F, 0x3F, 0x1F, 0xF8, 0x7E, 0x7F, 0x3F, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3E, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7F, 0xFE, 0x1F, 0xFC, 0x7E,
  0x7E, 0x7E, 0x0F, 0xF8, 0xFC, 0x7E, 0x3F, 0x07, 0xF0, 0xFC, 0x7C, 0x3F,
  0x00, 0x00, 0xF8, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0x7C, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x0F, 0xC0,
  0x7E, 0x7E, 0x00, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xFC, 0x7F,
  0x87, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFB, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x87,
  0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xC3,
  0xF0, 0xE7, 0xEF, 0xCF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC3, 0xF8,
  0x7F, 0x83, 0xE1, 0xF8, 0x07, 0x03, 0x80, 0x04, 0x04, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x9F,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x7F, 0xBF, 0x9F, 0xCF,
  0xE7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0,
  0x7F, 0xBF, 0xC3, 0xF9, 0xFE, 0x3F, 0xCF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x3F, 0xCF, 0x8F, 0xF1,
  0xC3, 0xFC, 0x20, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0x83, 0xFE, 0x1C, 0x07, 0xF8, 0x20, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFD, 0xFF, 0xC7, 0x01, 0xFE,
  0x20, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xEF, 0xF0, 0x07, 0xEF, 0xF0, 0x0F, 0xCF, 0xF0, 0x0F, 0xCF,
  0xF0, 0x1F, 0x8F, 0xF0, 0x1F, 0x8F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x38, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xEF, 0xCF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xC3, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x7C, 0x0F, 0xE7, 0xFC, 0x3F,
  0xBF, 0xF8, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xF9, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xF7, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xBF, 0xC1,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFF, 0x7F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x3F, 0xE3, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xBF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFC, 0x0F, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81,
  0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0x7F, 0x07, 0xFC, 0xFE,
  0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x10, 0x1F, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x3F, 0x3F, 0xDF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xF9, 0xFE, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xF3, 0xF0, 0x20, 0x04, 0x0F, 0xC7, 0xF9, 0xFE,
  0x7F, 0xDF, 0xF7, 0xF9, 0xFE, 0x3F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0x81, 0xFE, 0x20, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x06, 0x01, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F, 0x1F, 0x83,
  0xFF, 0xE3, 0xE7, 0xE0, 0xFF, 0xFC, 0x7E, 0xFC, 0x3F, 0xFF, 0x8F, 0xDF,
  0x07, 0xE3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x0F, 0xC3,
  0xFF, 0x87, 0xC1, 0xF8, 0x7F, 0xF1, 0xF8, 0x3F, 0x0F, 0xFE, 0x3F, 0x07,
  0xE1, 0xFF, 0xC7, 0xE0, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0x1F,
  0x83, 0xE0, 0xFF, 0xE3, 0xF0, 0x7C, 0x1F, 0xFC, 0x7E, 0x1F, 0x87, 0xFF,
  0x8F, 0xC3, 0xF0, 0xFB, 0xF0, 0xFC, 0x7F, 0x1F, 0x7E, 0x1F, 0xFF, 0xFF,
  0xE7, 0xC1, 0xFF, 0xBF, 0xF8, 0xFC, 0x3F, 0xF3, 0xFE, 0x1F, 0x83, 0xFC,
  0x7F, 0x83, 0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00,
  0xFF, 0x80, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xF8,
  0x1C, 0x3F, 0xE0, 0x08, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x8F, 0xFC, 0x07, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFE, 0x1F, 0xFC, 0xFF, 0x03, 0xFE, 0x7F,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0,
  0x1F, 0xF7, 0xF8, 0x1F, 0xF3, 0xFC, 0x3F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x1C,
  0x3F, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3,
  0xFF, 0x03, 0xFC, 0x7F, 0xF3, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0x60, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x83,
  0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF,
  0xFC, 0x0F, 0xDF, 0xFF, 0xDF, 0x81, 0xFB, 0xFF, 0xFB, 0xF0, 0x7F, 0x7F,
  0xFF, 0x7F, 0x0F, 0xCF, 0xFF, 0xEF, 0xE1, 0xF9, 0xFF, 0xFC, 0xFC, 0x3F,
  0x3F, 0xFF, 0x9F, 0x8F, 0xE7, 0xFF, 0xF3, 0xF9, 0xF8, 0xFF, 0xFE, 0x7F,
  0x3F, 0x1F, 0xFF, 0xC7, 0xEF, 0xE3, 0xFF, 0xF8, 0xFD, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0x07,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF,
  0x81, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0x7F, 0x8F,
  0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF,
  0x1F, 0xCF, 0xFF, 0xF1, 0xFE, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFE,
  0x1F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x3F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xF8, 0x3C, 0xFF, 0x00, 0xCF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFE, 0xF8, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0x07, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0xF0, 0x3F, 0x87, 0xF0,
  0x3F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xBE,
  0x0F, 0xF0, 0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0x3F, 0x87, 0xEF, 0xC3, 0xFC,
  0x1F, 0xC3, 0xF7, 0xE1, 0xFC, 0x0F, 0xE1, 0xFB, 0xF1, 0xFE, 0x07, 0xF8,
  0xFD, 0xF8, 0xFF, 0x03, 0xFC, 0xFE, 0xFE, 0x7F, 0x80, 0xFE, 0x7E, 0x3F,
  0x3F, 0xC0, 0x7F, 0x3F, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8F, 0xCF, 0xE0,
  0x1F, 0xCF, 0xC7, 0xEF, 0xF0, 0x0F, 0xF7, 0xE3, 0xF7, 0xF8, 0x03, 0xFF,
  0xF0, 0xFB, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xE3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x07, 0xF3, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF7,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x81, 0xFE, 0x08, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0x0F, 0xF7, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xCF,
  0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x3F, 0x83, 0xF0, 0x10, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x60, 0x3F, 0x8F, 0xF0, 0xFE, 0x7F, 0xE3, 0xFB,
  0xFF, 0xCF, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F,
  0xEF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0x8F, 0xE7, 0xFE, 0x3F, 0x0F,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFE, 0x0C, 0x7F,
  0x80, 0x9F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x13, 0xFE,
  0x0E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x18, 0x1F,
  0xC3, 0xFC, 0x7F, 0x1F, 0xF9, 0xFC, 0x7F, 0xF7, 0xF3, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xF7, 0xF1, 0xFF, 0x8F, 0xC1, 0xFC, 0x3F, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0xCF, 0xF0, 0xFE, 0x7F, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x4F,
  0xF0, 0x0E, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xC2, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC3, 0xF1,
  0xFF, 0x9F, 0xC7, 0xFF, 0x7F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xC7, 0xFF, 0x7F, 0x1F,
  0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x08, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF4, 0x00, 0x7F, 0x9E, 0x03, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x3E, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0x81, 0xFC, 0x7F,
  0x8F, 0xE7, 0xFE, 0x7F, 0x7F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0x38, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xDF,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x1F, 0x87, 0xF8, 0x3F, 0xE3,
  0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0x7F, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F,
  0xF1, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE,
  0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF,
  0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0x07, 0xE1, 0xFE, 0x3F, 0x3F, 0xF9, 0xF9,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x78,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFD,
  0xFE, 0x07, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xCF, 0xE0,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xF0, 0xFF, 0x0F, 0xC7, 0xFE,
  0x3F, 0xBF, 0xF8, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xE1, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xEF, 0xFF, 0x3F, 0xBF, 0xF8, 0xFE, 0x7F, 0xE3,
  0xF8, 0xFE, 0x0F, 0xE0, 0x40, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC3, 0xF1, 0xFF, 0x9F, 0xC7,
  0xFF, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xE1,
  0xFF, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xC7, 0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x1F,
  0xC7, 0xF0, 0x08, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x0E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFE, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFC, 0x0C, 0xFF, 0x01, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE3, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x40,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xEF, 0xCF, 0xFE, 0x7E, 0x7F,
  0xF3, 0xF0, 0xFF, 0x1F, 0x80, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xBF, 0x80,
  0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xF0, 0x3F, 0xDF,
  0xC0, 0xFF, 0xC1, 0xFE, 0xFF, 0x07, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0xF0,
  0x7F, 0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFB, 0xE1, 0xFC, 0x3F, 0xC7, 0xDF, 0x8F, 0xE1, 0xFE, 0x3E, 0xFC, 0x7F,
  0x07, 0xF3, 0xF7, 0xE7, 0xF8, 0x3F, 0x9F, 0x9F, 0x3F, 0xC1, 0xFC, 0xFC,
  0xF9, 0xFC, 0x0F, 0xE7, 0xC7, 0xCF, 0xE0, 0x7F, 0x3E, 0x3F, 0x7F, 0x01,
  0xFD, 0xF1, 0xFB, 0xF8, 0x0F, 0xEF, 0x8F, 0xDF, 0xC0, 0x7F, 0xFC, 0x3E,
  0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xFC, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xFB,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xF9, 0xFE, 0x0F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x3F,
  0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x02, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 39, 14, 2, -38 },
  { 45, 20, 14, 24, 2, -38 },
  { 80, 26, 38, 28, 1, -38 },
  { 204, 21, 43, 25, 2, -40 },
  { 317, 40, 38, 43, 1, -38 },
  { 507, 31, 39, 32, 1, -38 },
  { 659, 9, 14, 13, 2, -38 },
  { 675, 15, 46, 17, 2, -38 },
  { 762, 15, 46, 17, 0, -38 },
  { 849, 22, 22, 24, 1, -40 },
  { 910, 22, 26, 26, 2, -32 },
  { 982, 9, 14, 14, 2, -7 },
  { 998, 13, 7, 17, 2, -18 },
  { 1010, 8, 10, 14, 3, -9 },
  { 1020, 22, 38, 22, 0, -38 },
  { 1125, 21, 39, 25, 2, -38 },
  { 1228, 18, 38, 25, 2, -38 },
  { 1314, 22, 38, 25, 1, -38 },
  { 1419, 21, 39, 25, 2, -38 },
  { 1522, 24, 38, 25, 1, -38 },
  { 1636, 20, 39, 25, 3, -38 },
  { 1734, 22, 39, 25, 2, -38 },
  { 1842, 22, 38, 25, 2, -38 },
  { 1947, 22, 39, 25, 2, -38 },
  { 2055, 23, 39, 25, 1, -38 },
  { 2168, 9, 31, 14, 3, -30 },
  { 2203, 10, 37, 14, 2, -30 },
  { 2250, 23, 26, 26, 1, -32 },
  { 2325, 22, 17, 26, 2, -27 },
  { 2372, 22, 26, 26, 2, -32 },
  { 2444, 20, 39, 20, 0, -38 },
  { 2542, 35, 42, 39, 2, -38 },
  { 2726, 29, 38, 29, 0, -38 },
  { 2864, 24, 38, 29, 3, -38 },
  { 2978, 23, 39, 26, 2, -38 },
  { 3091, 25, 38, 30, 3, -38 },
  { 3210, 18, 38, 23, 3, -38 },
  { 3296, 18, 38, 23, 3, -38 },
  { 3382, 26, 39, 31, 2, -38 },
  { 3509, 25, 38, 32, 3, -38 },
  { 3628, 15, 38, 18, 1, -38 },
  { 3700, 14, 50, 15, -3, -38 },
  { 3788, 26, 38, 28, 3, -38 },
  { 3912, 18, 38, 22, 3, -38 },
  { 3998, 35, 38, 42, 3, -38 },
  { 4165, 28, 38, 34, 3, -38 },
  { 4298, 28, 39, 32, 2, -38 },
  { 4435, 22, 38, 27, 3, -38 },
  { 4540, 28, 47, 32, 2, -38 },
  { 4705, 25, 38, 28, 3, -38 },
  { 4824, 20, 39, 23, 2, -38 },
  { 4922, 22, 38, 23, 1, -38 },
  { 5027, 25, 39, 31, 3, -38 },
  { 5149, 28, 38, 28, 0, -38 },
  { 5282, 41, 38, 41, 0, -38 },
  { 5477, 26, 38, 26, 0, -38 },
  { 5601, 26, 38, 26, 0, -38 },
  { 5725, 21, 38, 23, 1, -38 },
  { 5825, 12, 47, 16, 3, -38 },
  { 5896, 22, 38, 22, 0, -38 },
  { 6001, 13, 47, 16, 1, -38 },
  { 6078, 27, 24, 28, 1, -38 },
  { 6159, 24, 5, 24, 0, 4 },
  { 6174, 13, 9, 17, 2, -41 },
  { 6189, 22, 31, 25, 1, -30 },
  { 6275, 22, 41, 27, 3, -40 },
  { 6388, 19, 31, 22, 2, -30 },
  { 6462, 22, 41, 27, 2, -40 },
  { 6575, 21, 31, 25, 2, -30 },
  { 6657, 18, 41, 17, 0, -41 },
  { 6750, 22, 43, 27, 2, -30 },
  { 6869, 21, 40, 27, 3, -40 },
  { 6974, 8, 41, 13, 3, -41 },
  { 7015, 13, 54, 13, -2, -41 },
  { 7103, 24, 40, 27, 3, -40 },
  { 7223, 8, 40, 13, 3, -40 },
  { 7263, 35, 30, 41, 3, -30 },
  { 7395, 21, 30, 27, 3, -30 },
  { 7474, 23, 31, 27, 2, -30 },
  { 7564, 22, 43, 27, 3, -30 },
  { 7683, 22, 43, 27, 2, -30 },
  { 7802, 16, 30, 19, 3, -30 },
  { 7862, 18, 31, 20, 1, -30 },
  { 7932, 16, 36, 18, 1, -35 },
  { 8004, 21, 30, 27, 3, -29 },
  { 8083, 25, 29, 25, 0, -29 },
  { 8174, 37, 29, 37, 0, -29 },
  { 8309, 23, 29, 24, 0, -29 },
  { 8393, 25, 42, 25, 0, -29 },
  { 8525, 18, 29, 20, 1, -29 },
  { 8591, 16, 47, 19, 1, -38 },
  { 8685, 7, 53, 23, 8, -41 },
  { 8732, 16, 47, 19, 2, -38 },
  { 8826, 23, 9, 26, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD53PT7B_H_
