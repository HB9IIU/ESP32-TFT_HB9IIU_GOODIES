#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0x73, 0xDC, 0x77, 0x1C, 0x0E, 0xE0,
  0x67, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x19,
  0xC1, 0xCE, 0x0E, 0x71, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0xEE, 0x06, 0x70,
  0x73, 0x83, 0x9C, 0x1C, 0xE0, 0x04, 0x00, 0x80, 0x38, 0x1F, 0xF7, 0xFD,
  0xFF, 0xBD, 0x17, 0xA0, 0xF4, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x0B,
  0xC1, 0x7C, 0x2F, 0xE5, 0xDF, 0xFB, 0xFE, 0x1F, 0x80, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x00, 0x07, 0xC0, 0xE0, 0xFE, 0x1C, 0x0E, 0xE1, 0xC0, 0xE7,
  0x1C, 0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x77, 0x00, 0xE7, 0x73, 0x8E,
  0xE7, 0x7E, 0x7E, 0xEF, 0xE7, 0xCE, 0xE7, 0x11, 0xCE, 0x70, 0x1C, 0xE7,
  0x01, 0xCE, 0x70, 0x38, 0xE7, 0x03, 0x8E, 0x70, 0x70, 0xFE, 0x07, 0x07,
  0xE0, 0x70, 0x3C, 0x04, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0x9E,
  0x0F, 0x38, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x05, 0xFC, 0xF7,
  0xFD, 0xEF, 0x7F, 0xDE, 0x7F, 0x3C, 0xFE, 0x78, 0xFC, 0xF9, 0xF9, 0xFF,
  0xF1, 0xFF, 0xF1, 0xF9, 0xF0, 0xFF, 0xFF, 0x77, 0x70, 0x0E, 0x3C, 0x71,
  0xE3, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70,
  0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87,
  0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x78, 0xE3,
  0xC7, 0x1E, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x06, 0x72, 0x7F, 0xE7, 0xFF,
  0xFF, 0xE1, 0xF8, 0x1F, 0xC7, 0xDE, 0x39, 0xC0, 0x88, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x7B, 0xFD, 0xEF, 0x73, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x04, 0x07, 0xE1, 0xFE, 0x3F,
  0xE7, 0xBD, 0xE3, 0xBC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x7B, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x07,
  0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xFD, 0xDE, 0x4F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x0C, 0x0F, 0xE3,
  0xFE, 0x7F, 0xE6, 0x3C, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x04, 0x0F, 0xF3, 0xFF, 0x3F, 0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x1F, 0xC7,
  0xFF, 0xFB, 0xFE, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x77, 0x83, 0xBC, 0x39, 0xE1, 0xCF, 0x1C, 0x78, 0xE3,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFC, 0x7F,
  0xCF, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0xFF, 0x3E, 0xFF, 0xDF,
  0xF1, 0xFC, 0x00, 0x01, 0x01, 0xF8, 0xFF, 0x1F, 0xE7, 0xC0, 0xE0, 0x3C,
  0x07, 0x98, 0xFF, 0xDF, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0x7B, 0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x00, 0x04, 0x07,
  0xF1, 0xFF, 0x7F, 0xEF, 0x1F, 0xE3, 0xFC, 0x73, 0xDE, 0x7F, 0x87, 0xE0,
  0xFE, 0x3F, 0xEF, 0xBD, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD, 0xFF,
  0x1F, 0xC0, 0x04, 0x07, 0xE1, 0xFE, 0x7F, 0xEF, 0x3D, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x7F, 0xFF, 0xBF, 0xF7, 0xDE, 0x03, 0xC0, 0x70, 0x1E,
  0x07, 0xCF, 0xF1, 0xFC, 0x3F, 0x00, 0x77, 0xFE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFD, 0xC0, 0x73, 0xFE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBD, 0xDE, 0xF7, 0xB8, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xF7, 0xF1, 0xF8,
  0x3E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x1E, 0x03, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0x7F, 0x3F, 0x9F,
  0xC3, 0xE0, 0x70, 0x08, 0x00, 0x08, 0x1F, 0xCF, 0xF9, 0xFF, 0x63, 0xC0,
  0xF0, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x83, 0xE0, 0x70, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x78, 0x3C, 0x38, 0x07, 0x9C, 0x10, 0xE7, 0x1F, 0x9D, 0x8F, 0xE7,
  0xE7, 0x39, 0xF9, 0xCE, 0x7E, 0x73, 0x9F, 0x9C, 0xE7, 0xE7, 0x39, 0xF9,
  0xCE, 0x7E, 0x7F, 0xFB, 0x8F, 0xFE, 0x71, 0xCE, 0x1C, 0x00, 0x03, 0x80,
  0x20, 0xFC, 0x70, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x1C,
  0xF0, 0x78, 0xE0, 0xF1, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF,
  0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xE0, 0xF8, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0x3E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x00, 0x03, 0x00, 0xFF, 0x1F, 0xE3, 0xFE, 0x7C, 0x27, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x7E, 0x63, 0xFE, 0x1F, 0xE0, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF,
  0x3E, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDE, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0x7F, 0xBF, 0xDE, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x01, 0x80, 0x7F, 0xC7,
  0xFE, 0x7F, 0xE7, 0xE1, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x3D, 0xE1, 0xEF, 0x0F, 0x7C, 0x79,
  0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0xFF, 0x8F, 0xBC, 0x79, 0xE7, 0xCF, 0x7C,
  0x7B, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F,
  0x7C, 0x79, 0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0xBC, 0x3E, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFB, 0x8F, 0xFE, 0xE3,
  0xBF, 0xB8, 0xEF, 0xFF, 0x3B, 0xFD, 0xDE, 0xFF, 0x77, 0x3F, 0xDD, 0xCF,
  0xF7, 0xF3, 0xFC, 0xFC, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF3, 0xE3, 0xFC,
  0x70, 0xFF, 0x1C, 0x3C, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF8, 0xFE, 0xE3, 0xFB, 0xCF, 0xEF, 0x3F, 0xDE, 0xFF, 0x7B, 0xFC,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x07, 0xC0, 0x01, 0x00, 0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7C, 0x79, 0xE1,
  0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0xF7, 0x87, 0xDE, 0x1F, 0x7C, 0xF8, 0xFF, 0xE1, 0xFF, 0x03,
  0xF8, 0xFF, 0x1F, 0xFB, 0xFF, 0x79, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F,
  0xF3, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7C,
  0x79, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDE, 0x1F, 0x7C, 0xF8, 0xFF, 0xE1,
  0xFF, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0x3E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3E,
  0xFF, 0xCF, 0xFC, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x7C, 0xF3, 0xCF, 0x3E,
  0xF1, 0xEF, 0x1F, 0xF0, 0xF0, 0x04, 0x0F, 0xF7, 0xFF, 0xFF, 0xF9, 0xBC,
  0x0F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xFF, 0xEF, 0xF9, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFC, 0x3F, 0x80, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x78,
  0x79, 0xE1, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC1, 0xCF, 0x07,
  0xB8, 0x1E, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1E, 0xE1, 0xF1,
  0xE7, 0x8F, 0x8F, 0x3C, 0x7C, 0x79, 0xE7, 0x63, 0xCF, 0x3B, 0x9E, 0x39,
  0xDD, 0xE1, 0xEE, 0xEF, 0x0F, 0x77, 0x78, 0x7F, 0xBB, 0xC3, 0xF9, 0xDE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xC1, 0xE0, 0xF8, 0xFB, 0xC7, 0x9F, 0x3C, 0x7B, 0xC3, 0xDE,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x1E, 0xF0, 0xF7, 0x87, 0x9E, 0x78, 0xF3, 0xC7, 0xFE, 0x1E, 0xF8,
  0x7B, 0xC3, 0xDE, 0x3C, 0xF9, 0xE3, 0xCF, 0x1E, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0xFF, 0xFF,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xFF, 0xFF, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xE0, 0x7F, 0x81, 0xEE, 0x0F, 0x3C, 0x3C, 0x70, 0xE1, 0xE7, 0x83, 0xBC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x3F,
  0x0F, 0xF9, 0xFF, 0x11, 0xE0, 0x1C, 0x03, 0xCF, 0xFB, 0xFF, 0xF9, 0xFE,
  0x3F, 0xCF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0x78, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x8F, 0x7C, 0xFF, 0xEF, 0xDE, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x9E, 0xFF,
  0xEF, 0xFE, 0xF7, 0xC0, 0x1F, 0x8F, 0xF7, 0xF9, 0xE6, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE2, 0x7F, 0x9F, 0xE3, 0xF8, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xCF, 0x7B, 0xF7, 0x7F, 0xFF,
  0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x3D,
  0xFF, 0xBF, 0x73, 0xEE, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x7C, 0x27, 0xFC, 0x7F, 0x87,
  0xF0, 0x06, 0x0F, 0xCF, 0xE7, 0xE3, 0xC1, 0xE1, 0xFD, 0xFE, 0xFF, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0x3C, 0xEF, 0xDD, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xFC, 0xF7, 0xFE, 0xFD, 0xCF, 0x78, 0x0F, 0x01,
  0xE8, 0x3D, 0xFF, 0x3F, 0xE7, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3D, 0xF7, 0xBF, 0xFF, 0xFF, 0xBF, 0xE7, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0x77,
  0xBE, 0xE2, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x00, 0x1C, 0x78, 0xF8, 0xE0, 0x80, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0xFD, 0xFB,
  0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE,
  0x3E, 0xE3, 0xCE, 0x78, 0xE7, 0x8E, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0x78, 0xE7, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0xCF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF3, 0xFE, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0xF7, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x9F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x38, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x9E, 0xF1, 0xEF, 0x1E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xE7, 0x9E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xF3, 0xCF, 0x7C, 0xFF, 0xEF, 0x9E, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x9E, 0xFF, 0xEF, 0x7E, 0xF7,
  0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0xEF,
  0xDD, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xFC, 0xF7, 0xFE, 0xFD, 0xCF, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0xF3, 0xFB, 0xBF, 0xDF, 0xEF, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x3E, 0x7F, 0xFF, 0xDE,
  0x6F, 0x07, 0xC3, 0xF0, 0xFE, 0x3F, 0x07, 0xC1, 0xF0, 0xFF, 0xF7, 0xFB,
  0xF8, 0x1C, 0x0E, 0x0F, 0x07, 0xEF, 0xF7, 0xF8, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF2, 0x7F, 0x3F, 0x8F, 0xC0, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F,
  0xC7, 0xBC, 0xF7, 0xFE, 0xFF, 0xCF, 0xB8, 0xF0, 0xFF, 0x87, 0x9E, 0x3C,
  0xF1, 0xE7, 0x9E, 0x1C, 0xF0, 0xE7, 0x87, 0xB8, 0x3D, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF1, 0xF1, 0xFE, 0x3E,
  0x3D, 0xC7, 0xC7, 0x3C, 0xF9, 0xE7, 0x9B, 0xBC, 0xF7, 0x77, 0x9E, 0xEE,
  0xF1, 0xDD, 0xDC, 0x3B, 0xBB, 0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF7, 0x9E, 0x79,
  0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0xC3, 0xFC, 0x79, 0xE7, 0x9E, 0xF0, 0xF0, 0xF0, 0xFF, 0x87, 0x9E, 0x3C,
  0xF1, 0xE7, 0x9E, 0x1C, 0xF0, 0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0x8F, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0x3F, 0x1E, 0x0F, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xF8, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF8, 0xF8, 0x38, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3F, 0x0F, 0x3F, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0xF8, 0xF8, 0xF0, 0x78, 0x3F, 0xEF, 0xFF, 0xE7, 0xF8, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 12, 1, -19 },
  { 22, 13, 19, 14, 1, -19 },
  { 53, 11, 23, 13, 1, -21 },
  { 85, 20, 20, 22, 1, -20 },
  { 135, 15, 20, 16, 1, -20 },
  { 173, 4, 7, 7, 1, -19 },
  { 177, 7, 24, 9, 1, -20 },
  { 198, 7, 24, 9, 0, -20 },
  { 219, 12, 12, 12, 0, -21 },
  { 237, 11, 13, 13, 1, -16 },
  { 255, 5, 7, 7, 1, -3 },
  { 260, 7, 4, 8, 1, -9 },
  { 264, 5, 4, 7, 1, -4 },
  { 267, 11, 20, 11, 0, -20 },
  { 295, 11, 20, 13, 1, -20 },
  { 323, 9, 19, 13, 1, -19 },
  { 345, 11, 20, 13, 1, -20 },
  { 373, 11, 20, 13, 1, -20 },
  { 401, 13, 19, 13, 0, -19 },
  { 432, 11, 19, 13, 1, -19 },
  { 459, 11, 20, 13, 1, -20 },
  { 487, 11, 19, 13, 1, -19 },
  { 514, 11, 20, 13, 1, -20 },
  { 542, 11, 20, 13, 1, -20 },
  { 570, 5, 15, 7, 1, -15 },
  { 580, 5, 19, 7, 1, -15 },
  { 592, 11, 13, 13, 1, -16 },
  { 610, 11, 9, 13, 1, -14 },
  { 623, 11, 13, 13, 1, -16 },
  { 641, 10, 20, 10, 0, -20 },
  { 666, 18, 22, 20, 1, -20 },
  { 716, 15, 19, 15, 0, -19 },
  { 752, 12, 19, 15, 2, -19 },
  { 781, 12, 20, 13, 1, -20 },
  { 811, 12, 19, 15, 2, -19 },
  { 840, 9, 19, 12, 2, -19 },
  { 862, 9, 19, 12, 2, -19 },
  { 884, 13, 20, 16, 1, -20 },
  { 917, 12, 19, 16, 2, -19 },
  { 946, 7, 19, 9, 1, -19 },
  { 963, 8, 25, 8, -2, -19 },
  { 988, 13, 19, 14, 2, -19 },
  { 1019, 9, 19, 11, 2, -19 },
  { 1041, 18, 19, 21, 2, -19 },
  { 1084, 14, 19, 17, 2, -19 },
  { 1118, 14, 20, 16, 1, -20 },
  { 1153, 11, 19, 14, 2, -19 },
  { 1180, 14, 25, 16, 1, -20 },
  { 1224, 12, 19, 14, 2, -19 },
  { 1253, 10, 20, 12, 1, -20 },
  { 1278, 12, 19, 12, 0, -19 },
  { 1307, 12, 19, 16, 2, -19 },
  { 1336, 14, 19, 14, 0, -19 },
  { 1370, 21, 19, 21, 0, -19 },
  { 1420, 13, 19, 13, 0, -19 },
  { 1451, 13, 19, 13, 0, -19 },
  { 1482, 11, 19, 12, 0, -19 },
  { 1509, 7, 24, 8, 1, -20 },
  { 1530, 11, 20, 11, 0, -20 },
  { 1558, 6, 24, 8, 1, -20 },
  { 1576, 14, 12, 14, 0, -19 },
  { 1597, 12, 3, 12, 0, 2 },
  { 1602, 7, 5, 9, 1, -21 },
  { 1607, 11, 15, 13, 1, -15 },
  { 1628, 12, 21, 14, 1, -21 },
  { 1660, 10, 15, 11, 1, -15 },
  { 1679, 11, 21, 14, 1, -21 },
  { 1708, 11, 15, 13, 1, -15 },
  { 1729, 9, 21, 8, 0, -21 },
  { 1753, 11, 21, 14, 1, -15 },
  { 1782, 11, 21, 14, 1, -21 },
  { 1811, 5, 21, 7, 1, -21 },
  { 1825, 7, 27, 7, -1, -21 },
  { 1849, 12, 21, 14, 2, -21 },
  { 1881, 4, 21, 7, 1, -21 },
  { 1892, 18, 15, 21, 1, -15 },
  { 1926, 11, 15, 14, 1, -15 },
  { 1947, 12, 15, 14, 1, -15 },
  { 1970, 12, 21, 14, 1, -15 },
  { 2002, 11, 21, 14, 1, -15 },
  { 2031, 9, 15, 10, 1, -15 },
  { 2048, 9, 15, 10, 1, -15 },
  { 2065, 9, 18, 9, 0, -18 },
  { 2086, 11, 15, 14, 1, -15 },
  { 2107, 13, 15, 13, 0, -15 },
  { 2132, 19, 15, 19, 0, -15 },
  { 2168, 12, 15, 12, 0, -15 },
  { 2191, 13, 21, 13, 0, -15 },
  { 2226, 10, 15, 10, 0, -15 },
  { 2245, 9, 23, 10, 0, -19 },
  { 2271, 4, 27, 12, 4, -21 },
  { 2285, 8, 23, 10, 1, -19 },
  { 2308, 11, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD27PT7B_H_
