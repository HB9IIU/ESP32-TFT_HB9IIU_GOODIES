#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x3E, 0x60,
  0x1D, 0x86, 0x61, 0x98, 0x6C, 0x7F, 0xDF, 0xF1, 0xB0, 0xEC, 0xFF, 0xFF,
  0xF3, 0x70, 0xD8, 0x36, 0x0D, 0x80, 0x10, 0x3C, 0x7F, 0xFE, 0xD0, 0xF0,
  0xF0, 0x7C, 0x1E, 0x17, 0x17, 0x97, 0xFE, 0xFC, 0x10, 0x10, 0xF8, 0xE1,
  0xF1, 0x83, 0x63, 0x06, 0xEC, 0x0D, 0xD8, 0x1B, 0x77, 0x3E, 0xDF, 0x7D,
  0xB6, 0x06, 0x6C, 0x0C, 0xDC, 0x39, 0xB0, 0x63, 0x60, 0xC7, 0xC3, 0x07,
  0x00, 0x1F, 0x03, 0xF0, 0x33, 0x83, 0x30, 0x3F, 0x03, 0xE0, 0x3C, 0xF7,
  0xEE, 0x7F, 0xEE, 0x7E, 0xF3, 0xC7, 0x7C, 0x7F, 0xE3, 0xEF, 0xFF, 0xFE,
  0x39, 0x9C, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x31, 0xC6, 0x38, 0xE1,
  0xC3, 0x0E, 0x38, 0x61, 0x86, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x1C, 0xE0,
  0x1C, 0x0E, 0x1B, 0xDF, 0xF1, 0xC1, 0xF1, 0xDC, 0x64, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFD, 0x80, 0xFF, 0xFE,
  0xFF, 0x80, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30,
  0x30, 0x70, 0x60, 0xE0, 0x7C, 0x7E, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xEE, 0x7E, 0x3C, 0x1C, 0xF7, 0xFF, 0xED, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x3E, 0x7F, 0x99, 0xC8, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0F, 0xF7, 0xFB, 0xFC, 0xFC, 0xFE, 0x4E,
  0x06, 0x0E, 0x7E, 0x78, 0x7E, 0x0F, 0x07, 0x0F, 0x8E, 0xFE, 0xFC, 0x07,
  0x07, 0x83, 0xC3, 0xE1, 0xF1, 0xB8, 0xDC, 0xCE, 0xE7, 0x7F, 0xFF, 0xE0,
  0xE0, 0x70, 0x38, 0x7E, 0xFE, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0x4E, 0x07,
  0x07, 0x07, 0xDE, 0xFE, 0xFC, 0x3E, 0x7E, 0x70, 0xE0, 0xE0, 0xDE, 0xFE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0x7E, 0x3C, 0xFF, 0xFF, 0x07, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x7E, 0xFE, 0xE7,
  0xE7, 0xEE, 0x7E, 0x3C, 0x7E, 0xEF, 0xE7, 0xC7, 0xE7, 0xFE, 0x7C, 0x7C,
  0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x07, 0x0E, 0x9E, 0xFC,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFD, 0x80,
  0x01, 0x07, 0x1F, 0x7C, 0xF0, 0xF0, 0x7E, 0x0F, 0x03, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x1F, 0x7C, 0xF0,
  0xC0, 0x80, 0xFD, 0xFD, 0x38, 0x30, 0xE3, 0xC7, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x87, 0x00, 0x1F, 0xC1, 0xC7, 0x1C, 0x0C, 0xCF, 0x7C, 0xFD, 0xE6,
  0xCF, 0x76, 0x7B, 0x33, 0xD9, 0x9E, 0xEC, 0xF3, 0xFD, 0xCC, 0xC6, 0x00,
  0x3C, 0x20, 0x7F, 0x00, 0x60, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0x83, 0xB8,
  0x77, 0x0E, 0xE1, 0xDC, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0xEF, 0x1F, 0xC1,
  0xC0, 0xFF, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0xFB, 0xF9, 0xFE, 0xE3, 0xF1,
  0xF8, 0xFF, 0xFF, 0xF7, 0xF0, 0x3F, 0x7F, 0x71, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xF0, 0x7B, 0x7F, 0x3F, 0xFE, 0x3F, 0xCE, 0x7B, 0x8E,
  0xE3, 0xB8, 0xFE, 0x3F, 0x8F, 0xE3, 0xB8, 0xEE, 0x3B, 0xFC, 0xFF, 0x3F,
  0x00, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE1, 0xC3, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x3F, 0xBF, 0xDE, 0x3E, 0x0E, 0x07, 0x03, 0x9F, 0xCF,
  0xE3, 0xF1, 0xFC, 0xEF, 0x77, 0xF9, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x70, 0xFD, 0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0xFF, 0xF0,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xF7, 0xFF, 0x80,
  0xE3, 0xF8, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x8F, 0xC3, 0xF8, 0xFE, 0x39,
  0xCE, 0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF1, 0xFF, 0xCD, 0xFE, 0x6F, 0xB3, 0x7D, 0xBB, 0xEF, 0x9F, 0x7C, 0xF9,
  0xE7, 0xCF, 0x3E, 0x71, 0xF3, 0x8C, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0xCF, 0xF9, 0xFB, 0xBF, 0x77, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xC0, 0x04, 0x0F, 0xC7, 0xF9, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0x9F, 0xE3, 0xF0, 0xFE, 0x7F, 0xB9,
  0xDC, 0xEE, 0x7F, 0x3B, 0xFD, 0xFE, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x04, 0x0F, 0xC7, 0xF9, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0x9F, 0xE3, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0xFE, 0x3F, 0xCE, 0x73, 0x9E, 0xE7, 0xB9, 0xCF, 0xF3, 0xF8, 0xFE, 0x3B,
  0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xF0, 0x7F, 0xFF, 0x9F, 0x0E, 0x1E, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3F, 0xFF, 0xDF, 0x00, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xEE,
  0xF7, 0xF9, 0xF8, 0xE1, 0xFC, 0x39, 0xC7, 0x38, 0xE7, 0x18, 0xE7, 0x0C,
  0xE1, 0xDC, 0x3B, 0x07, 0x60, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xE3,
  0x8F, 0xE3, 0x8E, 0xE3, 0xCE, 0x63, 0xCE, 0x73, 0xCE, 0x77, 0xCE, 0x76,
  0xDC, 0x76, 0xDC, 0x36, 0xFC, 0x36, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C,
  0x78, 0x1C, 0x78, 0xF3, 0xDC, 0xE7, 0x70, 0xFC, 0x3F, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x0F, 0xC3, 0xF1, 0xCE, 0x73, 0xB8, 0xF0, 0xE1, 0xDC, 0xE7,
  0x39, 0xCC, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x30, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xFF, 0xF8, 0x0C, 0x03, 0x81, 0xE0, 0x7C, 0x3B, 0x0C,
  0xE7, 0x19, 0xC7, 0xE0, 0xC0, 0xFF, 0x80, 0xE3, 0x8E, 0xFC, 0x7E, 0x4E,
  0x07, 0x7F, 0xFF, 0xE7, 0xC7, 0xEF, 0xFF, 0xF7, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0xE7, 0xFB, 0xDD, 0xCE, 0xE3, 0xF1, 0xF8, 0xFC, 0xEF, 0x77, 0xFB,
  0xF8, 0x3E, 0xFF, 0xD7, 0x0E, 0x1C, 0x38, 0x70, 0xF6, 0xFD, 0xF0, 0x07,
  0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x7B, 0x7C, 0x7E, 0xE6, 0xE7, 0xFF, 0xFF, 0xE0, 0xE0, 0xE2, 0x7E,
  0x3E, 0x3E, 0x79, 0xC3, 0x87, 0xDF, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x7B, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x7F, 0x07, 0x87, 0xFF, 0xFE, 0x78, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFD, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xC6, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x3F, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0x3B,
  0xB9, 0xDC, 0xFC, 0x7E, 0x3F, 0x9D, 0xCE, 0x77, 0x3B, 0x8E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xDE, 0x77, 0xFF, 0xFD, 0xEF, 0xCE, 0x7E, 0x73,
  0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0xDE, 0xFF,
  0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0xEE, 0x7F, 0xBD, 0xDC,
  0xEE, 0x3F, 0x1F, 0x8F, 0xCE, 0xF7, 0x7F, 0xBB, 0x9C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x7B, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0xCF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x00, 0x7F, 0xFC, 0xB8, 0xF3, 0xE3, 0xC7, 0x9F, 0xFF, 0x80,
  0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x4F, 0x3C, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x7B, 0xE3, 0xF1, 0xDC,
  0xEE, 0xE7, 0x71, 0xB8, 0xD8, 0x7C, 0x3E, 0x0F, 0x07, 0x00, 0xE7, 0x9F,
  0x9E, 0x76, 0x79, 0x9D, 0xEE, 0x77, 0xB9, 0xFB, 0xE7, 0xCF, 0x8F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x00, 0xE7, 0xBB, 0x9D, 0xC7, 0xC3, 0xE0,
  0xE0, 0xF8, 0x7C, 0x77, 0x3B, 0xB8, 0xE0, 0xE3, 0xF1, 0xDC, 0xEE, 0xE7,
  0x71, 0xB8, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC3, 0xC1, 0xE0,
  0xE0, 0x7E, 0xFC, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xFF, 0xF8, 0x1E,
  0x7C, 0xE1, 0xC3, 0x87, 0x0E, 0x7C, 0xE1, 0xF0, 0xE1, 0xC3, 0x87, 0x0E,
  0x1F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC7,
  0x1C, 0x71, 0xC7, 0x1F, 0x1D, 0xF7, 0x1C, 0x71, 0xC7, 0x3C, 0xE0, 0xE1,
  0xFF, 0xFF, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 10, 0, -14 },
  { 30, 8, 16, 10, 1, -15 },
  { 46, 15, 14, 16, 1, -14 },
  { 73, 12, 14, 12, 0, -14 },
  { 94, 3, 5, 5, 1, -14 },
  { 96, 5, 17, 6, 1, -14 },
  { 107, 6, 17, 6, 0, -14 },
  { 120, 9, 8, 9, 0, -15 },
  { 129, 8, 10, 10, 1, -12 },
  { 139, 3, 6, 5, 1, -3 },
  { 142, 5, 3, 6, 1, -7 },
  { 144, 3, 3, 5, 1, -3 },
  { 146, 8, 14, 8, 0, -14 },
  { 160, 8, 14, 10, 1, -14 },
  { 174, 6, 14, 10, 1, -14 },
  { 185, 9, 14, 10, 0, -14 },
  { 201, 8, 14, 10, 1, -14 },
  { 215, 9, 14, 10, 0, -14 },
  { 231, 8, 14, 10, 1, -14 },
  { 245, 8, 14, 10, 1, -14 },
  { 259, 8, 14, 10, 1, -14 },
  { 273, 8, 14, 10, 1, -14 },
  { 287, 8, 14, 10, 1, -14 },
  { 301, 3, 11, 5, 1, -11 },
  { 306, 3, 14, 5, 1, -11 },
  { 312, 8, 10, 10, 1, -12 },
  { 322, 8, 6, 10, 1, -10 },
  { 328, 8, 10, 10, 1, -12 },
  { 338, 7, 14, 8, 0, -14 },
  { 351, 13, 16, 15, 1, -14 },
  { 377, 11, 14, 11, 0, -14 },
  { 397, 9, 14, 11, 1, -14 },
  { 413, 8, 14, 10, 1, -14 },
  { 427, 10, 14, 11, 1, -14 },
  { 445, 7, 14, 9, 1, -14 },
  { 458, 7, 14, 9, 1, -14 },
  { 471, 9, 14, 12, 1, -14 },
  { 487, 10, 14, 12, 1, -14 },
  { 505, 6, 14, 7, 0, -14 },
  { 516, 5, 18, 6, -1, -14 },
  { 528, 10, 14, 11, 1, -14 },
  { 546, 7, 14, 8, 1, -14 },
  { 559, 13, 14, 16, 1, -14 },
  { 582, 11, 14, 13, 1, -14 },
  { 602, 10, 15, 12, 1, -15 },
  { 621, 9, 14, 10, 1, -14 },
  { 637, 10, 18, 12, 1, -15 },
  { 660, 10, 14, 11, 1, -14 },
  { 678, 7, 14, 9, 1, -14 },
  { 691, 9, 14, 9, 0, -14 },
  { 707, 9, 14, 12, 1, -14 },
  { 723, 11, 14, 11, 0, -14 },
  { 743, 16, 14, 16, 0, -14 },
  { 771, 10, 14, 10, 0, -14 },
  { 789, 10, 14, 10, 0, -14 },
  { 807, 8, 14, 9, 0, -14 },
  { 821, 5, 17, 6, 1, -14 },
  { 832, 8, 14, 8, 0, -14 },
  { 846, 5, 17, 6, 0, -14 },
  { 857, 10, 9, 11, 0, -14 },
  { 869, 9, 1, 9, 0, 2 },
  { 871, 5, 3, 6, 1, -15 },
  { 873, 8, 11, 10, 1, -11 },
  { 884, 9, 15, 10, 1, -15 },
  { 901, 7, 11, 8, 1, -11 },
  { 911, 8, 15, 10, 1, -15 },
  { 926, 8, 11, 9, 1, -11 },
  { 937, 7, 15, 6, 0, -15 },
  { 951, 8, 16, 10, 1, -11 },
  { 967, 8, 15, 10, 1, -15 },
  { 982, 3, 15, 5, 1, -15 },
  { 988, 5, 20, 5, -1, -15 },
  { 1001, 9, 15, 10, 1, -15 },
  { 1018, 3, 15, 5, 1, -15 },
  { 1024, 13, 11, 15, 1, -11 },
  { 1042, 8, 11, 10, 1, -11 },
  { 1053, 8, 11, 10, 1, -11 },
  { 1064, 9, 16, 10, 1, -11 },
  { 1082, 8, 16, 10, 1, -11 },
  { 1098, 6, 11, 7, 1, -11 },
  { 1107, 6, 11, 8, 1, -11 },
  { 1116, 6, 13, 7, 0, -13 },
  { 1126, 8, 11, 10, 1, -11 },
  { 1137, 9, 11, 9, 0, -11 },
  { 1150, 14, 11, 14, 0, -11 },
  { 1170, 9, 11, 9, 0, -11 },
  { 1183, 9, 16, 9, 0, -11 },
  { 1201, 7, 11, 8, 0, -11 },
  { 1211, 7, 17, 7, 0, -14 },
  { 1226, 3, 20, 9, 3, -15 },
  { 1234, 6, 17, 7, 1, -14 },
  { 1247, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD20PT7B_H_
