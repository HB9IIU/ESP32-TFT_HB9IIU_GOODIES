#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x33,
  0xFF, 0xF7, 0x80, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xF7, 0x9E, 0xE3, 0xDC,
  0x7B, 0x8F, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x73,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE, 0x07, 0x78, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x8E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x1C,
  0xE0, 0x73, 0x80, 0x06, 0x00, 0x60, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0xFE,
  0xF6, 0x2F, 0x60, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7E,
  0x06, 0xF0, 0x6F, 0xC6, 0xFF, 0x7E, 0xFF, 0xEF, 0xFC, 0x1F, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x3C, 0x07, 0x03, 0xF0, 0x38, 0x3F, 0xC3, 0x81, 0xCE,
  0x1C, 0x0E, 0x71, 0xE0, 0x73, 0x8E, 0x03, 0x9C, 0x70, 0x1C, 0xE7, 0x00,
  0xE7, 0x38, 0xC7, 0x3B, 0xDF, 0xBF, 0xDC, 0xFE, 0xFC, 0xEF, 0x73, 0xCE,
  0x73, 0x80, 0x73, 0x9C, 0x07, 0x9C, 0xE0, 0x38, 0xE7, 0x01, 0xC7, 0x38,
  0x1C, 0x39, 0xC0, 0xE1, 0xFE, 0x07, 0x07, 0xE0, 0x70, 0x1E, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7D, 0xE0, 0x78, 0xE0, 0x79, 0xE0, 0x7D,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x1F, 0x7F, 0x9E, 0xFF,
  0xDE, 0xF3, 0xFE, 0xF1, 0xFC, 0xF1, 0xFC, 0xF0, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0x9F, 0xFF, 0xFF, 0xF7, 0xB9, 0xCE, 0x0F, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F,
  0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0xEE, 0x67, 0xFF, 0x3F, 0xFE,
  0xFF, 0x81, 0xF8, 0x1F, 0xC1, 0xEF, 0x9F, 0x38, 0x11, 0x80, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7B, 0xDE, 0xFF, 0x7B, 0xDC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x79, 0xEF,
  0x9E, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x9E, 0x79, 0xE7, 0xFE, 0x7F, 0xC3, 0xFC, 0x1F, 0x80,
  0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBD, 0xCF, 0x23, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x1F, 0x0F, 0xFB, 0xFF, 0x7F, 0xF6, 0x1E, 0x83, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x0F, 0xFC, 0xFF,
  0xE7, 0xFE, 0x41, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0xC3, 0xF8, 0x3F,
  0x83, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0x7E, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1D, 0xE0, 0xEF, 0x0E, 0x78, 0x73, 0xC7,
  0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7F, 0x87, 0xFC, 0x7F, 0xE2, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x81, 0xEF, 0x7E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x07,
  0xE1, 0xFE, 0x3F, 0xE3, 0xFE, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x18, 0xF7,
  0xCF, 0xFE, 0xFF, 0xEF, 0x9F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9,
  0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xF9, 0xEF, 0x1E,
  0xF9, 0xE7, 0xBE, 0x7F, 0xC3, 0xF8, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x9F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x1F,
  0x03, 0xF8, 0x7F, 0xCF, 0xFE, 0xF9, 0xEF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF1,
  0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x7E, 0xF3, 0xCF, 0x01, 0xE0, 0x1E, 0x03,
  0xE4, 0xFC, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x7B, 0xFE, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x67, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xBD, 0xEF, 0x7F, 0xBD, 0xE0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFF,
  0x3F, 0x8F, 0xE0, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x00,
  0xC0, 0x08, 0x00, 0x1F, 0x0F, 0xF3, 0xFF, 0x3F, 0xF4, 0x3E, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x0C, 0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0x01, 0xC3, 0xC0, 0x1C, 0x70, 0xE3, 0xDC, 0x7F,
  0x3B, 0x9F, 0xE7, 0xF3, 0x9C, 0xFC, 0xF3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E,
  0x7E, 0x71, 0xCF, 0xCE, 0x39, 0xF9, 0xEF, 0x3F, 0x1F, 0xFE, 0x73, 0xE7,
  0xCE, 0x18, 0x61, 0xE0, 0x00, 0x1E, 0x00, 0x81, 0xF1, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xEF, 0x1F, 0x78, 0x7B, 0xC3, 0xDE, 0x3E, 0xF3, 0xE7,
  0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xFE, 0x1E, 0xF1,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xC7,
  0xFC, 0x7F, 0xE7, 0xC1, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x13,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x3F, 0xF9,
  0xFF, 0xEF, 0x1F, 0x78, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF7, 0xFF,
  0xBF, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF,
  0xFE, 0x7E, 0x09, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE7, 0xFF,
  0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x7C, 0x3C,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C,
  0x7C, 0xF1, 0xE3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xF7, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xEF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3,
  0xC7, 0xCF, 0x0F, 0xBC, 0x3E, 0xF0, 0x7C, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1D, 0xFE, 0xE3, 0xBF, 0xDE, 0xF7,
  0xFB, 0xDC, 0xFF, 0x7B, 0x9F, 0xE7, 0xF3, 0xFC, 0xFE, 0x7F, 0x9F, 0x8F,
  0xF3, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF0, 0xFF, 0x1E, 0x1E,
  0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0x3F, 0xDE, 0x7F, 0x9E, 0xFF, 0x3D,
  0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7,
  0xC7, 0xCF, 0x87, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3C,
  0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xFC, 0xFF,
  0xEF, 0xFE, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0xFF,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7,
  0xC7, 0xCF, 0x87, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3E,
  0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF,
  0x1F, 0x78, 0xFB, 0xC7, 0xDE, 0x3E, 0xF1, 0xF7, 0x9F, 0x3F, 0xF9, 0xFF,
  0x8F, 0xF8, 0x7B, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F, 0xBC, 0x7D,
  0xE1, 0xFF, 0x0F, 0x80, 0x1F, 0x87, 0xFD, 0xFF, 0xFF, 0xEF, 0x8D, 0xE0,
  0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0,
  0xF8, 0x1F, 0xC3, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFC,
  0xFF, 0xC1, 0xFC, 0x00, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF7,
  0x83, 0xCF, 0x87, 0x8F, 0x0F, 0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x3F, 0xE0,
  0xF0, 0x7B, 0xE1, 0xE0, 0xF7, 0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x1F,
  0x8F, 0x9E, 0x3F, 0x1E, 0x3C, 0x7E, 0x3C, 0x7C, 0xFE, 0x78, 0x79, 0xDC,
  0xF0, 0xF7, 0xBB, 0xE1, 0xEF, 0x77, 0xC3, 0xDC, 0xEF, 0x07, 0xB9, 0xDE,
  0x07, 0x73, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7D, 0xE1,
  0xE7, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xBC, 0x3C, 0xF0, 0xF3, 0xE7, 0xC7, 0x9E, 0x1F, 0xF8, 0x7C, 0xF8, 0x3F,
  0xE1, 0xF7, 0x87, 0xDF, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xEF, 0x07, 0xBC,
  0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0x78, 0x1E, 0x78, 0x78, 0xF0, 0xF0, 0xF3, 0xC1, 0xEF, 0x81, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xF0, 0xF0, 0x3F, 0x8F, 0xF9, 0xFF,
  0x98, 0xF0, 0x1E, 0x03, 0xC7, 0xFB, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x3F, 0xFF, 0xFF, 0xBB, 0xE7, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF7, 0x8F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFB, 0xEF, 0xFE,
  0xEF, 0xCE, 0x78, 0x1F, 0xCF, 0xF7, 0xFD, 0xF7, 0xF8, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE1, 0x7C, 0xDF, 0xF3, 0xFC, 0x7E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x3E, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0x79, 0xF7, 0xFF, 0x7F, 0xF3, 0xE7, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0x9E, 0xF0, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x67, 0xFE, 0x3F, 0xE1, 0xFC, 0x0F, 0xC7, 0xF3, 0xF8,
  0xFA, 0x3C, 0x0F, 0x07, 0xFB, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x3E, 0x73, 0xFF, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7D, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF,
  0x00, 0xF0, 0x0F, 0x41, 0xF7, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xF7, 0xFE, 0xFF, 0xFF,
  0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x7F, 0xFE, 0xF0, 0x01, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x1E, 0x7C, 0xF8, 0xF0,
  0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xFF, 0xF7, 0xEF, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xDE, 0x3E, 0xF3,
  0xE7, 0x9E, 0x3D, 0xF1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF9, 0xE3, 0xCF, 0x1F, 0x78, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xCF, 0x9D,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0x3F, 0xE3, 0xC7, 0xFC,
  0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8,
  0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xE7,
  0xDD, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x1F, 0x81, 0xFE,
  0x1F, 0xF8, 0xFB, 0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0, 0xFF,
  0x87, 0xBC, 0x3D, 0xF1, 0xE7, 0x9F, 0x3F, 0xF0, 0xFF, 0x83, 0xF0, 0xE7,
  0x8E, 0xFC, 0xFF, 0xEF, 0xBE, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFB, 0xEF, 0xFE, 0xFF, 0xCF, 0x7C, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x73,
  0xFF, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x8F, 0x7D, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xE7, 0xEF, 0xEF,
  0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x3F, 0x3F, 0xFF, 0xFE, 0x2F, 0x07, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC1, 0xF0, 0xFE, 0xFF, 0xFF, 0xFD, 0xFC, 0x1C, 0x0E, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x7D, 0x3F, 0x8F, 0xC7, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBB, 0xE7, 0xF8, 0x7F, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x1E,
  0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xE0, 0xEF, 0x07, 0xF8, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0xF0, 0xF8, 0xFF, 0x8F, 0x8F, 0x79, 0xF8,
  0xF7, 0x9F, 0x8F, 0x79, 0xF9, 0xE7, 0x9D, 0xDE, 0x3D, 0xDD, 0xE3, 0xDD,
  0xDE, 0x3F, 0x9D, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xFC, 0x1F,
  0x8F, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0xF8, 0xFB, 0xC7,
  0x9F, 0x7C, 0x7B, 0xC3, 0xDE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80,
  0xFE, 0x07, 0xF0, 0x7B, 0xC3, 0xDE, 0x3E, 0xF9, 0xE3, 0xDF, 0x1F, 0xF8,
  0x7F, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0xBC,
  0x1D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3E,
  0x1E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x87, 0xC3, 0xE3, 0xF1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x9F, 0xCF, 0xC7, 0xE3, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7E, 0x1F, 0x0F, 0x80,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x7C, 0x3F, 0x1F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xF1, 0xF8, 0xFC, 0xFE, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE3, 0xF1, 0xF8, 0xF8, 0x60, 0x00, 0x38, 0x1F,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 21, 8, 1, -21 },
  { 15, 11, 8, 13, 1, -21 },
  { 26, 14, 21, 15, 1, -21 },
  { 63, 12, 24, 14, 1, -22 },
  { 99, 21, 21, 23, 1, -21 },
  { 155, 16, 21, 17, 1, -21 },
  { 197, 5, 8, 7, 1, -21 },
  { 202, 8, 26, 9, 1, -21 },
  { 228, 8, 26, 9, 0, -21 },
  { 254, 13, 12, 13, 0, -22 },
  { 274, 12, 14, 14, 1, -17 },
  { 295, 5, 8, 8, 1, -4 },
  { 300, 7, 4, 9, 1, -10 },
  { 304, 5, 5, 8, 1, -5 },
  { 308, 12, 21, 12, 0, -21 },
  { 340, 12, 21, 14, 1, -21 },
  { 372, 10, 21, 14, 1, -21 },
  { 399, 11, 21, 14, 1, -21 },
  { 428, 12, 21, 14, 1, -21 },
  { 460, 13, 21, 14, 0, -21 },
  { 495, 12, 21, 14, 1, -21 },
  { 527, 12, 21, 14, 1, -21 },
  { 559, 12, 21, 14, 1, -21 },
  { 591, 12, 21, 14, 1, -21 },
  { 623, 12, 21, 14, 1, -21 },
  { 655, 5, 16, 8, 1, -16 },
  { 665, 5, 20, 8, 1, -16 },
  { 678, 12, 14, 14, 1, -17 },
  { 699, 12, 10, 14, 1, -15 },
  { 714, 12, 14, 14, 1, -17 },
  { 735, 11, 21, 11, 0, -21 },
  { 764, 19, 23, 22, 1, -21 },
  { 819, 16, 21, 16, 0, -21 },
  { 861, 13, 21, 16, 2, -21 },
  { 896, 13, 21, 14, 1, -21 },
  { 931, 13, 21, 17, 2, -21 },
  { 966, 9, 21, 13, 2, -21 },
  { 990, 9, 21, 13, 2, -21 },
  { 1014, 14, 21, 17, 1, -21 },
  { 1051, 13, 21, 17, 2, -21 },
  { 1086, 8, 21, 10, 1, -21 },
  { 1107, 8, 27, 8, -2, -21 },
  { 1134, 14, 21, 15, 2, -21 },
  { 1171, 10, 21, 12, 2, -21 },
  { 1198, 19, 21, 23, 2, -21 },
  { 1248, 15, 21, 19, 2, -21 },
  { 1288, 15, 21, 18, 1, -21 },
  { 1328, 12, 21, 15, 2, -21 },
  { 1360, 15, 26, 18, 1, -21 },
  { 1409, 13, 21, 15, 2, -21 },
  { 1444, 11, 21, 13, 1, -21 },
  { 1473, 12, 21, 13, 0, -21 },
  { 1505, 13, 21, 17, 2, -21 },
  { 1540, 15, 21, 15, 0, -21 },
  { 1580, 23, 21, 22, 0, -21 },
  { 1641, 14, 21, 14, 0, -21 },
  { 1678, 14, 21, 14, 0, -21 },
  { 1715, 12, 21, 13, 0, -21 },
  { 1747, 7, 26, 9, 1, -21 },
  { 1770, 12, 21, 12, 0, -21 },
  { 1802, 6, 26, 9, 1, -21 },
  { 1822, 15, 13, 16, 0, -21 },
  { 1847, 13, 3, 13, 0, 2 },
  { 1852, 7, 4, 9, 1, -22 },
  { 1856, 11, 16, 14, 1, -16 },
  { 1878, 12, 22, 15, 2, -22 },
  { 1911, 10, 16, 12, 1, -16 },
  { 1931, 12, 22, 15, 1, -22 },
  { 1964, 12, 16, 14, 1, -16 },
  { 1988, 10, 22, 9, 0, -22 },
  { 2016, 12, 23, 15, 1, -16 },
  { 2051, 11, 22, 15, 2, -22 },
  { 2082, 5, 22, 7, 1, -22 },
  { 2096, 7, 29, 7, -1, -22 },
  { 2122, 13, 22, 15, 2, -22 },
  { 2158, 4, 22, 7, 2, -22 },
  { 2169, 19, 16, 22, 2, -16 },
  { 2207, 11, 16, 15, 2, -16 },
  { 2229, 13, 16, 15, 1, -16 },
  { 2255, 12, 23, 15, 2, -16 },
  { 2290, 12, 23, 15, 1, -16 },
  { 2325, 8, 16, 10, 2, -16 },
  { 2341, 9, 16, 11, 1, -16 },
  { 2359, 9, 19, 10, 0, -19 },
  { 2381, 11, 16, 15, 2, -16 },
  { 2403, 13, 16, 14, 0, -16 },
  { 2429, 20, 16, 20, 0, -16 },
  { 2469, 13, 16, 13, 0, -16 },
  { 2495, 13, 23, 14, 0, -16 },
  { 2533, 9, 16, 11, 1, -16 },
  { 2551, 9, 26, 10, 0, -21 },
  { 2581, 4, 29, 12, 4, -22 },
  { 2596, 9, 26, 10, 1, -21 },
  { 2626, 12, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD29PT7B_H_
