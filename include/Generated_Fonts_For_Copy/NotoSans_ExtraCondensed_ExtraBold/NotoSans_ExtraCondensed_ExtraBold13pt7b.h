#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xF9, 0x90, 0x3C, 0x59, 0xFB, 0xF2, 0x9F, 0x9A,
  0x3C, 0x58, 0x23, 0xFD, 0x4E, 0x38, 0xF7, 0xF1, 0x08, 0x73, 0x34, 0x8D,
  0x63, 0x56, 0x7F, 0xC2, 0xD0, 0xB4, 0x6F, 0x11, 0x80, 0x78, 0x6C, 0x68,
  0x39, 0x76, 0xDE, 0xCE, 0xFE, 0x7F, 0xE8, 0x7B, 0x69, 0x26, 0xD9, 0x80,
  0xC6, 0x62, 0x33, 0x32, 0x66, 0xC0, 0x32, 0xDF, 0xCC, 0x78, 0xC0, 0x30,
  0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x18, 0xC4, 0x62,
  0x31, 0x88, 0xC0, 0x79, 0xE4, 0xF3, 0xCF, 0x34, 0xDE, 0x38, 0x77, 0xFB,
  0x33, 0x33, 0x30, 0xF9, 0x60, 0x86, 0x18, 0xC6, 0x3F, 0xFC, 0xF9, 0x60,
  0x9E, 0x78, 0x70, 0xFE, 0xF8, 0x18, 0xE3, 0x9E, 0x5B, 0x6F, 0xC6, 0x18,
  0xF6, 0x31, 0xEF, 0x0C, 0x7E, 0xF0, 0x39, 0x84, 0x36, 0xFF, 0x34, 0xDF,
  0x38, 0xFC, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x60, 0x79, 0xB6, 0xDE, 0x79,
  0xBC, 0xFB, 0x78, 0x79, 0xEC, 0xF3, 0x7D, 0xB0, 0x9E, 0x70, 0xF0, 0x3C,
  0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x38, 0x38, 0x30, 0xFF, 0xF0, 0x3F,
  0xFC, 0x83, 0x83, 0x87, 0x73, 0x00, 0xF4, 0xC6, 0x66, 0x30, 0x0C, 0x60,
  0x3F, 0x30, 0x93, 0xAA, 0xD5, 0x6E, 0xB5, 0x7E, 0x92, 0x61, 0x0F, 0x00,
  0x38, 0x70, 0xB3, 0x66, 0xCF, 0x9F, 0xE3, 0xC6, 0xFB, 0x6D, 0xBE, 0xFB,
  0x6D, 0xFE, 0xF0, 0x7E, 0x71, 0x8C, 0x63, 0x1F, 0x78, 0xFB, 0x6C, 0xF3,
  0xCF, 0x3D, 0xFE, 0xF0, 0xFC, 0xCF, 0xFC, 0xCF, 0xF0, 0xFC, 0xCC, 0xFC,
  0xCC, 0xC0, 0x7F, 0xAC, 0x30, 0xDF, 0x3C, 0xFF, 0x7C, 0xCF, 0x3C, 0xFF,
  0xFF, 0x3C, 0xF3, 0xCC, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFE, 0xDF, 0x6F, 0xBC, 0xF3, 0xCD, 0xB6, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCF, 0xF0, 0xE3, 0xE7, 0xE7, 0xE5, 0xFD, 0xFD, 0xD9, 0xD9, 0xD9,
  0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCE, 0x7B, 0x3C, 0xF3, 0xCF,
  0x3C, 0xFF, 0x78, 0xF6, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x7B, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0x78, 0x60, 0xC0, 0xFB, 0x6D, 0xB6, 0xF3, 0xCD, 0xB6,
  0xDC, 0x7B, 0x70, 0xC3, 0x8C, 0x7F, 0xF0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x78, 0xC7, 0x89, 0xB3,
  0x66, 0xCD, 0x0A, 0x1C, 0x38, 0xCC, 0xF3, 0x3C, 0xCD, 0x7A, 0x7F, 0x9F,
  0xE7, 0x39, 0xCE, 0x33, 0x00, 0xCD, 0xE7, 0x8E, 0x30, 0xE7, 0x9B, 0xCC,
  0xCD, 0xB6, 0x9E, 0x38, 0xC3, 0x0C, 0x30, 0xF8, 0xC6, 0x63, 0x31, 0x9F,
  0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x18, 0x43, 0x18, 0x43, 0x18,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC,
  0xCC, 0x79, 0x60, 0xDF, 0xCF, 0x76, 0xC0, 0xC6, 0x31, 0xFD, 0xEF, 0x7B,
  0xDD, 0x80, 0x7B, 0x51, 0x8C, 0x35, 0xE0, 0x0C, 0x30, 0xDF, 0x6F, 0x3C,
  0xD3, 0x7D, 0xF0, 0x79, 0xBC, 0xFF, 0x41, 0xA7, 0x80, 0x37, 0x6F, 0x66,
  0x66, 0x66, 0x7D, 0xBC, 0xF3, 0xCD, 0xF7, 0xC3, 0x7D, 0xE0, 0xC6, 0x31,
  0x7D, 0xEF, 0x7B, 0xDE, 0xC0, 0xF3, 0xFF, 0xF0, 0x6C, 0x36, 0xDB, 0x6D,
  0xFC, 0xC3, 0x0C, 0x36, 0xF3, 0xCF, 0x3C, 0xDB, 0x70, 0xFF, 0xFF, 0xF0,
  0xBF, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xBE, 0xF7, 0xBD, 0xEF, 0x60,
  0x79, 0xBC, 0xF3, 0x4D, 0xB3, 0x80, 0xBE, 0xF7, 0xBD, 0xFF, 0xD8, 0xC6,
  0x00, 0x7D, 0xBC, 0xF3, 0xCD, 0xF7, 0xC3, 0x0C, 0x30, 0xBE, 0xCC, 0xCC,
  0xC0, 0x7E, 0xB8, 0xE1, 0xFF, 0xC0, 0x66, 0xF6, 0x66, 0x67, 0x70, 0xDE,
  0xF7, 0xBD, 0xFF, 0xE0, 0xCF, 0x37, 0x9E, 0x78, 0xC3, 0x00, 0xDD, 0xEE,
  0xD5, 0x6E, 0xA7, 0x73, 0xB9, 0xDC, 0xDD, 0xE7, 0x0C, 0x79, 0xEC, 0xC0,
  0xCD, 0x37, 0x9E, 0x78, 0xC3, 0x0C, 0x71, 0x80, 0xF9, 0x8C, 0xC6, 0x7F,
  0xE0, 0x36, 0x66, 0x6C, 0x66, 0x67, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xE6,
  0x66, 0x73, 0x66, 0x66, 0xE0, 0x67, 0xF8, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 11, 6, 1, -10 },
  { 21, 10, 9, 10, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 3, 11, 4, 1, -9 },
  { 48, 4, 11, 4, 0, -9 },
  { 54, 6, 6, 6, 0, -10 },
  { 59, 6, 7, 6, 0, -8 },
  { 65, 3, 4, 3, 0, -2 },
  { 67, 4, 1, 4, 0, -4 },
  { 68, 2, 2, 3, 1, -2 },
  { 69, 5, 9, 5, 0, -9 },
  { 75, 6, 9, 6, 0, -9 },
  { 82, 4, 9, 6, 1, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 1, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 6, 9, 6, 0, -9 },
  { 142, 2, 7, 4, 1, -7 },
  { 144, 3, 9, 4, 0, -7 },
  { 148, 6, 6, 6, 0, -8 },
  { 153, 6, 5, 6, 0, -7 },
  { 157, 6, 6, 6, 0, -8 },
  { 162, 5, 9, 5, 0, -9 },
  { 168, 9, 10, 10, 0, -9 },
  { 180, 7, 9, 7, 0, -9 },
  { 188, 6, 9, 7, 1, -9 },
  { 195, 5, 9, 6, 1, -9 },
  { 201, 6, 9, 7, 1, -9 },
  { 208, 4, 9, 6, 1, -9 },
  { 213, 4, 9, 6, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 4, 9, 4, 0, -9 },
  { 237, 4, 12, 4, -1, -9 },
  { 243, 6, 9, 7, 1, -9 },
  { 250, 4, 9, 5, 1, -9 },
  { 255, 8, 9, 10, 1, -9 },
  { 264, 7, 9, 8, 1, -9 },
  { 272, 6, 9, 8, 1, -9 },
  { 279, 5, 9, 7, 1, -9 },
  { 285, 6, 11, 8, 1, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 5, 9, 6, 0, -9 },
  { 307, 6, 9, 6, 0, -9 },
  { 314, 6, 9, 8, 1, -9 },
  { 321, 7, 9, 7, 0, -9 },
  { 329, 10, 9, 10, 0, -9 },
  { 341, 6, 9, 6, 0, -9 },
  { 348, 6, 9, 6, 0, -9 },
  { 355, 5, 9, 6, 0, -9 },
  { 361, 3, 11, 4, 1, -9 },
  { 366, 5, 9, 5, 0, -9 },
  { 372, 3, 11, 4, 0, -9 },
  { 377, 7, 6, 7, 0, -9 },
  { 383, 6, 1, 6, 0, 1 },
  { 384, 3, 2, 4, 1, -10 },
  { 385, 6, 7, 6, 0, -7 },
  { 391, 5, 10, 7, 1, -10 },
  { 398, 5, 7, 5, 0, -7 },
  { 403, 6, 10, 7, 0, -10 },
  { 411, 6, 7, 6, 0, -7 },
  { 417, 4, 10, 4, 0, -10 },
  { 422, 6, 10, 7, 0, -7 },
  { 430, 5, 10, 7, 1, -10 },
  { 437, 2, 10, 3, 1, -10 },
  { 440, 3, 13, 3, 0, -10 },
  { 445, 6, 10, 7, 1, -10 },
  { 453, 2, 10, 3, 1, -10 },
  { 456, 8, 7, 10, 1, -7 },
  { 463, 5, 7, 7, 1, -7 },
  { 468, 6, 7, 7, 0, -7 },
  { 474, 5, 10, 7, 1, -7 },
  { 481, 6, 10, 7, 0, -7 },
  { 489, 4, 7, 5, 1, -7 },
  { 493, 5, 7, 5, 0, -7 },
  { 498, 4, 9, 4, 0, -9 },
  { 503, 5, 7, 7, 1, -7 },
  { 508, 6, 7, 6, 0, -7 },
  { 514, 9, 7, 9, 0, -7 },
  { 522, 6, 7, 6, 0, -7 },
  { 528, 6, 10, 6, 0, -7 },
  { 536, 5, 7, 5, 0, -7 },
  { 541, 4, 11, 5, 0, -9 },
  { 547, 2, 13, 6, 2, -10 },
  { 551, 4, 11, 5, 0, -9 },
  { 557, 6, 3, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD13PT7B_H_
