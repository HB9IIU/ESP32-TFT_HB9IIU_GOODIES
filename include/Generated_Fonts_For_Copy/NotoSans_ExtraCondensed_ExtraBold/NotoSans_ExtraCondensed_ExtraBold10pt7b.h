#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x5C, 0xD5, 0x39, 0xBE, 0xAF, 0xA9, 0xC0, 0x27, 0xF6, 0x73,
  0xF6, 0x20, 0x64, 0xA8, 0xA8, 0x7F, 0x15, 0x15, 0x26, 0x71, 0x47, 0x1B,
  0xFB, 0x67, 0xC0, 0xD0, 0x69, 0x6C, 0x93, 0x20, 0xC9, 0xB6, 0xD2, 0x80,
  0x2B, 0xF7, 0x50, 0x22, 0xF2, 0x20, 0x70, 0xE0, 0x70, 0x12, 0x26, 0x44,
  0xC0, 0x75, 0xDD, 0xD5, 0x70, 0x37, 0xF3, 0x33, 0x30, 0x79, 0x13, 0x64,
  0xF0, 0xF9, 0x37, 0x19, 0xF0, 0x31, 0x9C, 0xEF, 0xFC, 0xC0, 0x74, 0x67,
  0x19, 0xF0, 0x74, 0xFF, 0xD5, 0x70, 0xF1, 0x33, 0x26, 0x60, 0x7D, 0x77,
  0xDD, 0x70, 0x7D, 0xDF, 0x53, 0x60, 0xCC, 0x50, 0x1C, 0x1B, 0xB0, 0x60,
  0x80, 0xF8, 0x3E, 0x83, 0x07, 0xC8, 0x00, 0xEB, 0x26, 0x44, 0x40, 0x3C,
  0x85, 0xED, 0x5A, 0xAA, 0x91, 0x1C, 0x33, 0x9C, 0xB7, 0xE7, 0x20, 0xFB,
  0xBE, 0xBB, 0xE0, 0x7A, 0x31, 0x8C, 0x35, 0xC0, 0xEB, 0x99, 0x9B, 0xE0,
  0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x7B, 0x11, 0xB4, 0xA5, 0xE0, 0x99,
  0x9F, 0x99, 0x90, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xE0, 0xBB, 0xEE,
  0xAB, 0x90, 0x92, 0x49, 0x38, 0xCF, 0x3D, 0xFD, 0xB6, 0xDB, 0x40, 0xDE,
  0xFF, 0x7B, 0xDE, 0x60, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x80, 0xEB, 0xBE,
  0xC8, 0x80, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x86, 0x0C, 0xEB, 0xBE, 0xAB,
  0xB0, 0x7D, 0xC7, 0x3B, 0xF0, 0xF6, 0x66, 0x66, 0x60, 0x99, 0x99, 0x9B,
  0xF0, 0xCE, 0xD6, 0xA5, 0x38, 0xC0, 0xDB, 0xDA, 0xDA, 0x5A, 0x7A, 0x6E,
  0x66, 0xDA, 0x9C, 0x47, 0x2B, 0x60, 0xDA, 0x94, 0xE2, 0x10, 0x80, 0xF3,
  0x26, 0x4C, 0xF0, 0xFB, 0x6D, 0xB6, 0xE0, 0xC4, 0x46, 0x22, 0x10, 0xED,
  0xB6, 0xDB, 0xE0, 0x21, 0x95, 0xB0, 0xF8, 0xCC, 0x27, 0x1F, 0xD7, 0x88,
  0xAF, 0xBB, 0xBE, 0x27, 0xCC, 0xD7, 0x18, 0xD6, 0xFD, 0xEF, 0x6F, 0x27,
  0xDF, 0xC7, 0x6D, 0x74, 0x92, 0x5B, 0xF7, 0xBD, 0xBC, 0x6E, 0x88, 0xAF,
  0xBB, 0xBB, 0x75, 0x55, 0x75, 0x55, 0x70, 0x88, 0x9A, 0xEE, 0xAB, 0xFF,
  0xAB, 0xFB, 0x6D, 0xB6, 0xD0, 0xAF, 0xBB, 0xBB, 0x23, 0xB7, 0xB5, 0x38,
  0xAE, 0xBB, 0xBE, 0x88, 0x5B, 0xF7, 0xBD, 0xBC, 0x63, 0xBA, 0x49, 0x00,
  0x7E, 0xC6, 0xBE, 0x4B, 0xA4, 0x98, 0xBB, 0xBB, 0xBF, 0xDE, 0x94, 0xE7,
  0x30, 0xDF, 0xDD, 0xB3, 0x66, 0xC0, 0xF6, 0x67, 0xD0, 0xDE, 0x94, 0xE7,
  0x11, 0x9C, 0xFF, 0x26, 0xCF, 0x6D, 0xAC, 0xDB, 0x20, 0xFF, 0xC0, 0xC9,
  0x36, 0x96, 0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 4, 2, 5, 0, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 0, -8 },
  { 14, 8, 7, 8, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 2, 2, 2, 0, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 4, 5, 5, 0, -8 },
  { 39, 4, 5, 5, 0, -6 },
  { 42, 2, 2, 3, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 2, 2, 3, 0, -2 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 5, 0, -7 },
  { 53, 4, 7, 5, 0, -7 },
  { 57, 4, 7, 5, 0, -7 },
  { 61, 4, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 4, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 0, -7 },
  { 78, 4, 7, 5, 0, -7 },
  { 82, 4, 7, 5, 0, -7 },
  { 86, 4, 7, 5, 0, -7 },
  { 90, 1, 6, 3, 1, -6 },
  { 91, 2, 7, 3, 0, -6 },
  { 93, 5, 5, 5, 0, -6 },
  { 97, 5, 3, 5, 0, -5 },
  { 99, 5, 5, 5, 0, -6 },
  { 103, 4, 7, 4, 0, -7 },
  { 107, 7, 8, 7, 0, -7 },
  { 114, 5, 7, 5, 0, -7 },
  { 119, 4, 7, 5, 1, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 3, 7, 4, 1, -7 },
  { 135, 3, 7, 4, 1, -7 },
  { 138, 5, 7, 6, 0, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 3, 7, 3, 0, -7 },
  { 150, 3, 9, 3, -1, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 3, 7, 4, 1, -7 },
  { 161, 6, 7, 8, 1, -7 },
  { 167, 5, 7, 6, 1, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 4, 7, 5, 1, -7 },
  { 182, 6, 9, 6, 0, -7 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 4, 7, 4, 0, -7 },
  { 201, 4, 7, 6, 1, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 8, 7, 8, 0, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 5, 7, 5, 0, -7 },
  { 227, 4, 7, 4, 0, -7 },
  { 231, 3, 9, 3, 0, -7 },
  { 235, 4, 7, 4, 0, -7 },
  { 239, 3, 9, 3, 0, -7 },
  { 243, 5, 4, 5, 0, -7 },
  { 246, 5, 1, 5, 0, 1 },
  { 247, 3, 2, 3, 0, -8 },
  { 248, 4, 6, 5, 0, -6 },
  { 251, 4, 8, 5, 1, -8 },
  { 255, 4, 6, 4, 0, -6 },
  { 258, 5, 8, 5, 0, -8 },
  { 263, 4, 6, 5, 0, -6 },
  { 266, 3, 8, 3, 0, -8 },
  { 269, 5, 8, 5, 0, -6 },
  { 274, 4, 8, 5, 1, -8 },
  { 278, 2, 8, 3, 0, -8 },
  { 280, 2, 10, 3, 0, -8 },
  { 283, 4, 8, 5, 1, -8 },
  { 287, 1, 8, 3, 1, -8 },
  { 288, 6, 6, 8, 1, -6 },
  { 293, 4, 6, 5, 1, -6 },
  { 296, 5, 6, 5, 0, -6 },
  { 300, 4, 8, 5, 1, -6 },
  { 304, 5, 8, 5, 0, -6 },
  { 309, 3, 6, 4, 1, -6 },
  { 312, 4, 6, 4, 0, -6 },
  { 315, 3, 7, 3, 0, -7 },
  { 318, 4, 6, 5, 1, -6 },
  { 321, 5, 6, 5, 0, -6 },
  { 325, 7, 5, 7, 0, -5 },
  { 330, 4, 5, 4, 0, -5 },
  { 333, 5, 8, 5, 0, -6 },
  { 338, 4, 6, 4, 0, -6 },
  { 341, 3, 9, 4, 0, -7 },
  { 345, 1, 10, 4, 2, -8 },
  { 347, 3, 9, 4, 0, -7 },
  { 351, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD10PT7B_H_
