#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x16, 0x36, 0x34, 0x7F, 0x7F,
  0x2C, 0xFE, 0xFE, 0x2C, 0x68, 0x68, 0x23, 0xEE, 0xB8, 0xE1, 0xC3, 0x8B,
  0xBB, 0xE2, 0x08, 0x71, 0x87, 0x90, 0xDB, 0x0D, 0xB0, 0xDA, 0x47, 0xEE,
  0x35, 0xB0, 0xDB, 0x0D, 0xB0, 0x9A, 0x18, 0xE0, 0x38, 0x3E, 0x1B, 0x0D,
  0x83, 0xC3, 0xDD, 0xFD, 0xDE, 0xE7, 0x3F, 0x9F, 0xE0, 0xFF, 0x36, 0xCC,
  0xCC, 0xCC, 0xCC, 0xC6, 0x70, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x76, 0xE0,
  0x30, 0xAB, 0xF9, 0xC6, 0xC5, 0x00, 0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06,
  0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x18, 0x61,
  0x8C, 0x00, 0x73, 0xED, 0xB6, 0xDF, 0x7D, 0xF7, 0xDB, 0xE7, 0x00, 0x19,
  0xDF, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x3B, 0xF4, 0xC3, 0x0C, 0x71, 0x8C,
  0x63, 0xFF, 0xC0, 0x79, 0xF9, 0x30, 0x61, 0xC7, 0x07, 0x07, 0x0F, 0xFB,
  0xE0, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x93, 0x7F, 0xFE, 0x18, 0x30, 0xFB,
  0xEC, 0x30, 0xF3, 0xE1, 0x87, 0x1B, 0xEF, 0x00, 0x1C, 0x79, 0x83, 0x07,
  0xDF, 0xBB, 0xB7, 0x6E, 0xF8, 0xF0, 0xFF, 0xFC, 0x30, 0x60, 0xC3, 0x06,
  0x0C, 0x30, 0x61, 0xC0, 0x38, 0xF9, 0xB3, 0x67, 0xC7, 0x1F, 0x37, 0xE6,
  0xF9, 0xF0, 0x38, 0xF9, 0xB7, 0x7E, 0xEF, 0xDD, 0x86, 0x0C, 0xF9, 0xE0,
  0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x02, 0x1C, 0xE7, 0x07, 0x83, 0xC1,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x73, 0xDE, 0x30,
  0x00, 0x73, 0xE9, 0xC6, 0x18, 0xC2, 0x00, 0x01, 0xC7, 0x00, 0x1E, 0x1D,
  0xC4, 0x1B, 0x7A, 0x96, 0xED, 0xBB, 0x6E, 0xDA, 0x9F, 0xB0, 0x06, 0x10,
  0xFC, 0x1C, 0x3C, 0x3C, 0x3C, 0x36, 0x76, 0x66, 0x7E, 0x7F, 0xE7, 0xE3,
  0xF9, 0xFB, 0x36, 0x6D, 0xDF, 0x33, 0x67, 0xCD, 0xFB, 0xE0, 0x39, 0xFE,
  0x70, 0xC3, 0x0C, 0x30, 0xE3, 0xF7, 0xC0, 0xF1, 0xFB, 0x36, 0x7C, 0x78,
  0xF1, 0xE7, 0xCD, 0xFB, 0xE0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC7, 0xFE,
  0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6, 0x30, 0x3C, 0xFF, 0x8E, 0x0C, 0x1B,
  0xF7, 0xE3, 0xE6, 0xFD, 0xF8, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xBE, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFE, 0xC7, 0x9B, 0x76, 0xCF, 0x9F, 0x3E, 0x6E,
  0xCD, 0x9B, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE1, 0xF8,
  0xFF, 0x3F, 0xCF, 0xF2, 0xF5, 0xBD, 0xEF, 0x7B, 0xDC, 0xF3, 0x3C, 0xCC,
  0xE3, 0xE3, 0xF3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xCF, 0xC7, 0x38,
  0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xFD, 0xF0, 0xF3, 0xFD, 0xF3,
  0xCF, 0xFF, 0xB0, 0xC3, 0x0C, 0x00, 0x38, 0xFB, 0xBE, 0x3C, 0x78, 0xF1,
  0xE3, 0xE7, 0xFD, 0xF0, 0x60, 0xE0, 0xC0, 0xF1, 0xFB, 0x36, 0x6C, 0xDF,
  0xBE, 0x6C, 0xDD, 0x9B, 0x38, 0x39, 0xF6, 0x58, 0x71, 0xE1, 0xC3, 0x8F,
  0xFF, 0x80, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xF9, 0xF0, 0xC3, 0xE7, 0x66,
  0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0xC6, 0x7C, 0x67, 0xEE,
  0x66, 0xE6, 0x6F, 0x66, 0xF6, 0x6B, 0xE6, 0xBC, 0x39, 0xC3, 0x9C, 0x39,
  0xC0, 0xE6, 0xDD, 0xB1, 0xE3, 0x87, 0x0E, 0x1E, 0x6C, 0xDF, 0x98, 0xC7,
  0xCD, 0xBB, 0x63, 0xC7, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xF0, 0xC6,
  0x18, 0xC3, 0x18, 0x63, 0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6E, 0xC1,
  0x86, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x30, 0xC0, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x3C, 0x66, 0x66, 0xC3, 0xFF, 0xFC,
  0xEC, 0x7D, 0xB0, 0xDF, 0x6F, 0xB7, 0xDD, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C,
  0xF3, 0xCF, 0xFF, 0x80, 0x7F, 0xB1, 0x8C, 0x63, 0xEF, 0x0C, 0x30, 0xFF,
  0xDF, 0x3C, 0xF3, 0xCF, 0xFE, 0xC0, 0xFB, 0x6C, 0xFF, 0xFF, 0x0F, 0x9E,
  0x7B, 0x59, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xFF, 0x7C, 0xF3, 0xCF, 0x3F,
  0xFB, 0x0E, 0x7F, 0x98, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xC0, 0xBC, 0xFF, 0xFF, 0x23, 0x30, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF4,
  0xC1, 0x83, 0x06, 0x6D, 0x9F, 0x3C, 0x7C, 0xD9, 0x9B, 0x38, 0xFF, 0xFF,
  0xFC, 0xFB, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xFB,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0x7B, 0x7C, 0xF3, 0xCF, 0x3F, 0x9E, 0xFB,
  0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0xC3, 0x0C, 0x30, 0xFF, 0x7C, 0xF3, 0xCF,
  0x3F, 0xFB, 0x0C, 0x30, 0xC3, 0xFF, 0xCC, 0xCC, 0xCC, 0x7F, 0x78, 0xE3,
  0x8F, 0xFF, 0x23, 0x3F, 0xF6, 0x31, 0x8C, 0x7B, 0xC0, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xFF, 0xC6, 0xD9, 0xB3, 0x66, 0xC5, 0x0E, 0x1C, 0xCE, 0xFD,
  0xD9, 0xBB, 0x3D, 0x67, 0xA8, 0xF7, 0x0E, 0xE1, 0x9C, 0xEE, 0xD9, 0xE1,
  0xC3, 0x8F, 0x1B, 0x77, 0xC6, 0xD9, 0xB3, 0x66, 0xC7, 0x0E, 0x1C, 0x38,
  0x61, 0xC2, 0x00, 0xFF, 0xCE, 0x67, 0x33, 0xFF, 0x19, 0xCC, 0x63, 0x1B,
  0x9C, 0x31, 0x8C, 0x63, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x0C, 0x63,
  0x18, 0xE7, 0x31, 0x8C, 0xEE, 0x00, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 12, 7, 1, -11 },
  { 27, 12, 11, 12, 0, -11 },
  { 44, 9, 11, 9, 0, -11 },
  { 57, 2, 4, 4, 1, -11 },
  { 58, 4, 13, 5, 1, -11 },
  { 65, 4, 13, 5, 0, -11 },
  { 72, 7, 6, 7, 0, -11 },
  { 78, 7, 7, 7, 0, -9 },
  { 85, 3, 4, 4, 0, -2 },
  { 87, 4, 2, 5, 0, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 6, 11, 7, 1, -11 },
  { 107, 5, 11, 7, 1, -11 },
  { 114, 6, 11, 7, 0, -11 },
  { 123, 7, 11, 7, 0, -11 },
  { 133, 7, 11, 7, 0, -11 },
  { 143, 6, 11, 7, 1, -11 },
  { 152, 7, 11, 7, 0, -11 },
  { 162, 7, 11, 7, 0, -11 },
  { 172, 7, 11, 7, 0, -11 },
  { 182, 7, 11, 7, 0, -11 },
  { 192, 2, 8, 4, 1, -8 },
  { 194, 3, 10, 4, 0, -8 },
  { 198, 7, 7, 7, 0, -9 },
  { 205, 7, 5, 7, 0, -8 },
  { 210, 7, 7, 7, 0, -9 },
  { 217, 6, 11, 6, 0, -11 },
  { 226, 10, 12, 11, 1, -11 },
  { 241, 8, 11, 8, 0, -11 },
  { 252, 7, 11, 8, 1, -11 },
  { 262, 6, 11, 7, 1, -11 },
  { 271, 7, 11, 9, 1, -11 },
  { 281, 5, 11, 7, 1, -11 },
  { 288, 5, 11, 7, 1, -11 },
  { 295, 7, 11, 9, 1, -11 },
  { 305, 7, 11, 9, 1, -11 },
  { 315, 5, 11, 5, 0, -11 },
  { 322, 4, 14, 4, -1, -11 },
  { 329, 7, 11, 8, 1, -11 },
  { 339, 5, 11, 6, 1, -11 },
  { 346, 10, 11, 12, 1, -11 },
  { 360, 8, 11, 10, 1, -11 },
  { 371, 7, 11, 9, 1, -11 },
  { 381, 6, 11, 8, 1, -11 },
  { 390, 7, 14, 9, 1, -11 },
  { 403, 7, 11, 8, 1, -11 },
  { 413, 6, 11, 7, 0, -11 },
  { 422, 6, 11, 7, 0, -11 },
  { 431, 7, 11, 9, 1, -11 },
  { 441, 8, 11, 8, 0, -11 },
  { 452, 12, 11, 12, 0, -11 },
  { 469, 7, 11, 7, 0, -11 },
  { 479, 7, 11, 7, 0, -11 },
  { 489, 6, 11, 7, 0, -11 },
  { 498, 3, 13, 5, 1, -11 },
  { 503, 6, 11, 6, 0, -11 },
  { 512, 4, 13, 5, 0, -11 },
  { 519, 8, 7, 8, 0, -11 },
  { 526, 7, 2, 7, 0, 1 },
  { 528, 3, 2, 5, 1, -11 },
  { 529, 6, 8, 7, 0, -8 },
  { 535, 6, 11, 8, 1, -11 },
  { 544, 5, 8, 6, 1, -8 },
  { 549, 6, 11, 8, 1, -11 },
  { 558, 6, 8, 7, 1, -8 },
  { 564, 5, 11, 5, 0, -11 },
  { 571, 6, 12, 8, 1, -8 },
  { 580, 6, 11, 8, 1, -11 },
  { 589, 2, 12, 4, 1, -12 },
  { 592, 4, 16, 4, -1, -12 },
  { 600, 7, 11, 8, 1, -11 },
  { 610, 2, 11, 4, 1, -11 },
  { 613, 10, 8, 12, 1, -8 },
  { 623, 6, 8, 8, 1, -8 },
  { 629, 6, 8, 8, 1, -8 },
  { 635, 6, 12, 8, 1, -8 },
  { 644, 6, 12, 8, 1, -8 },
  { 653, 4, 8, 5, 1, -8 },
  { 657, 5, 8, 6, 0, -8 },
  { 662, 5, 10, 5, 0, -10 },
  { 669, 6, 8, 8, 1, -8 },
  { 675, 7, 8, 7, 0, -8 },
  { 682, 11, 8, 11, 0, -8 },
  { 693, 7, 8, 7, 0, -8 },
  { 700, 7, 12, 7, 0, -8 },
  { 711, 5, 8, 6, 0, -8 },
  { 716, 5, 13, 5, 0, -11 },
  { 725, 2, 15, 6, 2, -12 },
  { 729, 5, 13, 5, 0, -11 },
  { 738, 7, 3, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD15PT7B_H_
