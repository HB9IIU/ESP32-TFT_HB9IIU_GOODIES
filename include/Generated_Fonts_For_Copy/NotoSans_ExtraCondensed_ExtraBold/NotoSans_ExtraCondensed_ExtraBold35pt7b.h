#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF8, 0x00, 0x1C, 0xFB, 0xEF, 0xFE, 0xF8, 0xFC, 0xFD, 0xF3, 0xF7,
  0xCF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0x78, 0x78,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01,
  0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0x87, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x38, 0xE0, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F,
  0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0x66, 0xF3, 0x07, 0x98, 0x3E, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0xDF, 0x06, 0xF8, 0x37, 0xF9, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x3F, 0x00, 0xF0, 0x1F, 0xE0, 0x78,
  0x07, 0xF8, 0x1E, 0x03, 0xEF, 0x07, 0x00, 0xF3, 0xC3, 0xC0, 0x3C, 0xF0,
  0xF0, 0x0F, 0x3C, 0x78, 0x03, 0xCF, 0x1E, 0x00, 0xF3, 0xC7, 0x80, 0x3C,
  0xF3, 0xC0, 0x0F, 0x3C, 0xF3, 0xF3, 0xEF, 0x79, 0xFE, 0x7F, 0x9E, 0x7F,
  0x9F, 0xE7, 0xBC, 0xF3, 0xF3, 0xCF, 0x3C, 0x00, 0xF3, 0xCF, 0x00, 0x38,
  0xF3, 0xC0, 0x1E, 0x3C, 0xF0, 0x07, 0x8F, 0x3C, 0x03, 0xC3, 0xCF, 0x00,
  0xF0, 0xF3, 0xC0, 0x38, 0x3C, 0xF0, 0x1E, 0x07, 0xF8, 0x07, 0x81, 0xFE,
  0x03, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x3E, 0x3F, 0xE3,
  0xE7, 0xFE, 0x7E, 0x7F, 0xF7, 0xCF, 0xDF, 0xFC, 0xF8, 0xFF, 0xCF, 0x8F,
  0xF8, 0xF8, 0x7F, 0x8F, 0x83, 0xF0, 0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDE, 0x78, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F,
  0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78,
  0x3E, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE7,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xFC, 0x7C, 0xF8, 0xE1, 0xC0, 0x84, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xEF, 0xBF, 0xFB, 0xE0, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFE, 0x7E, 0xF9, 0xF1, 0xF7, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7E, 0xF8, 0xFF, 0xE3, 0xFF, 0x87,
  0xFC, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xDF, 0x39, 0xF1, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE,
  0x79, 0xF8, 0xC3, 0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70, 0xFC, 0x83, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x3F,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x1E, 0xF8, 0x3D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3C,
  0x3E, 0x78, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0x31, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x03, 0xFE, 0x3F, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF,
  0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF7, 0xE3, 0xEF, 0xE7, 0xFF, 0xEF,
  0xFF, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1,
  0xF3, 0xE3, 0xE7, 0xEF, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3E, 0x3E, 0x7C, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xFE, 0x1F, 0xFE, 0x3E, 0x7E, 0xF8, 0x7D, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC7, 0xDF, 0xFF, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xCF, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C,
  0x3E, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xFF, 0xE7, 0xF7, 0xFF, 0xCF, 0xFF,
  0x8F, 0xEF, 0x1F, 0x9E, 0x04, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x23, 0xEF, 0xFF,
  0xFF, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xFF, 0xBE,
  0x10, 0xF9, 0xFB, 0xF7, 0xEF, 0x86, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0x00, 0x02,
  0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F,
  0x80, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x3F,
  0xC3, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0x1F, 0xA0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x1F,
  0x1E, 0x38, 0x7F, 0x9E, 0x78, 0xFF, 0x8E, 0x79, 0xF3, 0x8F, 0x71, 0xE3,
  0x8F, 0xF1, 0xC3, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7,
  0x8F, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xF1, 0xE7, 0x9E, 0x71, 0xFF,
  0xFC, 0x78, 0xFD, 0xFC, 0x78, 0x78, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x20, 0x0F, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF3, 0xF9, 0xC7, 0xE0, 0x9F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x13, 0xF9, 0xE7, 0xFF, 0xC7,
  0xFF, 0x87, 0xFF, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xC3, 0xF3, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x0F, 0xCF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3,
  0xFC, 0x71, 0xF8, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x8F, 0xFF, 0xC7, 0xFB, 0xE3, 0xFD, 0xF1, 0xFE, 0xF8,
  0x1F, 0x7C, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xE7, 0xC1, 0xF3, 0xF8, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0xFF, 0xBF,
  0xEF, 0xF3, 0xF8, 0x70, 0x00, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF,
  0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xFB, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFC, 0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0x8F,
  0xC7, 0xE7, 0xE1, 0xF3, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF7, 0x87, 0xFF, 0xEF, 0x1E, 0xFF, 0xDE, 0x3D, 0xFF,
  0xBE, 0x7B, 0xFF, 0x3D, 0xF7, 0xFE, 0x7B, 0xCF, 0xFC, 0xF7, 0x9F, 0xF9,
  0xFF, 0x3F, 0xF1, 0xFE, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x8F,
  0xE3, 0xFF, 0x0F, 0xC7, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C,
  0x3E, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFE, 0xF1, 0xFF,
  0xBE, 0x7F, 0xEF, 0x9F, 0xF9, 0xF7, 0xFE, 0x7D, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF9, 0xF8, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3F,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xFB, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC7, 0xEF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xFC, 0x7F, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF9, 0xF8, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xFB, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xBF, 0xC7, 0xC3, 0xF3,
  0xE1, 0xF9, 0xF0, 0xFC, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7E, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7E, 0x0B, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7E, 0x7F,
  0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xFF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x80, 0x7D, 0xF0, 0x0F, 0xBC,
  0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xFF,
  0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFE, 0x0F, 0x83, 0xF7, 0xC3, 0xF8,
  0x7E, 0xF8, 0x7F, 0x0F, 0x9F, 0x0F, 0xE1, 0xF3, 0xE1, 0xFC, 0x3E, 0x7C,
  0x3F, 0x87, 0xC7, 0xCF, 0x79, 0xF8, 0xF9, 0xEF, 0x3E, 0x1F, 0x3D, 0xE7,
  0xC3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9F, 0x07, 0xBE, 0xF3, 0xE0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xBE,
  0x0F, 0x9F, 0x8F, 0xC7, 0xC7, 0xC3, 0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07,
  0xDF, 0x07, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF9, 0xF8, 0x7C, 0xF8, 0x3F,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0xC3, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x03, 0x00, 0x7F, 0xC7, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0x41,
  0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xF7, 0xFB, 0xCF,
  0x8F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x20, 0xFB, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF,
  0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x0F, 0xBF, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF3, 0xCF, 0xC0, 0x03, 0x00, 0x7F, 0x87, 0xFE, 0x7F, 0xE7, 0xFF,
  0x3F, 0x09, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x2F, 0xC2, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x82, 0x1F, 0x1F, 0xBE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xEF, 0x8F, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFC, 0x7E, 0x78, 0x03, 0x00, 0x3F, 0x83, 0xFF, 0x0F, 0xFE, 0x7E,
  0xFD, 0xF1, 0xF7, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x02, 0x7F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x83, 0xFC, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xF0,
  0x3E, 0x03, 0xE0, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x06, 0x00, 0x3F, 0x3C,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xDF, 0x1F,
  0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFE, 0xF8, 0xF9, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xB0, 0x3E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x30, 0xFB, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xC0, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x04,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x41, 0xE7, 0xE3, 0xF3, 0xDF, 0xEF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xCF, 0xFE, 0x1F, 0x0F,
  0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF,
  0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3,
  0xE1, 0xF0, 0x00, 0x83, 0xCF, 0xCF, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0x03, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F,
  0xDF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x87, 0xDF, 0x0F, 0xBE, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x00, 0x00, 0xC1, 0xE7, 0xE3, 0xDF, 0xE7, 0xFF, 0xCF, 0xFF,
  0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xBE, 0x1F, 0x7E, 0x7E, 0xFF, 0xFD, 0xFF,
  0xF3, 0xEF, 0xE7, 0xCF, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0x3C,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xDF, 0x1F,
  0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFE, 0xF8, 0xF9, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xFC, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0x06, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xCF, 0x84, 0xF8,
  0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x83,
  0xFC, 0x3E, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x9F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xF8, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFE, 0xF3,
  0xF3, 0xC0, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x1F, 0xBE, 0x3F, 0x8F, 0x9F, 0x1F,
  0xC7, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xE3, 0xE7, 0xB9, 0xF0, 0xFB,
  0xDC, 0xF8, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F, 0x73, 0xDE, 0x0F,
  0xB9, 0xEF, 0x03, 0xDC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF9, 0xFE,
  0x3F, 0x87, 0xE0, 0xFF, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F,
  0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x81, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xF8, 0x7F,
  0x0F, 0xE1, 0xF8, 0x38, 0x00, 0x7F, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xD0, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 25, 9, 2, -25 },
  { 20, 14, 9, 16, 1, -25 },
  { 36, 17, 25, 18, 1, -25 },
  { 90, 13, 29, 17, 2, -27 },
  { 138, 26, 25, 28, 1, -25 },
  { 220, 20, 25, 21, 1, -25 },
  { 283, 6, 9, 9, 1, -25 },
  { 290, 9, 31, 11, 2, -25 },
  { 325, 10, 31, 11, 0, -25 },
  { 364, 14, 15, 16, 1, -27 },
  { 391, 15, 17, 17, 1, -21 },
  { 423, 7, 10, 9, 1, -5 },
  { 432, 9, 5, 11, 1, -12 },
  { 438, 6, 6, 9, 2, -6 },
  { 443, 14, 25, 14, 0, -25 },
  { 487, 14, 25, 17, 1, -25 },
  { 531, 12, 25, 17, 1, -25 },
  { 569, 14, 25, 17, 1, -25 },
  { 613, 14, 25, 17, 1, -25 },
  { 657, 15, 25, 17, 1, -25 },
  { 704, 13, 25, 17, 2, -25 },
  { 745, 15, 25, 17, 1, -25 },
  { 792, 15, 25, 17, 1, -25 },
  { 839, 15, 25, 17, 1, -25 },
  { 886, 15, 25, 17, 1, -25 },
  { 933, 6, 20, 9, 2, -20 },
  { 948, 7, 25, 9, 1, -20 },
  { 970, 15, 17, 17, 1, -21 },
  { 1002, 15, 11, 17, 1, -18 },
  { 1023, 15, 17, 17, 1, -21 },
  { 1055, 13, 25, 13, 0, -25 },
  { 1096, 24, 28, 26, 1, -25 },
  { 1180, 19, 25, 19, 0, -25 },
  { 1240, 16, 25, 19, 2, -25 },
  { 1290, 15, 25, 17, 1, -25 },
  { 1337, 17, 25, 20, 2, -25 },
  { 1391, 12, 25, 15, 2, -25 },
  { 1429, 12, 25, 15, 2, -25 },
  { 1467, 17, 25, 20, 1, -25 },
  { 1521, 17, 25, 21, 2, -25 },
  { 1575, 10, 25, 12, 1, -25 },
  { 1607, 10, 33, 10, -2, -25 },
  { 1649, 17, 25, 19, 2, -25 },
  { 1703, 12, 25, 15, 2, -25 },
  { 1741, 23, 25, 28, 2, -25 },
  { 1813, 18, 25, 22, 2, -25 },
  { 1870, 19, 25, 21, 1, -25 },
  { 1930, 15, 25, 18, 2, -25 },
  { 1977, 19, 31, 21, 1, -25 },
  { 2051, 17, 25, 18, 2, -25 },
  { 2105, 13, 25, 15, 1, -25 },
  { 2146, 14, 25, 16, 1, -25 },
  { 2190, 16, 25, 20, 2, -25 },
  { 2240, 19, 25, 19, 0, -25 },
  { 2300, 27, 25, 27, 0, -25 },
  { 2385, 17, 25, 17, 0, -25 },
  { 2439, 17, 25, 17, 0, -25 },
  { 2493, 14, 25, 15, 1, -25 },
  { 2537, 8, 31, 11, 2, -25 },
  { 2568, 14, 25, 14, 0, -25 },
  { 2612, 8, 31, 11, 1, -25 },
  { 2643, 17, 16, 19, 1, -25 },
  { 2677, 16, 3, 16, 0, 3 },
  { 2683, 9, 6, 11, 1, -27 },
  { 2690, 14, 20, 17, 1, -20 },
  { 2725, 15, 27, 18, 2, -27 },
  { 2776, 13, 20, 15, 1, -20 },
  { 2809, 15, 27, 18, 1, -27 },
  { 2860, 14, 20, 16, 1, -20 },
  { 2895, 12, 27, 11, 0, -27 },
  { 2936, 15, 28, 18, 1, -20 },
  { 2989, 14, 27, 18, 2, -27 },
  { 3037, 5, 27, 9, 2, -27 },
  { 3054, 8, 35, 9, -1, -27 },
  { 3089, 16, 27, 18, 2, -27 },
  { 3143, 5, 27, 9, 2, -27 },
  { 3160, 23, 20, 27, 2, -20 },
  { 3218, 14, 20, 18, 2, -20 },
  { 3253, 15, 20, 18, 1, -20 },
  { 3291, 15, 28, 18, 2, -20 },
  { 3344, 15, 28, 18, 1, -20 },
  { 3397, 10, 20, 13, 2, -20 },
  { 3422, 12, 20, 13, 1, -20 },
  { 3452, 11, 23, 12, 0, -23 },
  { 3484, 14, 19, 18, 2, -19 },
  { 3518, 16, 19, 16, 0, -19 },
  { 3556, 25, 19, 25, 0, -19 },
  { 3616, 16, 19, 16, 0, -19 },
  { 3654, 16, 27, 16, 0, -19 },
  { 3708, 12, 19, 13, 1, -19 },
  { 3737, 11, 31, 12, 0, -25 },
  { 3780, 5, 35, 15, 5, -27 },
  { 3802, 11, 31, 12, 1, -25 },
  { 3845, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD35PT7B_H_
