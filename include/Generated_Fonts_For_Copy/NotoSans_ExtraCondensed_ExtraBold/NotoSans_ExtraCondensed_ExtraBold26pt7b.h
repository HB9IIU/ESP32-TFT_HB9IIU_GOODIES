#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0x38, 0x0C, 0xE1,
  0xCE, 0x1C, 0xC1, 0xCC, 0x1D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xC3,
  0x98, 0x39, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0x87, 0x38, 0x73, 0x87,
  0x30, 0x77, 0x00, 0x04, 0x01, 0x01, 0xF1, 0xFF, 0x7F, 0xFD, 0x2E, 0x43,
  0xD0, 0x7C, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xC1, 0x78, 0x5F, 0x17, 0xFF,
  0xFF, 0xE3, 0xE0, 0x10, 0x04, 0x01, 0x00, 0x38, 0x0E, 0x0F, 0x83, 0x83,
  0xF8, 0x70, 0x77, 0x1C, 0x0E, 0xE3, 0x81, 0xCE, 0x60, 0x39, 0x9C, 0x07,
  0x73, 0x80, 0xEE, 0xE7, 0xDF, 0xDD, 0xF9, 0xF3, 0xBB, 0x9C, 0xE6, 0x70,
  0x1D, 0xCE, 0x07, 0x39, 0xC0, 0xE7, 0x38, 0x1C, 0x67, 0x07, 0x0E, 0xE0,
  0xE1, 0xF8, 0x38, 0x1E, 0x00, 0x0E, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xDE,
  0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x79,
  0xFC, 0xF7, 0xBF, 0xCF, 0x7F, 0x9C, 0x7F, 0x3C, 0x7C, 0x78, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0x70, 0x0E, 0x38, 0xF1,
  0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70,
  0xF1, 0xE1, 0xC3, 0xC3, 0x87, 0x80, 0xF0, 0xE0, 0xE1, 0xC3, 0xC3, 0x87,
  0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3,
  0x8F, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x18, 0x3B, 0x77, 0xFF, 0xFF, 0xC3,
  0xC0, 0xFC, 0x3F, 0xCF, 0x3C, 0x66, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x7B, 0xBD, 0xEF, 0x70, 0xFF, 0xFF, 0xFF, 0x77, 0xFE, 0xE0, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x00, 0x1E, 0x0F, 0xC7, 0xF9, 0xFF, 0xF3, 0xFC, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0x3D, 0xEF, 0x7F, 0x8F, 0xE1,
  0xF0, 0x07, 0x87, 0xC7, 0xE7, 0xF3, 0xFF, 0xFD, 0xDE, 0x4F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1E,
  0x1F, 0xCF, 0xFB, 0xFF, 0x43, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x3F, 0xEF, 0xF9, 0xFF, 0x43, 0xC0, 0xF0, 0x3C, 0x1E, 0x3F, 0x0F, 0xC3,
  0xF8, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x1F, 0xFF, 0xFF, 0xEF, 0xF0, 0x01,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1D, 0xC1, 0xFC, 0x3B,
  0xC3, 0xBC, 0x73, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x70, 0x1C, 0x07,
  0x01, 0xFC, 0x7F, 0xBF, 0xF6, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0x1F,
  0xFF, 0xFF, 0xE7, 0xF0, 0x07, 0xC3, 0xF8, 0xFF, 0x3F, 0x67, 0x81, 0xE0,
  0x3C, 0x07, 0xFC, 0xEF, 0xDF, 0xFB, 0xCF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC,
  0x77, 0xDE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0xF1, 0xFF, 0x7D, 0xEF, 0x3D, 0xE7, 0x9C, 0xF3, 0xFC, 0x3F, 0x87, 0xE1,
  0xFE, 0x7F, 0xEF, 0x3D, 0xC3, 0xF8, 0x7F, 0x8E, 0xFF, 0xCF, 0xF8, 0xFC,
  0x00, 0x1E, 0x07, 0xE1, 0xFE, 0x7F, 0xEF, 0x3D, 0xE7, 0xBC, 0x77, 0x8F,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3E, 0xE1, 0x9C, 0x07, 0x80, 0xF0, 0x3C, 0x7F,
  0x8F, 0xE1, 0xF0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF,
  0xB8, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x7B, 0xDE, 0xE0,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9, 0xFC, 0x3C, 0x07, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xF8, 0x7F, 0x3F, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1E,
  0x1F, 0xCF, 0xF9, 0xFE, 0x43, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x01, 0xC0, 0x01,
  0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE3, 0x80, 0x73, 0x8F, 0x9D,
  0x8F, 0xEF, 0xCF, 0x77, 0xE7, 0x39, 0xF3, 0x1C, 0xFB, 0x8E, 0x7D, 0xC6,
  0x3E, 0x67, 0x3F, 0x3B, 0xDF, 0x9F, 0x7C, 0xC7, 0x9C, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x87, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xEE, 0x07, 0x38, 0x1C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x1C, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9E, 0x1E,
  0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xC0, 0xF8, 0x1F, 0xF3, 0xFF, 0x7F, 0xEF,
  0x3F, 0xE3, 0xFC, 0x77, 0x9E, 0xFF, 0x9F, 0xF3, 0xFF, 0x79, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x9F, 0xFF, 0xDF, 0xFB, 0xFC, 0x00, 0x07, 0x83, 0xFC,
  0xFF, 0xBF, 0xF7, 0x82, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE3, 0x3F, 0xE7, 0xFC, 0x3F, 0x00,
  0xFC, 0x0F, 0xF8, 0xFF, 0xCF, 0xFC, 0xF3, 0xEF, 0x1E, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0xFC,
  0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x03, 0xC0, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF3, 0xFF, 0x9F, 0xFC,
  0xFF, 0xE7, 0xFF, 0x07, 0xFC, 0x3D, 0xE1, 0xEF, 0x8F, 0x3F, 0xF9, 0xFF,
  0xC3, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFB, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xFD, 0xFF, 0xF8,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xDF, 0xBF, 0x7C, 0xE0, 0xF0, 0xFF,
  0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x7C, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFF, 0xDC, 0x7F, 0xEE, 0x77, 0xF7, 0x3B, 0xFB, 0xDD, 0xFC, 0xFE, 0xFE,
  0x7E, 0x7F, 0x3F, 0x3F, 0x9F, 0x9F, 0xC7, 0xCF, 0xE3, 0xC7, 0xF1, 0xE3,
  0xF8, 0xF1, 0xE0, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF9, 0xFD, 0xCF, 0xEF, 0x7F, 0x7B, 0xF9, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3E, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78, 0x7B, 0xE1, 0xEF, 0x07, 0xBC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7B, 0xE1, 0xE7, 0x87,
  0x9F, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xF8, 0x3F, 0xCF, 0xFB,
  0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFC, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9F, 0x3E,
  0x3F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0xC0, 0xFC, 0x0F, 0xF8, 0xFF, 0xCF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF7, 0xCF, 0xF8, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x78, 0xF7, 0xCF,
  0x3C, 0xF3, 0xEF, 0x1E, 0xF1, 0xF0, 0x1E, 0x1F, 0xF7, 0xFB, 0xFE, 0xF0,
  0xBC, 0x0F, 0x03, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x3F, 0xBE, 0xFF, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xFF, 0xE7, 0xFC,
  0x3F, 0x80, 0xF0, 0x3F, 0xC0, 0xF7, 0x07, 0x9E, 0x1E, 0x78, 0x79, 0xE1,
  0xE3, 0x87, 0x0E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xCE, 0x07, 0x78, 0x1D,
  0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x70, 0xF0,
  0xF7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE3, 0x9F,
  0x9E, 0x3B, 0xDD, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F,
  0x9F, 0xC1, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF0, 0xF3, 0xC7, 0x9E, 0x78, 0x73, 0xC3, 0xDE, 0x1F, 0xE0, 0x7F, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x1E, 0xE0, 0xF7,
  0x87, 0xBC, 0x78, 0xF3, 0xC7, 0xBC, 0x3E, 0xF0, 0x7F, 0x87, 0xDE, 0x3C,
  0xF1, 0xE3, 0x8E, 0x1E, 0xF0, 0xF7, 0x83, 0xB8, 0x1F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xC0, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0x38, 0x3C, 0xF0,
  0xE1, 0xC7, 0x87, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE3, 0xC7, 0x04,
  0x1F, 0xE7, 0xF9, 0xFF, 0x43, 0xC0, 0xF3, 0xFD, 0xFF, 0xFF, 0xFC, 0xFE,
  0x3F, 0xCF, 0xFF, 0xFF, 0x77, 0x9C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE2, 0x3D, 0xF7, 0xFE, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0x7B, 0xC0, 0x06, 0x1F,
  0xDF, 0xEF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x17,
  0xFB, 0xFC, 0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x23, 0xCF,
  0x7B, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF3, 0xEF, 0xFD, 0xFF, 0x9E, 0x70, 0x04, 0x0F, 0xC7, 0xF9, 0xEF,
  0xF1, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC1, 0x7F, 0xDF,
  0xF3, 0xF8, 0x0F, 0x0F, 0xCF, 0xC7, 0xA3, 0xC1, 0xE1, 0xFD, 0xFE, 0xFF,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x80, 0x10, 0x07, 0xDD, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0x0F, 0x01,
  0xE8, 0x79, 0xFF, 0x3F, 0xC7, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE6, 0x3D, 0xF7, 0xFE, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x7F, 0xF7,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF3, 0xC7, 0x00,
  0x03, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFB, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x04, 0x3D, 0xF7,
  0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF9, 0xE7, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0x03, 0x1E, 0xFB, 0xFF, 0x7F, 0xFF,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x78, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0xFC, 0x7F, 0x87, 0xC0,
  0x03, 0x1E, 0xFB, 0xFF, 0x7F, 0xFF, 0x9F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0xFF, 0xFF, 0xBD, 0xE7, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x18, 0x07, 0xDD, 0xFF, 0xBF, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xF7, 0xFE, 0xFF,
  0xCF, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE7,
  0xFF, 0xFF, 0xFD, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x18, 0x7F, 0xFF, 0xFF, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F,
  0x8F, 0xFF, 0xFF, 0xFE, 0x18, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF,
  0xBF, 0xF7, 0xEE, 0x79, 0xC0, 0xF0, 0xF7, 0x0F, 0x78, 0xE7, 0x9E, 0x79,
  0xE3, 0x9C, 0x39, 0xC3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xF0, 0xF1, 0xE3, 0xDC, 0x7C, 0xF7, 0x1F, 0x3D, 0xEF, 0xCE, 0x7B,
  0xF3, 0x9E, 0xED, 0xE3, 0xBB, 0x78, 0xEC, 0xFE, 0x3B, 0x3F, 0x0E, 0xCF,
  0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x1E, 0x07, 0xC7, 0x80, 0xF9, 0xE7,
  0x9E, 0x7B, 0xC3, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x83,
  0xF8, 0x3B, 0xC7, 0xBC, 0x79, 0xEF, 0x1F, 0xF0, 0xF7, 0x0F, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x9C, 0x3D, 0xC3, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0x7C, 0x07,
  0x80, 0x7F, 0xBF, 0xDF, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0x87, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0E, 0x3F, 0x1F, 0x0F, 0xC1, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF8, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xF8, 0xF8, 0x78, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x3C, 0x3F, 0x1F, 0x1F, 0x3E, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xF8, 0xF8, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 12, 1, -19 },
  { 22, 12, 19, 14, 1, -19 },
  { 51, 10, 22, 12, 1, -20 },
  { 79, 19, 19, 21, 1, -19 },
  { 125, 15, 19, 16, 1, -19 },
  { 161, 4, 7, 6, 1, -19 },
  { 165, 7, 23, 8, 1, -19 },
  { 186, 7, 23, 8, 0, -19 },
  { 207, 11, 11, 12, 0, -20 },
  { 223, 11, 12, 13, 1, -15 },
  { 240, 5, 6, 7, 1, -3 },
  { 244, 6, 4, 8, 1, -9 },
  { 247, 5, 4, 7, 1, -4 },
  { 250, 11, 19, 11, 0, -19 },
  { 277, 10, 19, 12, 1, -19 },
  { 301, 9, 19, 12, 1, -19 },
  { 323, 10, 19, 12, 1, -19 },
  { 347, 10, 19, 12, 1, -19 },
  { 371, 12, 19, 12, 0, -19 },
  { 400, 10, 19, 12, 1, -19 },
  { 424, 11, 19, 12, 1, -19 },
  { 451, 11, 19, 12, 1, -19 },
  { 478, 11, 19, 12, 1, -19 },
  { 505, 11, 19, 12, 1, -19 },
  { 532, 5, 14, 7, 1, -14 },
  { 541, 5, 17, 7, 1, -14 },
  { 552, 11, 13, 13, 1, -16 },
  { 570, 11, 8, 13, 1, -13 },
  { 581, 11, 13, 13, 1, -16 },
  { 599, 10, 19, 10, 0, -19 },
  { 623, 17, 21, 19, 1, -19 },
  { 668, 14, 19, 14, 0, -19 },
  { 702, 11, 19, 14, 2, -19 },
  { 729, 11, 19, 13, 1, -19 },
  { 756, 12, 19, 15, 2, -19 },
  { 785, 8, 19, 11, 2, -19 },
  { 804, 8, 19, 11, 2, -19 },
  { 823, 13, 19, 15, 1, -19 },
  { 854, 12, 19, 16, 2, -19 },
  { 883, 7, 19, 9, 1, -19 },
  { 900, 7, 25, 7, -1, -19 },
  { 922, 12, 19, 14, 2, -19 },
  { 951, 8, 19, 11, 2, -19 },
  { 970, 17, 19, 20, 2, -19 },
  { 1011, 13, 19, 17, 2, -19 },
  { 1042, 14, 19, 16, 1, -19 },
  { 1076, 10, 19, 13, 2, -19 },
  { 1100, 14, 23, 16, 1, -19 },
  { 1141, 12, 19, 14, 2, -19 },
  { 1170, 10, 19, 11, 1, -19 },
  { 1194, 11, 19, 12, 0, -19 },
  { 1221, 12, 19, 15, 2, -19 },
  { 1250, 14, 19, 14, 0, -19 },
  { 1284, 20, 19, 20, 0, -19 },
  { 1332, 13, 19, 13, 0, -19 },
  { 1363, 13, 19, 13, 0, -19 },
  { 1394, 11, 19, 11, 0, -19 },
  { 1421, 6, 23, 8, 1, -19 },
  { 1439, 11, 19, 11, 0, -19 },
  { 1466, 6, 23, 8, 1, -19 },
  { 1484, 14, 12, 14, 0, -19 },
  { 1505, 12, 2, 12, 0, 2 },
  { 1508, 6, 4, 8, 1, -20 },
  { 1511, 10, 15, 12, 1, -15 },
  { 1530, 11, 20, 13, 1, -20 },
  { 1558, 9, 15, 11, 1, -15 },
  { 1575, 11, 20, 13, 1, -20 },
  { 1603, 10, 15, 12, 1, -15 },
  { 1622, 9, 20, 8, 0, -20 },
  { 1645, 11, 21, 13, 1, -15 },
  { 1674, 11, 20, 13, 1, -20 },
  { 1702, 4, 20, 7, 1, -20 },
  { 1712, 6, 26, 7, -1, -20 },
  { 1732, 12, 20, 13, 1, -20 },
  { 1762, 4, 20, 7, 1, -20 },
  { 1772, 18, 15, 20, 1, -15 },
  { 1806, 11, 15, 13, 1, -15 },
  { 1827, 11, 15, 13, 1, -15 },
  { 1848, 11, 21, 13, 1, -15 },
  { 1877, 11, 21, 13, 1, -15 },
  { 1906, 8, 15, 9, 1, -15 },
  { 1921, 8, 15, 10, 1, -15 },
  { 1936, 8, 17, 9, 0, -17 },
  { 1953, 11, 14, 13, 1, -14 },
  { 1973, 12, 14, 12, 0, -14 },
  { 1994, 18, 14, 18, 0, -14 },
  { 2026, 12, 14, 12, 0, -14 },
  { 2047, 12, 20, 12, 0, -14 },
  { 2077, 9, 14, 10, 0, -14 },
  { 2093, 9, 23, 9, 0, -19 },
  { 2119, 3, 26, 11, 4, -20 },
  { 2129, 8, 23, 9, 1, -19 },
  { 2152, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD26PT7B_H_
