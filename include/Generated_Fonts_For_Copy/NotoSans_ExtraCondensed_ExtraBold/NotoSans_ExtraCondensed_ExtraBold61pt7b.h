#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x0C, 0x00, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0x7F,
  0xDF, 0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD,
  0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF,
  0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x1F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xBC, 0xF8, 0xFF, 0x3C, 0x18, 0xFF, 0x3C, 0x00, 0xFF,
  0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0xBC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE, 0x00,
  0x3D, 0xFE, 0x00, 0x3C, 0xFF, 0x00, 0x3C, 0xFF, 0x80, 0x3C, 0xFE, 0xE0,
  0x3C, 0xFE, 0xF8, 0x3D, 0xFE, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x3F, 0x81, 0xF0, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xFF, 0x87, 0xF3, 0xF8, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xCF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1,
  0xFE, 0xFE, 0x1F, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0x7F, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE1, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x83,
  0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xEF, 0xFD, 0xFF, 0x87, 0xFC, 0x7F, 0xFF,
  0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0xF9, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x02, 0x03, 0xF0, 0x10, 0xE0,
  0xFC, 0x1C, 0x7F, 0x3F, 0x3F, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E,
  0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xE1,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7,
  0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFB, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFC, 0xFF,
  0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC3, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xDF, 0xFF, 0xFD, 0xFF, 0x7F, 0x9F, 0xF3, 0xF1, 0xFF, 0x1E,
  0x1F, 0xF0, 0xC1, 0xFF, 0x08, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0x07, 0xFE,
  0x3C, 0x03, 0xFE, 0x18, 0x03, 0xFF, 0x10, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3E, 0x07,
  0xFF, 0x0C, 0x01, 0xFF, 0x84, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xDC, 0x00,
  0xFF, 0xEF, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x16, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xDF, 0xF0,
  0x03, 0xFB, 0xFE, 0x00, 0x7E, 0x7F, 0xC0, 0x1F, 0xCF, 0xF8, 0x07, 0xF1,
  0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0x87, 0xFC, 0x07, 0xF0, 0xFF, 0x81,
  0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x0F,
  0xF8, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x10,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x80, 0x07, 0xFE, 0xE0, 0x0F, 0xFE, 0xFE,
  0x3F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0x00, 0x7F, 0x9F, 0xF0, 0x7F, 0xDF, 0xFC, 0x3F, 0xCF,
  0xFF, 0x1F, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x7F,
  0xDF, 0xF0, 0x7F, 0xEF, 0xFC, 0x3F, 0xE3, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC7, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF,
  0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F,
  0xF9, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF, 0xF8, 0x7F, 0xEF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0, 0x7F,
  0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x9F, 0xFF, 0xBF, 0xC7,
  0xFF, 0xBF, 0xE1, 0xFF, 0x9F, 0xE0, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x82, 0x03, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE0, 0xC0, 0x0F, 0x87, 0xF8, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFF, 0x3F, 0xE3, 0xF8, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFE, 0x3F, 0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE7, 0xF8, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3E, 0x07, 0xFC, 0x30, 0x0F, 0xF8, 0x40, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFF, 0xC7, 0xF1, 0xFC, 0x0F,
  0xFF, 0xE3, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0xF8,
  0x7E, 0x7F, 0x07, 0xF9, 0xFC, 0x3F, 0xBF, 0x87, 0xF8, 0xFE, 0x1F, 0xDF,
  0x83, 0xF8, 0x7F, 0x07, 0xEF, 0xC3, 0xF8, 0x3F, 0x83, 0xF7, 0xE1, 0xFC,
  0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0xFF,
  0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0x87, 0xE0, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8,
  0x3F, 0x87, 0xEF, 0xE1, 0xFC, 0x1F, 0xC3, 0xF7, 0xF0, 0xFE, 0x1F, 0xE1,
  0xF9, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0xFC, 0x1F, 0xCF, 0xFD, 0xFC, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xDF, 0xFE, 0x1F, 0xC1, 0xFF,
  0xCF, 0xFE, 0x07, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7C,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0x9F,
  0xF0, 0x3F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F,
  0xFD, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0x9F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xF3, 0xFE, 0x03, 0xFF,
  0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB,
  0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFE, 0x07, 0x83, 0xFF, 0x00, 0x20, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x02, 0x0F, 0xFE, 0x01, 0xC1,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xF8, 0x1F, 0xFC, 0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x7F, 0xEF, 0xF8, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0xCF, 0xF8, 0x7F, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xE1, 0xFF, 0xC0, 0x02, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xCF,
  0xFC, 0x03, 0xFE, 0x7F, 0xF0, 0x1F, 0xF3, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xC7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xBF,
  0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF,
  0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x9F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0x7F,
  0x00, 0xFE, 0xFF, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0xFF, 0x7F, 0x81, 0xFF,
  0xFF, 0xFF, 0x7F, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0x81, 0xFD, 0xFF, 0xFF,
  0x3F, 0x83, 0xFD, 0xFF, 0xFF, 0x3F, 0xC3, 0xF9, 0xFF, 0xFF, 0xBF, 0xC3,
  0xF9, 0xFF, 0xFF, 0x9F, 0xC3, 0xF9, 0xFF, 0xFF, 0x9F, 0xC7, 0xF9, 0xFF,
  0xFF, 0x9F, 0xE7, 0xF1, 0xFF, 0xFF, 0x8F, 0xE7, 0xF1, 0xFF, 0xFF, 0x8F,
  0xE7, 0xF1, 0xFF, 0xFF, 0x8F, 0xEF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFE, 0xFF,
  0x83, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0xC7, 0xFC, 0x7F, 0xFF, 0x87, 0xFC,
  0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0xFE, 0x0F, 0xF3, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFF, 0xFC, 0x1F, 0xEF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0x7F,
  0xC1, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0x3F, 0xF8,
  0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF9, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x7F,
  0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF1,
  0xF9, 0xFF, 0x80, 0x73, 0xFF, 0x00, 0x27, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF8, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xF8, 0x07,
  0xFC, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7E, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFE, 0x7E, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x7F, 0x1F, 0xE0, 0x0F, 0xF9, 0xFC, 0x7F, 0x3F,
  0xE0, 0x0F, 0xF9, 0xFC, 0x7F, 0x3F, 0xE0, 0x0F, 0xF9, 0xFC, 0x7F, 0x3F,
  0xE0, 0x07, 0xF9, 0xFC, 0x7F, 0x3F, 0xE0, 0x07, 0xF9, 0xFC, 0x3F, 0x3F,
  0xC0, 0x07, 0xFB, 0xFC, 0x3F, 0xBF, 0xC0, 0x07, 0xFB, 0xF8, 0x3F, 0xBF,
  0xC0, 0x07, 0xFB, 0xF8, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF,
  0x80, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x03, 0xFF,
  0x0C, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0x3F, 0xFC, 0x7F,
  0x3F, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0xC3, 0xFE, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F,
  0xEF, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFC, 0xFF, 0xF0, 0xFF, 0x1F, 0xFC, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFE, 0xFC, 0x7F, 0xE0, 0x31, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x05, 0xFF, 0x80, 0x27, 0xFF, 0x07, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xF8,
  0x7F, 0xC1, 0xFF, 0x9F, 0xF0, 0xFF, 0xF7, 0xFC, 0x7F, 0xFD, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE1, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFE,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0x07,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x01, 0x1F, 0xF8, 0x03, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFC, 0x20, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0xC1, 0xFF, 0x8F, 0xF0, 0xFF, 0xF3, 0xFC, 0x7F, 0xFC, 0xFF, 0x1F,
  0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE1, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFE,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F,
  0xF0, 0x06, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0xC0, 0x03, 0xFE, 0x3E, 0x03, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x07, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFC, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC0, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x0F,
  0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x0F,
  0xFE, 0x0F, 0xFC, 0x3F, 0xCF, 0xFF, 0x8F, 0xFF, 0x1F, 0xEF, 0xFF, 0xCF,
  0xFF, 0xCF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1,
  0xFF, 0xE3, 0xFF, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xBF, 0xF0, 0x3F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xFC, 0x3F, 0xCF, 0xFF, 0x1F, 0xEF, 0xFF,
  0xCF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF,
  0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0xFD, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8,
  0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xC7, 0xFE, 0x0F,
  0xF1, 0xFF, 0xC3, 0xFC, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0xFF, 0xBF, 0xF0,
  0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFF, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFB, 0xFF, 0xE3, 0xFE, 0xFF,
  0xF8, 0xFF, 0x9F, 0xFC, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0x1C, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x3F,
  0xC1, 0xFF, 0x8F, 0xF0, 0xFF, 0xF3, 0xFC, 0x7F, 0xFC, 0xFF, 0x1F, 0xFF,
  0xBF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE1, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFE, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0,
  0x06, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xF8, 0x3C, 0xFF, 0x00, 0x8F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x63, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x1C, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF9, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFD,
  0xFE, 0x3F, 0xFE, 0x7F, 0x1F, 0xFE, 0x3F, 0x83, 0xFE, 0x1F, 0xC0, 0x38,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFC, 0x07, 0xF9,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x0F, 0xFE, 0x07, 0xFC, 0x7F, 0x83, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFB, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0x7E, 0x1F, 0xF0, 0x7F, 0x87, 0xEF, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFD, 0xFC, 0x7F, 0x81, 0xFF, 0x3F, 0xBF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xE3, 0xF3, 0xFE, 0x03, 0xFC, 0xFC, 0x7E, 0x7F, 0x80, 0x7F, 0x9F,
  0x8F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF1, 0xF9, 0xFE, 0x01, 0xFE, 0xFE, 0x3F,
  0x3F, 0xC0, 0x3F, 0xDF, 0xC7, 0xF7, 0xF8, 0x03, 0xFB, 0xF0, 0x7E, 0xFE,
  0x00, 0x7F, 0x7E, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01,
  0xFE, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xDF,
  0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x23,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x4F,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xA0, 0x01, 0xFF, 0xC8, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 45, 16, 3, -44 },
  { 58, 23, 16, 28, 3, -44 },
  { 104, 30, 44, 32, 1, -44 },
  { 269, 24, 50, 29, 3, -46 },
  { 419, 45, 44, 49, 2, -44 },
  { 667, 36, 45, 36, 1, -44 },
  { 870, 9, 16, 15, 3, -44 },
  { 888, 16, 54, 20, 3, -44 },
  { 996, 16, 54, 20, 1, -44 },
  { 1104, 26, 26, 28, 1, -47 },
  { 1189, 25, 29, 29, 2, -36 },
  { 1280, 11, 16, 16, 2, -8 },
  { 1302, 15, 9, 19, 2, -21 },
  { 1319, 10, 11, 16, 3, -10 },
  { 1333, 25, 45, 25, 0, -44 },
  { 1474, 25, 45, 29, 2, -44 },
  { 1615, 20, 44, 29, 3, -44 },
  { 1725, 24, 44, 29, 2, -44 },
  { 1857, 25, 45, 29, 2, -44 },
  { 1998, 27, 44, 29, 1, -44 },
  { 2147, 24, 45, 29, 3, -44 },
  { 2282, 25, 45, 29, 2, -44 },
  { 2423, 25, 44, 29, 2, -44 },
  { 2561, 25, 45, 29, 2, -44 },
  { 2702, 25, 45, 29, 2, -44 },
  { 2843, 10, 35, 16, 3, -34 },
  { 2887, 11, 42, 16, 2, -34 },
  { 2945, 25, 30, 29, 2, -37 },
  { 3039, 25, 19, 29, 2, -31 },
  { 3099, 26, 30, 29, 2, -37 },
  { 3197, 23, 45, 23, 0, -44 },
  { 3327, 41, 49, 45, 2, -44 },
  { 3579, 33, 44, 33, 0, -44 },
  { 3761, 27, 44, 33, 4, -44 },
  { 3910, 27, 45, 30, 2, -44 },
  { 4062, 28, 44, 35, 4, -44 },
  { 4216, 20, 44, 27, 4, -44 },
  { 4326, 20, 44, 26, 4, -44 },
  { 4436, 29, 45, 35, 3, -44 },
  { 4600, 29, 44, 36, 4, -44 },
  { 4760, 17, 44, 20, 2, -44 },
  { 4854, 16, 57, 17, -3, -44 },
  { 4968, 29, 44, 32, 4, -44 },
  { 5128, 21, 44, 25, 4, -44 },
  { 5244, 40, 44, 48, 4, -44 },
  { 5464, 31, 44, 39, 4, -44 },
  { 5635, 32, 45, 37, 2, -44 },
  { 5815, 25, 44, 31, 4, -44 },
  { 5953, 32, 54, 37, 2, -44 },
  { 6169, 28, 44, 32, 4, -44 },
  { 6323, 23, 45, 27, 2, -44 },
  { 6453, 25, 44, 27, 1, -44 },
  { 6591, 28, 45, 35, 4, -44 },
  { 6749, 32, 44, 32, 0, -44 },
  { 6925, 48, 44, 47, 0, -44 },
  { 7189, 30, 44, 30, 0, -44 },
  { 7354, 30, 44, 30, 0, -44 },
  { 7519, 25, 44, 27, 1, -44 },
  { 7657, 15, 54, 19, 3, -44 },
  { 7759, 25, 45, 25, 0, -44 },
  { 7900, 15, 54, 19, 1, -44 },
  { 8002, 31, 28, 33, 1, -44 },
  { 8111, 28, 5, 28, 0, 5 },
  { 8129, 15, 10, 20, 2, -47 },
  { 8148, 24, 35, 29, 2, -34 },
  { 8253, 26, 47, 31, 3, -46 },
  { 8406, 22, 35, 25, 2, -34 },
  { 8503, 26, 47, 31, 2, -46 },
  { 8656, 25, 35, 29, 2, -34 },
  { 8766, 21, 47, 19, 0, -47 },
  { 8890, 26, 49, 31, 2, -34 },
  { 9050, 25, 46, 31, 3, -46 },
  { 9194, 9, 47, 16, 3, -47 },
  { 9247, 14, 62, 16, -2, -47 },
  { 9356, 28, 46, 31, 3, -46 },
  { 9517, 9, 46, 15, 3, -46 },
  { 9569, 41, 34, 47, 3, -34 },
  { 9744, 25, 34, 31, 3, -34 },
  { 9851, 26, 35, 31, 2, -34 },
  { 9965, 26, 49, 31, 3, -34 },
  { 10125, 26, 49, 31, 2, -34 },
  { 10285, 18, 34, 22, 3, -34 },
  { 10362, 20, 35, 23, 2, -34 },
  { 10450, 19, 41, 21, 1, -40 },
  { 10548, 25, 35, 31, 3, -34 },
  { 10658, 28, 34, 28, 0, -34 },
  { 10777, 43, 33, 43, 0, -33 },
  { 10955, 27, 33, 27, 0, -33 },
  { 11067, 28, 49, 28, 0, -34 },
  { 11239, 21, 34, 23, 1, -34 },
  { 11329, 19, 54, 22, 1, -44 },
  { 11458, 8, 61, 26, 9, -47 },
  { 11519, 19, 54, 22, 2, -44 },
  { 11648, 26, 11, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD61PT7B_H_
