#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF3, 0xFB, 0xFD,
  0xFF, 0xFF, 0x3F, 0x8F, 0x81, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFB, 0xFC,
  0x7F, 0x7F, 0x8F, 0xEF, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xF3, 0xF0,
  0xFE, 0x7E, 0x1F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF1,
  0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x03, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3,
  0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xC7,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xEC, 0x7B, 0xF9, 0x82,
  0x7F, 0x30, 0x0F, 0xC6, 0x01, 0xFC, 0xC0, 0x1F, 0xD8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0x7F, 0x00, 0x67, 0xE0, 0x0C, 0xFE,
  0x01, 0x9F, 0xE0, 0x33, 0xFF, 0x06, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x7C, 0x00, 0x3E, 0x3E, 0x03, 0xE0,
  0x01, 0xF1, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0xFC, 0x7E,
  0x0F, 0x80, 0x07, 0xE3, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x87, 0xC0, 0x01,
  0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x1F,
  0x02, 0x01, 0xF1, 0xF9, 0xF0, 0xFE, 0x0F, 0x8F, 0x8F, 0x8F, 0xF8, 0x7E,
  0xFC, 0xFC, 0xFF, 0xE1, 0xFF, 0xE7, 0xC7, 0xFF, 0x8F, 0xFE, 0x3E, 0x7E,
  0xFC, 0x3F, 0xE3, 0xE3, 0xE3, 0xE0, 0xFE, 0x1F, 0x1F, 0x1F, 0x80, 0x01,
  0xF8, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x3F,
  0x00, 0x07, 0xC3, 0xF1, 0xF8, 0x00, 0x3E, 0x1F, 0x8F, 0xC0, 0x03, 0xF0,
  0xFC, 0x7E, 0x00, 0x1F, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x1F, 0x1F, 0x80,
  0x0F, 0x80, 0xF8, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0x1F,
  0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x1F, 0xE3, 0xFF, 0xF9,
  0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF3, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xCF,
  0xF1, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0xFF, 0x03,
  0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF9, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x04, 0x0F, 0x82, 0x3C, 0x7C, 0x71, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF3, 0xF8, 0x7F, 0x8F, 0xE0,
  0xF8, 0x7E, 0x03, 0xC1, 0xC0, 0x0C, 0x0C, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0x9F,
  0xDF, 0xEF, 0xFF, 0xF9, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0x1F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x08, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3E, 0x1F, 0xE3, 0xC0, 0xFE, 0x18, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8E, 0x0F, 0xF9, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xDF, 0xC0, 0x3F, 0x7F, 0x00, 0xF9, 0xFC, 0x07,
  0xE7, 0xF0, 0x1F, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xE1, 0xFC, 0x1F, 0x87,
  0xF0, 0x7C, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF7, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x3E, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xF9, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC3, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFD, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xBF,
  0xE7, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFE,
  0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x8F, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xBF, 0x07, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3E,
  0x3F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF3, 0xF9,
  0xFF, 0xFF, 0x7F, 0xBF, 0x8F, 0xC1, 0x00, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0x83, 0xFC, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x03, 0xFF, 0x1F, 0x0F, 0x83, 0xFF,
  0xCF, 0xCF, 0x83, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF, 0xF1, 0xF3, 0xE1, 0xF9,
  0xF8, 0xFB, 0xF1, 0xF8, 0xFC, 0x7D, 0xF0, 0xF8, 0x7E, 0x3F, 0xF8, 0x7C,
  0x3F, 0x0F, 0xFC, 0x7E, 0x1F, 0x87, 0xFE, 0x3F, 0x0F, 0xC7, 0xFF, 0x1F,
  0x87, 0xC3, 0xEF, 0x8F, 0xC3, 0xE1, 0xF7, 0xC7, 0xE1, 0xF0, 0xFB, 0xE3,
  0xF0, 0xF8, 0x7D, 0xF0, 0xF8, 0x7C, 0x3E, 0xF8, 0x7E, 0x7F, 0x3E, 0x7C,
  0x3F, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0x0F, 0x87, 0xFC, 0xFF, 0x07,
  0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x40, 0x07, 0xF0, 0x00, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xE0, 0xFF, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF,
  0xE0, 0x7F, 0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81,
  0xFE, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0x83, 0x87, 0xF8, 0x04, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x23, 0xFF,
  0x07, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0x9F,
  0xFE, 0x7F, 0x07, 0xFC, 0xFE, 0x07, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0xE7, 0xF0,
  0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xF0, 0x1C, 0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x87, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0x80, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0x9F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x83,
  0xFC, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF,
  0xF8, 0x1F, 0xBF, 0xFE, 0xFC, 0x1F, 0xBF, 0xFE, 0xFC, 0x1F, 0xFF, 0xFE,
  0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0x7E, 0x3F, 0x7F, 0xFE,
  0x7E, 0x3F, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE,
  0x3F, 0x7E, 0x7F, 0xFE, 0x3F, 0x7C, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFC, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x0F, 0xF8, 0x7F, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF7, 0xF1, 0xFF, 0xFB, 0xF8, 0xFF, 0xFD, 0xFC,
  0x7F, 0xFE, 0x7F, 0x3F, 0xFF, 0x3F, 0x9F, 0xFF, 0x8F, 0xE7, 0xFF, 0xC7,
  0xF3, 0xFF, 0xE1, 0xFD, 0xFF, 0xF0, 0xFE, 0xFF, 0xF8, 0x7F, 0x7F, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF9, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF,
  0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x9F,
  0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x8F, 0xFC, 0x7F, 0x07, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x1F, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x1F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xFD,
  0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xF3, 0xF3, 0xFC,
  0x0C, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x7F, 0x01, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xFF, 0x07, 0xF8,
  0xFE, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF,
  0xC1, 0xFC, 0x3F, 0x87, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0xC1,
  0xF8, 0x7F, 0xF8, 0xFF, 0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x1F, 0xC7, 0xCF,
  0x8F, 0xE0, 0x7F, 0x3F, 0x3E, 0x3F, 0x81, 0xFC, 0xFC, 0xFC, 0xFE, 0x07,
  0xF3, 0xF3, 0xF7, 0xF8, 0x0F, 0xCF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x3F,
  0x7F, 0x00, 0xFE, 0xF8, 0x7D, 0xFC, 0x03, 0xFF, 0xE1, 0xF7, 0xF0, 0x0F,
  0xFF, 0x87, 0xDF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7,
  0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1,
  0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x80,
  0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7,
  0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7,
  0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF9, 0xFE,
  0x0C, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF8,
  0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xBF, 0x3F, 0xFB, 0xF3,
  0xFF, 0x3F, 0x1F, 0xE1, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x7F, 0x0F, 0xEF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFD, 0xFF, 0xCF, 0xCF, 0xF8, 0xFC,
  0x7F, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFE, 0x0D, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x1B, 0xFF,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x0F, 0xE7, 0xF1, 0xFF, 0x7F, 0x3F, 0xFB, 0xF3, 0xFF, 0xBF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0x3F, 0x0F, 0xE1, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF9, 0xFC,
  0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x47, 0xFC, 0x3C, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x0F, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF,
  0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF6, 0x00, 0xFF, 0x7E, 0x3F, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x7F, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x1C,
  0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x01, 0xC0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0xFF, 0x83, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xBF, 0x81,
  0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0x8F, 0xF0,
  0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8,
  0x3F, 0xCF, 0xE0, 0x7F, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0x07, 0xF8, 0xFC,
  0xFF, 0x8F, 0xFC, 0xFD, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x7F, 0x0F, 0xCF, 0xF8,
  0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x1F,
  0xEF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0xF8, 0x7F, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xEF, 0xF8, 0xFE, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xFB, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xF8, 0x7F, 0xE3, 0xFF, 0xDF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE7, 0xF8, 0xF3, 0xF8, 0x19, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x07, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE1, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xF7, 0xF3, 0xFF,
  0x3F, 0x1F, 0xC3, 0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x1F, 0xDF, 0xC1, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0xC1, 0xFD, 0xFC,
  0x1F, 0xF0, 0x7F, 0x7F, 0x0F, 0xFC, 0x3F, 0x9F, 0xC3, 0xFF, 0x0F, 0xE3,
  0xF8, 0xFF, 0xC3, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x3F, 0x8F, 0xBE, 0x3F,
  0x0F, 0xE3, 0xEF, 0x9F, 0xC3, 0xF9, 0xFB, 0xE7, 0xF0, 0x7E, 0x7C, 0xF9,
  0xFC, 0x1F, 0xDF, 0x3E, 0x7F, 0x07, 0xF7, 0xCF, 0xDF, 0x81, 0xFD, 0xF1,
  0xF7, 0xE0, 0x3F, 0x7C, 0x7D, 0xF8, 0x0F, 0xDF, 0x1F, 0xFE, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xDF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x7F,
  0x87, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0xFE,
  0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x04, 0x00, 0x09, 0xFF, 0x00, 0x5F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x07, 0xFE, 0x80, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 36, 13, 2, -35 },
  { 42, 19, 13, 23, 2, -35 },
  { 73, 24, 35, 26, 1, -35 },
  { 178, 19, 40, 23, 2, -37 },
  { 273, 37, 35, 39, 1, -35 },
  { 435, 28, 35, 29, 1, -35 },
  { 558, 8, 13, 12, 2, -35 },
  { 571, 13, 43, 16, 2, -35 },
  { 641, 13, 43, 16, 0, -35 },
  { 711, 21, 20, 22, 1, -37 },
  { 764, 20, 23, 24, 2, -29 },
  { 822, 9, 13, 13, 2, -6 },
  { 837, 13, 7, 15, 1, -17 },
  { 849, 9, 9, 13, 2, -8 },
  { 860, 20, 35, 20, 0, -35 },
  { 948, 20, 35, 23, 2, -35 },
  { 1036, 16, 35, 23, 2, -35 },
  { 1106, 20, 35, 23, 1, -35 },
  { 1194, 19, 35, 23, 2, -35 },
  { 1278, 22, 35, 23, 1, -35 },
  { 1375, 19, 35, 23, 2, -35 },
  { 1459, 20, 35, 23, 2, -35 },
  { 1547, 21, 35, 23, 1, -35 },
  { 1639, 21, 35, 23, 1, -35 },
  { 1731, 21, 35, 23, 1, -35 },
  { 1823, 9, 28, 13, 2, -27 },
  { 1855, 9, 34, 13, 2, -27 },
  { 1894, 21, 24, 24, 1, -30 },
  { 1957, 21, 16, 24, 1, -25 },
  { 1999, 20, 24, 24, 2, -30 },
  { 2059, 18, 36, 19, 0, -35 },
  { 2140, 33, 39, 36, 2, -35 },
  { 2301, 27, 35, 27, 0, -35 },
  { 2420, 22, 35, 27, 3, -35 },
  { 2517, 21, 35, 24, 2, -35 },
  { 2609, 23, 35, 28, 3, -35 },
  { 2710, 16, 35, 22, 3, -35 },
  { 2780, 16, 35, 21, 3, -35 },
  { 2850, 24, 35, 28, 2, -35 },
  { 2955, 23, 35, 29, 3, -35 },
  { 3056, 14, 35, 16, 1, -35 },
  { 3118, 14, 46, 14, -3, -35 },
  { 3199, 23, 35, 26, 3, -35 },
  { 3300, 17, 35, 20, 3, -35 },
  { 3375, 32, 35, 39, 3, -35 },
  { 3515, 25, 35, 31, 3, -35 },
  { 3625, 26, 36, 30, 2, -36 },
  { 3742, 20, 35, 25, 3, -35 },
  { 3830, 26, 44, 30, 2, -36 },
  { 3973, 23, 35, 26, 3, -35 },
  { 4074, 19, 35, 21, 1, -35 },
  { 4158, 20, 35, 22, 1, -35 },
  { 4246, 22, 35, 28, 3, -35 },
  { 4343, 26, 35, 26, 0, -35 },
  { 4457, 38, 35, 38, 0, -35 },
  { 4624, 24, 35, 24, 0, -35 },
  { 4729, 24, 35, 24, 0, -35 },
  { 4834, 20, 35, 22, 1, -35 },
  { 4922, 12, 43, 15, 2, -35 },
  { 4987, 20, 35, 20, 0, -35 },
  { 5075, 12, 43, 15, 1, -35 },
  { 5140, 24, 22, 26, 1, -35 },
  { 5206, 22, 4, 22, 0, 4 },
  { 5217, 12, 8, 16, 2, -38 },
  { 5229, 20, 27, 23, 1, -27 },
  { 5297, 20, 37, 25, 3, -37 },
  { 5390, 17, 27, 20, 2, -27 },
  { 5448, 20, 37, 25, 2, -37 },
  { 5541, 20, 27, 23, 2, -27 },
  { 5609, 17, 37, 15, 0, -37 },
  { 5688, 20, 39, 25, 2, -27 },
  { 5786, 20, 37, 25, 3, -37 },
  { 5879, 8, 38, 12, 2, -38 },
  { 5917, 12, 50, 12, -2, -38 },
  { 5992, 22, 37, 25, 3, -37 },
  { 6094, 7, 37, 12, 3, -37 },
  { 6127, 32, 27, 38, 3, -27 },
  { 6235, 20, 27, 25, 3, -27 },
  { 6303, 21, 27, 25, 2, -27 },
  { 6374, 20, 39, 25, 3, -27 },
  { 6472, 20, 39, 25, 2, -27 },
  { 6570, 14, 27, 18, 3, -27 },
  { 6618, 17, 27, 19, 1, -27 },
  { 6676, 16, 32, 17, 0, -32 },
  { 6740, 20, 27, 25, 3, -27 },
  { 6808, 23, 27, 23, 0, -27 },
  { 6886, 34, 27, 35, 0, -27 },
  { 7001, 22, 27, 22, 0, -27 },
  { 7076, 23, 39, 23, 0, -27 },
  { 7189, 17, 27, 18, 1, -27 },
  { 7247, 15, 43, 17, 1, -35 },
  { 7328, 7, 49, 21, 7, -38 },
  { 7371, 16, 43, 17, 1, -35 },
  { 7457, 21, 9, 24, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD49PT7B_H_
