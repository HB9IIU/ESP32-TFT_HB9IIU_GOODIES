#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x3F, 0xE3, 0xF8, 0x18, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xDC,
  0x7C, 0xFF, 0x1C, 0x0C, 0xFF, 0x1C, 0x00, 0xFF, 0x1C, 0x00, 0xFF, 0x1C,
  0x00, 0xFF, 0x1C, 0x00, 0xFF, 0x9C, 0x00, 0xFF, 0xDC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1D, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C,
  0xFF, 0x00, 0x1C, 0x7F, 0x80, 0x1C, 0x7F, 0xC0, 0x1C, 0xFF, 0xE0, 0x1C,
  0xFF, 0xFC, 0x1D, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE1, 0xF8,
  0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x0F, 0xE0,
  0x78, 0x07, 0xF0, 0xFE, 0x3F, 0x83, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xFE, 0x0F, 0xE7, 0xF8, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x3F, 0xF8, 0x7E, 0x1F, 0xC7,
  0xF0, 0x3F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE0, 0x0C, 0x03, 0xF8, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0x87, 0xFE, 0x7F, 0xEF,
  0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x0F, 0xE0, 0x61,
  0xE1, 0xFC, 0x3C, 0x7F, 0xBF, 0xBF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x0E, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0x0F, 0xF9, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFE, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFE, 0x7F,
  0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE,
  0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFD, 0xFE, 0x7F, 0xE7, 0xE3, 0xFF, 0x1E, 0x1F, 0xF8, 0x60, 0xFF, 0xC1,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x8F, 0x80, 0x7F, 0xC3, 0x00, 0x3F,
  0xE0, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xDF, 0xFF, 0x07, 0x80, 0xFF, 0xC1, 0x80, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x80, 0x01, 0xFF, 0xBC,
  0x00, 0xFF, 0xEF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xDF, 0xF0, 0x01, 0xFD, 0xFF,
  0x00, 0x1F, 0xDF, 0xF0, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x07,
  0xF1, 0xFF, 0x00, 0x7F, 0x1F, 0xF0, 0x0F, 0xE1, 0xFF, 0x00, 0xFE, 0x1F,
  0xF0, 0x1F, 0xC1, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x18, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0x80, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0xC3, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3,
  0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0xFF, 0x9F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFC, 0x7F,
  0xE3, 0xFF, 0x9F, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xCF, 0xFC, 0x1F,
  0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFD, 0xFF, 0x0F, 0xFE, 0x7F, 0x81,
  0xFF, 0x1F, 0xE0, 0x0F, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x83, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x0F,
  0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xF8, 0xFE, 0x07, 0x00,
  0x0F, 0x81, 0xFE, 0x3F, 0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF3, 0xFE,
  0x3F, 0xE1, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7C, 0x0F, 0xFC, 0x60, 0x0F, 0xF8, 0x80, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xFF, 0x8F, 0xE1, 0xF8, 0x0F, 0xFF, 0xE1, 0xF8, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xFE, 0x1F, 0xCF, 0xC1, 0xFF,
  0xFF, 0x87, 0xF7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFD, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xDF, 0x83, 0xF8, 0x3F, 0x83, 0xF7,
  0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xE1, 0xFC, 0x0F,
  0xE0, 0xFF, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F,
  0xFF, 0x87, 0xF0, 0x7F, 0x87, 0xFF, 0xE1, 0xFC, 0x1F, 0xE1, 0xF9, 0xF8,
  0x3F, 0x87, 0xF8, 0x7E, 0x7E, 0x0F, 0xE3, 0xFE, 0x3F, 0x9F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFD, 0xFF, 0xF1, 0xFC, 0x1F, 0xFE, 0x7F,
  0xF8, 0x7F, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03,
  0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F,
  0xFE, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xCF, 0xF8, 0x0F, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0xCF, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xFC, 0xFF, 0x80, 0xFF, 0xEF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0x81, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0x80,
  0xF0, 0xFF, 0xE0, 0x04, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x08, 0x7F, 0xF8, 0x0F, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0x87, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0x3F, 0xE0, 0x1F, 0xFD, 0xFF, 0x00,
  0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x3F,
  0xF9, 0xFF, 0x03, 0xFF, 0xCF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x03, 0x83, 0xFF, 0xC0, 0x02, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF,
  0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x03,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x00, 0xFF,
  0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x03,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFF,
  0xBF, 0x80, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x3F, 0x9F, 0xFF, 0xFB, 0xFC,
  0x0F, 0xE7, 0xFF, 0xFE, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xC1, 0xFE,
  0x7F, 0xFF, 0xE7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF9, 0xFE, 0x1F, 0xCF, 0xFF,
  0xFE, 0x7F, 0x8F, 0xF3, 0xFF, 0xFF, 0x8F, 0xE3, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFC, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xDF,
  0xE3, 0xFF, 0xFF, 0x87, 0xF7, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF,
  0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF,
  0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0x87, 0xFC, 0xFF,
  0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0x83, 0xFE, 0xFF,
  0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0xFF, 0x87, 0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xC7, 0xFC, 0x0F, 0xFE, 0x3F, 0xE0, 0x3F,
  0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3,
  0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC,
  0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFC, 0xFF, 0x80,
  0x7F, 0xE7, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF,
  0xC0, 0x1C, 0xFF, 0xC0, 0x08, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0xFE, 0x0F, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x68, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFD,
  0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x07,
  0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x7F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xF0,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFE, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0x7F, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xBF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xDF, 0xC3, 0xFF, 0x03, 0xFE, 0x0F, 0xEF, 0xE1, 0xFF,
  0x80, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFB, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE3, 0xF9, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xF0, 0x0F, 0xF8, 0xFE, 0x3F, 0x9F, 0xF8, 0x03, 0xFC, 0xFF, 0x1F, 0xCF,
  0xF8, 0x01, 0xFE, 0x7F, 0x8F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xC7, 0xF3,
  0xFE, 0x00, 0x7F, 0xDF, 0xC1, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0xFE,
  0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x7F, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x07, 0xFE, 0x0E, 0x01, 0xFF, 0x84,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0x3F,
  0xFE, 0x7F, 0x8F, 0xFE, 0x1F, 0xC3, 0xFE, 0x0F, 0xE0, 0x38, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x3F,
  0xE3, 0xFF, 0x07, 0xFC, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x1F, 0xF7, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xC1, 0xFF, 0xBF, 0xF8, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x1F, 0xF7,
  0xFF, 0x07, 0xFE, 0xFF, 0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFB, 0xFF, 0xF1, 0xFF, 0x7F, 0xFC, 0x3F,
  0xC7, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xF0, 0x38,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x09, 0xFF, 0xC0, 0x33, 0xFF, 0xC3, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x03, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x7F, 0xF9, 0xFF,
  0x1F, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB,
  0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0x7F, 0xF1, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0x3F, 0xC1, 0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F,
  0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x10, 0xFF, 0xC0, 0x3C, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF,
  0xC3, 0xFC, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0,
  0xFF, 0xEF, 0xFC, 0x1F, 0xFD, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF,
  0x83, 0xFF, 0xBF, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0x3F, 0xE0, 0xFF,
  0xE7, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0x30, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x20, 0x00,
  0xFF, 0xC7, 0x80, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x7F, 0xF8,
  0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01,
  0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x83, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xEF,
  0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x83,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81,
  0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC7, 0xFF, 0x83, 0xFF, 0x8F,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF3, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0xC7, 0xFF, 0x0F,
  0xF3, 0xFF, 0xE3, 0xFC, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xDF, 0xFE, 0x3F, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF,
  0xBF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF,
  0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFF, 0x83, 0xFC, 0x7F, 0xF8, 0x7F,
  0xDF, 0xFF, 0x8F, 0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xDF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xFC, 0x0F, 0xFB, 0xFF,
  0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xDF, 0xF8, 0x0F, 0xFB, 0xFF, 0x83, 0xFF, 0x7F, 0xF8, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFD, 0xFF,
  0xF8, 0xFF, 0x9F, 0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC0, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x7F,
  0x8F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xEF, 0xFC, 0x1F, 0xFD,
  0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F,
  0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFD, 0xFF, 0x0F, 0xFF, 0x3F, 0xE0, 0xFF, 0xE7, 0xFC, 0x0F, 0xF0, 0xFF,
  0x80, 0x30, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xF0, 0x78,
  0xFF, 0x80, 0xC7, 0xF8, 0x02, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFD, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x05,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF3, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x1F,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0x3F, 0xC3, 0xFF, 0x8F, 0xF0,
  0x7F, 0xC1, 0xFC, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0x01, 0xFE, 0x7F,
  0xC0, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFD, 0xF8,
  0x7F, 0xC1, 0xFF, 0x1F, 0xDF, 0x87, 0xFC, 0x1F, 0xF1, 0xF9, 0xFC, 0x7F,
  0x81, 0xFF, 0x1F, 0x9F, 0xC7, 0xF8, 0x1F, 0xF1, 0xF9, 0xFC, 0xFF, 0x80,
  0xFF, 0x3F, 0x9F, 0xCF, 0xF8, 0x0F, 0xF3, 0xF8, 0xFC, 0xFF, 0x80, 0xFF,
  0x3F, 0x8F, 0xCF, 0xF0, 0x0F, 0xFB, 0xF0, 0xFC, 0xFF, 0x00, 0xFF, 0xBF,
  0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xF0, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x0F,
  0xFF, 0xF0, 0x07, 0xFB, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF9, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xF0, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00,
  0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x27, 0xFF, 0x00, 0x0D, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xD8, 0x01, 0xFF, 0xF2, 0x00, 0x07, 0xF8,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 46, 17, 3, -45 },
  { 65, 23, 16, 29, 3, -45 },
  { 111, 31, 45, 33, 1, -45 },
  { 286, 24, 52, 30, 3, -48 },
  { 442, 47, 47, 51, 2, -46 },
  { 719, 37, 47, 38, 1, -46 },
  { 937, 10, 16, 15, 3, -45 },
  { 957, 17, 56, 20, 3, -46 },
  { 1076, 16, 56, 20, 1, -46 },
  { 1188, 27, 27, 29, 1, -48 },
  { 1280, 26, 30, 30, 2, -37 },
  { 1378, 12, 16, 16, 2, -8 },
  { 1402, 16, 8, 20, 2, -21 },
  { 1418, 11, 11, 17, 3, -10 },
  { 1434, 26, 47, 26, 0, -46 },
  { 1587, 26, 47, 30, 2, -46 },
  { 1740, 21, 45, 30, 3, -45 },
  { 1859, 25, 46, 30, 2, -46 },
  { 2003, 26, 47, 30, 2, -46 },
  { 2156, 28, 45, 30, 1, -45 },
  { 2314, 24, 46, 30, 3, -45 },
  { 2452, 26, 47, 30, 2, -46 },
  { 2605, 26, 45, 30, 2, -45 },
  { 2752, 26, 47, 30, 2, -46 },
  { 2905, 26, 47, 30, 2, -46 },
  { 3058, 11, 36, 17, 3, -35 },
  { 3108, 12, 43, 17, 2, -35 },
  { 3173, 26, 31, 30, 2, -38 },
  { 3274, 26, 20, 30, 2, -32 },
  { 3339, 27, 31, 30, 2, -38 },
  { 3444, 23, 47, 24, 0, -46 },
  { 3580, 42, 51, 47, 2, -46 },
  { 3848, 35, 45, 35, 0, -45 },
  { 4045, 28, 45, 34, 4, -45 },
  { 4203, 27, 47, 31, 3, -46 },
  { 4362, 29, 45, 36, 4, -45 },
  { 4526, 21, 45, 28, 4, -45 },
  { 4645, 21, 45, 27, 4, -45 },
  { 4764, 30, 47, 36, 3, -46 },
  { 4941, 30, 45, 38, 4, -45 },
  { 5110, 17, 45, 21, 2, -45 },
  { 5206, 18, 59, 18, -4, -45 },
  { 5339, 30, 45, 34, 4, -45 },
  { 5508, 21, 45, 26, 4, -45 },
  { 5627, 42, 45, 50, 4, -45 },
  { 5864, 32, 45, 40, 4, -45 },
  { 6044, 33, 47, 38, 3, -46 },
  { 6238, 26, 45, 32, 4, -45 },
  { 6385, 33, 57, 38, 3, -46 },
  { 6621, 29, 45, 33, 4, -45 },
  { 6785, 24, 47, 28, 2, -46 },
  { 6926, 26, 45, 28, 1, -45 },
  { 7073, 29, 46, 36, 4, -45 },
  { 7240, 33, 45, 33, 0, -45 },
  { 7426, 49, 45, 49, 0, -45 },
  { 7702, 31, 45, 31, 0, -45 },
  { 7877, 31, 45, 31, 0, -45 },
  { 8052, 26, 45, 28, 1, -45 },
  { 8199, 15, 56, 19, 3, -46 },
  { 8304, 26, 47, 26, 0, -46 },
  { 8457, 15, 56, 19, 1, -46 },
  { 8562, 32, 29, 34, 1, -45 },
  { 8678, 29, 6, 28, 0, 5 },
  { 8700, 15, 10, 20, 3, -48 },
  { 8719, 25, 36, 30, 2, -35 },
  { 8832, 27, 49, 32, 3, -48 },
  { 8998, 23, 36, 26, 2, -35 },
  { 9102, 27, 49, 32, 2, -48 },
  { 9268, 26, 36, 30, 2, -35 },
  { 9385, 21, 48, 20, 0, -48 },
  { 9511, 27, 50, 32, 2, -35 },
  { 9680, 26, 48, 32, 3, -48 },
  { 9836, 10, 48, 16, 3, -48 },
  { 9896, 15, 63, 16, -2, -48 },
  { 10015, 28, 48, 32, 4, -48 },
  { 10183, 9, 48, 16, 3, -48 },
  { 10237, 42, 35, 48, 3, -35 },
  { 10421, 26, 35, 32, 3, -35 },
  { 10535, 27, 36, 32, 2, -35 },
  { 10657, 27, 50, 32, 3, -35 },
  { 10826, 27, 50, 32, 2, -35 },
  { 10995, 19, 35, 23, 3, -35 },
  { 11079, 21, 36, 24, 2, -35 },
  { 11174, 19, 43, 21, 1, -42 },
  { 11277, 26, 36, 32, 3, -35 },
  { 11394, 29, 35, 29, 0, -35 },
  { 11521, 44, 35, 44, 0, -35 },
  { 11714, 28, 35, 28, 0, -35 },
  { 11837, 29, 50, 29, 0, -35 },
  { 12019, 22, 35, 24, 1, -35 },
  { 12116, 20, 55, 22, 1, -45 },
  { 12254, 8, 63, 27, 10, -48 },
  { 12317, 20, 55, 22, 2, -45 },
  { 12455, 27, 11, 30, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD63PT7B_H_
