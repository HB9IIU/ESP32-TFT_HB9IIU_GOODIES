#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x00, 0x6F, 0xFF, 0xF7, 0xF3, 0xB9,
  0xDC, 0xEE, 0x77, 0x38, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xDC, 0x7F, 0xF7,
  0xFF, 0x1D, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0xB8, 0x3B, 0x83,
  0xB0, 0x33, 0x03, 0x30, 0x08, 0x0F, 0x1F, 0xFF, 0xEE, 0x97, 0x43, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0x78, 0xBF, 0x7F, 0xFC, 0xFC, 0x08, 0x04,
  0x00, 0x30, 0x08, 0x3C, 0x18, 0x3F, 0x1C, 0x19, 0x8E, 0x0C, 0xC6, 0x06,
  0x77, 0x03, 0x33, 0x01, 0x9B, 0xBC, 0xFD, 0xDF, 0x3C, 0xDD, 0x8C, 0xEE,
  0xE0, 0x67, 0x70, 0x73, 0xB8, 0x39, 0xDC, 0x18, 0xEE, 0x1C, 0x3E, 0x0C,
  0x1E, 0x00, 0x06, 0x00, 0x7E, 0x03, 0xFC, 0x0E, 0x70, 0x39, 0xC0, 0xEF,
  0x03, 0xF8, 0x07, 0xC0, 0x3E, 0x39, 0xFD, 0xE7, 0x7F, 0x9C, 0xFC, 0xF3,
  0xF1, 0xC7, 0x87, 0xFF, 0x1F, 0xFE, 0x3F, 0x7C, 0xFE, 0xEE, 0xEE, 0x1C,
  0xE3, 0x9C, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71,
  0xE3, 0x8F, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x38, 0xE7, 0x1C, 0xE0, 0x0E, 0x03, 0x80, 0xE1, 0xB7,
  0x7F, 0xFF, 0xF1, 0xF0, 0xFE, 0x7B, 0x84, 0xC0, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x7F, 0xFE, 0xEE,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0,
  0x00, 0x1C, 0x1F, 0x1F, 0xDE, 0xEF, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0xBD, 0xFC, 0xFE, 0x3E, 0x00, 0x0F, 0x1F, 0x3F,
  0x7F, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x18, 0x3F, 0x3F, 0xDC, 0xE4, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x0F,
  0x07, 0x07, 0x87, 0x87, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x7F, 0xBF,
  0xCC, 0xF0, 0x78, 0x3C, 0x1C, 0x7C, 0x3C, 0x1F, 0x81, 0xE0, 0xF0, 0x7C,
  0x3F, 0xFF, 0xFE, 0xFE, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x37, 0x0E, 0xE1, 0x9C, 0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0xE0, 0x1C, 0x7F, 0x3F, 0x9F, 0xCE, 0x0F, 0x07, 0xE3, 0xFD, 0xFE,
  0x4F, 0x83, 0xC0, 0xE0, 0xF8, 0x7F, 0xFB, 0xFD, 0xFC, 0x07, 0x0F, 0x8F,
  0xCF, 0x0F, 0x07, 0x03, 0xB9, 0xFE, 0xFF, 0xFB, 0xF8, 0xFC, 0x7E, 0x3F,
  0x9D, 0xFE, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x1C,
  0x3F, 0xBF, 0xDE, 0xFE, 0x3F, 0x1D, 0xDC, 0xFE, 0x3E, 0x3F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0xDF, 0xFE, 0x3E, 0x00, 0x18, 0x3F, 0x3F, 0xDE, 0xFE,
  0x7F, 0x1F, 0x8F, 0xC7, 0xF7, 0xFF, 0xDE, 0xE0, 0x70, 0x78, 0x3B, 0xFD,
  0xFC, 0xFC, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x06, 0xFF, 0x70, 0x6F, 0xF7,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0xEE, 0x00, 0x80, 0xC3, 0xE7, 0xFF, 0xC7,
  0x83, 0xE0, 0xFC, 0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3E, 0x0F, 0xC1, 0xF8, 0x3C, 0x3E,
  0x7E, 0xFC, 0x70, 0x20, 0x00, 0x1C, 0x7E, 0xFF, 0x67, 0x07, 0x07, 0x0F,
  0x0E, 0x1E, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x3C, 0x3C, 0x38, 0x03, 0x80,
  0x1F, 0xE0, 0x79, 0xE1, 0xC0, 0xE7, 0x00, 0xCC, 0xFD, 0xF9, 0xF9, 0xF7,
  0x33, 0xCC, 0x67, 0x99, 0xCF, 0x33, 0x9E, 0x77, 0x3E, 0xFF, 0xDC, 0xF7,
  0x98, 0x00, 0x38, 0x00, 0x3C, 0x30, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x07, 0x3C, 0x39,
  0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0x8F, 0x38, 0x7B, 0xC1, 0xDE, 0x0F,
  0xFF, 0x9F, 0xFB, 0xCF, 0x78, 0xEF, 0x1D, 0xE7, 0xBF, 0xE7, 0xF8, 0xFF,
  0xDE, 0x3B, 0xC7, 0x78, 0xFF, 0x1D, 0xFF, 0xBF, 0xE7, 0xF8, 0x06, 0x07,
  0xF3, 0xF9, 0xF6, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1E, 0x17, 0xF8, 0xFE, 0x1F, 0x80, 0xFF, 0x1F, 0xF3, 0xFF,
  0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x3D, 0xFF, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x07, 0x83, 0xFC, 0xFF, 0xBE, 0x67, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0x7F, 0x0E, 0xF1, 0xDF, 0xF9, 0xFF,
  0x1F, 0xC0, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0xFF,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x3C, 0xFF, 0xBE, 0xF0, 0xF1, 0xFE, 0x3B, 0xCF, 0x7B, 0xCF, 0x79, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF3, 0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xBC,
  0x7F, 0x8F, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF7, 0x6F,
  0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0x77, 0xF7, 0x7F, 0x7F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0x0F, 0x03, 0xFC, 0x7F, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xFE, 0xFF, 0xBF, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x0F, 0x03, 0xFC, 0x7F, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF,
  0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0xFC, 0xFF, 0x1F, 0xE3, 0xDE, 0x7B,
  0xCF, 0x3D, 0xE7, 0xBC, 0x77, 0x8F, 0x1C, 0x7F, 0xFF, 0xFF, 0xE1, 0xE0,
  0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x07, 0x07, 0x87, 0xFF, 0xFE, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7,
  0x1E, 0xFF, 0x9F, 0xF0, 0xFC, 0xF0, 0x7F, 0x0F, 0x70, 0xE7, 0x0E, 0x78,
  0xE7, 0x9E, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0xDC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xE1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x39,
  0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0xF9, 0xE7, 0x3F, 0x79, 0xEF, 0xDC, 0x3B,
  0x77, 0x0E, 0xCD, 0xC3, 0xF3, 0x70, 0xFC, 0xDC, 0x3F, 0x3E, 0x07, 0x8F,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0xF1, 0xEF, 0x38, 0xEF, 0x1D, 0xC3, 0xF8,
  0x3E, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xFE, 0x1D, 0xC3, 0xBC, 0xF3,
  0x9C, 0x7F, 0x8F, 0xF0, 0xEE, 0x3D, 0xE7, 0x1C, 0xE3, 0xBC, 0x7F, 0x07,
  0xE0, 0xF8, 0x1F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF,
  0xFC, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF,
  0xFC, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0x9C, 0x39, 0xC3,
  0x8E, 0x70, 0xEF, 0x07, 0xFF, 0xFF, 0xF0, 0xF1, 0xC3, 0x87, 0x3E, 0x3F,
  0x9F, 0xC8, 0xF0, 0x79, 0xFF, 0xFF, 0xEF, 0xE7, 0xF3, 0xFF, 0xFF, 0xF7,
  0xB8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF7, 0x3B, 0xEF, 0xFB, 0xCF, 0xF3,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0xFB, 0xFE, 0xEF, 0x00, 0x1E,
  0x7F, 0x7F, 0xF2, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF1, 0xFF, 0x7F, 0x3E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x3B, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0x1C, 0x3F,
  0x9F, 0xDC, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x3E, 0xEF, 0xF3,
  0xF0, 0x0C, 0x3F, 0x3E, 0x39, 0x38, 0x7E, 0xFE, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0xDF, 0xFF, 0xFF, 0xCF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3B, 0xC0,
  0xE0, 0x3B, 0x1E, 0xFF, 0x3F, 0xC1, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xE7, 0x3B, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0x6F, 0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0xF3, 0xC6, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xBB, 0xEF, 0x90, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x1D, 0xE7, 0xBC, 0xE7, 0xB8, 0xFF, 0x1D, 0xC3, 0xF8, 0x7F,
  0x8F, 0x71, 0xEF, 0x3C, 0xE7, 0x9E, 0xF1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x1D, 0xDF, 0x7F, 0xFF, 0xFF, 0x9E,
  0x7F, 0x3C, 0xFE, 0x79, 0xFC, 0xE3, 0xF9, 0xC7, 0xF3, 0x8F, 0xE7, 0x1F,
  0xCE, 0x3F, 0x9C, 0x7F, 0x38, 0xE0, 0xE7, 0x3B, 0xEF, 0xFB, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0x1E,
  0x1F, 0xC7, 0xFB, 0xCE, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0xE7,
  0xF9, 0xFC, 0x3E, 0x00, 0xE7, 0x3B, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0xFB, 0xBE, 0xFF, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x39, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3B, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0xE7, 0xDF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x00, 0x3D, 0xFF, 0xFF, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFF, 0xC0, 0x38, 0x70, 0xFF, 0xFF, 0xEF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE1, 0xC3, 0xE7, 0xC7, 0x80, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xF7, 0x3D, 0xC0, 0xF1,
  0xFE, 0x39, 0xC7, 0x38, 0xE7, 0x3C, 0xF7, 0x0E, 0xE1, 0xDC, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0xE3, 0xC7, 0xF3, 0xC7, 0x73, 0xCF, 0x73,
  0xEE, 0x77, 0xEE, 0x77, 0xEE, 0x7F, 0x6E, 0x3E, 0x6E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0xF3, 0xDC, 0xF7, 0xB8, 0xFE,
  0x3F, 0x07, 0xC1, 0xE0, 0x7C, 0x3F, 0x0F, 0xE7, 0xB9, 0xCF, 0xF3, 0xC0,
  0xF1, 0xFE, 0x39, 0xC7, 0x39, 0xE7, 0xBC, 0x77, 0x0E, 0xE1, 0xDC, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0x1C, 0x07, 0x83, 0xE0, 0x7C, 0x0F,
  0x00, 0x80, 0x00, 0x7F, 0x7F, 0x7F, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x7F, 0xFF, 0xFF, 0x03, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0xF8, 0xF0, 0xF8, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x81, 0xE3,
  0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x7C, 0x79, 0xF7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF3, 0xC7, 0x8C, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 12, 16, 12, 0, -16 },
  { 40, 9, 18, 11, 1, -17 },
  { 61, 17, 17, 18, 1, -17 },
  { 98, 14, 17, 14, 0, -17 },
  { 128, 4, 6, 6, 1, -16 },
  { 131, 6, 21, 7, 1, -17 },
  { 147, 6, 21, 7, 0, -17 },
  { 163, 10, 10, 11, 0, -18 },
  { 176, 9, 11, 11, 1, -14 },
  { 189, 4, 6, 6, 1, -3 },
  { 192, 6, 3, 7, 1, -8 },
  { 195, 4, 4, 6, 1, -4 },
  { 197, 9, 17, 10, 0, -17 },
  { 217, 9, 17, 11, 1, -17 },
  { 237, 8, 16, 11, 1, -16 },
  { 253, 9, 17, 11, 1, -17 },
  { 273, 9, 17, 11, 1, -17 },
  { 293, 11, 16, 11, 0, -16 },
  { 315, 9, 16, 11, 1, -16 },
  { 333, 9, 17, 11, 1, -17 },
  { 353, 9, 16, 11, 1, -16 },
  { 371, 9, 17, 11, 1, -17 },
  { 391, 9, 17, 11, 1, -17 },
  { 411, 4, 13, 6, 1, -13 },
  { 418, 4, 16, 6, 1, -13 },
  { 426, 9, 11, 11, 1, -14 },
  { 439, 9, 8, 11, 1, -12 },
  { 448, 9, 11, 11, 1, -14 },
  { 461, 8, 17, 9, 0, -17 },
  { 478, 15, 19, 17, 1, -17 },
  { 514, 13, 16, 13, 0, -16 },
  { 540, 11, 16, 12, 1, -16 },
  { 562, 10, 17, 11, 1, -17 },
  { 584, 11, 16, 13, 1, -16 },
  { 606, 8, 16, 10, 1, -16 },
  { 622, 8, 16, 10, 1, -16 },
  { 638, 11, 17, 13, 1, -17 },
  { 662, 11, 16, 14, 1, -16 },
  { 684, 6, 16, 8, 1, -16 },
  { 696, 6, 21, 6, -1, -16 },
  { 712, 11, 16, 12, 1, -16 },
  { 734, 8, 16, 10, 1, -16 },
  { 750, 16, 16, 18, 1, -16 },
  { 782, 12, 16, 15, 1, -16 },
  { 806, 12, 17, 14, 1, -17 },
  { 832, 10, 16, 12, 1, -16 },
  { 852, 12, 21, 14, 1, -17 },
  { 884, 11, 16, 12, 1, -16 },
  { 906, 8, 17, 10, 1, -17 },
  { 923, 10, 16, 10, 0, -16 },
  { 943, 11, 16, 13, 1, -16 },
  { 965, 12, 16, 12, 0, -16 },
  { 989, 18, 16, 18, 0, -16 },
  { 1025, 11, 16, 11, 0, -16 },
  { 1047, 11, 16, 11, 0, -16 },
  { 1069, 10, 16, 10, 0, -16 },
  { 1089, 6, 21, 7, 1, -17 },
  { 1105, 9, 17, 10, 0, -17 },
  { 1125, 6, 21, 7, 0, -17 },
  { 1141, 12, 10, 12, 0, -16 },
  { 1156, 10, 2, 10, 0, 2 },
  { 1159, 6, 4, 7, 1, -18 },
  { 1162, 9, 13, 11, 1, -13 },
  { 1177, 10, 17, 12, 1, -17 },
  { 1199, 8, 13, 10, 1, -13 },
  { 1212, 10, 17, 12, 1, -17 },
  { 1234, 9, 13, 11, 1, -13 },
  { 1249, 8, 18, 7, 0, -18 },
  { 1267, 10, 19, 12, 1, -13 },
  { 1291, 10, 17, 12, 1, -17 },
  { 1313, 4, 18, 6, 1, -18 },
  { 1322, 6, 24, 6, -1, -18 },
  { 1340, 11, 17, 12, 1, -17 },
  { 1364, 4, 17, 6, 1, -17 },
  { 1373, 15, 13, 18, 1, -13 },
  { 1398, 10, 13, 12, 1, -13 },
  { 1415, 10, 13, 12, 1, -13 },
  { 1432, 10, 19, 12, 1, -13 },
  { 1456, 10, 19, 12, 1, -13 },
  { 1480, 7, 13, 8, 1, -13 },
  { 1492, 7, 13, 9, 1, -13 },
  { 1504, 7, 15, 8, 0, -15 },
  { 1518, 10, 13, 12, 1, -13 },
  { 1535, 11, 13, 11, 0, -13 },
  { 1553, 16, 13, 16, 0, -13 },
  { 1579, 10, 13, 10, 0, -13 },
  { 1596, 11, 19, 11, 0, -13 },
  { 1623, 8, 13, 9, 0, -13 },
  { 1636, 8, 21, 8, 0, -17 },
  { 1657, 3, 23, 10, 3, -18 },
  { 1666, 7, 21, 8, 1, -17 },
  { 1685, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD23PT7B_H_
