#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x07, 0xEF, 0x83,
  0xE0, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0xF8,
  0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF0, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80,
  0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0x8F, 0x00, 0x3C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xB8, 0xCF, 0xCE, 0x03, 0xF3, 0x80, 0xFC,
  0xE0, 0x3F, 0xB8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xBF, 0x00, 0xEF, 0xE0, 0x3B, 0xFE, 0x0E, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x3F,
  0xFC, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0xF9, 0xF8, 0x3E, 0x00,
  0x3F, 0x1F, 0x07, 0xC0, 0x07, 0xE3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF1, 0xF0, 0x00, 0x7C, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0xF8, 0xF9, 0xF0, 0xFC, 0x1F,
  0x3F, 0x3E, 0x7F, 0xC3, 0xF7, 0xCF, 0x8F, 0xFC, 0x7F, 0xF9, 0xF3, 0xFF,
  0x87, 0xFE, 0x3E, 0x7F, 0xF8, 0x7F, 0x8F, 0x9F, 0x9F, 0x07, 0xE1, 0xF3,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF1, 0xF8, 0x00, 0x7C, 0x3E, 0x3F, 0x00, 0x0F, 0x87, 0xC7, 0xE0,
  0x03, 0xE0, 0xF8, 0xFC, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x0F, 0x83, 0xF3,
  0xE0, 0x03, 0xE0, 0x3E, 0xFC, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x1F, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE1, 0xFE, 0x1F, 0xFC, 0x3F, 0x87, 0xFF, 0xC7, 0xF1,
  0xFF, 0xFC, 0xFE, 0x3F, 0xBF, 0x9F, 0xCF, 0xF7, 0xFF, 0xF1, 0xFC, 0x7F,
  0xFE, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0x7F, 0xF0, 0xFE, 0x0F, 0xFE, 0x1F,
  0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xFC, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD,
  0xF3, 0xE0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0xFE, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x04, 0x1F, 0x04, 0xE3, 0xE3, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0x7E, 0x07, 0xEF, 0xC3, 0xF8, 0xFE, 0x3F, 0x1F, 0x81,
  0xC1, 0xE0, 0x18, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x9F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xFB, 0xF8, 0x7E, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xE7, 0xF3, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFB, 0xF9, 0xE7, 0xF1, 0x8F, 0xE2, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0x07, 0xF1, 0xC0, 0xFE, 0x10, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8E, 0x07, 0xF0, 0x80, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF8, 0x0F, 0xBF, 0x80, 0xFB, 0xF8, 0x1F,
  0x3F, 0x81, 0xF3, 0xF8, 0x3E, 0x3F, 0x83, 0xE3, 0xF8, 0x7C, 0x3F, 0x87,
  0xC3, 0xF8, 0xF8, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE1, 0x80, 0x7E, 0x7F, 0x07, 0xEF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0xFF,
  0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7,
  0xE0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x8F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF9, 0xFC, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF9, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFB, 0xFC, 0x7F, 0x1F,
  0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xF0, 0xFE, 0x7E, 0x0F, 0x8F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x10,
  0x7F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x0C, 0x1F, 0x8F, 0xEF, 0xF7, 0xF9, 0xFC,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE, 0x40, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x03,
  0xE0, 0xF8, 0xF8, 0x3F, 0xF3, 0xE7, 0xC3, 0xFF, 0xC7, 0xDF, 0x0F, 0xFF,
  0x1F, 0xF8, 0x7E, 0x7C, 0x7F, 0xE1, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xC3,
  0xFE, 0x3E, 0x1F, 0x0F, 0xF8, 0xF8, 0x7C, 0x3F, 0xE3, 0xE1, 0xF0, 0xFF,
  0x8F, 0x87, 0xC3, 0xFE, 0x3E, 0x1F, 0x0F, 0xF8, 0xF8, 0x7C, 0x7F, 0xE3,
  0xE3, 0xF1, 0xFF, 0x8F, 0x8F, 0xC7, 0xBE, 0x3F, 0x7F, 0x3E, 0xF8, 0x7F,
  0xDF, 0xFB, 0xE1, 0xFF, 0x7F, 0xC7, 0xC3, 0xF8, 0xFE, 0x1F, 0x03, 0xC0,
  0xE0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x08,
  0x07, 0xF0, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFE, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xC0, 0xC7,
  0xF8, 0x04, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x02, 0x3F,
  0xC0, 0x63, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8, 0xFF, 0xDF,
  0xC1, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x7F, 0xBF, 0x8F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0x03, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x07, 0xF3,
  0xFC, 0x1F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF,
  0xE0, 0x7F, 0xBF, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0,
  0x3F, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x7F, 0x03, 0xF9, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFC, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0x03, 0xFF, 0xFF, 0x7C, 0x0F, 0xBF,
  0xFD, 0xF8, 0x7E, 0xFF, 0xF7, 0xE1, 0xFB, 0xFF, 0xCF, 0x87, 0xCF, 0xFF,
  0x3E, 0x1F, 0x3F, 0xFC, 0xFC, 0xFC, 0xFF, 0xF3, 0xF3, 0xF3, 0xFF, 0xC7,
  0xCF, 0x8F, 0xFF, 0x1F, 0x3E, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F,
  0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFD, 0xF8, 0x7F, 0xFD, 0xFC,
  0x7F, 0xFC, 0xFC, 0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0x7E, 0x7F, 0xFC, 0x7E,
  0x7F, 0xFC, 0x7F, 0x7F, 0xFC, 0x3F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0x8F, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xF7, 0xF3, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xF8, 0xFF, 0x9F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3,
  0xF8, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFE,
  0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xF8, 0xF1, 0xFC, 0x04, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0,
  0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x7E, 0x03, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x07, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7F, 0xC1, 0xFC, 0x3F, 0x07, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0xE1, 0xFC,
  0x3F, 0x8F, 0xFE, 0x1F, 0xC3, 0xF8, 0xFB, 0xE1, 0xF8, 0x3F, 0x8F, 0xBE,
  0x3F, 0x81, 0xF8, 0xFB, 0xF3, 0xF8, 0x1F, 0x8F, 0x9F, 0x3F, 0x81, 0xFD,
  0xF9, 0xF3, 0xF8, 0x1F, 0xDF, 0x9F, 0x3F, 0x01, 0xFD, 0xF9, 0xF3, 0xF0,
  0x0F, 0xDF, 0x1F, 0x7F, 0x00, 0xFD, 0xF1, 0xFF, 0xF0, 0x0F, 0xDF, 0x0F,
  0xFF, 0x00, 0xFD, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x03, 0xFC, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x1F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFB, 0xFB, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xBF, 0x3F, 0xE7, 0xE3, 0xF8,
  0x7C, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE1, 0xC0, 0xFE, 0x7F, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xEF, 0xF9, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xCF, 0xF8, 0xFC, 0x7F, 0x00, 0x00, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x06, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x02, 0x7F, 0x8E, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xE1, 0xFC, 0x7F, 0x3F, 0x9F,
  0xF3, 0xF3, 0xFF, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x3F, 0xF7, 0xE3, 0xFE, 0xFC, 0x3F, 0x0F, 0x80, 0x01, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xE1,
  0xFB, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x02, 0x7F, 0x03, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0xFC, 0xFC, 0xFF,
  0xDF, 0x9F, 0xFB, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF9, 0xFF, 0xBF, 0x1F, 0xEF, 0xE1, 0xF9, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x98, 0x07, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC3, 0x83, 0xF9, 0xFC,
  0x7F, 0x7F, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x80, 0x7C, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7,
  0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFD, 0xFC, 0x0F, 0xDF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x03, 0xC1,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF3, 0xFF, 0x7F, 0xE7, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xFE, 0x7F, 0xFF,
  0x87, 0xF8, 0x7F, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F,
  0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8,
  0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFC, 0x00, 0x1C, 0x1F, 0x8F, 0xE3, 0xF3, 0xFE, 0x7E, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xF7, 0xF1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x0F, 0xC7, 0xF0, 0xFC, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0,
  0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0x9F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xEF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE7, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFB, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xBF, 0x1F,
  0xEF, 0xE1, 0xF9, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xBF, 0x83, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xCC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xFC,
  0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0x9F, 0x0F, 0xE3, 0xE0, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xF0,
  0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0x80,
  0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x7F, 0x7E, 0x0F, 0xF8, 0x7F, 0x7F, 0x0F,
  0xF8, 0x7E, 0x7F, 0x0F, 0xF8, 0x7E, 0x7F, 0x1F, 0xF8, 0x7E, 0x3F, 0x1F,
  0xF8, 0xFE, 0x3F, 0x1F, 0x78, 0xFE, 0x3F, 0x9F, 0x7C, 0xFC, 0x3F, 0x9E,
  0x7C, 0xFC, 0x1F, 0x9E, 0x7C, 0xFC, 0x1F, 0xBE, 0x7D, 0xFC, 0x1F, 0xBE,
  0x7D, 0xF8, 0x1F, 0xBE, 0x3D, 0xF8, 0x1F, 0xBE, 0x3D, 0xF8, 0x0F, 0xBE,
  0x3D, 0xF8, 0x0F, 0xBC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0xFF, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC,
  0x1F, 0x9F, 0xC1, 0xFD, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xDF, 0x81, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87,
  0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x00, 0x80, 0x00, 0x3F, 0x80, 0x17, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xE8, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 34, 12, 2, -33 },
  { 35, 17, 12, 21, 2, -33 },
  { 61, 22, 33, 24, 1, -33 },
  { 152, 18, 38, 22, 2, -35 },
  { 238, 35, 33, 37, 1, -33 },
  { 383, 27, 33, 27, 1, -33 },
  { 495, 7, 12, 11, 2, -33 },
  { 506, 12, 40, 15, 2, -33 },
  { 566, 13, 40, 15, 0, -33 },
  { 631, 19, 19, 21, 1, -35 },
  { 677, 20, 22, 22, 1, -27 },
  { 732, 9, 12, 12, 1, -6 },
  { 746, 12, 7, 14, 1, -16 },
  { 757, 8, 9, 12, 2, -8 },
  { 766, 19, 33, 19, 0, -33 },
  { 845, 18, 33, 22, 2, -33 },
  { 920, 15, 33, 22, 2, -33 },
  { 982, 19, 33, 22, 1, -33 },
  { 1061, 19, 33, 22, 1, -33 },
  { 1140, 20, 33, 22, 1, -33 },
  { 1223, 18, 33, 22, 2, -33 },
  { 1298, 20, 33, 22, 1, -33 },
  { 1381, 19, 33, 22, 1, -33 },
  { 1460, 20, 33, 22, 1, -33 },
  { 1543, 19, 33, 22, 1, -33 },
  { 1622, 8, 27, 12, 2, -26 },
  { 1649, 9, 32, 12, 1, -26 },
  { 1685, 20, 23, 22, 1, -28 },
  { 1743, 20, 15, 22, 1, -24 },
  { 1781, 20, 23, 22, 1, -28 },
  { 1839, 17, 34, 18, 0, -33 },
  { 1912, 30, 37, 34, 2, -33 },
  { 2051, 25, 33, 25, 0, -33 },
  { 2155, 20, 33, 25, 3, -33 },
  { 2238, 20, 33, 23, 2, -33 },
  { 2321, 21, 33, 26, 3, -33 },
  { 2408, 15, 33, 20, 3, -33 },
  { 2470, 15, 33, 20, 3, -33 },
  { 2532, 22, 33, 27, 2, -33 },
  { 2623, 22, 33, 28, 3, -33 },
  { 2714, 13, 33, 15, 1, -33 },
  { 2768, 13, 43, 13, -3, -33 },
  { 2838, 22, 33, 24, 3, -33 },
  { 2929, 15, 33, 19, 3, -33 },
  { 2991, 30, 33, 36, 3, -33 },
  { 3115, 24, 33, 30, 3, -33 },
  { 3214, 24, 33, 28, 2, -33 },
  { 3313, 19, 33, 23, 3, -33 },
  { 3392, 24, 41, 28, 2, -33 },
  { 3515, 21, 33, 24, 3, -33 },
  { 3602, 18, 33, 20, 1, -33 },
  { 3677, 19, 33, 20, 1, -33 },
  { 3756, 21, 33, 27, 3, -33 },
  { 3843, 24, 33, 24, 0, -33 },
  { 3942, 36, 33, 36, 0, -33 },
  { 4091, 23, 33, 23, 0, -33 },
  { 4186, 23, 33, 23, 0, -33 },
  { 4281, 18, 33, 20, 1, -33 },
  { 4356, 11, 41, 14, 2, -33 },
  { 4413, 19, 33, 19, 0, -33 },
  { 4492, 11, 41, 14, 1, -33 },
  { 4549, 23, 21, 25, 1, -33 },
  { 4610, 21, 4, 21, 0, 4 },
  { 4621, 11, 7, 15, 2, -35 },
  { 4631, 19, 26, 22, 1, -26 },
  { 4693, 20, 35, 24, 2, -35 },
  { 4781, 16, 26, 19, 2, -26 },
  { 4833, 19, 35, 24, 2, -35 },
  { 4917, 18, 26, 22, 2, -26 },
  { 4976, 16, 35, 14, 0, -35 },
  { 5046, 19, 37, 24, 2, -26 },
  { 5134, 19, 35, 24, 2, -35 },
  { 5218, 7, 35, 12, 2, -35 },
  { 5249, 11, 46, 12, -2, -35 },
  { 5313, 20, 35, 23, 3, -35 },
  { 5401, 7, 35, 12, 2, -35 },
  { 5432, 31, 26, 35, 2, -26 },
  { 5533, 19, 26, 24, 2, -26 },
  { 5595, 19, 26, 23, 2, -26 },
  { 5657, 20, 37, 24, 2, -26 },
  { 5750, 19, 37, 24, 2, -26 },
  { 5838, 14, 26, 17, 2, -26 },
  { 5884, 15, 26, 18, 1, -26 },
  { 5933, 15, 31, 16, 0, -31 },
  { 5992, 19, 25, 24, 2, -25 },
  { 6052, 21, 25, 21, 0, -25 },
  { 6118, 32, 25, 32, 0, -25 },
  { 6218, 20, 25, 21, 0, -25 },
  { 6281, 21, 36, 21, 0, -25 },
  { 6376, 16, 25, 17, 1, -25 },
  { 6426, 15, 41, 16, 0, -33 },
  { 6503, 6, 46, 20, 7, -35 },
  { 6538, 15, 41, 16, 1, -33 },
  { 6615, 20, 8, 22, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD46PT7B_H_
