#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xA0, 0x7F, 0xE0, 0x5F, 0x3C, 0xF7, 0x8E, 0xB0, 0xE4, 0xEF,
  0x80, 0x6A, 0x40, 0x95, 0x80, 0x5F, 0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xA0, 0xD5, 0xE9, 0x70, 0xE8, 0xE0, 0x4B, 0xA0, 0xD8, 0xE0,
  0xDA, 0xE0, 0xE9, 0x60, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xDB, 0x7F, 0xFE, 0x4F, 0xD0, 0xFE, 0xF0, 0x72, 0x30,
  0xF6, 0xF0, 0xFB, 0xFA, 0x72, 0xB0, 0xBE, 0xD0, 0xEB, 0xF8, 0xBA, 0xD0,
  0xAB, 0xDD, 0xBB, 0xFE, 0xD0, 0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB2, 0xF7,
  0x50, 0xF7, 0xE9, 0x20, 0xB6, 0xB0, 0xB5, 0x20, 0xAD, 0x94, 0xA0, 0xA9,
  0x50, 0xA9, 0x20, 0xCA, 0x70, 0xEA, 0xC0, 0x95, 0xD5, 0xC0, 0x54, 0xE0,
  0xC0, 0xFF, 0x80, 0x93, 0xDE, 0xEC, 0x27, 0xDE, 0xFF, 0x00, 0x6E, 0x80,
  0xF7, 0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x92, 0xEA, 0xF8, 0xFB, 0xB0, 0xF6,
  0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xBB, 0xB7, 0x80,
  0xA9, 0x00, 0xFF, 0x70, 0xEB, 0x80, 0xA9, 0x60, 0xDC, 0x59, 0x40, 0xFC,
  0x95, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 4, 4, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 2, 4, 3, 0, -4 },
  { 63, 2, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 1, 5, 2, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 2, 4, 3, 0, -4 },
  { 73, 4, 4, 5, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 5, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 2, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 5, 4, 5, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 2, 4, 2, 0, -4 },
  { 104, 2, 5, 2, 0, -4 },
  { 106, 3, 2, 3, 0, -4 },
  { 107, 3, 1, 3, 0, 0 },
  { 108, 2, 1, 2, 0, -5 },
  { 109, 3, 3, 3, 0, -3 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 2, 3, 2, 0, -3 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 2, 5, 2, 0, -5 },
  { 120, 3, 4, 3, 0, -3 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 1, 5, 2, 0, -5 },
  { 125, 1, 6, 2, 0, -5 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 1, 5, 2, 0, -5 },
  { 129, 4, 3, 5, 0, -3 },
  { 131, 3, 3, 3, 0, -3 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 4, 3, 0, -3 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 2, 3, 2, 0, -3 },
  { 140, 2, 3, 2, 0, -3 },
  { 141, 2, 4, 2, 0, -4 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 4, 3, 4, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 4, 3, 0, -3 },
  { 152, 2, 3, 2, 0, -3 },
  { 153, 2, 5, 2, 0, -4 },
  { 155, 1, 6, 3, 1, -5 },
  { 156, 2, 5, 2, 0, -4 },
  { 158, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD6PT7B_H_
