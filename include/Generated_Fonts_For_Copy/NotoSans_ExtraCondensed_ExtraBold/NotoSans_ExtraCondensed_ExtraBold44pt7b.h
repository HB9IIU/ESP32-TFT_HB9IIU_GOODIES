#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x7E, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF8, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0,
  0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00,
  0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F,
  0x00, 0xF8, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF,
  0x81, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0xFD, 0xC7, 0x7E,
  0xE0, 0xBF, 0x70, 0x1F, 0xB8, 0x0F, 0xDC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0E, 0xFC, 0x07, 0x3F, 0x03, 0x9F, 0xC1, 0xCF, 0xF8, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xFE, 0x03,
  0xE0, 0x07, 0xFF, 0x01, 0xF0, 0x03, 0xE7, 0xC1, 0xF0, 0x03, 0xE3, 0xE0,
  0xF8, 0x01, 0xF1, 0xF0, 0x78, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x7C, 0x7C,
  0x3E, 0x00, 0x3E, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x8F, 0x80, 0x07, 0xC7, 0xCF, 0x8F, 0xE1, 0xF3, 0xE7, 0xCF, 0xF8, 0xFF,
  0xF3, 0xCF, 0xFC, 0x7F, 0xF3, 0xE7, 0xFF, 0x1F, 0xF1, 0xF3, 0xEF, 0x87,
  0xF9, 0xF3, 0xE3, 0xE0, 0xF0, 0xF9, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x1F,
  0x00, 0x1F, 0x0F, 0x8F, 0x80, 0x0F, 0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xE3,
  0xE0, 0x07, 0xC0, 0xFB, 0xE0, 0x07, 0xC0, 0x7F, 0xF0, 0x03, 0xE0, 0x1F,
  0xF8, 0x01, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7E, 0x1F,
  0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x9F, 0xFF, 0x9F, 0xCF, 0xEF, 0xEF, 0xCF,
  0xE7, 0xFF, 0xE7, 0xF1, 0xFF, 0xF3, 0xF8, 0x7F, 0xF1, 0xFC, 0x3F, 0xF8,
  0xFE, 0x0F, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xE7, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFC, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF0, 0x03,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x18, 0x78, 0x67, 0xDE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xF3, 0xF1, 0xFC, 0xFE, 0x3E, 0x1F, 0x03,
  0x87, 0x80, 0x40, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x80,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7F, 0x1F, 0xDF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x1F, 0xCF, 0xC7, 0xE3, 0xFB,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xCF, 0xCE, 0x3F, 0x10, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xC3, 0xF8, 0xE0,
  0x7E, 0x10, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x83, 0xF8, 0x40,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81,
  0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE3, 0xE0, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFE, 0x31, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xF8, 0x7F, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x0C, 0x07, 0xEF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x7F, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE3, 0xFB, 0xF8, 0x3F,
  0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F,
  0x7E, 0x0F, 0xCF, 0xE3, 0xF8, 0xFE, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F,
  0xC7, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x7F, 0x1F,
  0xDF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0xFC,
  0x1F, 0xBF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8,
  0x7F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xC7, 0xE3, 0xF0, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x1F, 0xFF, 0x87,
  0xFB, 0xF9, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xF7,
  0xE0, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF1, 0x03, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x10, 0x7E, 0x7E, 0xFF, 0xFF, 0xFE, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x04, 0x1F, 0x8F, 0xCF, 0xF7, 0xFB,
  0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xE3, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x38, 0x7F, 0x20,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x07, 0xC1, 0xF3, 0xE0, 0xFF,
  0xCF, 0x9F, 0x0F, 0xFE, 0x3C, 0xF0, 0xFF, 0xF1, 0xFF, 0x8F, 0xCF, 0x8F,
  0xFC, 0x7C, 0x7C, 0x7F, 0xE3, 0xE3, 0xE3, 0xFE, 0x3E, 0x1F, 0x0F, 0xF1,
  0xF0, 0xF8, 0xFF, 0x8F, 0x87, 0xC7, 0xFC, 0x7C, 0x3E, 0x3F, 0xE3, 0xE1,
  0xF1, 0xFF, 0x1F, 0x0F, 0x8F, 0xF8, 0xF8, 0x7C, 0x7B, 0xE3, 0xE7, 0xE7,
  0xDF, 0x1F, 0xFF, 0xFC, 0xF8, 0x7F, 0xBF, 0xE7, 0xC3, 0xFC, 0xFE, 0x1F,
  0x07, 0x83, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x18, 0x01, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x7F, 0xBF, 0x07, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x1F, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0x8F, 0xFB,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0x63,
  0xFC, 0x04, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x18, 0xFF, 0x8F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xC7, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xC1, 0xFE, 0xFC,
  0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0x81, 0x8F, 0xF0, 0x04, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xFC, 0x1F, 0xCF, 0xF9, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x9F, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0xFF, 0x8F, 0xF0, 0x20, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF,
  0x03, 0xF9, 0xF8, 0x3F, 0xCF, 0xC1, 0xFC, 0x7E, 0x1F, 0xE3, 0xF0, 0xFE,
  0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xFB,
  0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7,
  0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFF, 0x7E, 0x03,
  0xFB, 0xF0, 0x1F, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xEF, 0xFF, 0xFC, 0x1F, 0x7F, 0xFB, 0xE0, 0xFB, 0xFF, 0xDF,
  0x0F, 0xDF, 0xFE, 0xFC, 0x7C, 0xFF, 0xF7, 0xE3, 0xEF, 0xFF, 0x9F, 0x1F,
  0x7F, 0xFC, 0xF9, 0xF3, 0xFF, 0xE7, 0xEF, 0x9F, 0xFF, 0x3F, 0x7C, 0xFF,
  0xF8, 0xFF, 0xE7, 0xFF, 0xC7, 0xFE, 0x3F, 0xFE, 0x3F, 0xF1, 0xFF, 0xF1,
  0xFF, 0x8F, 0xFF, 0x87, 0xFC, 0x7F, 0xFC, 0x3F, 0xC3, 0xFF, 0xE1, 0xFE,
  0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFE, 0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFD, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xCF,
  0xCF, 0xFF, 0x3F, 0x3F, 0xFC, 0x7E, 0xFF, 0xF1, 0xFB, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFD,
  0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x07,
  0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x1F, 0xEF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x07, 0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC7, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0xCF, 0xC7, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F,
  0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF,
  0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFE, 0x7C, 0xFE, 0x04, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF,
  0xFB, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0x7F, 0x7E, 0x07, 0xF8, 0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE7, 0xE0,
  0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0x07, 0xFC, 0x3F, 0x8F,
  0xC3, 0xFF, 0x0F, 0xE3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0xF0, 0xFC,
  0x3F, 0x0F, 0xFC, 0x7F, 0x0F, 0xE7, 0xEF, 0x1F, 0xC1, 0xF9, 0xF3, 0xE7,
  0xF0, 0x7E, 0x7C, 0xF9, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07, 0xE7, 0xCF,
  0x9F, 0x81, 0xF9, 0xF3, 0xEF, 0xE0, 0x3F, 0xFC, 0x7B, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF9,
  0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F,
  0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xFC,
  0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7F, 0x0F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFC, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x0F,
  0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x00, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0x81,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFE,
  0xFC, 0xFF, 0x9F, 0x1F, 0x87, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x18, 0x1F, 0xCF, 0xC3, 0xFB, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xC7, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x7F, 0x8F,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0x7F, 0xE7, 0xE7, 0xF8, 0xFC, 0x7E,
  0x00, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0x86, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x01, 0x7F, 0x87, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0x07,
  0xE1, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xC7, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xC1, 0xFD, 0xFC, 0x3F, 0xBF, 0x8F, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xBF, 0x0F, 0xE3, 0xE0, 0x00, 0x40,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xEF, 0xE7,
  0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x05, 0xFC, 0x06, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x01,
  0x80, 0x01, 0xFC, 0x7C, 0x7F, 0xDF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDF, 0xC7, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8,
  0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xFD, 0xFC, 0x3F, 0xBF, 0xCF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFD, 0xF8, 0xFF, 0xBF, 0x0F, 0xE7, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF4, 0x00, 0xFE, 0x60, 0x3F, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x40,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x38, 0x3F, 0xBF, 0x8F,
  0xDF, 0xF3, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xC0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03,
  0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFE,
  0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0x60, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x0F, 0xE3, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x18, 0x03, 0x87, 0xE7, 0xF8, 0xFF, 0x3F, 0x7F, 0xEF, 0xFD, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xCF,
  0xFF, 0xC3, 0xFC, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF,
  0x83, 0xF0, 0x7F, 0xFC, 0x1F, 0x83, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x07,
  0xE0, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xC1, 0xF8, 0x3F, 0xFE, 0x0F, 0xC1,
  0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x1F, 0x83, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFE, 0x0F, 0xC1, 0xF8, 0x00, 0x38, 0x3F, 0x3F, 0xCF, 0xDF,
  0xFB, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFE, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xF7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7F, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x1F, 0x8F, 0xC3, 0xF3,
  0xFC, 0x7E, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC7, 0xF7, 0xF0,
  0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0x7F, 0x8F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xF7, 0xF8, 0xFE, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFC,
  0x7C, 0x7F, 0xDF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xC7,
  0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xEF, 0xC1, 0xFD, 0xFC, 0x3F, 0xBF, 0xCF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFD, 0xF8, 0xFF, 0xBF, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F,
  0xC3, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0x3F, 0x02, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC,
  0x7F, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF1, 0x1F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xF3, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD, 0xF3, 0xFE, 0x7C, 0x7F, 0x1F, 0xFE,
  0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x07, 0xE3,
  0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xDF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFE, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x7F, 0xC3, 0xF3, 0xF0,
  0xFF, 0x87, 0xE7, 0xE1, 0xFF, 0x0F, 0xCF, 0xE3, 0xFE, 0x3F, 0x8F, 0xC7,
  0xBC, 0x7E, 0x1F, 0x8F, 0x7C, 0xFC, 0x3F, 0x3E, 0xF9, 0xF8, 0x7E, 0x7D,
  0xF3, 0xF0, 0x7E, 0xFB, 0xE7, 0xE0, 0xFD, 0xE3, 0xDF, 0x81, 0xFB, 0xC7,
  0xBF, 0x03, 0xF7, 0x8F, 0x7E, 0x07, 0xFF, 0x1E, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xEF, 0xE1,
  0xFC, 0xFC, 0x7F, 0x1F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x7F, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xF7, 0xF0, 0x7E, 0xFE, 0x1F, 0xCF, 0xC3, 0xF1, 0xFC, 0xFE, 0x1F,
  0x9F, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xF7, 0xF0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F,
  0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x2F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 31, 12, 2, -31 },
  { 32, 16, 11, 20, 2, -31 },
  { 54, 21, 31, 23, 1, -31 },
  { 136, 17, 36, 21, 2, -33 },
  { 213, 33, 32, 35, 1, -32 },
  { 345, 25, 32, 26, 1, -32 },
  { 445, 7, 11, 11, 2, -31 },
  { 455, 12, 39, 14, 2, -32 },
  { 514, 12, 39, 14, 0, -32 },
  { 573, 18, 19, 20, 1, -34 },
  { 616, 19, 21, 21, 1, -26 },
  { 666, 9, 12, 11, 1, -6 },
  { 680, 12, 6, 14, 1, -15 },
  { 689, 7, 7, 12, 2, -7 },
  { 696, 18, 32, 18, 0, -32 },
  { 768, 18, 32, 21, 1, -32 },
  { 840, 14, 31, 21, 2, -31 },
  { 895, 18, 32, 21, 1, -32 },
  { 967, 18, 32, 21, 1, -32 },
  { 1039, 19, 31, 21, 1, -31 },
  { 1113, 17, 31, 21, 2, -31 },
  { 1179, 19, 32, 21, 1, -32 },
  { 1255, 19, 31, 21, 1, -31 },
  { 1329, 19, 32, 21, 1, -32 },
  { 1405, 19, 32, 21, 1, -32 },
  { 1481, 8, 25, 12, 2, -25 },
  { 1506, 9, 31, 12, 1, -25 },
  { 1541, 19, 21, 21, 1, -26 },
  { 1591, 19, 15, 21, 1, -23 },
  { 1627, 19, 21, 21, 1, -26 },
  { 1677, 16, 32, 17, 0, -32 },
  { 1741, 29, 35, 33, 2, -32 },
  { 1868, 24, 31, 24, 0, -31 },
  { 1961, 19, 31, 24, 3, -31 },
  { 2035, 19, 32, 22, 2, -32 },
  { 2111, 20, 31, 25, 3, -31 },
  { 2189, 14, 31, 19, 3, -31 },
  { 2244, 14, 31, 19, 3, -31 },
  { 2299, 21, 32, 25, 2, -32 },
  { 2383, 20, 31, 26, 3, -31 },
  { 2461, 13, 31, 15, 1, -31 },
  { 2512, 12, 41, 12, -2, -31 },
  { 2574, 21, 31, 23, 3, -31 },
  { 2656, 15, 31, 18, 3, -31 },
  { 2715, 29, 31, 35, 3, -31 },
  { 2828, 22, 31, 28, 3, -31 },
  { 2914, 23, 32, 27, 2, -32 },
  { 3006, 18, 31, 22, 3, -31 },
  { 3076, 23, 39, 27, 2, -32 },
  { 3189, 20, 31, 23, 3, -31 },
  { 3267, 17, 32, 19, 1, -32 },
  { 3335, 18, 31, 19, 1, -31 },
  { 3405, 20, 31, 25, 3, -31 },
  { 3483, 23, 31, 23, 0, -31 },
  { 3573, 34, 31, 34, 0, -31 },
  { 3705, 22, 31, 22, 0, -31 },
  { 3791, 22, 31, 22, 0, -31 },
  { 3877, 18, 31, 19, 1, -31 },
  { 3947, 11, 39, 14, 2, -32 },
  { 4001, 18, 32, 18, 0, -32 },
  { 4073, 10, 39, 14, 1, -32 },
  { 4122, 22, 20, 24, 1, -31 },
  { 4177, 20, 4, 20, 0, 3 },
  { 4187, 11, 7, 14, 2, -34 },
  { 4197, 18, 25, 21, 1, -25 },
  { 4254, 19, 33, 22, 2, -33 },
  { 4333, 16, 25, 18, 1, -25 },
  { 4383, 19, 33, 22, 1, -33 },
  { 4462, 18, 25, 21, 1, -25 },
  { 4519, 15, 34, 14, 0, -34 },
  { 4583, 19, 36, 22, 1, -25 },
  { 4669, 18, 33, 23, 2, -33 },
  { 4744, 7, 34, 11, 2, -34 },
  { 4774, 10, 45, 11, -1, -34 },
  { 4831, 20, 33, 22, 2, -33 },
  { 4914, 7, 33, 11, 2, -33 },
  { 4943, 29, 25, 34, 2, -25 },
  { 5034, 18, 25, 23, 2, -25 },
  { 5091, 20, 25, 22, 1, -25 },
  { 5154, 19, 36, 22, 2, -25 },
  { 5240, 19, 36, 22, 1, -25 },
  { 5326, 13, 25, 16, 2, -25 },
  { 5367, 15, 25, 17, 1, -25 },
  { 5414, 14, 29, 15, 0, -29 },
  { 5465, 18, 24, 23, 2, -24 },
  { 5519, 20, 24, 21, 0, -24 },
  { 5579, 31, 24, 31, 0, -24 },
  { 5672, 19, 24, 20, 0, -24 },
  { 5729, 20, 35, 21, 0, -24 },
  { 5817, 15, 24, 17, 1, -24 },
  { 5862, 14, 39, 16, 0, -32 },
  { 5931, 5, 44, 19, 7, -34 },
  { 5959, 14, 39, 16, 1, -32 },
  { 6028, 19, 7, 21, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD44PT7B_H_
