#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF8, 0x00, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xE0, 0xF9, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF7,
  0xC7, 0x80, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x38, 0xE0, 0x3C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE1, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x79, 0xE1, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x8F, 0x01, 0xC7, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x7C, 0x0F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x3C, 0xC4,
  0xF3, 0x03, 0xCC, 0x0F, 0xB0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x0D, 0xF0, 0x37, 0xE0, 0xDF, 0xC3, 0x7B, 0xEF,
  0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1F, 0x00, 0xF0, 0x07, 0xF0, 0x1E, 0x01, 0xFF, 0x03, 0xC0, 0x3F,
  0xE0, 0xF0, 0x0F, 0x3C, 0x1E, 0x01, 0xE3, 0xC7, 0x80, 0x3C, 0x78, 0xF0,
  0x07, 0x8F, 0x1E, 0x00, 0xF1, 0xE7, 0x80, 0x1E, 0x3C, 0xF0, 0x03, 0xC7,
  0xBC, 0x38, 0x79, 0xE7, 0x9F, 0xC7, 0xFC, 0xF7, 0xFC, 0xFF, 0xBC, 0xFF,
  0x8F, 0xE7, 0x9E, 0xF0, 0xF8, 0xE7, 0x8F, 0x00, 0x3C, 0xF1, 0xE0, 0x07,
  0x9E, 0x3C, 0x01, 0xE3, 0xC7, 0x80, 0x3C, 0x78, 0xF0, 0x07, 0x0F, 0x1E,
  0x01, 0xE0, 0xE3, 0xC0, 0x3C, 0x1E, 0xF0, 0x0F, 0x03, 0xFE, 0x01, 0xE0,
  0x3F, 0x80, 0x78, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0x1F, 0xF1, 0xF1, 0xFF, 0xCF, 0x9F, 0xBF, 0xFC, 0xFD,
  0xFF, 0xE7, 0xC7, 0xFE, 0x3E, 0x1F, 0xF1, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7F, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x87, 0x87,
  0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC3,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x02, 0x3C, 0x6F, 0xFB, 0xDF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xF7, 0xC7,
  0xC7, 0xC3, 0x0E, 0x02, 0x10, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3E, 0x3E, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFD, 0xF1, 0xFB, 0xE3,
  0xE7, 0xC7, 0xCF, 0xDF, 0x8F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0,
  0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xFB,
  0xEE, 0x7C, 0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xC3, 0xF2, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC4, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xFE, 0x3F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xEC, 0x0F, 0xFE, 0x3F, 0xFC,
  0xFF, 0xFB, 0xFF, 0xE4, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x81, 0xFB, 0xCF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE1, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF3, 0xC3, 0xEF, 0xE7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFB, 0xE1, 0xF7, 0xC7, 0xEF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xFD, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0x7E, 0x7C, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xE3, 0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xDF, 0x1F, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC8, 0x7F, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB, 0xF7,
  0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF8, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFE, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F,
  0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00,
  0x00, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xB0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x3F, 0xCF, 0x78, 0x7F, 0xCF, 0x78,
  0xFF, 0xCF, 0x79, 0xF3, 0xC7, 0x71, 0xE3, 0xC7, 0xF1, 0xE3, 0xC7, 0xF1,
  0xE3, 0xC7, 0xF1, 0xE3, 0xC7, 0xF1, 0xC3, 0xC7, 0xF1, 0xE3, 0xCF, 0xF1,
  0xE7, 0xCF, 0x71, 0xE7, 0xDE, 0x79, 0xFF, 0xFE, 0x78, 0xFC, 0xFC, 0x78,
  0x38, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x0F,
  0xF7, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E,
  0xFD, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x06, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x02, 0x3F, 0xDE, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3,
  0xFB, 0xF0, 0xFD, 0xF8, 0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xDF, 0x87, 0xEF, 0xC7, 0xF7, 0xFF, 0xF3, 0xFF,
  0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF3, 0xF8, 0x11, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xE1, 0xFB, 0xFC,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0x00, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3,
  0xF1, 0xF9, 0xF8, 0xFD, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFE, 0xF8, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE1, 0xF3, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE3, 0xDF, 0xF9, 0xE7, 0xDF,
  0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF9, 0xF7, 0x9F, 0xF8, 0xFF, 0x9F,
  0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0x7F, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7,
  0xFE, 0x3E, 0xFF, 0xC7, 0xDF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF3, 0xF0, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F,
  0xF8, 0xFF, 0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x81,
  0xF3, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF3, 0xF0, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3,
  0xF3, 0xF1, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F,
  0x9F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF3, 0xF0,
  0xF9, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0xE3,
  0xFF, 0xDF, 0xFE, 0x7F, 0xFB, 0xF0, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xF3, 0xFB, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C,
  0xFC, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0,
  0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xF8, 0x0F, 0x01, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C,
  0x3F, 0x83, 0xE7, 0xC3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC,
  0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE7, 0xFC, 0x7C, 0x3E, 0x7B, 0xE7, 0xC3,
  0xE7, 0x9E, 0xFC, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79,
  0xEF, 0x81, 0xFF, 0x9E, 0xF8, 0x1F, 0xF0, 0xEF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x9F,
  0x87, 0xE7, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xF7,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0xC3, 0xE1,
  0xF1, 0xF8, 0x7E, 0x7C, 0x1F, 0xBF, 0x03, 0xF0, 0xFC, 0x0F, 0xFF, 0x03,
  0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x03, 0xE3, 0xE0, 0xF8,
  0x78, 0x7C, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0xE0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x18, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xF7, 0xFB, 0xCF,
  0xCF, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0xF8, 0xFB, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xF7, 0xEF,
  0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFE, 0xFF, 0xFD,
  0xF7, 0xF3, 0xC7, 0xC0, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x7F, 0xE7, 0xE3,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x2F, 0xC3, 0x7F, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F,
  0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x87, 0x9F, 0x3F, 0xBE, 0x7F, 0xFD, 0xFF, 0xFB, 0xF7, 0xF7,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x9F, 0xBF, 0xFF, 0x3F, 0xFE,
  0x7F, 0xBC, 0x7E, 0x78, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xC7, 0xCF, 0x87, 0x9E, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x06, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x01, 0x00, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xE1, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0x7B, 0xFF, 0xF7, 0xE7, 0xEF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xDF, 0x0F, 0xBF, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8,
  0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xB0, 0x3F, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0x30, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0xFB, 0xF9,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF8, 0x77, 0xFF,
  0xFF, 0xB8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFE, 0xFC, 0x70, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFC, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xF0, 0xF8, 0xF3, 0xF9, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF1, 0xF1, 0xE7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF1, 0xF1,
  0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF, 0xDF, 0x8F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFB, 0xEF, 0xE7, 0xCF, 0x8F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0x7B, 0xFF,
  0xF7, 0xEF, 0xEF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x0F, 0xBF, 0x3F, 0x7F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xEF, 0xFD, 0xFE, 0xBF, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xC7, 0xFF, 0x7F, 0xEF, 0xFE, 0xF8, 0x6F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF1, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFE, 0xF9, 0xF9, 0xF0,
  0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x0F, 0x3E, 0x07, 0xDF, 0x03,
  0xEF, 0x81, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x3F, 0x0F, 0xFE, 0x3F,
  0x87, 0xDF, 0x1F, 0xC3, 0xEF, 0x8F, 0xE3, 0xF7, 0xC7, 0xF1, 0xF3, 0xE3,
  0xFC, 0xF8, 0xF9, 0xDE, 0x7C, 0x7D, 0xEF, 0x3E, 0x3E, 0xF7, 0xBE, 0x1F,
  0x7B, 0xDF, 0x0F, 0xBC, 0xEF, 0x83, 0xDE, 0x77, 0xC1, 0xEE, 0x3F, 0xE0,
  0xF7, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F,
  0x7C, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x3E,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xE3,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83,
  0xF8, 0x7F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x07, 0xE3, 0xFC, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x07, 0x80, 0x3C, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0x3F, 0xA0, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 26, 9, 2, -26 },
  { 21, 13, 10, 17, 2, -26 },
  { 38, 17, 26, 19, 1, -26 },
  { 94, 14, 29, 17, 2, -27 },
  { 145, 27, 26, 29, 1, -26 },
  { 233, 21, 26, 21, 1, -26 },
  { 302, 5, 10, 9, 2, -26 },
  { 309, 9, 32, 12, 2, -26 },
  { 345, 10, 32, 12, 0, -26 },
  { 385, 15, 15, 17, 1, -27 },
  { 414, 15, 17, 17, 1, -21 },
  { 446, 7, 10, 9, 1, -5 },
  { 455, 9, 5, 11, 1, -12 },
  { 461, 6, 6, 9, 2, -6 },
  { 466, 15, 26, 15, 0, -26 },
  { 515, 15, 26, 17, 1, -26 },
  { 564, 11, 26, 17, 2, -26 },
  { 600, 14, 26, 17, 1, -26 },
  { 646, 15, 26, 17, 1, -26 },
  { 695, 16, 26, 17, 1, -26 },
  { 747, 14, 26, 17, 2, -26 },
  { 793, 15, 26, 17, 1, -26 },
  { 842, 15, 26, 17, 1, -26 },
  { 891, 15, 26, 17, 1, -26 },
  { 940, 15, 26, 17, 1, -26 },
  { 989, 6, 20, 10, 2, -20 },
  { 1004, 7, 25, 10, 1, -20 },
  { 1026, 15, 18, 17, 1, -22 },
  { 1060, 15, 12, 17, 1, -19 },
  { 1083, 15, 18, 17, 1, -22 },
  { 1117, 13, 26, 14, 0, -26 },
  { 1160, 24, 29, 27, 1, -26 },
  { 1247, 20, 26, 20, 0, -26 },
  { 1312, 16, 26, 19, 2, -26 },
  { 1364, 16, 26, 18, 1, -26 },
  { 1416, 17, 26, 21, 2, -26 },
  { 1472, 12, 26, 16, 2, -26 },
  { 1511, 12, 26, 16, 2, -26 },
  { 1550, 17, 26, 21, 2, -26 },
  { 1606, 17, 26, 22, 2, -26 },
  { 1662, 10, 26, 12, 1, -26 },
  { 1695, 10, 34, 10, -2, -26 },
  { 1738, 17, 26, 19, 2, -26 },
  { 1794, 12, 26, 15, 2, -26 },
  { 1833, 24, 26, 28, 2, -26 },
  { 1911, 19, 26, 23, 2, -26 },
  { 1973, 19, 26, 22, 1, -26 },
  { 2035, 15, 26, 18, 2, -26 },
  { 2084, 19, 32, 22, 1, -26 },
  { 2160, 17, 26, 19, 2, -26 },
  { 2216, 14, 26, 16, 1, -26 },
  { 2262, 14, 26, 16, 1, -26 },
  { 2308, 17, 26, 21, 2, -26 },
  { 2364, 19, 26, 19, 0, -26 },
  { 2426, 28, 26, 28, 0, -26 },
  { 2517, 18, 26, 18, 0, -26 },
  { 2576, 18, 26, 18, 0, -26 },
  { 2635, 14, 26, 16, 1, -26 },
  { 2681, 8, 32, 11, 2, -26 },
  { 2713, 15, 26, 15, 0, -26 },
  { 2762, 8, 32, 11, 1, -26 },
  { 2794, 18, 17, 19, 1, -26 },
  { 2833, 16, 3, 16, 0, 3 },
  { 2839, 9, 6, 12, 1, -28 },
  { 2846, 14, 20, 17, 1, -20 },
  { 2881, 15, 27, 18, 2, -27 },
  { 2932, 13, 20, 15, 1, -20 },
  { 2965, 15, 27, 18, 1, -27 },
  { 3016, 15, 20, 17, 1, -20 },
  { 3054, 12, 28, 11, 0, -28 },
  { 3096, 15, 29, 18, 1, -20 },
  { 3151, 15, 27, 19, 2, -27 },
  { 3202, 5, 28, 9, 2, -28 },
  { 3220, 8, 37, 9, -1, -28 },
  { 3257, 16, 27, 18, 2, -27 },
  { 3311, 5, 27, 9, 2, -27 },
  { 3328, 24, 20, 28, 2, -20 },
  { 3388, 15, 20, 19, 2, -20 },
  { 3426, 16, 20, 18, 1, -20 },
  { 3466, 15, 29, 18, 2, -20 },
  { 3521, 15, 29, 18, 1, -20 },
  { 3576, 11, 20, 13, 2, -20 },
  { 3604, 12, 20, 14, 1, -20 },
  { 3634, 12, 24, 12, 0, -24 },
  { 3670, 15, 20, 19, 2, -20 },
  { 3708, 17, 20, 17, 0, -20 },
  { 3751, 25, 20, 25, 0, -20 },
  { 3814, 16, 20, 16, 0, -20 },
  { 3854, 17, 29, 17, 0, -20 },
  { 3916, 12, 20, 14, 1, -20 },
  { 3946, 12, 32, 13, 0, -26 },
  { 3994, 5, 36, 15, 5, -28 },
  { 4017, 11, 32, 13, 1, -26 },
  { 4061, 15, 7, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD36PT7B_H_
