#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xEF, 0xE0, 0xEF, 0xE7, 0xE7,
  0xE7, 0xE6, 0x0D, 0x81, 0xB0, 0x76, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xE0,
  0xD8, 0x1B, 0x1F, 0xFB, 0xFF, 0x19, 0x83, 0x30, 0x6E, 0x0D, 0x80, 0x08,
  0x08, 0x7F, 0xFF, 0xEA, 0xE8, 0xE8, 0x78, 0x3E, 0x0F, 0x0F, 0x8B, 0xCF,
  0xFE, 0x7C, 0x08, 0x08, 0x78, 0x71, 0xF0, 0xC3, 0x73, 0x86, 0xE6, 0x0D,
  0xDC, 0x1B, 0xB0, 0x37, 0x6F, 0x7D, 0xDF, 0x7B, 0x76, 0x0E, 0xCC, 0x19,
  0x98, 0x33, 0x30, 0xE7, 0x61, 0x87, 0xC7, 0x0F, 0x00, 0x1F, 0x01, 0xFC,
  0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0x78, 0x07, 0xCE, 0x7F, 0x73,
  0xBF, 0x3C, 0xF9, 0xE7, 0xC7, 0xFE, 0x3F, 0xF0, 0xFD, 0xE0, 0xFF, 0xFE,
  0x3C, 0xE7, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87, 0x1C,
  0x38, 0xF0, 0xE1, 0xC3, 0x0E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x18,
  0xE3, 0x8C, 0x73, 0x80, 0x1C, 0x06, 0x13, 0x6F, 0xFF, 0xF8, 0xF0, 0xFC,
  0xE7, 0x12, 0x00, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0xFE, 0xEE, 0xEC, 0xFF, 0xFE, 0xEF, 0xE0, 0x03, 0x83, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0x03, 0x80, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x7C, 0xFE, 0xFF, 0x47, 0x07,
  0x0F, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE,
  0xFF, 0x07, 0x07, 0x0E, 0x7C, 0x7C, 0x7F, 0x07, 0x07, 0x07, 0xFF, 0xFE,
  0xFC, 0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0x71, 0xDC, 0x67,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x01, 0xC0, 0x70, 0x7E, 0x7E, 0xFE, 0xE0,
  0xE0, 0xFC, 0xFE, 0xFF, 0x0F, 0x07, 0x07, 0x07, 0xFF, 0xFE, 0xFC, 0x1F,
  0x3F, 0x79, 0xE0, 0xE0, 0xEE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x7E, 0x3C, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E,
  0x7C, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x7C, 0x7E, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x77, 0x07, 0x07, 0x9E, 0xFC, 0xF8, 0x6F,
  0xF6, 0x00, 0x00, 0x0E, 0xFE, 0x6F, 0xF6, 0x00, 0x00, 0x0F, 0xEE, 0xEE,
  0xC0, 0x01, 0x03, 0x0F, 0x3F, 0xF8, 0xE0, 0xF8, 0x3F, 0x0F, 0x03, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x60, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x7D, 0xF8, 0xF0, 0x60, 0x20, 0x00, 0x7C, 0xFE, 0x7F, 0x47,
  0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0F,
  0xC0, 0x7F, 0xC3, 0x03, 0x18, 0x06, 0x67, 0xDB, 0x3F, 0x7C, 0xCC, 0xF7,
  0x33, 0xDC, 0xCF, 0x73, 0x7C, 0xDD, 0xB3, 0xDE, 0xE6, 0x21, 0xC0, 0x03,
  0x86, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1B,
  0x83, 0xB8, 0x3B, 0x83, 0x9C, 0x39, 0xC7, 0xFC, 0x7F, 0xC7, 0xFE, 0x70,
  0xEF, 0x0E, 0xF0, 0xF0, 0xFE, 0x3F, 0xEF, 0xFB, 0xCE, 0xF3, 0xBC, 0xEF,
  0xF3, 0xFC, 0xF7, 0xBC, 0xEF, 0x3F, 0xCE, 0xFF, 0xBF, 0xEF, 0xE0, 0x1F,
  0x1F, 0xDF, 0xCE, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1E,
  0x07, 0xF3, 0xF8, 0x7C, 0xFE, 0x3F, 0xCF, 0xFB, 0xCF, 0xF3, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xCE, 0xFF, 0xBF, 0xCF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x00, 0x1F, 0x8F, 0xF7, 0xF9, 0xC0, 0xF0, 0x38, 0x0E, 0x7F,
  0x9F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC7, 0x7F, 0xCF, 0xF1, 0xFC, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1C, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x7F, 0xE0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCE, 0x3B, 0xEF, 0x10, 0xF1, 0xFC, 0xFF, 0x3B, 0xDC, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3D, 0xCF, 0x73, 0xDE, 0xF3, 0xBC, 0xFF,
  0x1C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0xFF, 0xFF, 0x80, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F,
  0xB3, 0xFE, 0xCF, 0xFB, 0xB7, 0xEE, 0xDF, 0x9F, 0x7E, 0x7D, 0xF9, 0xE7,
  0xE7, 0x9F, 0x8E, 0x7E, 0x31, 0xC0, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFB, 0xBF, 0x77, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF8, 0x78, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xC7, 0xF8, 0xE7, 0xFC, 0x7F, 0x07, 0xC0,
  0xFE, 0x7F, 0xBF, 0xFE, 0x7F, 0x3F, 0x9F, 0xDF, 0xFE, 0xFF, 0x7E, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xC7, 0xF8, 0xE7, 0xFC, 0xFF,
  0x07, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0xFE, 0x3F, 0xCF, 0xFB,
  0xCE, 0xF3, 0xBC, 0xEF, 0x7B, 0xFC, 0xFE, 0x3F, 0xCF, 0x73, 0xDC, 0xF3,
  0xBC, 0xEF, 0x3C, 0x7F, 0xFE, 0xFE, 0xE2, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x0E, 0x0F, 0x8F, 0xFE, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC7, 0x7F, 0xDF, 0xE3, 0xF0, 0xE0, 0xFC, 0x1D, 0xC7, 0xB8, 0xE7,
  0x1C, 0xE3, 0x8E, 0x71, 0xDC, 0x3B, 0x87, 0x70, 0x6E, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0xE1, 0xC7, 0xE1, 0xC7, 0xE3, 0xC7, 0x73, 0xC7, 0x73,
  0xCF, 0x73, 0xEE, 0x73, 0xEE, 0x77, 0xEE, 0x37, 0x6E, 0x3E, 0x6E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0xF3, 0xDC, 0xE7,
  0x38, 0xFE, 0x3F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0xC3, 0xF0, 0xEE,
  0x73, 0x9C, 0xFF, 0x1C, 0xE1, 0xDC, 0x77, 0x39, 0xCE, 0x3B, 0x8F, 0xC1,
  0xF0, 0x7C, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFF, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0E, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x06, 0x01, 0xC0,
  0x3C, 0x0F, 0x81, 0xB8, 0x77, 0x0C, 0x63, 0x8E, 0x70, 0xDC, 0x1C, 0xFF,
  0xFF, 0xF0, 0xF3, 0x8E, 0x3C, 0xFE, 0x7F, 0x47, 0x07, 0x7F, 0xFF, 0xE7,
  0xE7, 0xEF, 0xFF, 0x73, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x67, 0xFB, 0xFD,
  0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBF, 0xFD, 0xDC, 0x1C, 0xFF,
  0xFF, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xED, 0xF9, 0xF0, 0x03, 0x81, 0xC0,
  0xE0, 0x73, 0x3B, 0xDF, 0xFF, 0xCF, 0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F,
  0xBD, 0xFE, 0xF7, 0x1C, 0x7E, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xE0, 0xE0,
  0xF3, 0x7F, 0x3E, 0x1E, 0x7C, 0xFB, 0xC7, 0xDF, 0xBF, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x33, 0xBD, 0xFF, 0xFC, 0xFE, 0x7F, 0x1F,
  0x8F, 0xC7, 0xE7, 0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x3B, 0xFD, 0xFC, 0x7C,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0xFD, 0xEF, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xFF, 0xFF, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB8, 0xEE, 0x73,
  0xB8, 0xEE, 0x3F, 0x0F, 0xE3, 0xF8, 0xE7, 0x39, 0xCE, 0x3B, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x33, 0xFD, 0xEF, 0xFF, 0xFD, 0xE7,
  0xE7, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39,
  0xF8, 0xE7, 0xEE, 0x7F, 0xBF, 0xDE, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x70, 0x1C, 0x3F, 0x3F, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE7, 0xFB, 0x9F, 0xC7, 0xC0, 0xEE, 0x7F, 0xBF, 0xDE, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xFF, 0xDD, 0xCE, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x00, 0x33, 0xBD, 0xFF, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC7, 0xE7,
  0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xCF, 0xFF,
  0xFF, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x39, 0xFB, 0xF6, 0x2E, 0x1F,
  0x1F, 0x0E, 0x1F, 0xBB, 0xF7, 0xC0, 0x30, 0x60, 0xFF, 0xFF, 0xEE, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xD3, 0xE7, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xDF, 0xEF, 0x70, 0xE1, 0xF8, 0xE7,
  0x39, 0xCE, 0x73, 0x9D, 0xC3, 0x70, 0xFC, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0xE3, 0x8F, 0xCF, 0x19, 0xDF, 0x73, 0xBE, 0xE7, 0x6D, 0xCE, 0xDB, 0x9D,
  0xB6, 0x1B, 0x7C, 0x3E, 0xF8, 0x79, 0xF0, 0xF1, 0xE1, 0xE3, 0x80, 0xE3,
  0xB9, 0xDD, 0xC7, 0xE3, 0xE1, 0xF0, 0x78, 0x7C, 0x3F, 0x3B, 0x9D, 0xFC,
  0x70, 0xE1, 0xF8, 0xE7, 0x39, 0xCE, 0x73, 0x8D, 0xC3, 0xF0, 0xFC, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x07, 0xC1, 0xE0, 0x70, 0x00, 0x7E,
  0x7E, 0x7E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x7F, 0xFF, 0xFF, 0x1E,
  0x3C, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0xF9, 0xE1, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE3,
  0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x3C, 0xF7, 0x9C, 0x71, 0xC7, 0x1C, 0xF3,
  0x80, 0xF8, 0xFF, 0xE7, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 11, 15, 11, 0, -15 },
  { 35, 8, 17, 10, 1, -16 },
  { 52, 15, 15, 17, 1, -15 },
  { 81, 13, 15, 13, 0, -15 },
  { 106, 3, 5, 5, 1, -15 },
  { 108, 6, 18, 7, 1, -15 },
  { 122, 6, 18, 7, 0, -15 },
  { 136, 9, 9, 10, 0, -16 },
  { 147, 8, 11, 10, 1, -13 },
  { 158, 4, 6, 5, 1, -3 },
  { 161, 5, 3, 7, 1, -7 },
  { 163, 4, 3, 6, 1, -3 },
  { 165, 9, 15, 9, 0, -15 },
  { 182, 8, 15, 10, 1, -15 },
  { 197, 7, 15, 10, 1, -15 },
  { 211, 8, 15, 10, 1, -15 },
  { 226, 8, 15, 10, 1, -15 },
  { 241, 10, 15, 10, 0, -15 },
  { 260, 8, 15, 10, 1, -15 },
  { 275, 8, 15, 10, 1, -15 },
  { 290, 8, 15, 10, 1, -15 },
  { 305, 8, 15, 10, 1, -15 },
  { 320, 8, 15, 10, 1, -15 },
  { 335, 4, 12, 6, 1, -12 },
  { 341, 4, 15, 6, 1, -12 },
  { 349, 8, 11, 10, 1, -13 },
  { 360, 8, 7, 10, 1, -11 },
  { 367, 9, 11, 10, 1, -13 },
  { 380, 8, 15, 8, 0, -15 },
  { 395, 14, 17, 16, 1, -15 },
  { 425, 12, 15, 12, 0, -15 },
  { 448, 10, 15, 11, 1, -15 },
  { 467, 9, 15, 10, 1, -15 },
  { 484, 10, 15, 12, 1, -15 },
  { 503, 7, 15, 9, 1, -15 },
  { 517, 7, 15, 9, 1, -15 },
  { 531, 10, 15, 12, 1, -15 },
  { 550, 10, 15, 13, 1, -15 },
  { 569, 5, 15, 7, 1, -15 },
  { 579, 6, 20, 6, -1, -15 },
  { 594, 10, 15, 11, 1, -15 },
  { 613, 7, 15, 9, 1, -15 },
  { 627, 14, 15, 17, 1, -15 },
  { 654, 11, 15, 13, 1, -15 },
  { 675, 11, 15, 13, 1, -15 },
  { 696, 9, 15, 11, 1, -15 },
  { 713, 11, 19, 13, 1, -15 },
  { 740, 10, 15, 11, 1, -15 },
  { 759, 8, 15, 9, 1, -15 },
  { 774, 9, 15, 9, 0, -15 },
  { 791, 10, 15, 12, 1, -15 },
  { 810, 11, 15, 11, 0, -15 },
  { 831, 16, 15, 16, 0, -15 },
  { 861, 10, 15, 10, 0, -15 },
  { 880, 10, 15, 10, 0, -15 },
  { 899, 9, 15, 9, 0, -15 },
  { 916, 5, 18, 6, 1, -15 },
  { 928, 9, 15, 9, 0, -15 },
  { 945, 5, 18, 6, 0, -15 },
  { 957, 11, 10, 11, 0, -15 },
  { 971, 10, 2, 9, 0, 2 },
  { 974, 5, 3, 7, 1, -16 },
  { 976, 8, 12, 10, 1, -12 },
  { 988, 9, 16, 11, 1, -16 },
  { 1006, 7, 12, 9, 1, -12 },
  { 1017, 9, 16, 11, 1, -16 },
  { 1035, 8, 12, 10, 1, -12 },
  { 1047, 7, 16, 7, 0, -16 },
  { 1061, 9, 17, 11, 1, -12 },
  { 1081, 9, 16, 11, 1, -16 },
  { 1099, 3, 16, 5, 1, -16 },
  { 1105, 5, 21, 5, -1, -16 },
  { 1119, 10, 16, 11, 1, -16 },
  { 1139, 3, 16, 5, 1, -16 },
  { 1145, 14, 12, 16, 1, -12 },
  { 1166, 9, 12, 11, 1, -12 },
  { 1180, 9, 12, 11, 1, -12 },
  { 1194, 9, 17, 11, 1, -12 },
  { 1214, 9, 17, 11, 1, -12 },
  { 1234, 6, 12, 8, 1, -12 },
  { 1243, 7, 12, 8, 1, -12 },
  { 1254, 7, 14, 7, 0, -14 },
  { 1267, 9, 12, 11, 1, -12 },
  { 1281, 10, 12, 10, 0, -12 },
  { 1296, 15, 12, 15, 0, -12 },
  { 1319, 9, 12, 9, 0, -12 },
  { 1333, 10, 17, 10, 0, -12 },
  { 1355, 8, 12, 8, 0, -12 },
  { 1367, 7, 18, 7, 0, -15 },
  { 1383, 3, 21, 9, 3, -16 },
  { 1391, 6, 18, 7, 1, -15 },
  { 1405, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD21PT7B_H_
