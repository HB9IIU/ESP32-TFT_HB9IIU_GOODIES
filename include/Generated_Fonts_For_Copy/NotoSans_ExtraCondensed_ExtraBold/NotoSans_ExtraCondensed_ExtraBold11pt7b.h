#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDA, 0xD4, 0x28, 0xAF, 0xDC, 0x53, 0xE5, 0x14, 0x33, 0xF8,
  0xC3, 0x9F, 0xE4, 0x20, 0x66, 0x72, 0x3F, 0x1D, 0x66, 0xF0, 0xAC, 0x5C,
  0x66, 0x70, 0xB1, 0x63, 0x87, 0x5B, 0xB6, 0x3F, 0xD4, 0x2D, 0x2C, 0x92,
  0x64, 0xC9, 0xB2, 0x5B, 0x58, 0x27, 0xDC, 0xA0, 0x21, 0x3F, 0xF2, 0x10,
  0x70, 0xFC, 0xC0, 0x18, 0x8C, 0x46, 0x21, 0x18, 0x73, 0xF7, 0xBD, 0xED,
  0x6E, 0x37, 0xD3, 0x33, 0x33, 0x77, 0xC6, 0x23, 0x31, 0x1F, 0xF2, 0xC6,
  0xE7, 0x0E, 0x7E, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xEE, 0x8E, 0xB3, 0xBE,
  0x3B, 0x51, 0xED, 0xED, 0x6E, 0xFF, 0xC4, 0x23, 0x11, 0x8C, 0x76, 0xD6,
  0xE7, 0x6F, 0x6E, 0x72, 0xF7, 0xB7, 0x8C, 0x4E, 0xCC, 0x50, 0x1C, 0x08,
  0xD9, 0xC3, 0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0xEB, 0x33,
  0x60, 0x66, 0x3C, 0x62, 0x5F, 0x75, 0xF5, 0xFF, 0x56, 0x62, 0x3C, 0x30,
  0xC7, 0x9E, 0x49, 0xEC, 0xF3, 0xF7, 0xA5, 0xEF, 0x4E, 0xDE, 0x3B, 0x51,
  0x8C, 0x21, 0xA7, 0xE7, 0xA7, 0x39, 0xCE, 0xDC, 0xFE, 0x7F, 0x27, 0xFE,
  0x7F, 0x24, 0x3D, 0xE4, 0x37, 0xDD, 0x36, 0xCF, 0x9C, 0xE7, 0xFF, 0xCE,
  0x73, 0xED, 0xB6, 0xDF, 0x24, 0x92, 0x49, 0x3C, 0x9D, 0xAD, 0xCE, 0x5A,
  0xD3, 0x92, 0x49, 0x27, 0xC7, 0x9F, 0xBD, 0x7A, 0xF7, 0xED, 0xCB, 0xCE,
  0x7B, 0x5B, 0xDE, 0x73, 0x39, 0xF4, 0xF3, 0xCD, 0x36, 0xCE, 0xEF, 0x9B,
  0xF8, 0x88, 0x39, 0xF4, 0xF3, 0xCD, 0x36, 0xCE, 0x08, 0x30, 0xE7, 0xA5,
  0x6E, 0x5A, 0xD3, 0x7F, 0xB0, 0xC3, 0x0F, 0xDE, 0xFF, 0xC8, 0x42, 0x10,
  0x84, 0x9C, 0xE7, 0x39, 0xCF, 0x7E, 0xCF, 0x34, 0x96, 0x79, 0xC3, 0x0C,
  0xC9, 0xEC, 0xB6, 0x4B, 0xE5, 0x72, 0xB9, 0xD8, 0xCC, 0xDA, 0xDC, 0x63,
  0x39, 0x7B, 0xCA, 0xDE, 0xE3, 0x18, 0xC6, 0xFF, 0x8C, 0x46, 0x23, 0x1F,
  0xEA, 0xAA, 0xB0, 0xC4, 0x46, 0x23, 0x31, 0xED, 0xB6, 0xDB, 0x7C, 0x30,
  0xC7, 0x12, 0xCC, 0xF8, 0xE0, 0x72, 0xDF, 0xBD, 0xBC, 0x88, 0xFB, 0x99,
  0xBF, 0x75, 0xCC, 0x57, 0x18, 0xDE, 0xBD, 0xED, 0x6D, 0x72, 0xFF, 0x84,
  0xBC, 0x74, 0xE4, 0x44, 0x44, 0x6A, 0xF7, 0xB5, 0xBC, 0x6F, 0x60, 0x88,
  0xFB, 0xBB, 0xBB, 0xBF, 0x45, 0x55, 0x78, 0x84, 0x2D, 0x4E, 0x72, 0xD3,
  0xFF, 0xFF, 0x6E, 0xDD, 0xBB, 0x76, 0xC0, 0xFB, 0xBB, 0xBB, 0x72, 0xF3,
  0xB5, 0xB8, 0xFB, 0x99, 0xBF, 0x88, 0x80, 0x6A, 0xF7, 0xB5, 0xBC, 0x63,
  0x18, 0xFE, 0x49, 0x00, 0x7D, 0xE3, 0xBF, 0x4E, 0x44, 0x44, 0x70, 0xBB,
  0xBB, 0xBD, 0xDE, 0xD4, 0xA7, 0x18, 0xDB, 0xDA, 0x5A, 0x7A, 0x6E, 0x6C,
  0xDA, 0x9C, 0xE5, 0x6C, 0xDE, 0xD4, 0xE7, 0x18, 0x9C, 0xC0, 0xF3, 0x66,
  0xCF, 0x36, 0x66, 0xEE, 0x66, 0x63, 0xFF, 0xE0, 0xC6, 0x66, 0x77, 0x66,
  0x6C, 0x6D, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 5, 3, 5, 0, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 9, 8, 9, 0, -8 },
  { 25, 7, 8, 7, 0, -8 },
  { 32, 2, 3, 3, 0, -8 },
  { 33, 3, 10, 4, 0, -8 },
  { 37, 3, 10, 4, 0, -8 },
  { 41, 5, 4, 5, 0, -8 },
  { 44, 5, 6, 5, 0, -7 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 2, 3, 0, -4 },
  { 50, 1, 2, 3, 1, -2 },
  { 51, 5, 8, 5, 0, -8 },
  { 56, 5, 8, 5, 0, -8 },
  { 61, 4, 8, 5, 0, -8 },
  { 65, 5, 8, 5, 0, -8 },
  { 70, 5, 8, 5, 0, -8 },
  { 75, 5, 8, 5, 0, -8 },
  { 80, 4, 8, 5, 1, -8 },
  { 84, 5, 8, 5, 0, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 5, 8, 5, 0, -8 },
  { 99, 5, 8, 5, 0, -8 },
  { 104, 1, 6, 3, 1, -6 },
  { 105, 2, 7, 3, 0, -6 },
  { 107, 5, 6, 5, 0, -7 },
  { 111, 5, 4, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -7 },
  { 118, 4, 8, 4, 0, -8 },
  { 122, 8, 9, 8, 0, -8 },
  { 131, 6, 8, 6, 0, -8 },
  { 137, 5, 8, 6, 1, -8 },
  { 142, 5, 8, 5, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 3, 8, 5, 1, -8 },
  { 155, 3, 8, 5, 1, -8 },
  { 158, 6, 8, 6, 0, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 3, 8, 4, 0, -8 },
  { 172, 3, 10, 3, -1, -8 },
  { 176, 5, 8, 6, 1, -8 },
  { 181, 3, 8, 5, 1, -8 },
  { 184, 7, 8, 9, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 0, -8 },
  { 202, 4, 8, 6, 1, -8 },
  { 206, 6, 10, 7, 0, -8 },
  { 214, 5, 8, 6, 1, -8 },
  { 219, 5, 8, 5, 0, -8 },
  { 224, 5, 8, 5, 0, -8 },
  { 229, 5, 8, 6, 1, -8 },
  { 234, 6, 8, 6, 0, -8 },
  { 240, 9, 8, 9, 0, -8 },
  { 249, 5, 8, 5, 0, -8 },
  { 254, 5, 8, 5, 0, -8 },
  { 259, 5, 8, 5, 0, -8 },
  { 264, 2, 10, 3, 1, -8 },
  { 267, 4, 8, 5, 0, -8 },
  { 271, 3, 10, 3, 0, -8 },
  { 275, 6, 5, 6, 0, -8 },
  { 279, 5, 1, 5, 0, 1 },
  { 280, 3, 1, 4, 0, -8 },
  { 281, 5, 6, 5, 0, -6 },
  { 285, 4, 8, 6, 1, -8 },
  { 289, 4, 6, 5, 0, -6 },
  { 292, 5, 8, 6, 0, -8 },
  { 297, 5, 6, 5, 0, -6 },
  { 301, 4, 8, 3, 0, -8 },
  { 305, 5, 9, 6, 0, -6 },
  { 311, 4, 8, 6, 1, -8 },
  { 315, 1, 8, 3, 1, -8 },
  { 316, 2, 11, 3, 0, -8 },
  { 319, 5, 8, 6, 1, -8 },
  { 324, 1, 8, 3, 1, -8 },
  { 325, 7, 6, 8, 1, -6 },
  { 331, 4, 6, 6, 1, -6 },
  { 334, 5, 6, 6, 0, -6 },
  { 338, 4, 9, 6, 1, -6 },
  { 343, 5, 9, 6, 0, -6 },
  { 349, 3, 6, 4, 1, -6 },
  { 352, 4, 6, 4, 0, -6 },
  { 355, 4, 7, 4, 0, -7 },
  { 359, 4, 6, 6, 1, -6 },
  { 362, 5, 6, 5, 0, -6 },
  { 366, 8, 6, 8, 0, -6 },
  { 372, 5, 6, 5, 0, -6 },
  { 376, 5, 9, 5, 0, -6 },
  { 382, 4, 6, 4, 0, -6 },
  { 385, 4, 10, 4, 0, -8 },
  { 390, 1, 11, 5, 2, -8 },
  { 392, 4, 10, 4, 0, -8 },
  { 397, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD11PT7B_H_
