#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x10, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF,
  0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x7C, 0x3F,
  0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFC, 0xE1, 0xCF, 0xE7, 0x02, 0x7E, 0x38, 0x03,
  0xF1, 0xC0, 0x1F, 0xCE, 0x00, 0xFF, 0x70, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xEF,
  0xF0, 0x07, 0x3F, 0x80, 0x39, 0xFE, 0x01, 0xCF, 0xF8, 0x0E, 0x7F, 0xF0,
  0x77, 0xF7, 0xF3, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xC0,
  0x00, 0xFE, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x87, 0xE1, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF8, 0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0x07, 0xF3, 0xF1, 0xF8,
  0xFF, 0xE0, 0xFF, 0xFC, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0x1F, 0xFF,
  0x07, 0xFF, 0x8F, 0xCF, 0xEF, 0xE1, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0x3F,
  0xE1, 0xF8, 0xFC, 0x7E, 0x03, 0xE0, 0xFC, 0x7F, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE1, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x7F, 0x00, 0x01, 0xF8, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x87, 0xF0,
  0x00, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x03,
  0xF3, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFE,
  0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFC, 0x7F, 0xDF, 0xF7, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x08, 0x0F, 0xC0, 0x9E, 0x1F, 0x0F, 0x3F, 0x3E,
  0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC0,
  0xF8, 0x3F, 0x00, 0xF0, 0x78, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xCF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFC, 0x7F, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF9, 0xFE, 0x1F,
  0xE7, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE1,
  0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xCF, 0xF7, 0xF9, 0xFE, 0x7E, 0x3F, 0xC7,
  0x8F, 0xF8, 0x21, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xCF, 0xFE, 0x3E, 0x07,
  0xFC, 0x38, 0x07, 0xF8, 0x20, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0x87, 0xFE, 0x38, 0x0F, 0xF8, 0x40, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF7, 0xF8, 0x03,
  0xF7, 0xF8, 0x03, 0xF7, 0xF8, 0x07, 0xE7, 0xF8, 0x07, 0xE7, 0xF8, 0x0F,
  0xC7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0x87, 0xF8, 0x1F, 0x87, 0xF8, 0x3F,
  0x07, 0xF8, 0x3F, 0x07, 0xF8, 0x7E, 0x07, 0xF8, 0x7E, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x10, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xDC, 0x03, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFC, 0x04, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xC0,
  0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0xE1, 0xFD, 0xFF, 0xE3, 0xFB, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xBF, 0xE0, 0xFF, 0x7F,
  0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xE0, 0xFF, 0x3F, 0xC1,
  0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8,
  0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xCF, 0xF9, 0xFF, 0x0F, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFE, 0xFF,
  0x03, 0xFD, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x50,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xF3, 0xFE, 0xFF,
  0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xDF, 0xCF, 0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x3F, 0xCF,
  0xF0, 0x1C, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF1, 0xC3, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x08, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x10, 0x04, 0x0F, 0xE7, 0xF9, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x3F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF3, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F,
  0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF1, 0xFF, 0x38, 0x0F, 0xF2,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x7E,
  0x03, 0xFF, 0x87, 0xC3, 0xF0, 0x3F, 0xFE, 0x3F, 0x1F, 0x83, 0xFF, 0xF1,
  0xF9, 0xF8, 0x3F, 0xFF, 0x87, 0xCF, 0xC3, 0xF8, 0xFC, 0x3E, 0x7E, 0x1F,
  0x87, 0xE1, 0xFB, 0xE1, 0xF8, 0x3F, 0x0F, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F,
  0xF8, 0x7E, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x7E, 0x1F, 0xFE, 0x1F, 0x83,
  0xF0, 0xFF, 0xF1, 0xFC, 0x1F, 0x87, 0xFF, 0x8F, 0xE0, 0xFC, 0x3F, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF7, 0xE1, 0xF8, 0x7E, 0x0F, 0xBF, 0x0F, 0xC3, 0xF0,
  0xFD, 0xF8, 0x7E, 0x1F, 0xC7, 0xEF, 0xC3, 0xF9, 0xFE, 0x7E, 0x3E, 0x0F,
  0xFF, 0xFF, 0xF1, 0xF8, 0x7F, 0xF7, 0xFF, 0x0F, 0xC1, 0xFF, 0x1F, 0xF0,
  0x7E, 0x07, 0xF8, 0x7F, 0x01, 0xF8, 0x0F, 0x01, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x04, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFE,
  0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F,
  0xEF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xFD, 0xFF,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x07, 0xFD,
  0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFE,
  0xFC, 0x1F, 0xF0, 0x0C, 0x3F, 0xE0, 0x04, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x02, 0x3F, 0xF8, 0x0E, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFE, 0x1F, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F,
  0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0xFF,
  0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0xFC, 0x1F, 0xF8,
  0x03, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0x83, 0xFF, 0xEF, 0xF0, 0x07, 0xFD, 0xFE,
  0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF4, 0x7F, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF,
  0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0xFF,
  0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1,
  0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF,
  0x8F, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0xBF, 0xC0,
  0x3F, 0xEF, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0xFC, 0x07, 0xFF,
  0xFF, 0xEF, 0xC0, 0x7E, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xFF, 0xEF, 0xE0,
  0xFE, 0xFF, 0xFE, 0x7E, 0x0F, 0xEF, 0xFF, 0xE7, 0xE0, 0xFC, 0xFF, 0xFE,
  0x7F, 0x1F, 0xCF, 0xFF, 0xE7, 0xF1, 0xFC, 0xFF, 0xFE, 0x3F, 0x1F, 0x8F,
  0xFF, 0xE3, 0xF9, 0xF8, 0xFF, 0xFE, 0x3F, 0xBF, 0x8F, 0xFF, 0xE3, 0xFB,
  0xF8, 0xFF, 0xFE, 0x1F, 0xBF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFE,
  0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xE7, 0xF8,
  0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xE3, 0xFC, 0xFF, 0xFE, 0x3F, 0xCF, 0xFF,
  0xE1, 0xFE, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0xE0, 0xFE, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC,
  0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00,
  0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xDF,
  0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFE, 0x1F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE,
  0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x3F, 0xE3,
  0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0x81, 0xE7, 0xFC, 0x02, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFA, 0x00, 0x3F, 0xDC, 0x03, 0xFE, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x07, 0xF0,
  0x7E, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0x1F, 0xE3, 0xFB,
  0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x7E, 0x1F, 0xE0, 0x7F, 0x8F, 0xEF, 0xC7,
  0xF8, 0x0F, 0xF1, 0xF9, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0x3F, 0x9F, 0xE0,
  0x1F, 0xC7, 0xE3, 0xF3, 0xFC, 0x03, 0xFD, 0xFC, 0x7E, 0x7F, 0x80, 0x7F,
  0xBF, 0x8F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF1, 0xFB, 0xFC, 0x00, 0xFE, 0xFC,
  0x3F, 0x7F, 0x80, 0x1F, 0xDF, 0x83, 0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x7F,
  0xFE, 0x00, 0x7F, 0x7E, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0x3F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC7,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x80, 0xFF, 0x04, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xCF, 0xF7,
  0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFC, 0xFC, 0x7F, 0xE3, 0xF0, 0xFF, 0x0F, 0xC0,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x38,
  0x0F, 0xF3, 0xFC, 0x1F, 0xEF, 0xFE, 0x3F, 0xDF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xF7, 0xFC, 0x1F, 0xEF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0x7F, 0xF8, 0xFE, 0x7F, 0xE1,
  0xFC, 0x7F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFE, 0x1C, 0x7F, 0xC0, 0x47, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x27, 0xFC, 0x06, 0x7F, 0xE3, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x01, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0x0F,
  0xF0, 0x7F, 0x9F, 0xE3, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0xFB, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x07, 0xFD, 0xFE, 0x0F, 0xFB, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0x7F, 0x0F, 0xFC, 0xFE,
  0x0F, 0xF0, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFE,
  0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x02,
  0x7F, 0xC0, 0x78, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0B, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xF3, 0xF8, 0xFF,
  0xF7, 0xF3, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE3,
  0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F,
  0xEF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF,
  0xDF, 0xE1, 0xFF, 0xBF, 0xC1, 0xFC, 0x7F, 0x80, 0x60, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFA, 0x00, 0x1F, 0xE7, 0x80, 0x7F,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xE0, 0xFF, 0x3F, 0xE3, 0xFD, 0xFF, 0xCF,
  0xEF, 0xFF, 0xBF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F,
  0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF9,
  0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x3E, 0x0F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFE, 0x7F, 0xF1, 0xFF,
  0xCF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFB, 0xFF, 0xFF,
  0x87, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0xFF,
  0x8F, 0xE7, 0xFF, 0x3F, 0xBF, 0xFE, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFE,
  0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x01,
  0xFC, 0x7F, 0x83, 0xF9, 0xFF, 0xC7, 0xF3, 0xFF, 0x8F, 0xEF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x83, 0xFD, 0xFF,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xE7, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF7, 0xFF, 0x1F, 0xE7, 0xFC, 0x3F,
  0xC7, 0xF0, 0x7F, 0x83, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xF3,
  0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xE3, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF, 0xC1,
  0xFF, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF1, 0xFF, 0xDF, 0xE1, 0xFF, 0xBF, 0xC1, 0xFC, 0x7F, 0x80, 0x60, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0x1C, 0xFF, 0x00, 0x9F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x7F,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x0F, 0xFF, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x9C, 0x7F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0x00,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0x7F, 0x1F, 0xF8, 0xFC, 0x3F, 0xC3, 0xF0, 0x08,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0x07, 0xF9, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xF8, 0x3F,
  0x8F, 0xF0, 0x7F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xE1, 0xFE, 0x1F, 0xE1,
  0xF7, 0xC3, 0xFC, 0x3F, 0xC7, 0xEF, 0x87, 0xF8, 0x7F, 0x8F, 0xDF, 0x8F,
  0xE0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0xFE, 0x3F, 0x7E, 0x7F, 0x81, 0xFE,
  0x7C, 0xFC, 0xFF, 0x03, 0xFD, 0xF8, 0xF9, 0xFE, 0x07, 0xFB, 0xF1, 0xF3,
  0xF8, 0x07, 0xF7, 0xE3, 0xF7, 0xF0, 0x0F, 0xEF, 0xC7, 0xEF, 0xE0, 0x1F,
  0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0xBE, 0x1F, 0xFF, 0x00, 0x3F, 0x7C, 0x3F,
  0xFE, 0x00, 0x7E, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xF7, 0xF8,
  0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE7, 0xF8,
  0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFE,
  0x7F, 0xC1, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF7, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x3F, 0xF8,
  0x03, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 40, 14, 3, -39 },
  { 46, 21, 14, 25, 2, -39 },
  { 83, 27, 39, 29, 1, -39 },
  { 215, 21, 45, 26, 3, -42 },
  { 334, 42, 40, 44, 1, -40 },
  { 544, 32, 41, 33, 1, -40 },
  { 708, 9, 14, 13, 2, -39 },
  { 724, 14, 49, 18, 3, -40 },
  { 810, 15, 49, 18, 0, -40 },
  { 902, 23, 23, 25, 1, -42 },
  { 969, 23, 27, 26, 2, -33 },
  { 1047, 10, 14, 14, 2, -7 },
  { 1065, 14, 8, 17, 2, -19 },
  { 1079, 9, 10, 14, 3, -9 },
  { 1091, 23, 41, 23, 0, -40 },
  { 1209, 22, 41, 26, 2, -40 },
  { 1322, 19, 39, 26, 2, -39 },
  { 1415, 23, 40, 26, 1, -40 },
  { 1530, 22, 41, 26, 2, -40 },
  { 1643, 24, 39, 26, 1, -39 },
  { 1760, 21, 40, 26, 3, -39 },
  { 1865, 23, 41, 26, 2, -40 },
  { 1983, 22, 39, 26, 2, -39 },
  { 2091, 23, 41, 26, 2, -40 },
  { 2209, 22, 41, 26, 2, -40 },
  { 2322, 9, 32, 15, 3, -31 },
  { 2358, 10, 38, 15, 2, -31 },
  { 2406, 24, 27, 26, 1, -33 },
  { 2487, 23, 18, 26, 2, -28 },
  { 2539, 23, 27, 26, 2, -33 },
  { 2617, 20, 41, 21, 0, -40 },
  { 2720, 37, 44, 41, 2, -40 },
  { 2924, 30, 39, 30, 0, -39 },
  { 3071, 25, 39, 30, 3, -39 },
  { 3193, 24, 41, 27, 2, -40 },
  { 3316, 26, 39, 31, 3, -39 },
  { 3443, 18, 39, 24, 4, -39 },
  { 3531, 18, 39, 24, 4, -39 },
  { 3619, 27, 41, 32, 2, -40 },
  { 3758, 25, 39, 33, 4, -39 },
  { 3880, 16, 39, 18, 1, -39 },
  { 3958, 15, 51, 15, -3, -39 },
  { 4054, 26, 39, 29, 4, -39 },
  { 4181, 19, 39, 23, 3, -39 },
  { 4274, 36, 39, 43, 4, -39 },
  { 4450, 28, 39, 35, 4, -39 },
  { 4587, 29, 41, 33, 2, -40 },
  { 4736, 23, 39, 28, 3, -39 },
  { 4849, 29, 49, 33, 2, -40 },
  { 5027, 26, 39, 29, 3, -39 },
  { 5154, 21, 41, 24, 2, -40 },
  { 5262, 23, 39, 24, 1, -39 },
  { 5375, 26, 40, 32, 3, -39 },
  { 5505, 29, 39, 29, 0, -39 },
  { 5647, 43, 39, 43, 0, -39 },
  { 5857, 27, 39, 27, 0, -39 },
  { 5989, 27, 39, 27, 0, -39 },
  { 6121, 22, 39, 24, 1, -39 },
  { 6229, 13, 49, 17, 3, -40 },
  { 6309, 22, 41, 23, 0, -40 },
  { 6422, 13, 49, 17, 1, -40 },
  { 6502, 28, 25, 29, 1, -39 },
  { 6590, 25, 5, 25, 0, 4 },
  { 6606, 14, 9, 18, 2, -42 },
  { 6622, 22, 32, 26, 1, -31 },
  { 6710, 23, 43, 28, 3, -42 },
  { 6834, 20, 32, 23, 2, -31 },
  { 6914, 23, 43, 28, 2, -42 },
  { 7038, 22, 32, 26, 2, -31 },
  { 7126, 19, 42, 17, 0, -42 },
  { 7226, 23, 44, 28, 2, -31 },
  { 7353, 22, 42, 28, 3, -42 },
  { 7469, 8, 42, 14, 3, -42 },
  { 7511, 13, 55, 14, -2, -42 },
  { 7601, 25, 42, 28, 3, -42 },
  { 7733, 8, 42, 14, 3, -42 },
  { 7775, 36, 31, 42, 3, -31 },
  { 7915, 22, 31, 28, 3, -31 },
  { 8001, 24, 32, 28, 2, -31 },
  { 8097, 23, 44, 28, 3, -31 },
  { 8224, 23, 44, 28, 2, -31 },
  { 8351, 16, 31, 20, 3, -31 },
  { 8413, 19, 32, 21, 1, -31 },
  { 8489, 17, 37, 19, 1, -36 },
  { 8568, 22, 31, 28, 3, -30 },
  { 8654, 25, 30, 26, 0, -30 },
  { 8748, 39, 30, 39, 0, -30 },
  { 8895, 24, 30, 25, 0, -30 },
  { 8985, 25, 43, 26, 0, -30 },
  { 9120, 19, 30, 21, 1, -30 },
  { 9192, 17, 49, 20, 1, -40 },
  { 9297, 7, 55, 24, 8, -42 },
  { 9346, 17, 49, 20, 2, -40 },
  { 9451, 24, 9, 26, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD55PT7B_H_
