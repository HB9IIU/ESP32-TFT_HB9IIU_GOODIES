#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0xEF, 0x9B, 0x36, 0x6C, 0xC0, 0x1B,
  0x0D, 0x86, 0xC3, 0x67, 0xFB, 0xFC, 0xD8, 0x6C, 0xFF, 0x9B, 0x0D, 0x84,
  0xC6, 0xC0, 0x10, 0x21, 0xFF, 0xED, 0x1A, 0x3C, 0x3E, 0x1E, 0x3E, 0x5F,
  0xEF, 0xC2, 0x04, 0x00, 0x38, 0x61, 0xE3, 0x06, 0xCC, 0x3B, 0x60, 0xED,
  0x81, 0xB6, 0xE7, 0xB7, 0x8E, 0xDB, 0x06, 0x6C, 0x19, 0xB0, 0x66, 0xC3,
  0x1F, 0x0C, 0x38, 0x1E, 0x07, 0xC1, 0xDC, 0x3B, 0x83, 0x60, 0x7C, 0x0F,
  0x33, 0xFE, 0xEF, 0xDC, 0xF3, 0xDE, 0x3F, 0xE3, 0xFE, 0xFB, 0x6C, 0x3B,
  0x98, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0xC6, 0x31, 0xC7, 0xE3, 0x1C, 0x63,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x39, 0x9C, 0x18, 0x18, 0x5B, 0xFF, 0x3C,
  0x3C, 0x76, 0x24, 0x30, 0x60, 0xC1, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0xFF,
  0x60, 0xFF, 0xFF, 0x80, 0x06, 0x0C, 0x30, 0x61, 0xC3, 0x06, 0x1C, 0x30,
  0xE1, 0x83, 0x0E, 0x00, 0x78, 0xFB, 0xB6, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0xBF, 0xE7, 0x80, 0x1C, 0xF7, 0xFF, 0xDD, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x3C, 0xFE, 0x6E, 0x47, 0x06, 0x0E, 0x0E, 0x1C, 0x38, 0x38,
  0x70, 0x7F, 0x7F, 0x79, 0xFB, 0x38, 0x70, 0xCF, 0x9E, 0x3E, 0x0E, 0x1E,
  0x3F, 0xEF, 0x80, 0x0E, 0x0E, 0x1E, 0x1E, 0x36, 0x3E, 0x6E, 0x6E, 0xFF,
  0xFF, 0x0E, 0x0E, 0x0E, 0xFD, 0xFB, 0xF7, 0x0E, 0x1F, 0xBF, 0x07, 0x0E,
  0x1E, 0x3F, 0xEF, 0x80, 0x3C, 0xFB, 0xC7, 0x0C, 0x1F, 0xBF, 0xE7, 0xCF,
  0x9F, 0xBF, 0xE7, 0xC0, 0xFF, 0xFF, 0xF8, 0x60, 0xC3, 0x86, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x00, 0x79, 0xFB, 0xBE, 0x7E, 0xCF, 0x9E, 0x7E, 0xCF,
  0x9F, 0x3F, 0xF7, 0xC0, 0x3C, 0x7E, 0x76, 0x67, 0xE7, 0x67, 0x7F, 0x7F,
  0x37, 0x07, 0x0E, 0x7E, 0x78, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x60, 0x01, 0x07, 0x1F, 0x7C, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x81, 0x83, 0xC1, 0xE0, 0xE7, 0xFC, 0x60,
  0x80, 0x79, 0xF9, 0x38, 0x70, 0xC3, 0x8E, 0x18, 0x30, 0x00, 0xC3, 0x83,
  0x00, 0x1F, 0x03, 0xFC, 0x60, 0xE6, 0x76, 0xCF, 0x2D, 0x93, 0xDB, 0x3D,
  0xB3, 0xDB, 0x2D, 0xFE, 0xCC, 0xCE, 0x00, 0x70, 0x83, 0xF8, 0x1E, 0x07,
  0x81, 0xE0, 0xFC, 0x3F, 0x0D, 0xC3, 0x31, 0xCE, 0x7F, 0x9F, 0xE6, 0x3B,
  0x86, 0xE1, 0xC0, 0xFC, 0xFE, 0xEF, 0xE7, 0xE7, 0xFE, 0xFE, 0xEF, 0xE7,
  0xE7, 0xE7, 0xFE, 0xFC, 0x3E, 0xFD, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xCB, 0xF3, 0xE0, 0xFC, 0x7F, 0x3F, 0xDC, 0xEE, 0x37, 0x1F, 0x8F,
  0xC7, 0xE3, 0x73, 0xBB, 0xDF, 0xCF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0xFF,
  0xFF, 0xE3, 0x8E, 0x3F, 0xFC, 0xFF, 0xFE, 0x38, 0xE3, 0x8F, 0xFF, 0xE3,
  0x8E, 0x38, 0xE0, 0x1F, 0x7F, 0x73, 0xE0, 0xE0, 0xE0, 0xEF, 0xEF, 0xE3,
  0xE3, 0xF3, 0x7F, 0x3F, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFF, 0xF3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x1E, 0xFC, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xFE, 0xE0, 0xE3, 0xF3, 0xBB, 0x9D, 0xCF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xEE, 0x77, 0x39, 0xDC, 0xEE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xF9,
  0xFF, 0x9F, 0xFD, 0xFE, 0xF7, 0xEF, 0x7E, 0xF7, 0xEF, 0x7E, 0x67, 0xE6,
  0x70, 0xE1, 0xF8, 0xFC, 0x7F, 0x3F, 0x9F, 0xEF, 0xF7, 0xDB, 0xEF, 0xF3,
  0xF9, 0xFC, 0x7E, 0x38, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xE3, 0xE0, 0xFC, 0xFE, 0xEE, 0xE7, 0xE7,
  0xE6, 0xFE, 0xFC, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F, 0xBD, 0xDC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xE3, 0xE0, 0x30,
  0x1C, 0x07, 0xFC, 0x7F, 0x3B, 0x9C, 0xEE, 0x77, 0x73, 0xF9, 0xF8, 0xEC,
  0x77, 0x3B, 0x9C, 0xEE, 0x78, 0x7F, 0xFE, 0xF0, 0xE3, 0xC7, 0x8F, 0x1C,
  0x39, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE7, 0x7F, 0x3E, 0xE1, 0xF8, 0x66, 0x39, 0x8E, 0x73, 0x1C,
  0xC3, 0x70, 0xDC, 0x36, 0x0F, 0x81, 0xE0, 0x78, 0x1C, 0x00, 0xE3, 0x1F,
  0x8C, 0x7E, 0x79, 0xD9, 0xE6, 0x67, 0x99, 0x9E, 0xE7, 0x7B, 0x9F, 0xFE,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xBB, 0x9D,
  0xC6, 0xC3, 0xE1, 0xE0, 0x70, 0x78, 0x3E, 0x1B, 0x1D, 0xCC, 0xEE, 0x38,
  0xE3, 0xB1, 0x9D, 0xCE, 0xE3, 0x61, 0xF0, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFE, 0xFE, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF,
  0xE0, 0xC1, 0x83, 0x83, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x0E,
  0x07, 0x83, 0xC3, 0x71, 0x99, 0x8D, 0xC3, 0xFF, 0xFF, 0xE6, 0x30, 0x3E,
  0x7E, 0x27, 0x07, 0x3F, 0x7F, 0x67, 0xE7, 0x7F, 0x7B, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFC, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xFE, 0xDC, 0x7F,
  0xFE, 0x70, 0xC3, 0x0C, 0x39, 0xFD, 0xF0, 0x06, 0x0C, 0x18, 0x37, 0x7F,
  0xFB, 0xE3, 0xC7, 0x8F, 0x1F, 0x7F, 0xEE, 0xC0, 0x79, 0xFB, 0x3E, 0x7F,
  0xFF, 0xF0, 0x71, 0xFC, 0xF8, 0x1C, 0xF7, 0x5C, 0x7B, 0xE7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC0, 0x77, 0xFF, 0xBE, 0x3C, 0x78, 0xF1, 0xF7, 0xFE,
  0xEC, 0x1C, 0x7F, 0xFF, 0x80, 0xE1, 0xC3, 0x87, 0x0D, 0xDF, 0xFB, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xC0, 0xDF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x31, 0xCC, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xF7, 0x80,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE, 0xEC, 0xFC, 0xD8, 0xFC, 0xEC, 0xEE,
  0xE6, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDC, 0xEF, 0xFF, 0xEF,
  0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xDD,
  0xFF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCC, 0x7D, 0xFF, 0xBE, 0x3C,
  0x78, 0xF1, 0xF7, 0xFE, 0xF8, 0xDC, 0xFE, 0xEE, 0xE6, 0xE7, 0xE7, 0xE7,
  0xE6, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x77, 0xFF, 0xBE, 0x3C, 0x78,
  0xF1, 0xF7, 0xFE, 0xEC, 0x18, 0x30, 0x60, 0xC0, 0xDE, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x3D, 0xFE, 0x5C, 0x78, 0xF0, 0xE3, 0xFF, 0xE0, 0x30,
  0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xCF, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF7, 0xFE, 0xEC, 0xE3, 0xE7, 0x67, 0x66, 0x76, 0x3E, 0x3E,
  0x3C, 0x3C, 0x1C, 0xE7, 0x3F, 0x39, 0x9B, 0xCC, 0xDA, 0xE6, 0xDF, 0x3E,
  0xF1, 0xF7, 0x87, 0xBC, 0x39, 0xE1, 0xCF, 0x00, 0xE7, 0x66, 0x7E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x7E, 0x66, 0xE7, 0xE3, 0xE7, 0x67, 0x76, 0x76, 0x3E,
  0x3E, 0x3C, 0x1C, 0x1C, 0x18, 0x38, 0x78, 0x70, 0xFF, 0xF1, 0xC7, 0x38,
  0xE7, 0x1C, 0xFF, 0xF0, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x3C, 0xF0, 0xC3,
  0x8E, 0x38, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6,
  0x31, 0xCF, 0x7B, 0x98, 0xC6, 0x33, 0x98, 0x71, 0xFF, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 8, 1, -13 },
  { 11, 9, 13, 9, 0, -13 },
  { 26, 7, 15, 9, 1, -14 },
  { 40, 14, 13, 14, 0, -13 },
  { 63, 11, 13, 11, 0, -13 },
  { 81, 3, 5, 4, 1, -13 },
  { 83, 5, 16, 6, 1, -13 },
  { 93, 5, 16, 6, 0, -13 },
  { 103, 8, 8, 8, 0, -14 },
  { 111, 7, 9, 9, 1, -11 },
  { 119, 3, 4, 5, 1, -2 },
  { 121, 4, 2, 6, 1, -6 },
  { 122, 3, 3, 5, 1, -3 },
  { 124, 7, 13, 7, 0, -13 },
  { 136, 7, 13, 9, 1, -13 },
  { 148, 6, 13, 9, 1, -13 },
  { 158, 8, 13, 9, 0, -13 },
  { 171, 7, 13, 9, 1, -13 },
  { 183, 8, 13, 9, 0, -13 },
  { 196, 7, 13, 9, 1, -13 },
  { 208, 7, 13, 9, 1, -13 },
  { 220, 7, 13, 9, 1, -13 },
  { 232, 7, 13, 9, 1, -13 },
  { 244, 8, 13, 9, 0, -13 },
  { 257, 3, 10, 5, 1, -10 },
  { 261, 3, 12, 5, 1, -10 },
  { 266, 8, 9, 9, 0, -11 },
  { 275, 7, 6, 9, 1, -9 },
  { 281, 7, 9, 9, 1, -11 },
  { 289, 7, 13, 7, 0, -13 },
  { 301, 12, 14, 13, 1, -13 },
  { 322, 10, 13, 10, 0, -13 },
  { 339, 8, 13, 10, 1, -13 },
  { 352, 7, 13, 9, 1, -13 },
  { 364, 9, 13, 10, 1, -13 },
  { 379, 6, 13, 8, 1, -13 },
  { 389, 6, 13, 8, 1, -13 },
  { 399, 8, 13, 10, 1, -13 },
  { 412, 9, 13, 11, 1, -13 },
  { 427, 6, 13, 6, 0, -13 },
  { 437, 5, 17, 5, -1, -13 },
  { 448, 9, 13, 10, 1, -13 },
  { 463, 6, 13, 7, 1, -13 },
  { 473, 12, 13, 14, 1, -13 },
  { 493, 9, 13, 12, 1, -13 },
  { 508, 9, 13, 11, 1, -13 },
  { 523, 8, 13, 9, 1, -13 },
  { 536, 9, 16, 11, 1, -13 },
  { 554, 9, 13, 9, 1, -13 },
  { 569, 6, 13, 8, 1, -13 },
  { 579, 8, 13, 8, 0, -13 },
  { 592, 8, 13, 10, 1, -13 },
  { 605, 10, 13, 10, 0, -13 },
  { 622, 14, 13, 14, 0, -13 },
  { 645, 9, 13, 9, 0, -13 },
  { 660, 9, 13, 9, 0, -13 },
  { 675, 8, 13, 8, 0, -13 },
  { 688, 4, 16, 6, 1, -13 },
  { 696, 7, 13, 7, 0, -13 },
  { 708, 5, 16, 6, 0, -13 },
  { 718, 9, 8, 10, 0, -13 },
  { 727, 8, 2, 8, 0, 1 },
  { 729, 4, 3, 6, 1, -14 },
  { 731, 8, 10, 9, 0, -10 },
  { 741, 8, 14, 9, 1, -14 },
  { 755, 6, 10, 7, 1, -10 },
  { 763, 7, 14, 9, 1, -14 },
  { 776, 7, 10, 8, 1, -10 },
  { 785, 6, 14, 6, 0, -14 },
  { 796, 7, 14, 9, 1, -10 },
  { 809, 7, 14, 9, 1, -14 },
  { 822, 3, 14, 5, 1, -14 },
  { 828, 5, 18, 5, -1, -14 },
  { 840, 8, 14, 9, 1, -14 },
  { 854, 3, 14, 5, 1, -14 },
  { 860, 12, 10, 14, 1, -10 },
  { 875, 7, 10, 9, 1, -10 },
  { 884, 7, 10, 9, 1, -10 },
  { 893, 8, 14, 9, 1, -10 },
  { 907, 7, 14, 9, 1, -10 },
  { 920, 5, 10, 6, 1, -10 },
  { 927, 6, 10, 7, 0, -10 },
  { 935, 6, 12, 6, 0, -12 },
  { 944, 7, 10, 9, 1, -10 },
  { 953, 8, 10, 8, 0, -10 },
  { 963, 13, 10, 13, 0, -10 },
  { 980, 8, 10, 8, 0, -10 },
  { 990, 8, 14, 8, 0, -10 },
  { 1004, 6, 10, 7, 0, -10 },
  { 1012, 6, 16, 6, 0, -13 },
  { 1024, 2, 18, 8, 3, -14 },
  { 1029, 5, 16, 6, 1, -13 },
  { 1039, 8, 3, 9, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD18PT7B_H_
