#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x09, 0xFF, 0xFF, 0xFF, 0xFC, 0xFB, 0xE7, 0xDF, 0x3E, 0xF9, 0xF7, 0x8F,
  0xBC, 0x7D, 0xE3, 0xEF, 0x1F, 0x78, 0x78, 0x07, 0x9C, 0x07, 0x1C, 0x07,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x3F, 0xC7, 0xFF, 0xFF, 0xFB, 0xFF, 0xDE, 0xC4, 0xF6, 0x07, 0xB0, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x06, 0xF8, 0x37,
  0xC1, 0x9F, 0x0D, 0xFE, 0x7F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x1F,
  0xE0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0x3C, 0x3C, 0x07, 0x9E, 0x1C, 0x03,
  0xCF, 0x1E, 0x01, 0xE7, 0x8F, 0x00, 0xF3, 0xCF, 0x00, 0x79, 0xE7, 0x80,
  0x3C, 0xF3, 0x8F, 0x1E, 0x7B, 0xCF, 0xE7, 0xF9, 0xEF, 0xF3, 0xFD, 0xE7,
  0xFC, 0xFC, 0xF3, 0x9E, 0x18, 0x73, 0xCF, 0x00, 0x79, 0xE7, 0x80, 0x3C,
  0xF1, 0xC0, 0x1C, 0x78, 0xE0, 0x1E, 0x3C, 0xF0, 0x0E, 0x1E, 0x78, 0x0F,
  0x07, 0xBC, 0x07, 0x83, 0xFC, 0x03, 0x80, 0xFE, 0x03, 0xC0, 0x3E, 0x00,
  0x01, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80,
  0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x7E, 0xFF, 0xCF, 0x9F, 0xF9, 0xF7,
  0xEF, 0xBE, 0xF9, 0xFF, 0x9F, 0x1F, 0xF3, 0xE1, 0xFC, 0x7C, 0x3F, 0x8F,
  0xC7, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xE7, 0xE0,
  0xFD, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x78, 0x0F, 0x8F, 0x87, 0x87, 0xC3,
  0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87,
  0x87, 0xC7, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x21, 0xE2, 0xF7, 0xBB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E,
  0x38, 0xF0, 0x61, 0x80, 0x84, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x7D, 0xF7,
  0xDF, 0x79, 0xEF, 0xBE, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xFF,
  0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x7F, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0xC7, 0xDF, 0x3E, 0x7C, 0xF9, 0xFF,
  0xE3, 0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF,
  0x1F, 0xF3, 0xFF, 0x7D, 0xFF, 0xDF, 0x39, 0xF1, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0x00, 0xFF, 0x87, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF9, 0xC3, 0xE2, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x06, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0x83,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0x78, 0x1F, 0xF0, 0x7B, 0xE0, 0xF7, 0xC3, 0xCF, 0x87, 0x9F, 0x1E, 0x3E,
  0x3C, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7F, 0xF3, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x7F, 0x87, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x00, 0x70,
  0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE7, 0x8F, 0xBF, 0x3F, 0xFE, 0xFF, 0xFB, 0xFB, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x1F, 0x7C, 0xFD, 0xFF,
  0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7E, 0xF9, 0xF1, 0xF7, 0x87,
  0xDE, 0x1F, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9F, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x03, 0x00, 0x7F, 0x03,
  0xFF, 0x1F, 0xFC, 0x7F, 0xFB, 0xF3, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xDF,
  0x0E, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF1, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x7F, 0x80, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x13, 0xFF, 0xFF, 0xFE, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0xBC, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x3F, 0x00,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x01, 0xFC, 0x1F, 0xF1, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E,
  0x00, 0x20, 0x00, 0x06, 0x01, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x30,
  0xF8, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x3F, 0x81, 0xF0, 0x0F, 0x83, 0xC0,
  0x0F, 0x0F, 0x00, 0x0F, 0x1C, 0x3F, 0xCE, 0x78, 0xFF, 0x9E, 0xF3, 0xFF,
  0x3D, 0xC7, 0x9E, 0x7F, 0x9E, 0x3C, 0xFF, 0x3C, 0x79, 0xFE, 0x78, 0xF3,
  0xFC, 0xF1, 0xE7, 0xF9, 0xE3, 0xCF, 0xF3, 0xC7, 0x9D, 0xE7, 0x9F, 0x39,
  0xC7, 0xFF, 0xF3, 0xCF, 0xEF, 0xC7, 0x8F, 0x8F, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x20, 0x1F, 0xE7, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3E, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xDF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFF, 0xDF, 0x3F, 0xBE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC7, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x00,
  0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE1, 0x9F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x13, 0xF0, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x20, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xF1, 0xF8, 0x10, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFD, 0xF1, 0xFE,
  0xF8, 0xFF, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x83, 0xEF, 0xC1, 0xF3, 0xF0,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xF7, 0xFF, 0xFF,
  0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0xFF, 0xF7, 0xFB, 0xF0,
  0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC,
  0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xBF, 0xF7, 0x8F, 0x7F, 0xEF, 0x1E, 0xFF, 0xDE, 0x7D, 0xFF, 0xBE,
  0xF3, 0xFF, 0x3D, 0xE7, 0xFE, 0x7B, 0xCF, 0xFC, 0xFF, 0x1F, 0xF9, 0xFE,
  0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xE1, 0xFF, 0x8F, 0xC3,
  0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3C, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFE, 0xF1, 0xFF, 0xBE, 0x7F, 0xEF, 0x9F,
  0xF9, 0xF7, 0xFE, 0x7D, 0xFF, 0x8F, 0x7F, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E,
  0x3F, 0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xCF, 0xFE, 0x3F, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF0, 0x3F,
  0x7C, 0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3E, 0x3F, 0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF9, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0,
  0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E,
  0xF8, 0x3E, 0xF8, 0x3F, 0x03, 0x80, 0xFF, 0x8F, 0xFE, 0xFF, 0xE7, 0xFF,
  0x7E, 0x3B, 0xE0, 0x5F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x83,
  0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFE, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x1E, 0x07,
  0xFF, 0x03, 0xE0, 0xFB, 0xE0, 0x7C, 0x1F, 0x3C, 0x1F, 0x83, 0xE7, 0xC3,
  0xF0, 0x7C, 0xF8, 0x7E, 0x1F, 0x1F, 0x0F, 0xE3, 0xE3, 0xE3, 0xFC, 0x7C,
  0x7C, 0x7F, 0x8F, 0x87, 0xCF, 0xF1, 0xF0, 0xF9, 0xEE, 0x3E, 0x1F, 0x3D,
  0xEF, 0x83, 0xEF, 0xBD, 0xF0, 0x7D, 0xE7, 0xBE, 0x07, 0xBC, 0xF7, 0xC0,
  0xF7, 0x9E, 0xF8, 0x1F, 0xF1, 0xDE, 0x03, 0xFE, 0x3B, 0xC0, 0x7F, 0x87,
  0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x3E, 0x1F, 0x0F, 0x8F,
  0x87, 0xCF, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xC7,
  0xC3, 0xE3, 0xE3, 0xE1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xBE,
  0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x78, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x1F, 0x1E, 0x0F, 0x0F,
  0x0F, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xFB, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xC3, 0xFF,
  0x8F, 0xFE, 0x7F, 0xF3, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0xFF, 0x3F, 0xFB,
  0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFB, 0xCF, 0x8E, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x78, 0xFB, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF,
  0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xBF, 0xFE, 0xF7, 0xF3,
  0xCF, 0x80, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0xFF, 0x7E, 0x27, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x37, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x9F, 0x3F, 0xBE,
  0x7F, 0xFD, 0xFF, 0xFB, 0xE7, 0xF7, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC7, 0xEF, 0x8F,
  0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x3E, 0x7C, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x7C, 0x79, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x9F, 0xFE,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0x23, 0xE0, 0x3E, 0x03, 0xFC, 0x7F, 0xCF, 0xFC, 0xFF, 0xC3, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x3E, 0x7F,
  0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xCF, 0xEF, 0x8F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F, 0xDF,
  0x1F, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7C, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x98, 0x3F, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0xF8, 0xFF, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0x3F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0xF7, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFC,
  0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F,
  0xBF, 0x1F, 0x7C, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x87, 0xEF, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E, 0x3E, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE1, 0xF3, 0xDF, 0xCF,
  0xEF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0xE3, 0xF1, 0xFF,
  0x8F, 0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1, 0xFF, 0x87,
  0xC7, 0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1, 0xFF, 0x87, 0xC7,
  0xFE, 0x1F, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1, 0xFF, 0x87, 0xC7, 0xC0,
  0xF3, 0xE3, 0xDF, 0xCF, 0x7F, 0xBF, 0xFE, 0xFE, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0xBE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F,
  0x9F, 0x1F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xF1, 0xE3,
  0xCF, 0xCF, 0x7F, 0xBF, 0xFE, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xBE, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x3E,
  0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xCF, 0xEF, 0x8F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F,
  0xDF, 0x1F, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7C, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0xF1, 0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x80, 0x1F, 0x8F, 0xFD, 0xFF, 0xFF, 0xEF, 0x8D, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x8F, 0xF8, 0x7F, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x00, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xF3, 0xF3, 0xC0, 0xF8, 0x1F,
  0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1E, 0x7C, 0x7E, 0x3E,
  0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3C, 0x3C, 0xEF, 0x3C,
  0x3E, 0xE7, 0x7C, 0x3E, 0xE7, 0x7C, 0x3F, 0xE7, 0x7C, 0x1F, 0xE7, 0xF8,
  0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0xF8,
  0xF9, 0xF1, 0xF1, 0xF7, 0xC3, 0xEF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xDF, 0x0F,
  0xBE, 0x1F, 0x7C, 0x7C, 0x7C, 0xF8, 0xFB, 0xF0, 0xF8, 0xF8, 0x1F, 0xFC,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x83, 0xF1,
  0xFE, 0x3E, 0x07, 0xF0, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFC, 0x1F,
  0xC0, 0xF8, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0x00, 0x00, 0x3C,
  0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 13, 9, 16, 1, -24 },
  { 31, 16, 24, 18, 1, -24 },
  { 79, 13, 28, 16, 2, -26 },
  { 125, 25, 25, 27, 1, -25 },
  { 204, 19, 25, 20, 1, -25 },
  { 264, 6, 9, 8, 1, -24 },
  { 271, 9, 30, 11, 2, -25 },
  { 305, 9, 30, 11, 0, -25 },
  { 339, 14, 15, 16, 1, -26 },
  { 366, 14, 16, 16, 1, -20 },
  { 394, 6, 9, 9, 1, -4 },
  { 401, 9, 4, 11, 1, -11 },
  { 406, 5, 6, 9, 2, -6 },
  { 410, 14, 25, 14, 0, -25 },
  { 454, 14, 25, 16, 1, -25 },
  { 498, 12, 24, 16, 1, -24 },
  { 534, 14, 25, 16, 1, -25 },
  { 578, 14, 25, 16, 1, -25 },
  { 622, 15, 24, 16, 1, -24 },
  { 667, 13, 24, 16, 2, -24 },
  { 706, 14, 25, 16, 1, -25 },
  { 750, 14, 24, 16, 1, -24 },
  { 792, 14, 25, 16, 1, -25 },
  { 836, 14, 25, 16, 1, -25 },
  { 880, 5, 19, 9, 2, -19 },
  { 892, 6, 24, 9, 1, -19 },
  { 910, 14, 16, 16, 1, -20 },
  { 938, 14, 12, 16, 1, -18 },
  { 959, 14, 16, 16, 1, -20 },
  { 987, 13, 25, 13, 0, -25 },
  { 1028, 23, 28, 25, 1, -25 },
  { 1109, 19, 24, 19, 0, -24 },
  { 1166, 15, 24, 18, 2, -24 },
  { 1211, 15, 25, 17, 1, -25 },
  { 1258, 16, 24, 19, 2, -24 },
  { 1306, 11, 24, 15, 2, -24 },
  { 1339, 11, 24, 15, 2, -24 },
  { 1372, 17, 25, 20, 1, -25 },
  { 1426, 16, 24, 20, 2, -24 },
  { 1474, 9, 24, 11, 1, -24 },
  { 1501, 9, 31, 10, -2, -24 },
  { 1536, 16, 24, 18, 2, -24 },
  { 1584, 12, 24, 14, 2, -24 },
  { 1620, 23, 24, 27, 2, -24 },
  { 1689, 18, 24, 22, 2, -24 },
  { 1743, 18, 25, 21, 1, -25 },
  { 1800, 14, 24, 17, 2, -24 },
  { 1842, 18, 31, 21, 1, -25 },
  { 1912, 16, 24, 18, 2, -24 },
  { 1960, 13, 25, 15, 1, -25 },
  { 2001, 14, 24, 15, 1, -24 },
  { 2043, 16, 24, 20, 2, -24 },
  { 2091, 18, 24, 18, 0, -24 },
  { 2145, 27, 24, 26, 0, -24 },
  { 2226, 17, 24, 17, 0, -24 },
  { 2277, 17, 24, 17, 0, -24 },
  { 2328, 13, 24, 15, 1, -24 },
  { 2367, 8, 31, 10, 2, -25 },
  { 2398, 14, 25, 14, 0, -25 },
  { 2442, 8, 31, 10, 1, -25 },
  { 2473, 17, 15, 18, 1, -24 },
  { 2505, 15, 3, 15, 0, 3 },
  { 2511, 9, 5, 11, 1, -26 },
  { 2517, 13, 19, 16, 1, -19 },
  { 2548, 14, 26, 17, 2, -26 },
  { 2594, 12, 19, 14, 1, -19 },
  { 2623, 15, 26, 17, 1, -26 },
  { 2672, 14, 19, 16, 1, -19 },
  { 2706, 12, 26, 11, 0, -26 },
  { 2745, 15, 27, 17, 1, -19 },
  { 2796, 14, 26, 17, 2, -26 },
  { 2842, 5, 26, 9, 2, -26 },
  { 2859, 8, 34, 9, -1, -26 },
  { 2893, 15, 26, 17, 2, -26 },
  { 2942, 5, 26, 9, 2, -26 },
  { 2959, 22, 19, 26, 2, -19 },
  { 3012, 14, 19, 17, 2, -19 },
  { 3046, 15, 19, 17, 1, -19 },
  { 3082, 14, 27, 17, 2, -19 },
  { 3130, 15, 27, 17, 1, -19 },
  { 3181, 10, 19, 12, 2, -19 },
  { 3205, 11, 19, 13, 1, -19 },
  { 3232, 11, 23, 12, 0, -23 },
  { 3264, 14, 19, 17, 2, -19 },
  { 3298, 16, 19, 16, 0, -19 },
  { 3336, 24, 19, 24, 0, -19 },
  { 3393, 15, 19, 15, 0, -19 },
  { 3429, 16, 27, 16, 0, -19 },
  { 3483, 11, 19, 13, 1, -19 },
  { 3510, 11, 30, 12, 0, -24 },
  { 3552, 4, 34, 15, 5, -26 },
  { 3569, 11, 30, 12, 1, -24 },
  { 3611, 14, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD34PT7B_H_
