#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7C, 0xE0,
  0x19, 0x86, 0xC1, 0xB0, 0x6C, 0x7F, 0xDF, 0xF1, 0xB0, 0xCC, 0xFF, 0xBF,
  0xE3, 0x60, 0xD8, 0x36, 0x1D, 0x80, 0x10, 0xFF, 0xFF, 0x9D, 0x1E, 0x1E,
  0x1E, 0x1E, 0x2E, 0x5F, 0xFF, 0xC2, 0x04, 0x00, 0x60, 0xC3, 0xE3, 0x0D,
  0x9C, 0x36, 0x60, 0xD9, 0x83, 0x6C, 0x0D, 0xB7, 0xBF, 0xFE, 0x76, 0xCC,
  0x1B, 0x30, 0xCC, 0xC3, 0x37, 0x1C, 0x78, 0x61, 0xE0, 0x1C, 0x07, 0xE0,
  0xDC, 0x39, 0x83, 0x70, 0x7C, 0x07, 0x83, 0xE7, 0x7E, 0xFC, 0xFB, 0x8F,
  0x3B, 0xC7, 0xFC, 0x7D, 0xC0, 0xFF, 0xFC, 0x39, 0x9C, 0xCE, 0x73, 0x98,
  0xC6, 0x39, 0xCE, 0x31, 0xC6, 0x38, 0xE3, 0x1C, 0x63, 0x9C, 0x63, 0x18,
  0xC6, 0x73, 0x99, 0xCE, 0xE0, 0x1C, 0x1C, 0x59, 0x7F, 0xFF, 0x3C, 0x36,
  0x77, 0x24, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0xFF,
  0xEC, 0xFF, 0xFF, 0x80, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18,
  0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0x38, 0xFB, 0xFF, 0x7E, 0xFC, 0xF1,
  0xE3, 0xE7, 0xDF, 0xBF, 0x77, 0xCF, 0x80, 0x0C, 0x73, 0xDF, 0xFD, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x1C, 0x7E, 0xFF, 0x47, 0x07, 0x07,
  0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x7F, 0x7F, 0x79, 0xFB, 0xFC, 0x70,
  0xE1, 0xDE, 0x3E, 0x0E, 0x1C, 0x3C, 0x7F, 0xFF, 0x80, 0x06, 0x07, 0x03,
  0x83, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x7F, 0xFF, 0xE0, 0xC0, 0x60,
  0x30, 0xFF, 0xFF, 0xFF, 0x0E, 0x1F, 0x3F, 0x7F, 0x0E, 0x1C, 0x3C, 0x7F,
  0xFF, 0x00, 0x1E, 0x7D, 0xFF, 0x0E, 0x1B, 0xBF, 0xF7, 0xE7, 0x8F, 0x9F,
  0x77, 0xEF, 0x80, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0x87, 0x0E, 0x18, 0x70,
  0xE3, 0x87, 0x0E, 0x00, 0x38, 0x7E, 0xEE, 0xE6, 0xEE, 0xFE, 0x7C, 0x7C,
  0xEE, 0xC6, 0xC7, 0xE6, 0xFE, 0x7C, 0x38, 0xFB, 0xFF, 0x7C, 0x78, 0xFB,
  0xFF, 0x76, 0x0C, 0x38, 0xEF, 0xDF, 0x00, 0x5F, 0xA0, 0x00, 0xFF, 0x80,
  0x5F, 0xB0, 0x00, 0x1F, 0xFD, 0x80, 0x03, 0x0F, 0x7C, 0xF0, 0xE0, 0x7C,
  0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C,
  0x1F, 0x0F, 0x7C, 0xF0, 0xC0, 0x80, 0x39, 0xFB, 0xFA, 0x70, 0xE1, 0xC7,
  0x1C, 0x30, 0x00, 0x01, 0x83, 0x87, 0x00, 0x07, 0x01, 0xFC, 0x30, 0xE6,
  0x07, 0xCF, 0xBC, 0xDB, 0xD9, 0xBD, 0x9B, 0xD9, 0xBD, 0x9B, 0xDE, 0xFC,
  0xEE, 0x60, 0x07, 0x0C, 0x3F, 0xC0, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x3F,
  0x0E, 0xC3, 0xB8, 0xCE, 0x73, 0x9F, 0xE7, 0xFD, 0xC7, 0xE1, 0xF8, 0x70,
  0xF8, 0x7F, 0x3F, 0xDC, 0xEE, 0x77, 0x3B, 0xF9, 0xFE, 0xE7, 0x71, 0xB9,
  0xFC, 0xEF, 0xF7, 0xF0, 0x1C, 0x3F, 0x7E, 0xF1, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x73, 0x7F, 0x3E, 0xF8, 0x7F, 0x3F, 0xDC, 0xFE, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFF, 0xEF, 0xE7, 0xE0, 0xFF, 0xFF,
  0xF8, 0xE3, 0x8F, 0xFF, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8F, 0xFF, 0xFF, 0x8E, 0x38, 0xE3, 0x80, 0x0E, 0x1F, 0xDF, 0xDE,
  0x0E, 0x07, 0x03, 0xBF, 0xDF, 0xEF, 0xF1, 0xF8, 0xEE, 0x77, 0xF9, 0xFC,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1C, 0xFF, 0xF7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0xFF, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xF7, 0xFF, 0x80, 0xE3, 0xF1, 0xF9, 0xDD, 0xEE, 0xE7, 0xE3, 0xF1, 0xF8,
  0xFE, 0x77, 0x39, 0xDC, 0xEE, 0x7F, 0x1C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0, 0xF0, 0x7F, 0x83, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF, 0xF6, 0xFD, 0xB7, 0xED, 0xBF, 0x7D,
  0xFB, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C, 0xF1, 0xFC, 0x7F, 0x1F, 0xE7,
  0xF9, 0xFF, 0x7F, 0xDF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8,
  0xF0, 0x1E, 0x1F, 0xC7, 0xFB, 0x8E, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x39, 0xDE, 0x7F, 0x0F, 0x80, 0xF8, 0xFE, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xC7,
  0xFB, 0x8E, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x39, 0xDE,
  0x7F, 0x0F, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xF8, 0x7F, 0x3F, 0xDC, 0xEE,
  0x77, 0x3B, 0xBD, 0xFC, 0xFC, 0x77, 0x3B, 0x9C, 0xEE, 0x77, 0x1C, 0x39,
  0xFF, 0xF7, 0x2E, 0x1C, 0x3E, 0x3E, 0x1C, 0x1E, 0x3E, 0xFF, 0xDF, 0x00,
  0xFF, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xE1, 0xF8, 0x76, 0x1D, 0xC6, 0x73,
  0x9C, 0xE3, 0x38, 0xCC, 0x3F, 0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x80,
  0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x37, 0x1C, 0xE6, 0x79, 0xCE, 0xFB, 0x9D,
  0xB7, 0x3B, 0x6C, 0x76, 0xD8, 0x7D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC3, 0xC7,
  0x87, 0x8E, 0x00, 0xE3, 0xB9, 0xDD, 0xC6, 0xE3, 0xE1, 0xF0, 0x78, 0x38,
  0x3E, 0x1F, 0x0D, 0xCE, 0xE7, 0x3F, 0x1C, 0xE3, 0xF1, 0xDC, 0xEE, 0xE3,
  0x71, 0xF0, 0xF8, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xFF,
  0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xFF,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0xE0, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8, 0x0C,
  0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0C, 0xC7, 0x39, 0xC6, 0xE1, 0xC0, 0xFF,
  0xFF, 0xC0, 0xE6, 0x70, 0x39, 0xF9, 0xF8, 0x71, 0xFF, 0xFB, 0xE7, 0xCF,
  0xFF, 0xD8, 0xE0, 0xE0, 0xE0, 0xEC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFE, 0xDE, 0x19, 0xFF, 0xF8, 0xE3, 0x0C, 0x38, 0xE7, 0xF7,
  0xC0, 0x07, 0x07, 0x07, 0x27, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7, 0xC7, 0xE7,
  0xEF, 0xFF, 0x77, 0x38, 0xFB, 0xFF, 0x3C, 0x7F, 0xFF, 0xE0, 0xE3, 0xFD,
  0xF8, 0x08, 0xF7, 0xDC, 0x73, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x00, 0x30, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7, 0xC7, 0xE7, 0xEF, 0xFF, 0x77,
  0x07, 0x86, 0xFE, 0xFC, 0x30, 0xE0, 0xE0, 0xE0, 0xEC, 0xFE, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x5F, 0x81, 0xFF, 0xFF, 0xFF,
  0xF8, 0x11, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F,
  0xFC, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x77, 0x73, 0xB9, 0xF8, 0xFC,
  0x7E, 0x3B, 0x9D, 0xCE, 0x77, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x66, 0xF7, 0xBF, 0xFD, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC,
  0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0x0C, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x18, 0x7E, 0xFE, 0xE7, 0xE7, 0xC7, 0xC7,
  0xE7, 0xE6, 0x7E, 0x3C, 0x0C, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x30, 0x7F, 0xFF, 0xE7,
  0xE7, 0xC7, 0xC7, 0xE7, 0xEF, 0xFF, 0x77, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x7F, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x33, 0xFF, 0xB0,
  0xE3, 0xE7, 0xC7, 0x9F, 0xEF, 0x80, 0x30, 0xC7, 0x3F, 0xFD, 0xC7, 0x1C,
  0x71, 0xC7, 0x5F, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF,
  0xFF, 0x7F, 0xE3, 0xB1, 0x9D, 0xCE, 0xE7, 0x61, 0xB0, 0xF8, 0x7C, 0x1C,
  0x0E, 0x00, 0xE7, 0x3B, 0x3D, 0xD9, 0xEE, 0xFB, 0x67, 0xDB, 0x3E, 0xD8,
  0xF7, 0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x00, 0xE7, 0x76, 0x3E, 0x3E, 0x3C,
  0x3C, 0x3E, 0x7E, 0x77, 0xE7, 0xE3, 0xB1, 0x9D, 0xCE, 0xE3, 0x61, 0xB0,
  0xF8, 0x7C, 0x1C, 0x0E, 0x07, 0x03, 0x07, 0x83, 0x81, 0x80, 0x7E, 0xFC,
  0x70, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xFC, 0x0C, 0xF3, 0xCE, 0x38, 0xE3,
  0x9E, 0xF3, 0xC3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC3, 0x8F, 0x1C, 0x71, 0xC7, 0x1E, 0x3D, 0xF7, 0x1C, 0x71, 0xC7,
  0x38, 0xE0, 0x7C, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 10, 0, -14 },
  { 30, 7, 15, 9, 1, -14 },
  { 44, 14, 14, 15, 1, -14 },
  { 69, 11, 14, 11, 0, -14 },
  { 89, 3, 5, 5, 1, -14 },
  { 91, 5, 17, 6, 1, -14 },
  { 102, 5, 17, 6, 0, -14 },
  { 113, 8, 9, 9, 0, -15 },
  { 122, 8, 9, 9, 1, -11 },
  { 131, 3, 5, 5, 1, -2 },
  { 133, 4, 2, 6, 1, -6 },
  { 134, 3, 3, 5, 1, -3 },
  { 136, 8, 14, 8, 0, -14 },
  { 150, 7, 14, 9, 1, -14 },
  { 163, 6, 14, 9, 1, -14 },
  { 174, 8, 14, 9, 0, -14 },
  { 188, 7, 14, 9, 1, -14 },
  { 201, 9, 14, 9, 0, -14 },
  { 217, 7, 14, 9, 1, -14 },
  { 230, 7, 14, 9, 1, -14 },
  { 243, 7, 14, 9, 1, -14 },
  { 256, 8, 14, 9, 1, -14 },
  { 270, 7, 14, 9, 1, -14 },
  { 283, 3, 11, 5, 1, -11 },
  { 288, 3, 14, 5, 1, -11 },
  { 294, 8, 9, 9, 1, -11 },
  { 303, 8, 6, 9, 1, -10 },
  { 309, 8, 9, 9, 1, -11 },
  { 318, 7, 14, 7, 0, -14 },
  { 331, 12, 15, 14, 1, -14 },
  { 354, 10, 14, 10, 0, -14 },
  { 372, 9, 14, 10, 1, -14 },
  { 388, 8, 14, 9, 1, -14 },
  { 402, 9, 14, 11, 1, -14 },
  { 418, 6, 14, 8, 1, -14 },
  { 429, 6, 14, 8, 1, -14 },
  { 440, 9, 14, 11, 1, -14 },
  { 456, 9, 14, 11, 1, -14 },
  { 472, 6, 14, 6, 0, -14 },
  { 483, 5, 18, 5, -1, -14 },
  { 495, 9, 14, 10, 1, -14 },
  { 511, 7, 14, 8, 1, -14 },
  { 524, 13, 14, 15, 1, -14 },
  { 547, 10, 14, 12, 1, -14 },
  { 565, 10, 14, 12, 1, -14 },
  { 583, 8, 14, 10, 1, -14 },
  { 597, 10, 17, 12, 1, -14 },
  { 619, 9, 14, 10, 1, -14 },
  { 635, 7, 14, 8, 1, -14 },
  { 648, 8, 14, 8, 0, -14 },
  { 662, 9, 14, 11, 1, -14 },
  { 678, 10, 14, 10, 0, -14 },
  { 696, 15, 14, 15, 0, -14 },
  { 723, 9, 14, 9, 0, -14 },
  { 739, 9, 14, 9, 0, -14 },
  { 755, 8, 14, 8, 0, -14 },
  { 769, 4, 17, 6, 1, -14 },
  { 778, 8, 14, 8, 0, -14 },
  { 792, 5, 17, 6, 0, -14 },
  { 803, 10, 9, 10, 0, -14 },
  { 815, 9, 2, 9, 0, 1 },
  { 818, 4, 3, 6, 1, -15 },
  { 820, 7, 11, 9, 1, -11 },
  { 830, 8, 14, 10, 1, -14 },
  { 844, 6, 11, 8, 1, -11 },
  { 853, 8, 14, 10, 1, -14 },
  { 867, 7, 11, 9, 1, -11 },
  { 877, 6, 15, 6, 0, -15 },
  { 889, 8, 16, 10, 1, -11 },
  { 905, 8, 14, 10, 1, -14 },
  { 919, 3, 15, 5, 1, -15 },
  { 925, 5, 20, 5, -1, -15 },
  { 938, 9, 14, 10, 1, -14 },
  { 954, 3, 14, 5, 1, -14 },
  { 960, 13, 11, 15, 1, -11 },
  { 978, 8, 11, 10, 1, -11 },
  { 989, 8, 11, 10, 1, -11 },
  { 1000, 8, 16, 10, 1, -11 },
  { 1016, 8, 16, 10, 1, -11 },
  { 1032, 6, 11, 7, 1, -11 },
  { 1041, 6, 11, 7, 1, -11 },
  { 1050, 6, 13, 6, 0, -13 },
  { 1060, 8, 10, 10, 1, -10 },
  { 1070, 9, 10, 9, 0, -10 },
  { 1082, 13, 10, 13, 0, -10 },
  { 1099, 8, 10, 9, 0, -10 },
  { 1109, 9, 15, 9, 0, -10 },
  { 1126, 7, 10, 7, 0, -10 },
  { 1135, 6, 17, 7, 0, -14 },
  { 1148, 2, 19, 8, 3, -15 },
  { 1153, 6, 17, 7, 1, -14 },
  { 1166, 9, 3, 9, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD19PT7B_H_
