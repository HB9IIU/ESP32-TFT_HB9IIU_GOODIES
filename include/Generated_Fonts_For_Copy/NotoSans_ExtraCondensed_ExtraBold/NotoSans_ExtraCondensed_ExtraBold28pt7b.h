#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x00, 0x04, 0x7F,
  0xFE, 0xF0, 0xFB, 0xFF, 0x7F, 0xC7, 0xF8, 0xE7, 0x1C, 0xE3, 0x9C, 0x70,
  0x0E, 0x70, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0x30, 0x3B, 0x81, 0x9C, 0x1C, 0xE0, 0xE7, 0x00, 0x06, 0x00, 0xC0,
  0x7F, 0x3F, 0xF7, 0xFD, 0xEC, 0xBD, 0x87, 0xB0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xBC, 0x37, 0xE7, 0xFF, 0xFB, 0xFE, 0x0F,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x3C, 0x0F, 0x03, 0xF0, 0x70, 0x3F, 0xC3,
  0x81, 0xCE, 0x38, 0x0E, 0x71, 0xC0, 0x73, 0x9E, 0x03, 0x9C, 0xE0, 0x1C,
  0xE7, 0x00, 0xE7, 0x73, 0xE7, 0xFB, 0xBF, 0x9F, 0xBD, 0xFC, 0x79, 0xCE,
  0xE0, 0x0E, 0xF7, 0x80, 0xE7, 0x9C, 0x07, 0x38, 0xE0, 0x79, 0xEF, 0x03,
  0x87, 0x70, 0x1C, 0x3F, 0x81, 0xC1, 0xFC, 0x0E, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x1E, 0x7F, 0x9E, 0xFF, 0xBE, 0xF7, 0xFC,
  0xF3, 0xFC, 0xF1, 0xF8, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xBF, 0xFF, 0xFD, 0xE7, 0x39, 0xC0, 0x0F, 0x1E, 0x3C, 0x3C, 0x38,
  0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x0F, 0xF0, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0xF0, 0x07, 0x00, 0x70, 0x47, 0x17,
  0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0x81, 0xFC, 0x3D, 0xE7, 0xDE, 0x18, 0xC0,
  0x88, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7B, 0xDE,
  0xFF, 0x7B, 0xDC, 0xFF, 0xFF, 0xF8, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF, 0x9F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF,
  0x7B, 0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0x07, 0x87, 0xC3, 0xE3, 0xF3, 0xFF,
  0xFD, 0xDE, 0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3F, 0x0F, 0xF3, 0xFF, 0x7B, 0xF6, 0x3E,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x9F, 0xFB,
  0xFF, 0x39, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x3F, 0x87, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0xE7, 0xFF, 0xFB, 0xFF, 0x7F,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x83, 0xBC, 0x1D, 0xE1, 0xCF, 0x0E, 0x78, 0xE3, 0xC7, 0x1E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xF8, 0x7F, 0xCF, 0xF9,
  0xFF, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0xE7, 0xFF, 0xFB, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0xFF, 0xBF, 0x17, 0x80, 0xE0, 0x3C, 0x07,
  0xBC, 0xFF, 0xDF, 0xFF, 0xEF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0x7B, 0xEF, 0xFC, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x1F, 0x87,
  0xFC, 0x7F, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0x79, 0xE7, 0xFC, 0x3F, 0xC1,
  0xF0, 0x3F, 0x87, 0xFC, 0xF9, 0xEF, 0x1E, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF,
  0xFE, 0x7F, 0xC3, 0xF8, 0x1F, 0x0F, 0xF1, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x7F, 0xFF, 0xBF, 0x73, 0xDE, 0x03, 0xC0,
  0x78, 0x1E, 0x87, 0xCF, 0xF1, 0xFC, 0x3F, 0x00, 0x23, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0x47, 0xFF, 0xEF, 0x23, 0xFE, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xBD, 0xEF, 0xF7, 0xBD, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7F, 0x1F, 0xCF, 0xF0, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0,
  0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F, 0x00,
  0xC0, 0x08, 0x00, 0x3F, 0x3F, 0xEF, 0xFD, 0xDF, 0x43, 0xC0, 0xF0, 0x3C,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x1E,
  0x0F, 0x83, 0xE0, 0x70, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x3C, 0x1E,
  0x01, 0xC3, 0x80, 0x3C, 0xE1, 0xF3, 0x9C, 0xFF, 0x73, 0x9E, 0xE7, 0xE7,
  0x1C, 0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x9E, 0x7E, 0x73, 0x8D, 0xCE,
  0x73, 0xB9, 0xFF, 0xF7, 0x9F, 0x7C, 0x71, 0xC7, 0x0F, 0x00, 0x00, 0xF0,
  0x08, 0x0F, 0x8F, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFF, 0x3F, 0xFE, 0x78, 0x3C, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xF0, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEF, 0x7E, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xFF,
  0xCF, 0xF8, 0xFF, 0xEF, 0x3E, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xEE, 0x7C,
  0x27, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xC1, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0xFF,
  0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC3, 0xDE,
  0x3E, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x8F,
  0xCE, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE7, 0xFF,
  0x9F, 0xFE, 0x7F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDF, 0x1F, 0x7E, 0x7C,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFC, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xF0, 0xFF, 0xFF, 0xFE, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFE, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFF, 0xFE, 0xFE, 0xF8,
  0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x3E, 0x7B, 0xE3, 0xDF, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x79, 0xE3, 0xCF,
  0x9E, 0x3C, 0xF1, 0xF7, 0x8F, 0xBC, 0x3D, 0xE1, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFD, 0xCE, 0xFF, 0x73, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xCF, 0xCF, 0xF3, 0xE3, 0xFC, 0x78,
  0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xDE, 0xFF, 0x7B,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x1F, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7,
  0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDE, 0x0F, 0x3E, 0x3E, 0x7E, 0xFC,
  0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x7F, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xF1,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xDE, 0x0F, 0x3E, 0x3E, 0x7E, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0xFF, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xE7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0x78, 0x7B, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1,
  0xE7, 0x8F, 0xBC, 0x7D, 0xE1, 0xF0, 0x3F, 0x9F, 0xF7, 0xFF, 0xFF, 0xF0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xF0, 0x1F,
  0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x8F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDC,
  0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF0, 0x78, 0x3F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xBE, 0x3E, 0x1E, 0x78,
  0xF8, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xCF, 0x9E, 0x3F, 0x3C, 0x79, 0xFC,
  0xF0, 0xF7, 0x73, 0xC3, 0xDD, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCF, 0xE0,
  0xF7, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0xF8, 0x79, 0xE3, 0xE7, 0xCF,
  0x0F, 0x3C, 0x3D, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0x3C, 0x3C,
  0xF1, 0xE3, 0xE7, 0x87, 0xBE, 0x1F, 0xF8, 0x7D, 0xE1, 0xE7, 0x87, 0x9F,
  0x3E, 0x3C, 0xF0, 0xF3, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFE, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x3C,
  0x78, 0x78, 0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF8, 0x78, 0xF0, 0xF0, 0x06, 0x0F, 0xF1, 0xFF, 0x1F, 0xF2,
  0x1E, 0x03, 0xC3, 0xFB, 0xFF, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFB, 0xE7, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x98, 0xF7, 0xCF, 0x7E, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0x7E, 0xF3, 0xC0,
  0x06, 0x0F, 0xF7, 0xFD, 0xFE, 0xF8, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0xFC, 0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF1, 0xCF, 0x3E, 0xF7, 0xFF, 0x7F, 0xFF, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x9F, 0x7F,
  0xF7, 0xFF, 0x3E, 0xF0, 0x06, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0x1F, 0xE3,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x07, 0x86, 0xFF, 0xCF,
  0xF8, 0xFE, 0x1F, 0x8F, 0xCF, 0xE7, 0x83, 0xC1, 0xE1, 0xFF, 0xFF, 0xFF,
  0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0x1C, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xF7, 0xFF, 0x7E,
  0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x41, 0xE7, 0xFE, 0x7F, 0xC7, 0xF8, 0x1E,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x18, 0xF7, 0xEF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x23, 0xBF, 0xF7,
  0x00, 0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x08,
  0x38, 0xF9, 0xF1, 0xC0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3F, 0xFB, 0xF7, 0xC7,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF1, 0xEF,
  0x3E, 0xF3, 0xCF, 0x78, 0xF7, 0x8E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F,
  0x78, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0x83, 0x1E, 0xFD, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0x3F, 0xF1,
  0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3,
  0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7,
  0x8F, 0x01, 0x8F, 0x7E, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0x07, 0x03, 0xFC, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC1,
  0xF8, 0x01, 0x8F, 0x7C, 0xF7, 0xEF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xF7, 0xEF,
  0x3C, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00,
  0x0C, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xF7, 0xFF, 0x7E, 0xF3, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03,
  0xEF, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x1C, 0x3F, 0xFF, 0xFF, 0xEF, 0x17, 0x83, 0xF1, 0xFC,
  0x7F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7F, 0xFF, 0xFD, 0xFC, 0x1C, 0x0E, 0x0F,
  0x07, 0x87, 0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x79, 0x3F, 0x9F, 0xC7, 0xE0, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xF7,
  0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0x70, 0xF0, 0x7B, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0x8F, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0x70,
  0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF1, 0xF1, 0xF7, 0x9F, 0x9E,
  0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9B, 0xBC, 0x3B, 0xBB,
  0xC3, 0xF9, 0xBC, 0x3F, 0x9F, 0xC3, 0xF9, 0xF8, 0x3F, 0x9F, 0x81, 0xF9,
  0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x0F, 0x00, 0xF8, 0xF7, 0x9E,
  0x3D, 0xE3, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xFC,
  0x3F, 0xC3, 0xDE, 0x79, 0xE7, 0x9F, 0xF8, 0xF0, 0xF8, 0x7B, 0xC7, 0x9E,
  0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0x00, 0x7F, 0xDF, 0xF7, 0xFC,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0x87, 0xC7, 0xE3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x9F, 0x8F, 0x87, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFC, 0x3E, 0x1F, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xC3, 0xF0,
  0xF9, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xE3, 0xE1,
  0xF0, 0x80, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7E, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 20, 7, 1, -20 },
  { 14, 11, 7, 13, 1, -20 },
  { 24, 13, 20, 15, 1, -20 },
  { 57, 11, 23, 13, 1, -21 },
  { 89, 21, 20, 22, 1, -20 },
  { 142, 16, 20, 17, 1, -20 },
  { 182, 5, 7, 7, 1, -20 },
  { 187, 8, 24, 9, 1, -20 },
  { 211, 8, 24, 9, 0, -20 },
  { 235, 12, 12, 13, 0, -21 },
  { 253, 12, 14, 13, 1, -17 },
  { 274, 5, 8, 7, 1, -4 },
  { 279, 7, 3, 9, 1, -9 },
  { 282, 5, 5, 7, 1, -5 },
  { 286, 11, 20, 12, 0, -20 },
  { 314, 11, 20, 13, 1, -20 },
  { 342, 9, 20, 13, 1, -20 },
  { 365, 11, 20, 13, 1, -20 },
  { 393, 11, 20, 13, 1, -20 },
  { 421, 13, 20, 13, 0, -20 },
  { 454, 11, 20, 13, 1, -20 },
  { 482, 11, 20, 13, 1, -20 },
  { 510, 11, 20, 13, 1, -20 },
  { 538, 12, 20, 13, 1, -20 },
  { 568, 11, 20, 13, 1, -20 },
  { 596, 5, 16, 8, 1, -16 },
  { 606, 5, 20, 8, 1, -16 },
  { 619, 12, 14, 13, 1, -17 },
  { 640, 12, 9, 13, 1, -14 },
  { 654, 12, 14, 13, 1, -17 },
  { 675, 10, 20, 11, 0, -20 },
  { 700, 19, 22, 21, 1, -20 },
  { 753, 15, 20, 15, 0, -20 },
  { 791, 12, 20, 15, 2, -20 },
  { 821, 12, 20, 14, 1, -20 },
  { 851, 13, 20, 16, 2, -20 },
  { 884, 9, 20, 12, 2, -20 },
  { 907, 9, 20, 12, 2, -20 },
  { 930, 14, 20, 16, 1, -20 },
  { 965, 13, 20, 17, 2, -20 },
  { 998, 8, 20, 9, 1, -20 },
  { 1018, 8, 26, 8, -2, -20 },
  { 1044, 13, 20, 15, 2, -20 },
  { 1077, 9, 20, 12, 2, -20 },
  { 1100, 18, 20, 22, 2, -20 },
  { 1145, 14, 20, 18, 2, -20 },
  { 1180, 15, 20, 17, 1, -20 },
  { 1218, 11, 20, 14, 2, -20 },
  { 1246, 15, 25, 17, 1, -20 },
  { 1293, 13, 20, 15, 2, -20 },
  { 1326, 10, 20, 12, 1, -20 },
  { 1351, 12, 20, 12, 0, -20 },
  { 1381, 13, 20, 16, 2, -20 },
  { 1414, 15, 20, 15, 0, -20 },
  { 1452, 22, 20, 22, 0, -20 },
  { 1507, 14, 20, 14, 0, -20 },
  { 1542, 14, 20, 14, 0, -20 },
  { 1577, 12, 20, 12, 0, -20 },
  { 1607, 7, 25, 9, 1, -20 },
  { 1629, 11, 20, 12, 0, -20 },
  { 1657, 6, 25, 9, 1, -20 },
  { 1676, 15, 13, 15, 0, -20 },
  { 1701, 13, 3, 13, 0, 2 },
  { 1706, 7, 4, 9, 1, -21 },
  { 1710, 11, 16, 13, 1, -16 },
  { 1732, 12, 21, 14, 1, -21 },
  { 1764, 10, 16, 12, 1, -16 },
  { 1784, 12, 21, 14, 1, -21 },
  { 1816, 11, 16, 13, 1, -16 },
  { 1838, 9, 21, 9, 0, -21 },
  { 1862, 12, 23, 14, 1, -16 },
  { 1897, 12, 21, 14, 1, -21 },
  { 1929, 5, 22, 7, 1, -22 },
  { 1943, 7, 29, 7, -1, -22 },
  { 1969, 12, 21, 14, 2, -21 },
  { 2001, 5, 21, 7, 1, -21 },
  { 2015, 19, 16, 21, 1, -16 },
  { 2053, 12, 16, 14, 1, -16 },
  { 2077, 12, 16, 14, 1, -16 },
  { 2101, 12, 23, 14, 1, -16 },
  { 2136, 12, 23, 14, 1, -16 },
  { 2171, 8, 16, 10, 2, -16 },
  { 2187, 9, 16, 11, 1, -16 },
  { 2205, 9, 19, 10, 0, -19 },
  { 2227, 12, 15, 14, 1, -15 },
  { 2250, 13, 15, 13, 0, -15 },
  { 2275, 20, 15, 20, 0, -15 },
  { 2313, 12, 15, 13, 0, -15 },
  { 2336, 13, 22, 13, 0, -15 },
  { 2372, 10, 15, 11, 0, -15 },
  { 2391, 9, 25, 10, 0, -20 },
  { 2420, 4, 28, 12, 4, -22 },
  { 2434, 9, 25, 10, 1, -20 },
  { 2463, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD28PT7B_H_
