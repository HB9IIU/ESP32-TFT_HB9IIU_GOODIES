#ifndef _NOTOSANS_THINITALIC43PT7B_H_
#define _NOTOSANS_THINITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x20, 0x90, 0x58, 0x68,
  0x24, 0x12, 0x09, 0x05, 0x04, 0x82, 0x41, 0x20, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x10,
  0x08, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x20, 0x10, 0x00, 0x08, 0x04, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x80,
  0x00, 0x40, 0x20, 0x00, 0x10, 0x08, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x04,
  0x02, 0x00, 0x7F, 0xFF, 0xFE, 0x20, 0x80, 0x20, 0x00, 0x20, 0x10, 0x00,
  0x08, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x20,
  0x00, 0x10, 0x08, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x3F, 0x80, 0x1C, 0x47, 0x03, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x08,
  0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0xC1,
  0x00, 0x04, 0x10, 0x00, 0x33, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x2C, 0x00, 0x02, 0x30, 0x00, 0x41, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x04, 0x08, 0x00, 0x40, 0x80, 0x08, 0x08, 0x00, 0x81, 0x80, 0x08, 0x10,
  0x80, 0x86, 0x0F, 0x89, 0xC0, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x82,
  0x18, 0x00, 0x41, 0x02, 0x00, 0x20, 0x80, 0x40, 0x18, 0x20, 0x10, 0x04,
  0x10, 0x04, 0x02, 0x04, 0x01, 0x01, 0x81, 0x00, 0x40, 0xC0, 0x80, 0x30,
  0x20, 0x20, 0x08, 0x10, 0x08, 0x02, 0x0C, 0x02, 0x00, 0x82, 0x00, 0x80,
  0x21, 0x0E, 0x20, 0x10, 0x86, 0x68, 0x04, 0x62, 0x06, 0x02, 0x11, 0x01,
  0x81, 0x88, 0xC0, 0x50, 0xC4, 0x20, 0x13, 0xE3, 0x08, 0x04, 0x00, 0x84,
  0x01, 0x00, 0x41, 0x00, 0x40, 0x20, 0x40, 0x10, 0x18, 0x10, 0x04, 0x04,
  0x0C, 0x01, 0x02, 0x02, 0x00, 0x81, 0x80, 0x80, 0x20, 0xC0, 0x20, 0x18,
  0x20, 0x0C, 0x04, 0x10, 0x01, 0x03, 0x0C, 0x00, 0x61, 0x86, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x02, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x40, 0x04, 0x00,
  0x10, 0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x40, 0x08,
  0x00, 0x18, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x46, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x40, 0x00, 0x06, 0x18, 0x00, 0x46,
  0x03, 0x00, 0x23, 0x00, 0x40, 0x08, 0x80, 0x08, 0x04, 0x40, 0x03, 0x03,
  0x30, 0x00, 0x40, 0x88, 0x00, 0x08, 0x42, 0x00, 0x01, 0x30, 0x80, 0x00,
  0x78, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x07, 0x01, 0x00, 0x03, 0x60, 0x60,
  0x03, 0x08, 0x0C, 0x03, 0x81, 0x01, 0xFF, 0x80, 0x60, 0x25, 0xA4, 0x94,
  0x92, 0x00, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x38, 0x10, 0x03, 0x04, 0x00,
  0x31, 0x00, 0x03, 0x40, 0xC0, 0x3F, 0xE0, 0x14, 0x00, 0x09, 0x00, 0x04,
  0x20, 0x02, 0x08, 0x01, 0x02, 0x01, 0x80, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x0C, 0x20, 0x86, 0x10, 0xC2, 0x08, 0x41, 0x08, 0x00,
  0xFF, 0xC0, 0x78, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x03, 0x00,
  0x40, 0x60, 0x06, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x31, 0x00,
  0x03, 0x30, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C,
  0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x02,
  0x04, 0x00, 0x40, 0x60, 0x0C, 0x03, 0x01, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x60, 0x18, 0x0D, 0x02, 0x21, 0x8C, 0x41, 0x30, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0xC0,
  0x0C, 0x01, 0x80, 0x40, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0x81, 0x80, 0x30, 0x01, 0x01, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x80, 0x01, 0x83, 0x80, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x40, 0x00, 0x23, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00,
  0x40, 0x80, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40, 0x06, 0x01,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x40, 0x01, 0x83, 0x00, 0x04, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x08, 0x00, 0x60, 0x60, 0x06, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0xF8, 0x06, 0x30, 0x60, 0x4C, 0x01, 0x05,
  0x00, 0x08, 0x60, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00,
  0x88, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x20, 0x20, 0x06, 0x03, 0x01,
  0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x07, 0x00,
  0x40, 0x0C, 0x04, 0x00, 0x20, 0x60, 0x01, 0x82, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x80, 0x03, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81, 0x80, 0x08, 0x04,
  0x00, 0x80, 0x10, 0x18, 0x00, 0x63, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x07, 0x06, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00,
  0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x30, 0x00, 0x30, 0x80, 0x01, 0x06, 0x00, 0x30, 0x18, 0x03,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x0C, 0x03, 0x00, 0x60,
  0x60, 0x02, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00,
  0x13, 0x00, 0x03, 0x10, 0x00, 0x71, 0x00, 0x0F, 0x08, 0x01, 0xA0, 0x60,
  0x62, 0x03, 0xFC, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x0C,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x70,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x02, 0x18, 0x00, 0x7C, 0x01, 0x08, 0x01, 0xC3,
  0x80, 0x8C, 0x01, 0x80, 0x40, 0x64, 0x01, 0x00, 0x20, 0x12, 0x01, 0x00,
  0x20, 0x0A, 0x01, 0x80, 0x10, 0x0D, 0x00, 0x80, 0x08, 0x06, 0x80, 0xC0,
  0x04, 0x02, 0x40, 0x40, 0x04, 0x01, 0x60, 0x20, 0x02, 0x00, 0xB0, 0x10,
  0x01, 0x00, 0xD8, 0x08, 0x01, 0x80, 0x4C, 0x04, 0x00, 0xC0, 0x66, 0x02,
  0x00, 0xC0, 0x21, 0x01, 0x00, 0x90, 0x20, 0x80, 0xC0, 0x88, 0x30, 0x40,
  0x3F, 0x87, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x80, 0xC0, 0x01, 0x00, 0x80, 0x04, 0x01, 0x00, 0x18, 0x02,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x07, 0xFF, 0xF0,
  0x08, 0x00, 0x20, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x06,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0x80, 0x06, 0x03, 0xE0, 0x08, 0x00, 0x30, 0x10, 0x00, 0x20, 0x20,
  0x00, 0x60, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10, 0x40, 0x00, 0x40, 0x80, 0x01,
  0x81, 0x00, 0x0C, 0x03, 0xFF, 0xE0, 0x0C, 0x03, 0xC0, 0x10, 0x00, 0x60,
  0x20, 0x00, 0x60, 0x40, 0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x84,
  0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00,
  0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0x81, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x40, 0x01, 0x80,
  0x20, 0x00, 0x20, 0x10, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x08,
  0x00, 0x18, 0x04, 0x00, 0x38, 0x06, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x07, 0xC0, 0x30,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFE, 0x40, 0x00, 0x02,
  0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x20, 0x00,
  0x04, 0x18, 0x00, 0x04, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x60,
  0x07, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04,
  0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x08, 0x10,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00,
  0x06, 0x00, 0x01, 0xFC, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x07, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x80, 0x40, 0x01, 0x00, 0x20, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x08, 0x03, 0x00, 0x04, 0x03, 0x00, 0x02, 0x02,
  0x00, 0x03, 0x02, 0x00, 0x01, 0x02, 0x00, 0x00, 0x86, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x26, 0x80, 0x00, 0x34, 0x40, 0x00, 0x14, 0x30, 0x00, 0x0C,
  0x08, 0x00, 0x04, 0x06, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x20, 0x00, 0x80, 0x10, 0x00, 0x60, 0x08, 0x00, 0x10, 0x04, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x03, 0x02, 0x80, 0x00, 0x07, 0x02, 0x80, 0x00,
  0x05, 0x02, 0x80, 0x00, 0x0B, 0x02, 0x80, 0x00, 0x0A, 0x06, 0x80, 0x00,
  0x12, 0x04, 0xC0, 0x00, 0x32, 0x04, 0x40, 0x00, 0x22, 0x04, 0x40, 0x00,
  0x46, 0x0C, 0x40, 0x00, 0x44, 0x08, 0x40, 0x00, 0x84, 0x08, 0x40, 0x01,
  0x84, 0x08, 0x20, 0x01, 0x04, 0x08, 0x20, 0x02, 0x08, 0x18, 0x20, 0x02,
  0x08, 0x10, 0x20, 0x04, 0x08, 0x10, 0x20, 0x0C, 0x08, 0x10, 0x20, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20,
  0x10, 0x20, 0x10, 0x60, 0x10, 0x20, 0x10, 0x40, 0x30, 0x20, 0x18, 0x80,
  0x20, 0x40, 0x08, 0x80, 0x20, 0x40, 0x09, 0x00, 0x20, 0x40, 0x0B, 0x00,
  0x20, 0x40, 0x0A, 0x00, 0x40, 0xC0, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x00,
  0x40, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01,
  0x40, 0x00, 0x20, 0x28, 0x00, 0x04, 0x05, 0x80, 0x00, 0x81, 0x10, 0x00,
  0x20, 0x23, 0x00, 0x04, 0x04, 0x20, 0x00, 0x80, 0x84, 0x00, 0x10, 0x30,
  0x40, 0x06, 0x04, 0x08, 0x00, 0x80, 0x81, 0x80, 0x10, 0x10, 0x10, 0x02,
  0x02, 0x03, 0x00, 0x40, 0xC0, 0x20, 0x18, 0x10, 0x04, 0x02, 0x02, 0x00,
  0x40, 0x40, 0x40, 0x08, 0x08, 0x08, 0x01, 0x81, 0x03, 0x00, 0x10, 0x60,
  0x40, 0x03, 0x08, 0x08, 0x00, 0x21, 0x01, 0x00, 0x04, 0x20, 0x20, 0x00,
  0x44, 0x08, 0x00, 0x09, 0x01, 0x00, 0x01, 0xA0, 0x20, 0x00, 0x14, 0x04,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x20, 0x40, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x18, 0x00, 0x06, 0x04, 0x00,
  0x06, 0x01, 0x00, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x0C, 0x0F, 0x80, 0x20, 0x03, 0x00, 0x80, 0x06, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x30, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x10, 0x00, 0x10, 0xC0, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20,
  0x00, 0x40, 0x80, 0x03, 0x06, 0x00, 0x18, 0x10, 0x03, 0x80, 0x7F, 0xF0,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x18, 0x00,
  0x06, 0x04, 0x00, 0x06, 0x01, 0x00, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xFE, 0x00, 0x0C, 0x0F, 0x80, 0x20, 0x03, 0x00, 0x80, 0x06, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00,
  0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x40, 0x80, 0x06, 0x06, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x40,
  0x30, 0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x30, 0x06, 0x00, 0x80, 0x08,
  0x02, 0x00, 0x20, 0x08, 0x00, 0x40, 0x20, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x01, 0xC0, 0xC0, 0x02, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x60, 0x06, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x0C, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00,
  0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x01, 0x18, 0x00, 0x10,
  0x40, 0x00, 0x82, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00,
  0x60, 0x20, 0x02, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x10, 0x01,
  0x00, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x04, 0x00, 0x10, 0x60,
  0x00, 0x82, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0x90, 0x00, 0x04,
  0x80, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x50,
  0x00, 0x48, 0x00, 0x28, 0x00, 0x24, 0x00, 0x34, 0x00, 0x22, 0x00, 0x12,
  0x00, 0x11, 0x00, 0x19, 0x00, 0x10, 0x80, 0x08, 0x80, 0x08, 0x40, 0x0C,
  0x40, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x10, 0x06, 0x10, 0x06, 0x08, 0x02,
  0x08, 0x02, 0x04, 0x03, 0x04, 0x01, 0x02, 0x01, 0x02, 0x01, 0x01, 0x00,
  0x81, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x40, 0x20,
  0x40, 0x30, 0x40, 0x10, 0x20, 0x08, 0x20, 0x08, 0x20, 0x04, 0x30, 0x04,
  0x10, 0x02, 0x10, 0x02, 0x10, 0x01, 0x18, 0x01, 0x88, 0x00, 0x88, 0x00,
  0x48, 0x00, 0x44, 0x00, 0x24, 0x00, 0x24, 0x00, 0x14, 0x00, 0x12, 0x00,
  0x0A, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x05, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x18, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x20, 0x00, 0xC0, 0x02,
  0x00, 0x30, 0x00, 0x40, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x20, 0x10, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x10, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x90,
  0x00, 0x08, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x04,
  0x04, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x10,
  0x30, 0x00, 0x81, 0x00, 0x04, 0x10, 0x00, 0x31, 0x80, 0x00, 0x88, 0x00,
  0x04, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x81, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0A,
  0x00, 0x01, 0x30, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x0C,
  0x18, 0x00, 0x80, 0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x60, 0x04, 0x04,
  0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x02, 0x20, 0x00, 0x26,
  0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0xC2, 0x18, 0x41, 0x0C,
  0x20, 0x00, 0xFE, 0x10, 0x38, 0x31, 0x06, 0x01, 0x90, 0xC0, 0x0A, 0x18,
  0x00, 0x61, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x04, 0x60, 0x00, 0x44,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00, 0x88, 0x00, 0x08,
  0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x8C, 0x00, 0x30, 0x40, 0x05,
  0x04, 0x00, 0xD0, 0x60, 0x19, 0x03, 0x02, 0x20, 0x1F, 0xC2, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x07, 0xE0, 0x08, 0xC0, 0xC0, 0x48, 0x03, 0x06, 0x80, 0x08,
  0x28, 0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x64,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00,
  0xC5, 0x00, 0x04, 0x28, 0x00, 0x41, 0x20, 0x04, 0x09, 0x80, 0xC0, 0x83,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x30, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x03,
  0xF8, 0x20, 0x1C, 0x0C, 0xC0, 0x60, 0x09, 0x01, 0x80, 0x0A, 0x06, 0x00,
  0x14, 0x08, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x41, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10,
  0x40, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x82, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x04, 0x00, 0x28, 0x08, 0x00, 0x90, 0x18, 0x02, 0x20, 0x18,
  0x18, 0x80, 0x1F, 0xE1, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41,
  0x00, 0x31, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x40, 0x02,
  0x60, 0x06, 0x20, 0x3C, 0x1F, 0xF0, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC1,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x8C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x04, 0x07, 0x03, 0x10, 0x30, 0x04, 0x81,
  0x80, 0x0A, 0x0C, 0x00, 0x28, 0x20, 0x00, 0x61, 0x00, 0x01, 0x84, 0x00,
  0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x08,
  0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40,
  0x00, 0xC1, 0x80, 0x03, 0x02, 0x00, 0x14, 0x08, 0x00, 0x90, 0x30, 0x04,
  0xC0, 0x60, 0x62, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x1F, 0xC0, 0x46, 0x06, 0x04, 0xC0, 0x30, 0xD0, 0x01, 0x0A, 0x00, 0x10,
  0xE0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x03,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00,
  0x62, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00,
  0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0xC0, 0x00, 0x80, 0x01, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x30, 0x40, 0x04, 0x04, 0x00, 0x80, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x08, 0x18, 0x00, 0x83, 0x00, 0x18, 0x60, 0x01, 0x0C, 0x00, 0x11,
  0x80, 0x01, 0x3C, 0x00, 0x14, 0x40, 0x02, 0x86, 0x00, 0x30, 0x20, 0x02,
  0x03, 0x00, 0x20, 0x10, 0x02, 0x01, 0x80, 0x40, 0x08, 0x04, 0x00, 0xC0,
  0x40, 0x04, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x00, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x04, 0x3F, 0x00, 0xFC, 0x02, 0x30, 0x61,
  0xC3, 0x01, 0x20, 0x11, 0x80, 0x41, 0x20, 0x09, 0x80, 0x20, 0xA0, 0x02,
  0x80, 0x18, 0x60, 0x01, 0x80, 0x04, 0x30, 0x00, 0xC0, 0x06, 0x10, 0x00,
  0xC0, 0x02, 0x18, 0x00, 0x60, 0x01, 0x08, 0x00, 0x20, 0x00, 0x84, 0x00,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x00, 0x21, 0x80,
  0x04, 0x00, 0x10, 0x80, 0x02, 0x00, 0x08, 0x40, 0x01, 0x00, 0x04, 0x20,
  0x00, 0x80, 0x06, 0x10, 0x00, 0x80, 0x02, 0x10, 0x00, 0x40, 0x01, 0x08,
  0x00, 0x20, 0x00, 0x84, 0x00, 0x10, 0x00, 0x42, 0x00, 0x18, 0x00, 0x63,
  0x00, 0x08, 0x00, 0x20, 0x04, 0x1F, 0xC0, 0x46, 0x06, 0x04, 0xC0, 0x30,
  0xD0, 0x01, 0x0A, 0x00, 0x10, 0xE0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01,
  0x18, 0x00, 0x11, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x23, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0xC0,
  0x00, 0x80, 0x00, 0x7F, 0x00, 0x38, 0x18, 0x06, 0x00, 0x40, 0xC0, 0x06,
  0x18, 0x00, 0x21, 0x00, 0x03, 0x20, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x86, 0x00, 0x10, 0x20, 0x03, 0x01, 0x80, 0xC0, 0x0F, 0xF8, 0x00,
  0x01, 0x07, 0xE0, 0x02, 0x30, 0x30, 0x04, 0xC0, 0x30, 0x1A, 0x00, 0x20,
  0x28, 0x00, 0x60, 0x70, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x06,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40,
  0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00,
  0x08, 0x10, 0x00, 0x30, 0x50, 0x00, 0x40, 0xA0, 0x01, 0x01, 0x20, 0x04,
  0x02, 0x60, 0x30, 0x0C, 0x7F, 0xC0, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x08, 0x1C, 0x0C, 0x41, 0x80, 0x24, 0x18, 0x00, 0xA1, 0x80, 0x05,
  0x08, 0x00, 0x18, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x22,
  0x00, 0x03, 0x10, 0x00, 0x18, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x10, 0x00,
  0xA0, 0x80, 0x09, 0x06, 0x00, 0x98, 0x18, 0x18, 0x80, 0x7F, 0x84, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x04, 0x1F, 0x04, 0x60, 0x04, 0x80, 0x0D, 0x00, 0x0A, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x03, 0xFC, 0x0E, 0x03, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x30, 0x7F, 0xE0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x07, 0xFF, 0x88, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x07, 0xF0, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x11,
  0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x02,
  0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00,
  0xC4, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00,
  0x28, 0xC0, 0x07, 0x04, 0x00, 0x50, 0x40, 0x19, 0x06, 0x03, 0x10, 0x3F,
  0xC2, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x2C, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x02, 0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x30, 0x60, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x20, 0x60, 0x08, 0x10, 0x02, 0x0C, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x58, 0x00, 0x14,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x80, 0x04, 0x00, 0x38, 0x00, 0x80,
  0x07, 0x00, 0x30, 0x01, 0x20, 0x05, 0x00, 0x24, 0x01, 0x20, 0x08, 0x80,
  0x24, 0x01, 0x10, 0x08, 0x80, 0x42, 0x01, 0x10, 0x08, 0x40, 0x42, 0x02,
  0x08, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10,
  0x20, 0x80, 0x86, 0x02, 0x10, 0x10, 0x80, 0x46, 0x02, 0x30, 0x08, 0x80,
  0x44, 0x01, 0x30, 0x09, 0x80, 0x24, 0x01, 0x20, 0x05, 0x80, 0x1C, 0x00,
  0xA0, 0x03, 0x00, 0x14, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x08, 0x30, 0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x10,
  0x08, 0x00, 0x80, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x4C, 0x00,
  0x02, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x05, 0x00, 0x00, 0x48,
  0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x06, 0x04, 0x00, 0x60, 0x20, 0x02,
  0x01, 0x80, 0x20, 0x04, 0x02, 0x00, 0x30, 0x20, 0x00, 0x82, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x10,
  0x00, 0x40, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00,
  0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x78, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x78, 0x00, 0xF0, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x1F, 0x80, 0x16, 0x0E, 0x01, 0x80, 0x3C, 0xE0, 0x00, 0x38,
};

const GFXglyph NotoSans_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 11, 13, 5, -31 },
  { 45, 26, 31, 26, 1, -31 },
  { 146, 20, 36, 24, 2, -33 },
  { 236, 26, 32, 33, 4, -31 },
  { 340, 26, 31, 29, 2, -31 },
  { 441, 3, 11, 7, 5, -31 },
  { 446, 12, 38, 10, 1, -31 },
  { 503, 12, 38, 10, -3, -31 },
  { 560, 18, 18, 23, 5, -33 },
  { 601, 20, 20, 25, 3, -25 },
  { 651, 6, 11, 8, -2, -5 },
  { 660, 10, 1, 13, 2, -12 },
  { 662, 3, 2, 9, 1, -2 },
  { 663, 19, 31, 13, -2, -31 },
  { 737, 20, 31, 24, 3, -31 },
  { 815, 11, 31, 24, 7, -31 },
  { 858, 22, 31, 24, 0, -31 },
  { 944, 22, 31, 24, 1, -31 },
  { 1030, 22, 31, 24, 1, -31 },
  { 1116, 21, 31, 24, 2, -31 },
  { 1198, 20, 31, 24, 3, -31 },
  { 1276, 19, 31, 24, 5, -31 },
  { 1350, 21, 31, 24, 2, -31 },
  { 1432, 20, 31, 24, 2, -31 },
  { 1510, 7, 23, 9, 1, -23 },
  { 1531, 10, 29, 9, -2, -23 },
  { 1568, 20, 19, 25, 3, -25 },
  { 1616, 20, 10, 25, 3, -20 },
  { 1641, 20, 19, 25, 3, -25 },
  { 1689, 15, 31, 17, 3, -31 },
  { 1748, 33, 34, 36, 2, -30 },
  { 1889, 23, 31, 24, -2, -31 },
  { 1979, 23, 31, 26, 2, -31 },
  { 2069, 23, 31, 26, 4, -31 },
  { 2159, 25, 31, 29, 2, -31 },
  { 2256, 22, 31, 23, 2, -31 },
  { 2342, 22, 31, 21, 2, -31 },
  { 2428, 25, 31, 30, 4, -31 },
  { 2525, 27, 31, 29, 2, -31 },
  { 2630, 14, 31, 12, 0, -31 },
  { 2685, 17, 38, 10, -7, -31 },
  { 2766, 25, 31, 23, 2, -31 },
  { 2863, 16, 31, 21, 2, -31 },
  { 2925, 32, 31, 35, 2, -31 },
  { 3049, 27, 31, 29, 2, -31 },
  { 3154, 25, 31, 31, 4, -31 },
  { 3251, 22, 31, 24, 2, -31 },
  { 3337, 25, 38, 31, 4, -31 },
  { 3456, 22, 31, 24, 2, -31 },
  { 3542, 21, 31, 21, 1, -31 },
  { 3624, 21, 31, 21, 4, -31 },
  { 3706, 26, 31, 30, 4, -31 },
  { 3807, 21, 31, 23, 5, -31 },
  { 3889, 33, 31, 36, 5, -31 },
  { 4017, 27, 31, 21, -3, -31 },
  { 4122, 21, 31, 21, 4, -31 },
  { 4204, 25, 31, 23, 0, -31 },
  { 4301, 16, 38, 13, 0, -31 },
  { 4377, 7, 31, 13, 4, -31 },
  { 4405, 16, 38, 13, -3, -31 },
  { 4481, 20, 19, 24, 2, -31 },
  { 4529, 17, 1, 16, -4, 5 },
  { 4532, 5, 7, 10, 6, -33 },
  { 4537, 20, 23, 24, 2, -23 },
  { 4595, 21, 33, 24, 1, -33 },
  { 4682, 18, 23, 19, 2, -23 },
  { 4734, 23, 33, 24, 2, -33 },
  { 4829, 17, 23, 21, 3, -23 },
  { 4878, 24, 43, 11, -6, -33 },
  { 5007, 22, 33, 24, 1, -23 },
  { 5098, 20, 33, 24, 1, -33 },
  { 5181, 8, 31, 9, 1, -31 },
  { 5212, 15, 41, 9, -6, -31 },
  { 5289, 20, 33, 19, 1, -33 },
  { 5372, 8, 33, 9, 1, -33 },
  { 5405, 33, 23, 36, 1, -23 },
  { 5500, 20, 23, 24, 1, -23 },
  { 5558, 20, 23, 24, 2, -23 },
  { 5616, 23, 33, 24, -1, -23 },
  { 5711, 21, 33, 24, 2, -23 },
  { 5798, 16, 23, 16, 1, -23 },
  { 5844, 16, 23, 18, 1, -23 },
  { 5890, 12, 28, 13, 2, -28 },
  { 5932, 20, 23, 24, 2, -23 },
  { 5990, 18, 23, 18, 2, -23 },
  { 6042, 27, 23, 28, 2, -23 },
  { 6120, 21, 23, 20, -1, -23 },
  { 6181, 25, 33, 18, -5, -23 },
  { 6285, 20, 23, 19, -1, -23 },
  { 6343, 15, 38, 14, 1, -31 },
  { 6415, 1, 43, 23, 12, -33 },
  { 6421, 15, 38, 14, -2, -31 },
  { 6493, 20, 4, 25, 3, -17 },
};

const GFXfont NotoSans_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_THINITALIC43PT7B_H_
