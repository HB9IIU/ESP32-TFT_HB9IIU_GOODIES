#ifndef _NOTOSANS_THINITALIC35PT7B_H_
#define _NOTOSANS_THINITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x22,
  0x85, 0x0A, 0x14, 0x50, 0xA1, 0x42, 0x84, 0x00, 0x20, 0x40, 0x02, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x40, 0x02,
  0x04, 0x00, 0x10, 0x20, 0x3F, 0xFF, 0xF8, 0x08, 0x08, 0x00, 0x40, 0x80,
  0x02, 0x04, 0x00, 0x20, 0x20, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80,
  0x80, 0xFF, 0xFF, 0xE0, 0x20, 0x40, 0x01, 0x02, 0x00, 0x10, 0x10, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0xF0, 0x03, 0x2F, 0x0C,
  0x20, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x80, 0x0C, 0x80, 0x06, 0x80, 0x01, 0xC0, 0x00, 0xB0, 0x01, 0x08, 0x01,
  0x0C, 0x01, 0x04, 0x01, 0x04, 0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x82,
  0x30, 0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0F,
  0x80, 0x18, 0x42, 0x00, 0x42, 0x04, 0x02, 0x08, 0x10, 0x10, 0x40, 0x40,
  0x81, 0x01, 0x02, 0x04, 0x04, 0x10, 0x20, 0x10, 0x80, 0x80, 0x84, 0x02,
  0x02, 0x10, 0x08, 0x08, 0x8F, 0xA0, 0x44, 0x42, 0x81, 0x22, 0x05, 0x08,
  0x90, 0x17, 0xC4, 0x40, 0x40, 0x21, 0x01, 0x01, 0x88, 0x04, 0x04, 0x20,
  0x20, 0x20, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x20, 0x20, 0x41,
  0x00, 0x81, 0x08, 0x02, 0x08, 0x60, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x10,
  0x20, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x02, 0x04, 0x00, 0x21, 0x80, 0x01, 0x60, 0x00,
  0x18, 0x00, 0x04, 0xC0, 0x01, 0x84, 0x00, 0x20, 0x20, 0x14, 0x01, 0x02,
  0x80, 0x10, 0x28, 0x00, 0x84, 0x80, 0x04, 0x88, 0x00, 0x28, 0x80, 0x03,
  0x08, 0x00, 0x70, 0x80, 0x0C, 0x86, 0x03, 0x08, 0x3F, 0xC0, 0x40, 0x29,
  0x25, 0x24, 0x80, 0x00, 0xC0, 0x40, 0x30, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x00, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x0C, 0x10, 0x06, 0x20, 0x02, 0x40, 0x03, 0xFF,
  0x03, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x84, 0x06, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x08, 0x44,
  0x22, 0x11, 0x08, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x02,
  0x02, 0x04, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x20, 0x60, 0x1F, 0xC0, 0x01,
  0x07, 0x09, 0x31, 0x42, 0x82, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x00, 0xFE, 0x00, 0x40, 0x60, 0x20, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0x00, 0x82, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x7F,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x31, 0x00, 0x30,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x34,
  0x00, 0x19, 0x00, 0x04, 0x40, 0x02, 0x20, 0x01, 0x08, 0x00, 0x82, 0x00,
  0x40, 0x80, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x01, 0x03, 0x00,
  0x40, 0x80, 0x20, 0x40, 0x08, 0x3F, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0x00, 0x60, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x83, 0x00, 0x40, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x09, 0xFE, 0x09, 0x01, 0x85, 0x00,
  0x43, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x80, 0x60, 0x40, 0x60,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x03, 0x01, 0x01, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x08, 0x40, 0x04, 0x20, 0x04, 0x10, 0x02, 0x08, 0x02,
  0x02, 0x02, 0x00, 0x86, 0x00, 0x3C, 0x00, 0x36, 0x00, 0xE0, 0x80, 0x80,
  0x20, 0x80, 0x08, 0x80, 0x04, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x23, 0x00, 0x20, 0xC0, 0x20, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x06, 0x04, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x20, 0x03, 0x20,
  0x05, 0x10, 0x1A, 0x0F, 0xE2, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF,
  0x00, 0x08, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x3F, 0x84, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x04, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x04, 0xC0, 0x1E, 0x01, 0x20, 0x18, 0x60, 0x50, 0x08, 0x08, 0x14, 0x04,
  0x02, 0x05, 0x02, 0x00, 0x81, 0x81, 0x80, 0x40, 0x60, 0x40, 0x10, 0x18,
  0x10, 0x04, 0x06, 0x04, 0x02, 0x02, 0x81, 0x00, 0x80, 0xA0, 0x40, 0x60,
  0x68, 0x10, 0x18, 0x12, 0x04, 0x0A, 0x08, 0x80, 0xF8, 0x7C, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x11, 0x00,
  0x04, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x1F, 0xFE, 0x04,
  0x00, 0x40, 0x80, 0x08, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x07, 0xFE, 0x01,
  0x00, 0x60, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x30, 0x7F, 0xF0,
  0x20, 0x1C, 0x08, 0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x42, 0x00, 0x60, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x04, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x10, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x40, 0x30, 0x08,
  0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00,
  0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x20, 0x80, 0x0C, 0x08, 0x03, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC1,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC1, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x0F,
  0xFF, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x18, 0x01, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x01, 0xFE, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x20, 0x00,
  0x81, 0x80, 0x10, 0x0F, 0xFE, 0x00, 0x04, 0x00, 0x04, 0x10, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80,
  0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x02,
  0x07, 0xFF, 0xF8, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00,
  0x10, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x01, 0x80, 0x07, 0xE0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0xFC, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x30,
  0x40, 0x04, 0x08, 0x00, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00, 0x80, 0xC0,
  0x08, 0x18, 0x01, 0x02, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x11, 0x00,
  0x01, 0x70, 0x00, 0x2C, 0x80, 0x03, 0x08, 0x00, 0x20, 0x40, 0x02, 0x04,
  0x00, 0x20, 0x20, 0x04, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x08, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xA0, 0x00, 0x14,
  0x28, 0x00, 0x0E, 0x0A, 0x00, 0x02, 0x82, 0x80, 0x01, 0x20, 0x90, 0x00,
  0x48, 0x44, 0x00, 0x24, 0x11, 0x00, 0x19, 0x04, 0x40, 0x04, 0x41, 0x10,
  0x02, 0x10, 0x44, 0x00, 0x84, 0x20, 0x80, 0x42, 0x08, 0x20, 0x30, 0x82,
  0x08, 0x08, 0x20, 0x82, 0x04, 0x08, 0x20, 0x81, 0x02, 0x10, 0x10, 0x81,
  0x04, 0x04, 0x60, 0x41, 0x01, 0x10, 0x10, 0x40, 0x48, 0x04, 0x20, 0x12,
  0x01, 0x08, 0x05, 0x00, 0x82, 0x00, 0xC0, 0x20, 0x80, 0x20, 0x08, 0x00,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x42, 0x80, 0x02, 0x14, 0x00, 0x10, 0x90,
  0x01, 0x04, 0x80, 0x08, 0x24, 0x00, 0x42, 0x10, 0x02, 0x10, 0x80, 0x10,
  0x82, 0x01, 0x04, 0x10, 0x08, 0x20, 0x40, 0x42, 0x02, 0x02, 0x10, 0x10,
  0x10, 0x80, 0x41, 0x04, 0x02, 0x08, 0x20, 0x08, 0x42, 0x00, 0x42, 0x10,
  0x01, 0x10, 0x80, 0x09, 0x04, 0x00, 0x48, 0x40, 0x01, 0x42, 0x00, 0x0A,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x06, 0x01,
  0x00, 0x18, 0x10, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x48, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x80, 0x00, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x40, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x01, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x10, 0x80, 0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x10, 0x40, 0x0C, 0x20, 0x06, 0x0F, 0xFE, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x18, 0x06, 0x01, 0x00, 0x18, 0x10, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00,
  0x50, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x40, 0x80, 0x0C, 0x03, 0x00, 0xC0,
  0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x01, 0x00, 0xC0,
  0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x08, 0x20, 0x0C,
  0x0F, 0xFC, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x10, 0x10, 0x04, 0x04,
  0x01, 0x01, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x06, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x43, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x21, 0x00, 0x60, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x10, 0x20,
  0x01, 0x81, 0x00, 0x18, 0x06, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00,
  0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x08, 0x10, 0x04, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x01, 0x02, 0x00, 0x41, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0xA0, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x28, 0x01, 0x40, 0x05, 0x00, 0x24, 0x01, 0x20, 0x08, 0x80, 0x24, 0x01,
  0x10, 0x08, 0x80, 0x42, 0x01, 0x10, 0x08, 0x40, 0x42, 0x02, 0x08, 0x08,
  0x40, 0x41, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x10, 0x10, 0x80, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02,
  0x10, 0x08, 0x80, 0x44, 0x01, 0x30, 0x04, 0x80, 0x24, 0x00, 0xA0, 0x04,
  0x80, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x14, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x10,
  0x01, 0x00, 0x40, 0x08, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x04, 0x10,
  0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x22,
  0x00, 0x01, 0x04, 0x00, 0x08, 0x10, 0x00, 0x40, 0x40, 0x01, 0x00, 0x80,
  0x08, 0x02, 0x00, 0x40, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x80,
  0x00, 0x80, 0x80, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x88, 0x00, 0x42, 0x00,
  0x41, 0x00, 0x40, 0x80, 0x60, 0x20, 0x20, 0x10, 0x20, 0x08, 0x20, 0x02,
  0x10, 0x01, 0x10, 0x00, 0x90, 0x00, 0x50, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x41, 0x03,
  0xF0, 0x00, 0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x01, 0xFC, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x50, 0x00, 0x88,
  0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x04, 0x04, 0x04, 0x04, 0x08, 0x04,
  0x10, 0x04, 0x30, 0x02, 0x20, 0x02, 0x40, 0x02, 0x80, 0x03, 0xFF, 0xF8,
  0x84, 0x42, 0x11, 0x01, 0xE0, 0x06, 0x19, 0x08, 0x09, 0x10, 0x06, 0x20,
  0x06, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x28, 0xC0,
  0x48, 0x40, 0x90, 0x3F, 0x10, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x78,
  0x04, 0xC3, 0x02, 0x80, 0x42, 0x80, 0x21, 0x80, 0x08, 0xC0, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x26,
  0x00, 0x13, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x08, 0x60, 0x0C, 0x48, 0x0C,
  0x23, 0xF8, 0x00, 0x01, 0xF8, 0x18, 0x10, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x41, 0xFE,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x01, 0xE0, 0x81, 0x86, 0x40,
  0x80, 0x50, 0x40, 0x0C, 0x20, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x60, 0xC0, 0x28, 0x10, 0x32, 0x03,
  0xF0, 0x80, 0x01, 0xF0, 0x18, 0x20, 0x80, 0x44, 0x01, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x90, 0x06, 0x40, 0x63, 0xFE, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x41, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xC4, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x24, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x40, 0xC3, 0x20, 0x40, 0x28, 0x20, 0x06, 0x10, 0x01, 0x88,
  0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x61, 0x00, 0x30,
  0x60, 0x14, 0x08, 0x19, 0x01, 0xF8, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x20, 0x18, 0x07, 0xF8,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x7C, 0x09, 0x82, 0x0A, 0x01, 0x14,
  0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x06, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0xF8, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x01, 0x08, 0x06, 0x08, 0x0C, 0x10, 0x18, 0x10,
  0x20, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x22, 0x00, 0x25, 0x00, 0x29,
  0x00, 0x30, 0x80, 0x60, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x40,
  0x20, 0x80, 0x10, 0x80, 0x10, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x00, 0x00, 0x78, 0x0F, 0x02, 0x63, 0x0C, 0x20,
  0xA0, 0x24, 0x04, 0x50, 0x0A, 0x01, 0x18, 0x03, 0x00, 0x46, 0x00, 0xC0,
  0x11, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01, 0x20, 0x02, 0x00, 0x48, 0x01,
  0x00, 0x12, 0x00, 0x40, 0x08, 0x80, 0x10, 0x02, 0x40, 0x04, 0x00, 0x90,
  0x02, 0x00, 0x24, 0x00, 0x80, 0x09, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01,
  0x20, 0x02, 0x00, 0x48, 0x01, 0x00, 0x10, 0x00, 0x7C, 0x09, 0x82, 0x0A,
  0x01, 0x14, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x01, 0xF0, 0x06,
  0x0C, 0x08, 0x06, 0x10, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x0C, 0x40, 0x18, 0x20, 0x30, 0x1F, 0xC0, 0x00,
  0x1E, 0x00, 0x4C, 0x30, 0x0A, 0x01, 0x02, 0x80, 0x20, 0x60, 0x02, 0x0C,
  0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x20, 0xC0,
  0x08, 0x18, 0x03, 0x04, 0x80, 0xC0, 0x8F, 0xE0, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x83, 0x0C, 0x82, 0x01, 0x42, 0x00,
  0x62, 0x00, 0x32, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x31,
  0x00, 0x30, 0xC0, 0x28, 0x20, 0x64, 0x0F, 0xC2, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x00, 0x78, 0x4C, 0x02, 0x80, 0x28, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x30,
  0x31, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x12, 0x00, 0x87, 0xFC, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x7F, 0xE4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x07, 0xC0,
  0x30, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x28, 0x80, 0x68, 0x40, 0xC8, 0x3F, 0x10,
  0x80, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x21, 0x00, 0x84, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x08, 0x80, 0x22, 0x00, 0x90,
  0x02, 0x80, 0x0A, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x20, 0x0E, 0x01,
  0x80, 0x28, 0x05, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x40,
  0x88, 0x11, 0x02, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x04,
  0x41, 0x08, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01,
  0x82, 0x00, 0x81, 0x00, 0x80, 0x40, 0x80, 0x20, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x44, 0x00,
  0x42, 0x00, 0x40, 0x80, 0x40, 0x40, 0x40, 0x10, 0x40, 0x08, 0x40, 0x02,
  0x00, 0x02, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x04, 0x01,
  0x00, 0x80, 0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x02, 0x00,
  0x10, 0x40, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x09, 0x00,
  0x00, 0x90, 0x00, 0x0A, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x09, 0x80, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x70, 0x08, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x30, 0x0E, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x07, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x38, 0x02,
  0x00, 0x00, 0x3C, 0x01, 0xC3, 0x83, 0x80, 0x7C,
};

const GFXglyph NotoSans_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 25, 7, 1, -25 },
  { 23, 7, 9, 11, 4, -25 },
  { 31, 21, 25, 21, 1, -25 },
  { 97, 16, 29, 19, 2, -27 },
  { 155, 22, 25, 27, 3, -25 },
  { 224, 20, 25, 24, 2, -25 },
  { 287, 3, 9, 6, 4, -25 },
  { 291, 10, 31, 8, 1, -25 },
  { 330, 10, 31, 8, -2, -25 },
  { 369, 15, 15, 19, 4, -27 },
  { 398, 16, 16, 20, 3, -20 },
  { 430, 5, 9, 6, -2, -4 },
  { 436, 9, 1, 11, 1, -10 },
  { 438, 2, 2, 7, 1, -2 },
  { 439, 16, 25, 11, -2, -25 },
  { 489, 16, 25, 19, 2, -25 },
  { 539, 8, 25, 19, 6, -25 },
  { 564, 18, 25, 19, 0, -25 },
  { 621, 17, 25, 19, 1, -25 },
  { 675, 18, 25, 19, 1, -25 },
  { 732, 18, 25, 19, 1, -25 },
  { 789, 17, 25, 19, 2, -25 },
  { 843, 16, 25, 19, 4, -25 },
  { 893, 17, 25, 19, 2, -25 },
  { 947, 16, 25, 19, 2, -25 },
  { 997, 6, 19, 7, 1, -19 },
  { 1012, 8, 24, 7, -2, -19 },
  { 1036, 16, 16, 20, 3, -21 },
  { 1068, 16, 8, 20, 3, -16 },
  { 1084, 16, 16, 20, 3, -21 },
  { 1116, 12, 25, 14, 3, -25 },
  { 1154, 26, 28, 29, 2, -25 },
  { 1245, 19, 25, 19, -2, -25 },
  { 1305, 18, 25, 21, 2, -25 },
  { 1362, 19, 25, 21, 3, -25 },
  { 1422, 20, 25, 24, 2, -25 },
  { 1485, 18, 25, 19, 2, -25 },
  { 1542, 18, 25, 17, 2, -25 },
  { 1599, 20, 25, 24, 3, -25 },
  { 1662, 22, 25, 24, 2, -25 },
  { 1731, 11, 25, 10, 0, -25 },
  { 1766, 14, 31, 8, -6, -25 },
  { 1821, 20, 25, 19, 2, -25 },
  { 1884, 12, 25, 17, 2, -25 },
  { 1922, 26, 25, 28, 2, -25 },
  { 2004, 21, 25, 24, 2, -25 },
  { 2070, 21, 25, 25, 3, -25 },
  { 2136, 18, 25, 20, 2, -25 },
  { 2193, 21, 31, 25, 3, -25 },
  { 2275, 18, 25, 20, 2, -25 },
  { 2332, 17, 25, 17, 1, -25 },
  { 2386, 17, 25, 17, 3, -25 },
  { 2440, 21, 25, 24, 3, -25 },
  { 2506, 17, 25, 19, 4, -25 },
  { 2560, 27, 25, 29, 4, -25 },
  { 2645, 22, 25, 17, -2, -25 },
  { 2714, 17, 25, 17, 3, -25 },
  { 2768, 20, 25, 19, 0, -25 },
  { 2831, 13, 31, 11, 0, -25 },
  { 2882, 6, 25, 11, 3, -25 },
  { 2901, 14, 31, 11, -3, -25 },
  { 2956, 16, 15, 19, 2, -25 },
  { 2986, 13, 1, 13, -3, 4 },
  { 2988, 4, 6, 8, 5, -27 },
  { 2991, 16, 19, 19, 2, -19 },
  { 3029, 17, 27, 20, 1, -27 },
  { 3087, 14, 19, 16, 2, -19 },
  { 3121, 18, 27, 20, 2, -27 },
  { 3182, 14, 19, 17, 2, -19 },
  { 3216, 19, 35, 9, -5, -27 },
  { 3300, 18, 27, 20, 1, -19 },
  { 3361, 16, 27, 19, 1, -27 },
  { 3415, 7, 25, 7, 1, -25 },
  { 3437, 13, 33, 7, -5, -25 },
  { 3491, 16, 27, 15, 1, -27 },
  { 3545, 7, 27, 7, 1, -27 },
  { 3569, 26, 19, 29, 1, -19 },
  { 3631, 16, 19, 19, 1, -19 },
  { 3669, 16, 19, 20, 2, -19 },
  { 3707, 19, 27, 20, -1, -19 },
  { 3772, 17, 27, 20, 2, -19 },
  { 3830, 13, 19, 13, 1, -19 },
  { 3861, 14, 19, 15, 0, -19 },
  { 3895, 10, 23, 11, 2, -23 },
  { 3924, 16, 18, 19, 2, -18 },
  { 3960, 14, 18, 14, 2, -18 },
  { 3992, 22, 18, 23, 2, -18 },
  { 4042, 17, 18, 16, -1, -18 },
  { 4081, 20, 27, 14, -4, -18 },
  { 4149, 15, 18, 15, 0, -18 },
  { 4183, 12, 31, 11, 1, -25 },
  { 4230, 1, 35, 19, 10, -27 },
  { 4235, 13, 31, 11, -2, -25 },
  { 4286, 16, 3, 20, 3, -14 },
};

const GFXfont NotoSans_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_THINITALIC35PT7B_H_
