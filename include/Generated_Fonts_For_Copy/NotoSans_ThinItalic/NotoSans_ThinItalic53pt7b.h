#ifndef _NOTOSANS_THINITALIC53PT7B_H_
#define _NOTOSANS_THINITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x26, 0x04, 0x81, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x12, 0x06,
  0x40, 0x88, 0x13, 0x02, 0x40, 0x48, 0x19, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x02, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x00, 0xC0, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x10, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x01, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x02, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xE1, 0x03, 0x01, 0x81,
  0x00, 0x03, 0x01, 0x00, 0x06, 0x03, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02,
  0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04,
  0x00, 0x06, 0x04, 0x00, 0x03, 0x04, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x09, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x10, 0x30, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10,
  0x08, 0x00, 0x30, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x18, 0x00, 0x20,
  0x10, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x80, 0x40, 0xC0, 0xF0, 0x47,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0x03, 0x0C, 0x00, 0x06, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x80, 0x02, 0x03, 0x00, 0x40, 0x03, 0x01, 0x00, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x40, 0x04, 0x01, 0x80, 0x60,
  0x02, 0x01, 0x80, 0x30, 0x01, 0x00, 0x80, 0x10, 0x00, 0x80, 0xC0, 0x08,
  0x00, 0xC0, 0xC0, 0x04, 0x00, 0x60, 0xC0, 0x02, 0x00, 0x20, 0x40, 0x01,
  0x00, 0x10, 0x61, 0xF8, 0x80, 0x18, 0x61, 0x86, 0x40, 0x08, 0x61, 0x81,
  0xA0, 0x0C, 0x21, 0x80, 0x50, 0x04, 0x31, 0x80, 0x2C, 0x04, 0x30, 0xC0,
  0x13, 0x0E, 0x10, 0x40, 0x0C, 0xFC, 0x10, 0x60, 0x06, 0x00, 0x18, 0x20,
  0x02, 0x00, 0x18, 0x10, 0x01, 0x00, 0x08, 0x18, 0x00, 0x80, 0x08, 0x08,
  0x00, 0x40, 0x0C, 0x04, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x30, 0x04, 0x01,
  0x00, 0x10, 0x06, 0x00, 0x80, 0x08, 0x06, 0x00, 0x40, 0x0C, 0x06, 0x00,
  0x20, 0x04, 0x02, 0x00, 0x10, 0x06, 0x03, 0x00, 0x08, 0x02, 0x03, 0x00,
  0x06, 0x03, 0x03, 0x00, 0x01, 0x83, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x60, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x40, 0x01, 0x80, 0x00, 0x40, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x80, 0x03, 0x08, 0x00, 0xC0, 0x02, 0x10,
  0x00, 0x60, 0x04, 0x30, 0x00, 0x20, 0x0C, 0x60, 0x00, 0x30, 0x08, 0x60,
  0x00, 0x18, 0x18, 0x40, 0x00, 0x0C, 0x30, 0x40, 0x00, 0x04, 0x20, 0xC0,
  0x00, 0x06, 0x40, 0xC0, 0x00, 0x03, 0x80, 0x40, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x02, 0x80, 0x60, 0x00, 0x0C, 0xC0, 0x20, 0x00, 0x18, 0x60, 0x30,
  0x00, 0x70, 0x20, 0x1C, 0x01, 0xC0, 0x30, 0x07, 0xFF, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x00, 0x33, 0x22, 0x26, 0x64, 0x44, 0xC8, 0x88, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x40, 0x08, 0x03, 0x80, 0xC0, 0x07, 0x04,
  0x00, 0x0C, 0x20, 0x00, 0x19, 0x00, 0x40, 0x29, 0xFE, 0x00, 0xF0, 0x00,
  0x0A, 0x00, 0x00, 0x98, 0x00, 0x08, 0x40, 0x01, 0x83, 0x00, 0x18, 0x08,
  0x01, 0x80, 0x40, 0x18, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x06, 0x08, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1C,
  0x0E, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x20, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x34, 0x06, 0x60, 0x63, 0x0C, 0x10, 0xC0, 0x98, 0x04, 0x80, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0x01, 0x80, 0x07, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x80, 0xE0, 0x03, 0x80,
  0x06, 0x01, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x18, 0x04, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x04,
  0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x20,
  0x00, 0xC0, 0x08, 0x00, 0x10, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x70, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x03, 0x00, 0xF0, 0x03, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0x00, 0x40, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0xFF, 0x00, 0x63, 0xC0, 0xE0,
  0x23, 0x00, 0x18, 0x13, 0x00, 0x06, 0x0A, 0x00, 0x01, 0x0E, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x04, 0x40, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0x20, 0x00, 0x30, 0x18, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10,
  0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x30,
  0x10, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x20, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x38, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x80, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x30, 0x20, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x0C, 0x18, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78,
  0x10, 0x00, 0x36, 0x06, 0x00, 0x39, 0x00, 0xE0, 0x38, 0xC0, 0x0F, 0xF8,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x0F, 0x01, 0xC1, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x08, 0x00, 0x0F, 0xC0, 0x02, 0x18,
  0x00, 0x3F, 0xF8, 0x02, 0x10, 0x00, 0xC0, 0x08, 0x03, 0x30, 0x01, 0x80,
  0x18, 0x03, 0x20, 0x03, 0x00, 0x18, 0x03, 0x60, 0x06, 0x00, 0x10, 0x03,
  0x60, 0x0C, 0x00, 0x10, 0x03, 0x40, 0x08, 0x00, 0x30, 0x03, 0x40, 0x18,
  0x00, 0x20, 0x03, 0xC0, 0x10, 0x00, 0x20, 0x02, 0xC0, 0x30, 0x00, 0x20,
  0x02, 0xC0, 0x30, 0x00, 0x60, 0x06, 0x80, 0x30, 0x00, 0x40, 0x06, 0x80,
  0x20, 0x00, 0xC0, 0x04, 0x80, 0x20, 0x00, 0xC0, 0x0C, 0x80, 0x20, 0x01,
  0xC0, 0x08, 0xC0, 0x30, 0x01, 0x40, 0x18, 0xC0, 0x30, 0x02, 0x40, 0x30,
  0xC0, 0x18, 0x06, 0x40, 0x60, 0x40, 0x0C, 0x1C, 0x61, 0xC0, 0x40, 0x07,
  0xF0, 0x3F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x60, 0x02, 0x00, 0x02, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x00, 0x18, 0x07, 0xF0, 0x01,
  0x80, 0x01, 0xC0, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x00, 0x80, 0x07,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x07, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x0F, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC4,
  0x00, 0x07, 0xFF, 0x88, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x23, 0x60, 0x00, 0x00,
  0x98, 0x80, 0x00, 0x02, 0xC3, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x01, 0x00, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x01,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x05, 0x00, 0x00, 0x00,
  0x28, 0x0A, 0x00, 0x00, 0x00, 0xF0, 0x14, 0x00, 0x00, 0x01, 0x60, 0x2C,
  0x00, 0x00, 0x06, 0x80, 0xD8, 0x00, 0x00, 0x19, 0x01, 0x90, 0x00, 0x00,
  0x26, 0x02, 0x20, 0x00, 0x00, 0xCC, 0x04, 0x40, 0x00, 0x01, 0x10, 0x18,
  0xC0, 0x00, 0x06, 0x20, 0x31, 0x80, 0x00, 0x18, 0x40, 0x41, 0x00, 0x00,
  0x21, 0x80, 0x82, 0x00, 0x00, 0xC3, 0x01, 0x04, 0x00, 0x01, 0x04, 0x06,
  0x08, 0x00, 0x06, 0x08, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x10, 0x30, 0x00,
  0x20, 0x60, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x40, 0x40, 0x01, 0x01, 0x01,
  0x80, 0x80, 0x06, 0x02, 0x03, 0x01, 0x00, 0x18, 0x04, 0x04, 0x03, 0x00,
  0x20, 0x18, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x30, 0x04, 0x01, 0x00, 0x40,
  0x60, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x03, 0x01, 0x00, 0x30,
  0x20, 0x06, 0x02, 0x00, 0x60, 0xC0, 0x08, 0x0C, 0x00, 0x41, 0x00, 0x10,
  0x18, 0x00, 0x86, 0x00, 0x20, 0x20, 0x01, 0x18, 0x00, 0xC0, 0x40, 0x02,
  0x20, 0x01, 0x80, 0x80, 0x06, 0xC0, 0x02, 0x03, 0x00, 0x0D, 0x00, 0x04,
  0x06, 0x00, 0x0E, 0x00, 0x08, 0x08, 0x00, 0x18, 0x00, 0x30, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01,
  0x01, 0xC0, 0x00, 0x01, 0x01, 0x40, 0x00, 0x03, 0x01, 0x60, 0x00, 0x03,
  0x01, 0x60, 0x00, 0x02, 0x03, 0x20, 0x00, 0x02, 0x02, 0x30, 0x00, 0x06,
  0x02, 0x10, 0x00, 0x06, 0x02, 0x18, 0x00, 0x04, 0x06, 0x08, 0x00, 0x04,
  0x06, 0x0C, 0x00, 0x04, 0x04, 0x0C, 0x00, 0x0C, 0x04, 0x04, 0x00, 0x0C,
  0x04, 0x06, 0x00, 0x08, 0x0C, 0x02, 0x00, 0x08, 0x0C, 0x03, 0x00, 0x08,
  0x08, 0x01, 0x00, 0x18, 0x08, 0x01, 0x80, 0x18, 0x08, 0x01, 0x80, 0x10,
  0x18, 0x00, 0x80, 0x10, 0x18, 0x00, 0xC0, 0x10, 0x10, 0x00, 0x40, 0x30,
  0x10, 0x00, 0x60, 0x30, 0x30, 0x00, 0x20, 0x20, 0x30, 0x00, 0x30, 0x20,
  0x30, 0x00, 0x30, 0x60, 0x20, 0x00, 0x10, 0x60, 0x20, 0x00, 0x18, 0x40,
  0x60, 0x00, 0x08, 0x40, 0x60, 0x00, 0x0C, 0x40, 0x40, 0x00, 0x04, 0xC0,
  0x40, 0x00, 0x06, 0xC0, 0x40, 0x00, 0x06, 0x80, 0xC0, 0x00, 0x02, 0x80,
  0xC0, 0x00, 0x03, 0x80, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x30, 0x1F, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x18, 0x04, 0x00, 0x0E, 0x01, 0x80, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x3F, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x70, 0x04, 0x00, 0x78,
  0x01, 0xFF, 0xF8, 0x00, 0x30, 0x02, 0x00, 0x04, 0x00, 0x60, 0x00, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00,
  0x10, 0x00, 0x20, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00,
  0x08, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x08, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x03, 0x80, 0xF0,
  0x03, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x04, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x40, 0x40, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00,
  0x04, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x60, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80,
  0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x88,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x30,
  0x80, 0x02, 0x08, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00, 0x60, 0xC0, 0x04,
  0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x0C, 0x00,
  0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04,
  0x06, 0x00, 0x40, 0x60, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00,
  0x40, 0xC0, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41, 0x80,
  0x04, 0x18, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x43, 0x00, 0x04, 0x30,
  0x00, 0x42, 0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x44,
  0x00, 0x06, 0x40, 0x00, 0x4C, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x06,
  0x80, 0x00, 0x58, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x08, 0x60, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x30, 0x04, 0x00, 0x18,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x03, 0x01, 0x01, 0x01, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x10, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x10, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x08, 0x03, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x04, 0x08, 0x00, 0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x83,
  0x04, 0x18, 0x20, 0xC1, 0x82, 0x04, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xC1,
  0x01, 0xC0, 0x61, 0x03, 0x00, 0x33, 0x06, 0x00, 0x12, 0x0C, 0x00, 0x0A,
  0x18, 0x00, 0x0A, 0x10, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x70,
  0x80, 0x00, 0xF0, 0xC0, 0x00, 0xA0, 0xC0, 0x01, 0x20, 0x60, 0x02, 0x20,
  0x60, 0x0C, 0x60, 0x38, 0x18, 0x40, 0x1F, 0xF0, 0x40, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x20, 0xFF, 0x80, 0x30, 0xC0, 0x60, 0x11, 0x80, 0x18, 0x09,
  0x80, 0x06, 0x05, 0x80, 0x01, 0x06, 0x80, 0x00, 0xC2, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02,
  0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x38, 0x00, 0x06, 0x14, 0x00,
  0x02, 0x0A, 0x00, 0x03, 0x0D, 0x80, 0x03, 0x04, 0x60, 0x03, 0x02, 0x18,
  0x06, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xC0, 0x78, 0x06, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x7F,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00, 0x7F,
  0xE0, 0x80, 0x1C, 0x07, 0x18, 0x03, 0x00, 0x19, 0x80, 0x60, 0x00, 0x90,
  0x0C, 0x00, 0x05, 0x01, 0x80, 0x00, 0x50, 0x10, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x70, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x38, 0x08,
  0x00, 0x07, 0x80, 0xC0, 0x00, 0x50, 0x0C, 0x00, 0x09, 0x00, 0x60, 0x01,
  0x10, 0x06, 0x00, 0x61, 0x00, 0x38, 0x1C, 0x30, 0x01, 0xFF, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x1C,
  0x03, 0x00, 0x30, 0x30, 0x01, 0x82, 0x00, 0x04, 0x30, 0x00, 0x23, 0x00,
  0x01, 0x10, 0x00, 0x09, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0xC0, 0x00, 0xC6,
  0x00, 0x1C, 0x20, 0x07, 0x81, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x10, 0x1C, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x04, 0x01, 0xC0,
  0x70, 0x80, 0x60, 0x03, 0x30, 0x18, 0x00, 0x24, 0x06, 0x00, 0x02, 0x81,
  0x80, 0x00, 0x50, 0x20, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x14, 0x08, 0x00, 0x07, 0x81, 0x80, 0x00, 0xA0,
  0x30, 0x00, 0x24, 0x02, 0x00, 0x08, 0x80, 0x60, 0x06, 0x30, 0x07, 0x03,
  0x86, 0x00, 0x7F, 0xC0, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0xC0, 0x02, 0x0F, 0xF8, 0x06, 0x18, 0x0E, 0x04, 0x60, 0x06, 0x04, 0xC0,
  0x03, 0x05, 0x80, 0x03, 0x0D, 0x00, 0x01, 0x0A, 0x00, 0x01, 0x0E, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x60, 0xC0,
  0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60, 0x18, 0x01,
  0x00, 0x30, 0x04, 0x00, 0x40, 0x10, 0x00, 0x80, 0xC0, 0x01, 0x03, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x23, 0xC0, 0x00,
  0x4C, 0x80, 0x01, 0xB1, 0x80, 0x02, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x08,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x80, 0x04, 0x01, 0x00,
  0x0C, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x20, 0x00,
  0x30, 0x40, 0x00, 0x20, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x04,
  0x1F, 0xE0, 0x0F, 0xF0, 0x18, 0xE0, 0xE0, 0x70, 0x30, 0x23, 0x00, 0x41,
  0x80, 0x30, 0x4C, 0x00, 0xC6, 0x00, 0x60, 0xB0, 0x00, 0x98, 0x00, 0x43,
  0xC0, 0x01, 0x60, 0x00, 0x85, 0x00, 0x02, 0x80, 0x01, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x00, 0x08,
  0xC0, 0x00, 0x60, 0x00, 0x11, 0x80, 0x00, 0xC0, 0x00, 0x62, 0x00, 0x01,
  0x00, 0x00, 0x84, 0x00, 0x02, 0x00, 0x01, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x00, 0x18, 0x80, 0x00,
  0x40, 0x00, 0x21, 0x00, 0x00, 0x80, 0x00, 0x46, 0x00, 0x01, 0x00, 0x00,
  0x8C, 0x00, 0x06, 0x00, 0x03, 0x10, 0x00, 0x08, 0x00, 0x06, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x40, 0x00, 0x20, 0x00, 0x11, 0x80, 0x00, 0xC0, 0x00,
  0x23, 0x00, 0x01, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x00, 0x01, 0x88, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x02, 0x0F, 0xF8, 0x06, 0x18,
  0x0E, 0x04, 0x60, 0x06, 0x04, 0xC0, 0x03, 0x05, 0x80, 0x03, 0x0D, 0x00,
  0x01, 0x0E, 0x00, 0x01, 0x0E, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x04, 0x1F, 0xF0, 0x00, 0xC3, 0x01, 0x80,
  0x08, 0xC0, 0x0C, 0x00, 0x98, 0x00, 0x60, 0x0B, 0x00, 0x02, 0x01, 0xA0,
  0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0xA0, 0x00,
  0x10, 0x0A, 0x00, 0x03, 0x01, 0xB0, 0x00, 0x60, 0x19, 0x80, 0x0C, 0x01,
  0x0C, 0x03, 0x00, 0x10, 0x7F, 0xE0, 0x01, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x40, 0x70, 0x1C, 0x20, 0x60,
  0x03, 0x30, 0x60, 0x00, 0x90, 0x60, 0x00, 0x28, 0x60, 0x00, 0x14, 0x20,
  0x00, 0x0E, 0x30, 0x00, 0x07, 0x10, 0x00, 0x01, 0x18, 0x00, 0x00, 0x88,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02,
  0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x01, 0x42, 0x00, 0x01,
  0xE1, 0x80, 0x00, 0xA0, 0xC0, 0x00, 0x90, 0x20, 0x00, 0x88, 0x18, 0x01,
  0x8C, 0x07, 0x03, 0x86, 0x00, 0xFF, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0x0F,
  0xE0, 0xC7, 0x00, 0x11, 0x80, 0x02, 0x60, 0x00, 0x58, 0x00, 0x1A, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFE, 0x03, 0x00,
  0x70, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x80, 0x03,
  0x0E, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x3F, 0xFF, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xF8, 0x02, 0x00, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x70, 0x80, 0x00, 0x50, 0x80, 0x00, 0xB0, 0xC0, 0x01, 0xA0, 0xC0,
  0x03, 0x20, 0x60, 0x06, 0x20, 0x70, 0x18, 0x20, 0x1F, 0xF0, 0x60, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x80, 0x00,
  0x4C, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40,
  0x01, 0x02, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x0C, 0x02, 0x00, 0x40,
  0x10, 0x06, 0x00, 0x80, 0x60, 0x04, 0x02, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00,
  0x44, 0x00, 0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xA0, 0x00, 0x60, 0x00, 0xD0, 0x00, 0x50, 0x00, 0x4C, 0x00, 0x28, 0x00,
  0x26, 0x00, 0x26, 0x00, 0x23, 0x00, 0x13, 0x00, 0x11, 0x80, 0x11, 0x80,
  0x18, 0xC0, 0x08, 0x40, 0x08, 0x60, 0x08, 0x20, 0x0C, 0x10, 0x0C, 0x10,
  0x04, 0x08, 0x04, 0x08, 0x06, 0x04, 0x06, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x03, 0x01, 0x03, 0x01, 0x81, 0x00, 0x81, 0x00, 0xC1, 0x80, 0x41, 0x80,
  0x60, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x10, 0xC0, 0x08, 0x40, 0x08, 0x40,
  0x04, 0x60, 0x04, 0x60, 0x02, 0x20, 0x02, 0x20, 0x01, 0x30, 0x01, 0xB0,
  0x00, 0x90, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x78, 0x00, 0x28, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x70,
  0xF0, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x60,
};

const GFXglyph NotoSans_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 38, 11, 2, -38 },
  { 49, 11, 14, 16, 6, -38 },
  { 69, 31, 38, 33, 2, -38 },
  { 217, 24, 43, 29, 3, -40 },
  { 346, 33, 39, 40, 5, -38 },
  { 507, 32, 39, 36, 2, -38 },
  { 663, 4, 14, 9, 6, -38 },
  { 670, 14, 46, 13, 2, -38 },
  { 751, 14, 46, 13, -3, -38 },
  { 832, 21, 22, 28, 7, -40 },
  { 890, 24, 24, 30, 4, -31 },
  { 962, 7, 13, 10, -2, -6 },
  { 974, 13, 1, 17, 2, -15 },
  { 976, 2, 3, 11, 2, -3 },
  { 977, 23, 38, 16, -2, -38 },
  { 1087, 25, 39, 29, 3, -38 },
  { 1209, 13, 38, 29, 9, -38 },
  { 1271, 26, 38, 29, 1, -38 },
  { 1395, 27, 39, 29, 1, -38 },
  { 1527, 27, 38, 29, 1, -38 },
  { 1656, 26, 39, 29, 2, -38 },
  { 1783, 25, 39, 29, 4, -38 },
  { 1905, 24, 38, 29, 6, -38 },
  { 2019, 26, 39, 29, 2, -38 },
  { 2146, 26, 39, 29, 2, -38 },
  { 2273, 8, 28, 11, 2, -28 },
  { 2301, 12, 35, 11, -2, -28 },
  { 2354, 24, 24, 30, 4, -31 },
  { 2426, 24, 12, 30, 4, -25 },
  { 2462, 24, 24, 30, 4, -31 },
  { 2534, 18, 38, 21, 4, -38 },
  { 2620, 40, 42, 44, 3, -37 },
  { 2830, 29, 38, 29, -3, -38 },
  { 2968, 28, 38, 32, 3, -38 },
  { 3101, 30, 39, 31, 4, -38 },
  { 3248, 31, 38, 36, 3, -38 },
  { 3396, 27, 38, 28, 3, -38 },
  { 3525, 27, 38, 26, 3, -38 },
  { 3654, 31, 39, 37, 4, -38 },
  { 3806, 33, 38, 36, 3, -38 },
  { 3963, 17, 38, 15, 0, -38 },
  { 4044, 21, 47, 12, -9, -38 },
  { 4168, 30, 38, 29, 3, -38 },
  { 4311, 19, 38, 26, 3, -38 },
  { 4402, 39, 38, 43, 3, -38 },
  { 4588, 32, 38, 36, 3, -38 },
  { 4740, 32, 39, 38, 4, -38 },
  { 4896, 27, 38, 30, 3, -38 },
  { 5025, 32, 47, 38, 4, -38 },
  { 5213, 27, 38, 30, 3, -38 },
  { 5342, 26, 39, 26, 1, -38 },
  { 5469, 26, 38, 26, 5, -38 },
  { 5593, 32, 39, 37, 5, -38 },
  { 5749, 26, 38, 28, 6, -38 },
  { 5873, 40, 38, 44, 7, -38 },
  { 6063, 33, 38, 26, -3, -38 },
  { 6220, 26, 38, 26, 5, -38 },
  { 6344, 30, 38, 29, 0, -38 },
  { 6487, 20, 46, 16, 0, -38 },
  { 6602, 8, 38, 16, 5, -38 },
  { 6640, 20, 46, 16, -4, -38 },
  { 6755, 24, 23, 29, 3, -38 },
  { 6824, 20, 1, 20, -5, 6 },
  { 6827, 6, 9, 12, 8, -41 },
  { 6834, 24, 30, 29, 3, -29 },
  { 6924, 25, 41, 30, 2, -40 },
  { 7053, 21, 30, 24, 3, -29 },
  { 7132, 28, 41, 30, 3, -40 },
  { 7276, 21, 30, 26, 3, -29 },
  { 7355, 29, 54, 14, -7, -41 },
  { 7551, 27, 42, 30, 1, -29 },
  { 7693, 24, 40, 29, 2, -40 },
  { 7813, 10, 38, 11, 2, -38 },
  { 7861, 20, 51, 11, -8, -38 },
  { 7989, 23, 40, 23, 2, -40 },
  { 8104, 10, 40, 11, 2, -40 },
  { 8154, 39, 29, 45, 2, -29 },
  { 8296, 24, 29, 29, 2, -29 },
  { 8383, 24, 30, 30, 3, -29 },
  { 8473, 28, 41, 30, -1, -29 },
  { 8617, 25, 41, 30, 3, -29 },
  { 8746, 19, 28, 20, 2, -28 },
  { 8813, 20, 30, 22, 1, -29 },
  { 8888, 14, 36, 16, 3, -35 },
  { 8951, 24, 29, 29, 3, -28 },
  { 9038, 21, 28, 22, 3, -28 },
  { 9112, 33, 28, 35, 3, -28 },
  { 9228, 27, 28, 24, -2, -28 },
  { 9323, 30, 41, 22, -6, -28 },
  { 9477, 24, 28, 23, -1, -28 },
  { 9561, 19, 46, 17, 1, -38 },
  { 9671, 1, 53, 28, 15, -40 },
  { 9678, 19, 46, 17, -3, -38 },
  { 9788, 24, 5, 30, 4, -21 },
};

const GFXfont NotoSans_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_THINITALIC53PT7B_H_
