#ifndef _NOTOSANS_THINITALIC34PT7B_H_
#define _NOTOSANS_THINITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x80, 0x00, 0x00, 0x04, 0x30, 0x42, 0x85, 0x0A, 0x28, 0x50,
  0xA1, 0x44, 0x88, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x40, 0x80, 0x08,
  0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x81, 0x03, 0xFF, 0xFF, 0x01,
  0x02, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x04, 0x04, 0x0F, 0xFF, 0xFC, 0x04, 0x08, 0x00, 0x80, 0x80,
  0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x01, 0x00, 0x10, 0x20,
  0x01, 0x02, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xE0, 0x64,
  0x21, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00,
  0xC4, 0x00, 0xC8, 0x00, 0x70, 0x00, 0x58, 0x00, 0x88, 0x01, 0x08, 0x02,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x20, 0x88, 0x7F, 0xE0,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xCC,
  0x01, 0x88, 0x20, 0x08, 0x41, 0x00, 0x84, 0x04, 0x08, 0x20, 0x20, 0xC1,
  0x02, 0x04, 0x10, 0x10, 0x40, 0x80, 0x84, 0x04, 0x04, 0x20, 0x20, 0x22,
  0x39, 0x02, 0x22, 0x28, 0x12, 0x20, 0xC1, 0x12, 0x05, 0x11, 0x10, 0x23,
  0x11, 0x01, 0x01, 0x08, 0x08, 0x08, 0x40, 0x40, 0x82, 0x02, 0x08, 0x20,
  0x20, 0x81, 0x01, 0x04, 0x08, 0x08, 0x40, 0x20, 0x84, 0x01, 0x08, 0x40,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x18, 0xC0, 0x02, 0x02, 0x00, 0x20, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x04,
  0x00, 0x21, 0x80, 0x02, 0x60, 0x00, 0x18, 0x00, 0x06, 0x80, 0x00, 0x84,
  0x00, 0x30, 0x40, 0x34, 0x02, 0x02, 0x80, 0x10, 0x48, 0x00, 0x84, 0x80,
  0x08, 0x88, 0x00, 0x50, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x09, 0x04,
  0x03, 0x08, 0x3F, 0xC0, 0xC0, 0x55, 0xAA, 0x80, 0x00, 0xC0, 0x40, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x18,
  0x08, 0x08, 0x0C, 0x04, 0x0C, 0x00, 0x00, 0x80, 0x02, 0x00, 0x08, 0x20,
  0x40, 0x41, 0x00, 0xC4, 0x00, 0xD0, 0x40, 0xFE, 0x05, 0x00, 0x24, 0x01,
  0x08, 0x08, 0x20, 0x40, 0x40, 0x01, 0x00, 0x04, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x08, 0x44, 0x22, 0x11, 0x18, 0xFF, 0x70, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x00, 0x70, 0x03, 0x8C, 0x06, 0x02, 0x08, 0x02,
  0x08, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10,
  0x40, 0x30, 0x20, 0x60, 0x1F, 0x80, 0x03, 0x0D, 0x12, 0x62, 0x82, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x00, 0x38, 0x00, 0x63, 0x80, 0xC0,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0x01, 0xC3, 0x03, 0x00, 0x41, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x21, 0x00, 0x20, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01,
  0x04, 0x01, 0x02, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40,
  0x80, 0x20, 0x80, 0x10, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x03, 0xFF, 0x81,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0xE0, 0x07, 0x8C, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x42, 0x00, 0xC0, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0xE1, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x23, 0xE0, 0x4C, 0x18,
  0x50, 0x04, 0x60, 0x04, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20,
  0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x03, 0x8C, 0x04, 0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x08, 0x02, 0x08, 0x04, 0x04, 0x18, 0x03, 0x60, 0x03,
  0xC0, 0x0C, 0x20, 0x30, 0x10, 0x40, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x60, 0x30, 0x3F,
  0xC0, 0x00, 0x60, 0x03, 0x18, 0x0C, 0x04, 0x18, 0x02, 0x10, 0x02, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20,
  0x02, 0x20, 0x06, 0x30, 0x0A, 0x18, 0x72, 0x07, 0x84, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0xFE, 0x00, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0x00, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x20,
  0x00, 0x00, 0x0E, 0x0E, 0x30, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x40, 0x01, 0x80, 0xC0,
  0x00, 0x40, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x02, 0x40,
  0x3F, 0xC1, 0x40, 0x20, 0x20, 0xA0, 0x20, 0x20, 0x50, 0x20, 0x10, 0x30,
  0x20, 0x08, 0x18, 0x10, 0x04, 0x0C, 0x08, 0x04, 0x06, 0x08, 0x02, 0x03,
  0x04, 0x01, 0x02, 0x82, 0x01, 0x81, 0x41, 0x01, 0x41, 0x20, 0x41, 0xA1,
  0x90, 0x1F, 0x1F, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x40, 0x80,
  0x08, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0xFF, 0xF0, 0x20, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x08,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x07,
  0xFE, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0xC1, 0x00, 0xC0,
  0xFF, 0xE0, 0x20, 0x04, 0x08, 0x00, 0x82, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01,
  0x08, 0x01, 0x83, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x3C, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x20, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x80, 0x30, 0x08, 0x00,
  0x80, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44,
  0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0xC0,
  0x80, 0x70, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x84, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x84, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xC1,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0E, 0x1E, 0x03, 0x00, 0x10, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x03, 0xFC, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x30, 0x0F,
  0xFC, 0x00, 0x04, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x7F, 0xFF, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x82,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x07, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x07, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x61, 0x00, 0x10,
  0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x30, 0x04, 0x0C, 0x00,
  0x82, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x12, 0x80, 0x03,
  0x88, 0x00, 0x41, 0x00, 0x08, 0x10, 0x02, 0x02, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20,
  0x01, 0x04, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xFF, 0x04, 0x00, 0x01, 0x85, 0x00, 0x00, 0xC2, 0x80,
  0x00, 0xA1, 0x40, 0x00, 0x60, 0xA0, 0x00, 0x50, 0x50, 0x00, 0x48, 0x48,
  0x00, 0x24, 0x22, 0x00, 0x22, 0x11, 0x00, 0x12, 0x08, 0x80, 0x11, 0x04,
  0x40, 0x10, 0x84, 0x20, 0x08, 0x42, 0x10, 0x08, 0x21, 0x04, 0x04, 0x20,
  0x82, 0x04, 0x10, 0x81, 0x04, 0x08, 0x40, 0x82, 0x04, 0x20, 0x42, 0x02,
  0x10, 0x11, 0x02, 0x08, 0x09, 0x01, 0x08, 0x05, 0x00, 0x84, 0x02, 0x80,
  0x42, 0x01, 0x80, 0x41, 0x00, 0xC0, 0x20, 0x04, 0x00, 0x08, 0x60, 0x00,
  0x82, 0x80, 0x04, 0x14, 0x00, 0x20, 0x90, 0x01, 0x04, 0x80, 0x08, 0x44,
  0x00, 0x82, 0x10, 0x04, 0x10, 0x80, 0x20, 0x82, 0x01, 0x04, 0x10, 0x08,
  0x40, 0x40, 0x82, 0x02, 0x04, 0x10, 0x10, 0x20, 0x80, 0x41, 0x08, 0x02,
  0x10, 0x40, 0x08, 0x82, 0x00, 0x44, 0x10, 0x01, 0x20, 0x80, 0x09, 0x08,
  0x00, 0x50, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x00, 0x7C,
  0x00, 0x18, 0x30, 0x06, 0x00, 0xC0, 0x80, 0x04, 0x10, 0x00, 0x21, 0x00,
  0x02, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x28,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x40, 0x00, 0x84, 0x00, 0x10, 0x20, 0x02, 0x01, 0x00, 0x40, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x04, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00,
  0xC4, 0x00, 0xC2, 0x03, 0x81, 0xFC, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x18, 0x30, 0x06, 0x00, 0xC0,
  0x80, 0x04, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x16, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x10, 0x20,
  0x02, 0x01, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x04, 0x01, 0x82, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x84, 0x01, 0x83,
  0xFF, 0x01, 0x02, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x08,
  0x10, 0x04, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x11, 0x00,
  0x08, 0x00, 0x38, 0x03, 0x87, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x80,
  0x30, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x18, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x20, 0x20, 0x02, 0x00, 0x80, 0x20, 0x03, 0xFE, 0x00, 0x80, 0x01, 0xC0,
  0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x20,
  0x80, 0x10, 0x40, 0x10, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x04, 0x01, 0x02, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x21, 0x01,
  0x10, 0x08, 0x40, 0x44, 0x04, 0x10, 0x21, 0x01, 0x04, 0x08, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21,
  0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80,
  0x24, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x02, 0x00, 0x18, 0x08, 0x00, 0x80,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x08, 0x08, 0x00, 0x40, 0x80, 0x01, 0x04,
  0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x28, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00,
  0x02, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x10, 0x04, 0x01, 0x00,
  0x20, 0x10, 0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x30, 0x80, 0x01, 0xA0,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x40, 0x10, 0x40, 0x08, 0x20, 0x02, 0x20, 0x01, 0x20, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x81, 0x04, 0x10,
  0x41, 0x04, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0x82,
  0x08, 0x20, 0x81, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0xA0, 0x02, 0x40, 0x0C, 0x80, 0x10, 0x80, 0x41, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x04, 0x20, 0x08, 0x40, 0x11, 0x00, 0x24, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8, 0x84, 0x42, 0x10, 0x07, 0xF2, 0x10,
  0x34, 0x40, 0x29, 0x00, 0x32, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x03, 0x20,
  0x0C, 0x40, 0x28, 0x40, 0x90, 0x7E, 0x20, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0xFC, 0x0B, 0x02, 0x14, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x60, 0x02, 0x60, 0x04, 0x60, 0x08, 0x90, 0x10, 0x8F, 0xE0, 0x03,
  0xFC, 0x30, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x20, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x03, 0xF1, 0x03, 0x02, 0x41, 0x00, 0x50, 0x80, 0x18, 0x20, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x30, 0x80, 0x08, 0x20, 0x06, 0x08, 0x02, 0x82, 0x00,
  0xA0, 0x40, 0xC8, 0x0F, 0xC4, 0x00, 0x03, 0xF0, 0x30, 0x21, 0x80, 0x8C,
  0x01, 0x20, 0x05, 0x00, 0x24, 0x01, 0x90, 0x18, 0xFF, 0x82, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x20,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x83, 0x02, 0x42,
  0x00, 0xA2, 0x00, 0x61, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00,
  0x61, 0x00, 0x70, 0x80, 0x28, 0x20, 0x64, 0x0F, 0xC4, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x80, 0x40,
  0x3F, 0xC0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xFC, 0x0B, 0x02, 0x16,
  0x01, 0x14, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x04, 0x10, 0x40, 0x00, 0x00,
  0x02, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x02, 0x10, 0x08, 0x40,
  0x60, 0x81, 0x81, 0x04, 0x02, 0x10, 0x08, 0x40, 0x11, 0x00, 0x26, 0x00,
  0x52, 0x00, 0xC4, 0x03, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x10, 0x80, 0x21, 0x00, 0x20, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x00, 0x09, 0xF8, 0x3F, 0x04, 0x81, 0x10, 0x21, 0x40, 0x48, 0x08, 0x60,
  0x0C, 0x01, 0x18, 0x03, 0x00, 0x44, 0x00, 0x80, 0x11, 0x00, 0x60, 0x08,
  0x80, 0x10, 0x02, 0x20, 0x04, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00, 0x40,
  0x09, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01, 0x10, 0x02, 0x00, 0x44, 0x00,
  0x80, 0x11, 0x00, 0x40, 0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00, 0x80,
  0x08, 0xFC, 0x13, 0x02, 0x16, 0x01, 0x14, 0x01, 0x18, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x03, 0xF0, 0x18, 0x18, 0x40, 0x11, 0x00, 0x16, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x50, 0x00, 0xA0, 0x02, 0x20, 0x08, 0x60, 0x20, 0x3F, 0x80, 0x02, 0x3F,
  0x01, 0x30, 0x20, 0x50, 0x04, 0x14, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x86, 0x00, 0x21, 0x80, 0x10, 0x60, 0x08, 0x24, 0x04,
  0x08, 0xFE, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF1, 0x0C,
  0x09, 0x10, 0x05, 0x20, 0x06, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x28, 0x40, 0xC8, 0x3F, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x08, 0xF1, 0x30, 0x14, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x07, 0xF8, 0x20, 0x11, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x80, 0x61, 0xFE, 0x00,
  0x08, 0x08, 0x04, 0x02, 0x0F, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03,
  0xE0, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x28, 0x80, 0x50, 0x40, 0x90, 0x7F,
  0x10, 0x80, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x22, 0x01, 0x04,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x24, 0x00,
  0x90, 0x02, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0xA0, 0x18, 0x05, 0x01, 0x40, 0x28, 0x0A, 0x02, 0x40, 0x90,
  0x12, 0x04, 0x41, 0x10, 0x42, 0x08, 0x82, 0x10, 0x84, 0x20, 0x84, 0x21,
  0x04, 0x41, 0x10, 0x22, 0x04, 0x81, 0x20, 0x28, 0x09, 0x01, 0x40, 0x50,
  0x0C, 0x02, 0x80, 0x60, 0x08, 0x02, 0x00, 0x40, 0x00, 0x08, 0x01, 0x82,
  0x00, 0x81, 0x00, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x00, 0x80, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x42,
  0x00, 0x41, 0x00, 0x40, 0x40, 0x40, 0x20, 0x40, 0x08, 0x40, 0x06, 0x00,
  0x02, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x80, 0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x09, 0x00, 0x00,
  0xA0, 0x00, 0x0A, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0xE0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0xF0, 0x00,
  0x18, 0x01, 0xCC, 0x06, 0x07, 0x30, 0x01, 0x80,
};

const GFXglyph NotoSans_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 11, 4, -24 },
  { 27, 20, 24, 21, 1, -24 },
  { 87, 15, 28, 19, 2, -26 },
  { 140, 21, 25, 26, 3, -25 },
  { 206, 20, 25, 23, 2, -25 },
  { 269, 2, 9, 6, 4, -24 },
  { 272, 10, 29, 8, 1, -24 },
  { 309, 9, 29, 8, -2, -24 },
  { 342, 14, 15, 18, 4, -26 },
  { 369, 15, 16, 19, 3, -20 },
  { 399, 5, 8, 6, -2, -4 },
  { 404, 8, 1, 11, 1, -10 },
  { 405, 2, 2, 7, 1, -2 },
  { 406, 14, 24, 10, -1, -24 },
  { 448, 16, 25, 19, 2, -25 },
  { 498, 8, 24, 19, 6, -24 },
  { 522, 17, 25, 19, 0, -25 },
  { 576, 17, 25, 19, 1, -25 },
  { 630, 17, 24, 19, 1, -24 },
  { 681, 17, 24, 19, 1, -24 },
  { 732, 16, 25, 19, 2, -25 },
  { 782, 15, 24, 19, 4, -24 },
  { 827, 16, 25, 19, 2, -25 },
  { 877, 16, 25, 19, 2, -25 },
  { 927, 5, 18, 7, 1, -18 },
  { 939, 8, 22, 7, -2, -18 },
  { 961, 15, 15, 19, 3, -20 },
  { 990, 15, 8, 19, 3, -16 },
  { 1005, 15, 15, 19, 3, -20 },
  { 1034, 11, 25, 14, 3, -25 },
  { 1069, 25, 27, 28, 2, -24 },
  { 1154, 19, 24, 19, -2, -24 },
  { 1211, 18, 24, 20, 2, -24 },
  { 1265, 19, 25, 20, 3, -25 },
  { 1325, 20, 24, 23, 2, -24 },
  { 1385, 17, 24, 18, 2, -24 },
  { 1436, 17, 24, 17, 2, -24 },
  { 1487, 20, 25, 23, 3, -25 },
  { 1550, 21, 24, 23, 2, -24 },
  { 1613, 11, 24, 9, 0, -24 },
  { 1646, 14, 30, 8, -6, -24 },
  { 1699, 19, 24, 18, 2, -24 },
  { 1756, 12, 24, 17, 2, -24 },
  { 1792, 25, 24, 27, 2, -24 },
  { 1867, 21, 24, 23, 2, -24 },
  { 1930, 20, 25, 24, 3, -25 },
  { 1993, 17, 24, 19, 2, -24 },
  { 2044, 20, 31, 24, 3, -25 },
  { 2122, 17, 24, 19, 2, -24 },
  { 2173, 16, 25, 17, 1, -25 },
  { 2223, 17, 24, 16, 3, -24 },
  { 2274, 21, 24, 24, 3, -24 },
  { 2337, 17, 24, 18, 4, -24 },
  { 2388, 26, 24, 28, 4, -24 },
  { 2466, 21, 24, 17, -2, -24 },
  { 2529, 17, 24, 16, 3, -24 },
  { 2580, 19, 24, 18, 0, -24 },
  { 2637, 13, 29, 10, 0, -24 },
  { 2685, 6, 24, 10, 3, -24 },
  { 2703, 12, 29, 10, -2, -24 },
  { 2747, 15, 15, 19, 2, -24 },
  { 2776, 13, 1, 13, -3, 4 },
  { 2778, 4, 5, 8, 5, -26 },
  { 2781, 15, 18, 19, 2, -18 },
  { 2815, 16, 26, 19, 1, -26 },
  { 2867, 14, 18, 15, 2, -18 },
  { 2899, 18, 26, 19, 2, -26 },
  { 2958, 14, 18, 17, 2, -18 },
  { 2990, 18, 34, 9, -4, -26 },
  { 3067, 17, 26, 19, 1, -18 },
  { 3123, 16, 26, 19, 1, -26 },
  { 3175, 6, 25, 7, 1, -25 },
  { 3194, 12, 33, 7, -5, -25 },
  { 3244, 15, 26, 15, 1, -26 },
  { 3293, 6, 26, 7, 1, -26 },
  { 3313, 26, 18, 29, 1, -18 },
  { 3372, 16, 18, 19, 1, -18 },
  { 3408, 15, 18, 19, 2, -18 },
  { 3442, 18, 26, 19, -1, -18 },
  { 3501, 16, 26, 19, 2, -18 },
  { 3553, 12, 18, 13, 1, -18 },
  { 3580, 14, 18, 14, 0, -18 },
  { 3612, 9, 22, 11, 2, -22 },
  { 3637, 16, 18, 19, 2, -18 },
  { 3673, 14, 18, 14, 2, -18 },
  { 3705, 21, 18, 22, 2, -18 },
  { 3753, 17, 18, 15, -1, -18 },
  { 3792, 20, 26, 14, -4, -18 },
  { 3857, 15, 18, 15, 0, -18 },
  { 3891, 12, 29, 11, 1, -24 },
  { 3935, 1, 34, 18, 10, -26 },
  { 3940, 12, 29, 11, -2, -24 },
  { 3984, 15, 4, 19, 3, -14 },
};

const GFXfont NotoSans_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_THINITALIC34PT7B_H_
