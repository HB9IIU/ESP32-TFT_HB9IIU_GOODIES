#ifndef _NOTOSANS_THINITALIC33PT7B_H_
#define _NOTOSANS_THINITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x80, 0x00, 0x00, 0x04, 0x30, 0x42, 0x85, 0x12, 0x28, 0x50,
  0xA1, 0x44, 0x88, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x82, 0x00, 0x10, 0x20, 0x3F,
  0xFF, 0xF0, 0x10, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00,
  0x40, 0x40, 0x04, 0x08, 0x00, 0x40, 0x80, 0xFF, 0xFF, 0xC0, 0x81, 0x00,
  0x08, 0x10, 0x00, 0x81, 0x00, 0x10, 0x10, 0x01, 0x02, 0x00, 0x10, 0x20,
  0x01, 0x02, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x1F, 0xE0, 0xC4,
  0x22, 0x08, 0x04, 0x10, 0x10, 0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00,
  0x44, 0x00, 0x70, 0x00, 0x38, 0x00, 0x48, 0x00, 0x88, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x10, 0x84, 0x3F, 0xF0, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x21, 0x18, 0x02, 0x20,
  0x80, 0x44, 0x08, 0x08, 0x40, 0x81, 0x04, 0x08, 0x10, 0x80, 0x82, 0x08,
  0x08, 0x40, 0x80, 0x88, 0x08, 0x10, 0x80, 0x81, 0x13, 0xE8, 0x12, 0x61,
  0x82, 0x44, 0x1C, 0x44, 0x81, 0x38, 0x88, 0x10, 0x10, 0x81, 0x03, 0x10,
  0x10, 0x21, 0x01, 0x04, 0x10, 0x10, 0x81, 0x02, 0x08, 0x10, 0x21, 0x01,
  0x02, 0x20, 0x10, 0x44, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x20, 0x80, 0x08,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x20, 0x04, 0x08, 0x00, 0x46, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC8,
  0x00, 0x60, 0x80, 0x50, 0x08, 0x0E, 0x01, 0x02, 0x80, 0x10, 0x90, 0x01,
  0x12, 0x00, 0x24, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x32, 0x10, 0x08,
  0x41, 0xFE, 0x04, 0x55, 0xAA, 0x80, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x0C, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x20, 0x40, 0x61, 0x00, 0x68, 0x00, 0x6F,
  0xC0, 0xC0, 0x05, 0x00, 0x64, 0x02, 0x08, 0x10, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x13, 0x22, 0x44, 0x88, 0xFF,
  0x70, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x04, 0x18, 0x10,
  0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0x44, 0x01, 0x08, 0x04,
  0x08, 0x10, 0x0F, 0xC0, 0x01, 0x03, 0x0D, 0x11, 0x61, 0xC2, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x00, 0x7C, 0x00, 0xC1, 0x01, 0x80, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x06, 0x08,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x08, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x80, 0x30, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x88, 0x00, 0x84, 0x00, 0x84,
  0x00, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x40, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x40, 0x10, 0x40, 0x08, 0x40, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x03, 0xFF,
  0x81, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x02, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x42, 0x00, 0xC0, 0xFF,
  0x80, 0x00, 0x3F, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x80, 0x47, 0x70, 0x50,
  0x08, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F,
  0xC0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x01, 0xF0,
  0x0C, 0x18, 0x30, 0x08, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x08, 0x04, 0x08, 0x10, 0x08, 0xC0, 0x0E, 0x00, 0xE4, 0x02, 0x06,
  0x18, 0x02, 0x40, 0x04, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48,
  0x00, 0x90, 0x02, 0x10, 0x08, 0x1F, 0xE0, 0x01, 0xF0, 0x0C, 0x10, 0x20,
  0x10, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x19, 0x00, 0x32, 0x00, 0xA2, 0x06, 0x83, 0xF1, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x7F, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x46, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x18, 0x20, 0x41, 0x02, 0x08, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x0C, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x0C, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x00, 0x40, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08,
  0x80, 0x3C, 0x04, 0x40, 0x61, 0x81, 0x40, 0x40, 0x40, 0xA0, 0x40, 0x20,
  0x60, 0x40, 0x20, 0x30, 0x20, 0x10, 0x18, 0x20, 0x08, 0x14, 0x10, 0x08,
  0x0A, 0x08, 0x04, 0x05, 0x04, 0x02, 0x04, 0x82, 0x03, 0x02, 0x41, 0x82,
  0x82, 0x20, 0x66, 0x2E, 0x08, 0x0C, 0x08, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28,
  0x00, 0x09, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x08, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x20, 0x3F,
  0xF8, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0x07, 0xF0, 0x04,
  0x07, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x88, 0x03, 0x07, 0xFE, 0x02, 0x00,
  0x81, 0x00, 0x30, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x48, 0x00, 0x44, 0x00, 0x62, 0x00, 0xC1, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x60, 0x30, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x40, 0x3F, 0xE0, 0x07, 0xC0, 0x01, 0x03, 0xC0, 0x20,
  0x0C, 0x04, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x11, 0x00, 0x04, 0x20, 0x01, 0x88, 0x00, 0x61, 0x00, 0x10, 0x20, 0x1C,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x3F, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x1C, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFD, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x02, 0x0C, 0x00, 0x80, 0x7F, 0xE0,
  0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x43, 0xFF, 0xFC, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x07, 0xC0, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x86, 0x01, 0xE0, 0x00, 0x04,
  0x00, 0x61, 0x00, 0x18, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x10, 0x04, 0x04, 0x00, 0x83, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x12, 0x80, 0x02, 0x90, 0x00, 0x61, 0x00, 0x08, 0x20, 0x02, 0x02,
  0x00, 0x40, 0x40, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x08, 0x01,
  0x01, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x04, 0x00, 0x01, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0A, 0x00, 0x05, 0x0A, 0x00, 0x05, 0x0A,
  0x00, 0x0A, 0x12, 0x00, 0x12, 0x12, 0x00, 0x12, 0x12, 0x00, 0x22, 0x11,
  0x00, 0x22, 0x21, 0x00, 0x44, 0x21, 0x00, 0x84, 0x21, 0x00, 0x84, 0x21,
  0x01, 0x04, 0x21, 0x01, 0x04, 0x40, 0x82, 0x08, 0x40, 0x84, 0x08, 0x40,
  0x84, 0x08, 0x40, 0x88, 0x08, 0x40, 0x88, 0x10, 0x80, 0x50, 0x10, 0x80,
  0x60, 0x10, 0x80, 0x60, 0x10, 0x80, 0x40, 0x10, 0x08, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x10, 0xA0, 0x02, 0x0A, 0x00, 0x21, 0x20, 0x02, 0x11,
  0x00, 0x21, 0x10, 0x02, 0x10, 0x80, 0x41, 0x08, 0x04, 0x20, 0x40, 0x42,
  0x04, 0x04, 0x20, 0x40, 0x42, 0x02, 0x08, 0x20, 0x20, 0x84, 0x01, 0x08,
  0x40, 0x10, 0x84, 0x00, 0x88, 0x40, 0x09, 0x04, 0x00, 0x90, 0x80, 0x05,
  0x08, 0x00, 0x50, 0x80, 0x02, 0x08, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x60,
  0x60, 0x10, 0x02, 0x04, 0x00, 0x21, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00,
  0x0A, 0x00, 0x01, 0x40, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0xC4, 0x00, 0x10, 0x40, 0x04,
  0x0C, 0x03, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x08, 0x1C, 0x08, 0x02, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x02, 0x20, 0x06, 0x20, 0x18, 0x3F, 0xE0, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x60, 0x10, 0x02,
  0x04, 0x00, 0x21, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x02, 0x40, 0x00, 0xC4, 0x00, 0x10, 0x40, 0x04, 0x0C, 0x03, 0x00,
  0x7F, 0x80, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x08, 0x1C, 0x08, 0x02, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x02, 0x20, 0x04, 0x20, 0x78, 0x3F, 0xC0, 0x20, 0x40, 0x40,
  0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x04, 0x01, 0xFC, 0x06, 0x03, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x80, 0x20, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x21, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x02, 0x04, 0x00, 0x40,
  0x20, 0x18, 0x01, 0xFE, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x02, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x50, 0x02, 0x80, 0x28, 0x02, 0x40, 0x14,
  0x01, 0x20, 0x12, 0x01, 0x10, 0x09, 0x00, 0x88, 0x08, 0x80, 0x84, 0x04,
  0x40, 0x42, 0x04, 0x10, 0x21, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41,
  0x02, 0x10, 0x21, 0x01, 0x08, 0x10, 0x80, 0x88, 0x08, 0x40, 0x44, 0x04,
  0x40, 0x24, 0x02, 0x20, 0x12, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x05, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x02,
  0x00, 0x08, 0x10, 0x00, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x08,
  0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x02,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x28, 0x00,
  0x02, 0x40, 0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x20, 0x20, 0x01, 0x01,
  0x00, 0x10, 0x08, 0x01, 0x00, 0x20, 0x10, 0x01, 0x01, 0x00, 0x04, 0x18,
  0x00, 0x20, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x08,
  0x20, 0x10, 0x20, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80,
  0x11, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xF0, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFC, 0x00, 0x84, 0x10, 0x84, 0x21, 0x08,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x03, 0xF0,
  0x41, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x80,
  0x04, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x08, 0x08, 0x20,
  0x10, 0x40, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x00, 0x80, 0xFF,
  0xF8, 0x84, 0x42, 0x10, 0x03, 0xC0, 0x18, 0x64, 0x40, 0x49, 0x00, 0x62,
  0x00, 0xC8, 0x00, 0x90, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x48, 0x01, 0x10, 0x06, 0x20, 0x0C, 0x40, 0x28, 0x40, 0x90,
  0x7E, 0x40, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x78, 0x11, 0x84, 0x12, 0x02, 0x14, 0x02,
  0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x60, 0x04, 0xA0, 0x08,
  0x90, 0x30, 0x8F, 0xC0, 0x01, 0xF0, 0x30, 0x46, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x07, 0xC2, 0x0C, 0x12, 0x0C, 0x05, 0x08, 0x01, 0x84, 0x00, 0xC4,
  0x00, 0x42, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x01, 0x42, 0x01, 0x40, 0x81,
  0x20, 0x3F, 0x10, 0x00, 0x01, 0xE0, 0x30, 0x82, 0x02, 0x20, 0x12, 0x00,
  0xA0, 0x05, 0x00, 0x48, 0x04, 0x83, 0xC7, 0x60, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x20, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x83, 0x84, 0x83, 0x01, 0x42, 0x00, 0x61, 0x00, 0x31,
  0x00, 0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x61, 0x00, 0x50, 0x80, 0x50, 0x20,
  0x48, 0x0F, 0xC4, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x80, 0xC0, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x3C,
  0x11, 0x84, 0x24, 0x04, 0x50, 0x08, 0xC0, 0x11, 0x00, 0x26, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x48, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x08, 0x04, 0x30, 0x00, 0x00,
  0x00, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x0F, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x01, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x83,
  0x01, 0x0C, 0x04, 0x20, 0x08, 0x80, 0x13, 0x00, 0x2A, 0x00, 0x62, 0x01,
  0x84, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80,
  0x30, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x80, 0x00, 0xF0, 0x1C, 0x09,
  0x84, 0x31, 0x85, 0x81, 0x20, 0x42, 0x80, 0xA0, 0x11, 0x80, 0x60, 0x08,
  0x80, 0x30, 0x04, 0xC0, 0x10, 0x02, 0x40, 0x08, 0x02, 0x20, 0x04, 0x01,
  0x10, 0x04, 0x00, 0x88, 0x02, 0x00, 0x48, 0x01, 0x00, 0x24, 0x00, 0x80,
  0x22, 0x00, 0x40, 0x11, 0x00, 0x40, 0x08, 0x80, 0x20, 0x04, 0x80, 0x10,
  0x02, 0x40, 0x08, 0x02, 0x00, 0x00, 0x78, 0x23, 0x08, 0x48, 0x08, 0xA0,
  0x11, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08,
  0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x80,
  0x09, 0x00, 0x10, 0x01, 0xE0, 0x0C, 0x30, 0x60, 0x31, 0x00, 0x22, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x02, 0x20, 0x08, 0x60, 0x20, 0x7F,
  0x80, 0x00, 0x1E, 0x01, 0x18, 0x40, 0x48, 0x08, 0x14, 0x02, 0x06, 0x00,
  0x41, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x80, 0x10, 0xA0,
  0x08, 0x24, 0x0C, 0x08, 0xFC, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xE1, 0x0E, 0x12, 0x18, 0x0A, 0x20, 0x06, 0x20, 0x06, 0x40, 0x04,
  0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x28, 0x80, 0x50, 0x40, 0x90, 0x3F, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x71, 0x18, 0x12, 0x01, 0x40, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x01, 0xE0, 0x60, 0xC4, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x80, 0x43, 0xFC,
  0x00, 0x08, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x07, 0xC0, 0x20, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00,
  0xC8, 0x01, 0x10, 0x06, 0x20, 0x14, 0x60, 0x48, 0x7F, 0x10, 0x80, 0x0C,
  0x00, 0xA0, 0x09, 0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x08, 0x10, 0x41,
  0x02, 0x10, 0x10, 0x80, 0x88, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x06, 0x00,
  0x20, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20, 0x88, 0x22, 0x08, 0x84, 0x21,
  0x08, 0x41, 0x10, 0x88, 0x12, 0x08, 0x81, 0x20, 0x90, 0x14, 0x06, 0x01,
  0x40, 0x60, 0x18, 0x04, 0x01, 0x80, 0x40, 0x10, 0x00, 0x08, 0x01, 0x04,
  0x02, 0x04, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x04, 0x20, 0x08, 0x20, 0x10,
  0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x08, 0x02, 0x00, 0x20, 0x40, 0x08,
  0x08, 0x01, 0x01, 0x00, 0x40, 0x20, 0x10, 0x02, 0x02, 0x00, 0x40, 0x80,
  0x08, 0x10, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF,
  0xE0, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x70, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0xF0, 0x00, 0x7C, 0x03,
  0x07, 0x0A, 0x01, 0xC0,
};

const GFXglyph NotoSans_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 10, 4, -24 },
  { 27, 20, 24, 20, 1, -24 },
  { 87, 15, 27, 18, 2, -25 },
  { 138, 20, 24, 25, 3, -24 },
  { 198, 19, 24, 23, 2, -24 },
  { 255, 2, 9, 6, 4, -24 },
  { 258, 9, 29, 8, 1, -24 },
  { 291, 9, 29, 8, -2, -24 },
  { 324, 14, 14, 18, 4, -25 },
  { 349, 16, 15, 19, 2, -19 },
  { 379, 4, 8, 6, -1, -4 },
  { 383, 8, 1, 10, 1, -9 },
  { 384, 2, 2, 7, 1, -2 },
  { 385, 14, 24, 10, -1, -24 },
  { 427, 15, 24, 18, 2, -24 },
  { 472, 8, 24, 18, 5, -24 },
  { 496, 17, 24, 18, 0, -24 },
  { 547, 16, 24, 18, 1, -24 },
  { 595, 17, 24, 18, 0, -24 },
  { 646, 17, 24, 18, 1, -24 },
  { 697, 16, 24, 18, 2, -24 },
  { 745, 15, 24, 18, 4, -24 },
  { 790, 15, 24, 18, 2, -24 },
  { 835, 15, 24, 18, 2, -24 },
  { 880, 5, 18, 7, 1, -18 },
  { 892, 7, 22, 7, -1, -18 },
  { 912, 15, 14, 19, 3, -19 },
  { 939, 16, 7, 19, 2, -15 },
  { 953, 15, 14, 19, 3, -19 },
  { 980, 11, 24, 13, 3, -24 },
  { 1013, 25, 26, 28, 2, -23 },
  { 1095, 18, 24, 18, -2, -24 },
  { 1149, 17, 24, 20, 2, -24 },
  { 1200, 18, 24, 20, 3, -24 },
  { 1254, 19, 24, 22, 2, -24 },
  { 1311, 16, 24, 18, 2, -24 },
  { 1359, 16, 24, 16, 2, -24 },
  { 1407, 19, 24, 23, 3, -24 },
  { 1464, 20, 24, 22, 2, -24 },
  { 1524, 10, 24, 9, 0, -24 },
  { 1554, 14, 30, 8, -6, -24 },
  { 1607, 19, 24, 18, 2, -24 },
  { 1664, 12, 24, 16, 2, -24 },
  { 1700, 24, 24, 27, 2, -24 },
  { 1772, 20, 24, 22, 2, -24 },
  { 1832, 19, 24, 24, 3, -24 },
  { 1889, 16, 24, 18, 2, -24 },
  { 1937, 19, 30, 24, 3, -24 },
  { 2009, 16, 24, 19, 2, -24 },
  { 2057, 16, 24, 16, 1, -24 },
  { 2105, 16, 24, 16, 3, -24 },
  { 2153, 20, 24, 23, 3, -24 },
  { 2213, 17, 24, 18, 3, -24 },
  { 2264, 25, 24, 27, 4, -24 },
  { 2339, 21, 24, 16, -2, -24 },
  { 2402, 16, 24, 16, 3, -24 },
  { 2450, 19, 24, 18, 0, -24 },
  { 2507, 12, 29, 10, 0, -24 },
  { 2551, 5, 24, 10, 3, -24 },
  { 2566, 12, 29, 10, -2, -24 },
  { 2610, 15, 15, 18, 2, -24 },
  { 2639, 13, 1, 12, -3, 4 },
  { 2641, 4, 5, 7, 5, -25 },
  { 2644, 15, 18, 18, 2, -18 },
  { 2678, 16, 25, 19, 1, -25 },
  { 2728, 13, 18, 15, 2, -18 },
  { 2758, 17, 25, 19, 2, -25 },
  { 2812, 13, 18, 16, 2, -18 },
  { 2842, 18, 33, 9, -4, -25 },
  { 2917, 17, 26, 19, 1, -18 },
  { 2973, 15, 25, 18, 1, -25 },
  { 3020, 6, 24, 7, 1, -24 },
  { 3038, 12, 32, 7, -5, -24 },
  { 3086, 15, 25, 14, 1, -25 },
  { 3133, 6, 25, 7, 1, -25 },
  { 3152, 25, 18, 28, 1, -18 },
  { 3209, 15, 18, 18, 1, -18 },
  { 3243, 15, 18, 19, 2, -18 },
  { 3277, 18, 26, 19, -1, -18 },
  { 3336, 16, 26, 19, 2, -18 },
  { 3388, 12, 18, 12, 1, -18 },
  { 3415, 13, 18, 14, 0, -18 },
  { 3445, 9, 22, 10, 2, -22 },
  { 3470, 15, 17, 18, 2, -17 },
  { 3502, 13, 17, 14, 2, -17 },
  { 3530, 20, 17, 21, 2, -17 },
  { 3573, 16, 17, 15, -1, -17 },
  { 3607, 19, 25, 14, -4, -17 },
  { 3667, 14, 17, 14, 0, -17 },
  { 3697, 12, 29, 11, 1, -24 },
  { 3741, 1, 33, 18, 9, -25 },
  { 3746, 12, 29, 11, -2, -24 },
  { 3790, 15, 3, 19, 3, -13 },
};

const GFXfont NotoSans_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_THINITALIC33PT7B_H_
