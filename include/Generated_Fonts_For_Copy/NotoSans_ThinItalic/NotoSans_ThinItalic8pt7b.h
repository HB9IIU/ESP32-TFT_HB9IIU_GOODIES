#ifndef _NOTOSANS_THINITALIC8PT7B_H_
#define _NOTOSANS_THINITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x29, 0x96, 0xBF, 0x30, 0x36, 0x62, 0x3E, 0xCE,
  0xBD, 0xD6, 0xDC, 0x32, 0x88, 0xD9, 0x7C, 0xC0, 0x5A, 0xA8, 0x24, 0x92,
  0xB0, 0x5F, 0x00, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x76,
  0xDB, 0x80, 0x75, 0x50, 0x71, 0x12, 0x4E, 0x71, 0x17, 0x1F, 0x13, 0x59,
  0x72, 0x74, 0x61, 0x1F, 0x73, 0x5B, 0xC0, 0xF2, 0x24, 0x88, 0x35, 0x57,
  0x9F, 0x75, 0x97, 0x1E, 0x10, 0x18, 0x3B, 0x10, 0xFC, 0x89, 0xC0, 0xD6,
  0x80, 0x39, 0x1B, 0xEB, 0xBE, 0x07, 0x80, 0x22, 0x57, 0x99, 0x72, 0x5A,
  0xA8, 0xF8, 0x78, 0x88, 0x8E, 0x72, 0x52, 0x98, 0xF8, 0x74, 0x74, 0x8E,
  0x74, 0x47, 0x88, 0x78, 0x8B, 0x9F, 0x4A, 0x5E, 0x98, 0xC4, 0x69, 0x29,
  0x00, 0x24, 0x94, 0xB0, 0x4A, 0x98, 0xC9, 0x48, 0x49, 0x29, 0xC0, 0x45,
  0x14, 0xD3, 0xB6, 0x90, 0x4A, 0x5A, 0xB9, 0x48, 0x79, 0x99, 0x9F, 0x75,
  0x56, 0x88, 0x79, 0x99, 0x9D, 0x20, 0x75, 0x56, 0x99, 0x74, 0x42, 0x1E,
  0xF4, 0x44, 0x88, 0x8C, 0x65, 0x29, 0x70, 0x99, 0xAC, 0xC8, 0x96, 0x9A,
  0xB6, 0x92, 0x40, 0x4A, 0x88, 0x8A, 0x48, 0x9A, 0xC8, 0x88, 0x78, 0x88,
  0x84, 0x70, 0x69, 0x49, 0x30, 0xFC, 0x24, 0x92, 0x78, 0x22, 0x59, 0xE0,
  0x80, 0x79, 0x9E, 0x46, 0x59, 0x9F, 0x78, 0x8E, 0x09, 0x55, 0x29, 0x70,
  0x7E, 0x8E, 0x36, 0x24, 0x44, 0x4C, 0x79, 0x9E, 0x1E, 0x46, 0x59, 0x99,
  0x46, 0xA0, 0x20, 0xA4, 0x94, 0x45, 0x6C, 0xAA, 0x56, 0xA0, 0x7E, 0x59,
  0x65, 0x79, 0x99, 0x79, 0x9F, 0x79, 0x9F, 0x88, 0x79, 0x9E, 0x12, 0x72,
  0x40, 0xE8, 0xF0, 0xEA, 0x4C, 0x59, 0x9E, 0x9A, 0xC4, 0xAD, 0x55, 0x20,
  0x74, 0x4A, 0x4A, 0x94, 0x44, 0x60, 0x69, 0x70, 0x29, 0x65, 0x30, 0xFF,
  0x55, 0x58, 0xE0,
};

const GFXglyph NotoSans_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 6, 1, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 1, 1, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 3, 7, 2, -1, -6 },
  { 25, 3, 3, 4, 1, -6 },
  { 27, 3, 4, 5, 1, -5 },
  { 29, 1, 2, 1, 0, -1 },
  { 30, 2, 1, 3, 0, -3 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 3, 6, 2, 0, -6 },
  { 35, 3, 6, 4, 1, -6 },
  { 38, 2, 6, 4, 1, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 3, 6, 4, 1, -6 },
  { 55, 4, 6, 4, 1, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 1, 4, 2, 0, -4 },
  { 65, 1, 5, 2, 0, -4 },
  { 66, 3, 4, 5, 1, -5 },
  { 68, 3, 2, 5, 1, -4 },
  { 69, 3, 4, 5, 1, -5 },
  { 71, 2, 6, 3, 1, -6 },
  { 73, 6, 7, 7, 0, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 4, 6, 5, 1, -6 },
  { 89, 5, 6, 5, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 4, 6, 6, 1, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 3, 6, 2, 0, -6 },
  { 109, 3, 7, 2, -1, -6 },
  { 112, 5, 6, 4, 0, -6 },
  { 116, 3, 6, 4, 0, -6 },
  { 119, 6, 6, 6, 0, -6 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 4, 6, 6, 1, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 4, 7, 6, 1, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 1, -6 },
  { 147, 5, 6, 6, 1, -6 },
  { 151, 4, 6, 4, 1, -6 },
  { 154, 6, 6, 7, 1, -6 },
  { 159, 5, 6, 4, 0, -6 },
  { 163, 4, 6, 4, 1, -6 },
  { 166, 5, 6, 4, 0, -6 },
  { 170, 3, 7, 2, 0, -6 },
  { 173, 1, 6, 2, 1, -6 },
  { 174, 3, 7, 2, -1, -6 },
  { 177, 4, 4, 4, 0, -6 },
  { 179, 3, 1, 3, -1, 0 },
  { 180, 1, 1, 2, 1, -6 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 6, 5, 0, -6 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 4, 8, 2, -1, -6 },
  { 198, 4, 6, 5, 0, -4 },
  { 201, 4, 6, 4, 0, -6 },
  { 204, 2, 6, 2, 0, -6 },
  { 206, 3, 8, 2, -1, -6 },
  { 209, 4, 6, 4, 0, -6 },
  { 212, 2, 6, 2, 0, -6 },
  { 214, 6, 4, 7, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 4, 5, 0, -4 },
  { 221, 4, 6, 5, 0, -4 },
  { 224, 4, 6, 5, 0, -4 },
  { 227, 3, 4, 3, 0, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 3, 5, 2, 0, -5 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 4, 4, 3, 0, -4 },
  { 237, 5, 4, 5, 0, -4 },
  { 240, 4, 4, 4, 0, -4 },
  { 242, 5, 6, 3, -1, -4 },
  { 246, 3, 4, 3, 0, -4 },
  { 248, 3, 7, 3, 0, -6 },
  { 251, 1, 8, 4, 2, -6 },
  { 252, 2, 7, 3, 0, -6 },
  { 254, 3, 1, 5, 1, -3 },
};

const GFXfont NotoSans_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_THINITALIC8PT7B_H_
