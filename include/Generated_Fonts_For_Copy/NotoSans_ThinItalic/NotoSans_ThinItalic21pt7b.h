#ifndef _NOTOSANS_THINITALIC21PT7B_H_
#define _NOTOSANS_THINITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0x80, 0x4A, 0x53, 0x29,
  0x00, 0x04, 0x20, 0x44, 0x04, 0x40, 0x84, 0x08, 0x87, 0xFF, 0x10, 0x81,
  0x08, 0x11, 0x0D, 0xFE, 0x21, 0x02, 0x10, 0x22, 0x04, 0x20, 0x42, 0x00,
  0x02, 0x00, 0x81, 0xFC, 0x88, 0x24, 0x09, 0x02, 0x40, 0x50, 0x0C, 0x02,
  0xC0, 0x88, 0x22, 0x08, 0x82, 0x4F, 0xE0, 0x40, 0x10, 0x00, 0x38, 0x12,
  0x21, 0x21, 0x09, 0x08, 0x88, 0x48, 0x42, 0x82, 0x25, 0xD1, 0x51, 0xF5,
  0x08, 0x48, 0x42, 0x42, 0x22, 0x12, 0x11, 0x20, 0x89, 0x07, 0x80, 0x07,
  0x80, 0x84, 0x10, 0x41, 0x04, 0x10, 0x80, 0x90, 0x06, 0x01, 0xC0, 0x62,
  0x18, 0x11, 0x81, 0x28, 0x0A, 0x80, 0x48, 0x1C, 0x7E, 0x20, 0x56, 0x80,
  0x0C, 0x41, 0x08, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x00, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10,
  0x42, 0x08, 0x42, 0x00, 0x08, 0x08, 0x88, 0x70, 0x1F, 0x28, 0x48, 0x84,
  0x04, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00,
  0x29, 0x48, 0xF8, 0x80, 0x00, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x0F, 0x84, 0x12,
  0x04, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0x81, 0x10, 0x83, 0xC0, 0x0C, 0xE4, 0xA2, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x00, 0x0F, 0xC2, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x3F,
  0xE0, 0x0F, 0xC2, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x78,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x3F, 0xC0, 0x00, 0x60,
  0x14, 0x03, 0x00, 0xA0, 0x24, 0x08, 0x82, 0x20, 0x84, 0x20, 0x88, 0x13,
  0xFF, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xC4, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x4F, 0xE0, 0x07, 0xC2, 0x01, 0x00, 0x80, 0x20, 0x10, 0x05, 0xF1, 0x82,
  0x40, 0xA0, 0x18, 0x0A, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x7F, 0xC0, 0x20,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x0C, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x44, 0x20,
  0xB0, 0x78, 0x61, 0x20, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x47, 0xE0, 0x1F,
  0x88, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05, 0x03, 0x3F, 0x80, 0x20,
  0x08, 0x04, 0x02, 0x01, 0x8F, 0x80, 0x20, 0x00, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x10, 0x88, 0x40, 0x01, 0x83, 0x06, 0x0C,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x18, 0x30, 0xE0, 0x80, 0x00,
  0x7C, 0x04, 0x08, 0x10, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xF8, 0x0C, 0x04, 0x10, 0x02, 0x20, 0x01, 0x40, 0xE1,
  0x43, 0x11, 0x44, 0x11, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x42,
  0x88, 0xA4, 0x87, 0x18, 0x40, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0xE0,
  0x00, 0x80, 0x10, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x41, 0x08,
  0x22, 0xFC, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x08, 0x1F, 0xC2, 0x04,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x32, 0xFC, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x28, 0x05, 0x01, 0x3F, 0xC0, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x0F, 0xE0, 0x1F, 0xC1, 0x02, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x80, 0x48, 0x18,
  0xFE, 0x00, 0x1F, 0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x3F, 0xC0, 0x1F,
  0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0xFC, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0xF1, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x3C, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x44, 0x04, 0x3F, 0x80, 0x10, 0x08, 0x80, 0x48, 0x02,
  0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x4B, 0xFE, 0x40, 0x12, 0x01, 0x10,
  0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x01, 0x00, 0x1E, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x3C, 0x00, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x3C, 0x00, 0x10, 0x11, 0x02, 0x20,
  0xC2, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x40, 0x64, 0x04, 0x20, 0x42,
  0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x80, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xFF, 0x10, 0x01,
  0x10, 0x03, 0x28, 0x05, 0x28, 0x06, 0x28, 0x0A, 0x28, 0x12, 0x28, 0x12,
  0x44, 0x24, 0x44, 0x24, 0x44, 0x44, 0x44, 0x84, 0x44, 0x84, 0x85, 0x08,
  0x82, 0x08, 0x82, 0x08, 0x10, 0x08, 0x80, 0x4A, 0x02, 0x50, 0x12, 0x41,
  0x12, 0x08, 0x88, 0x48, 0x42, 0x42, 0x22, 0x09, 0x10, 0x48, 0x81, 0x48,
  0x0A, 0x40, 0x22, 0x01, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80,
  0x44, 0x08, 0x3F, 0x00, 0x1F, 0x82, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40,
  0x48, 0x12, 0x0C, 0x7E, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08, 0x3B, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x1F, 0x82, 0x08, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x12, 0x0C, 0x7E, 0x08, 0x41, 0x04, 0x20, 0x88, 0x11,
  0x01, 0x20, 0x20, 0x0F, 0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x3F, 0x80,
  0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x20, 0x09, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x41, 0xFC, 0x00, 0x80, 0x30, 0x0A, 0x01,
  0x40, 0x44, 0x08, 0x82, 0x10, 0x82, 0x10, 0x44, 0x08, 0x81, 0x20, 0x24,
  0x03, 0x00, 0x40, 0x08, 0x00, 0x81, 0x01, 0x83, 0x02, 0x83, 0x02, 0x83,
  0x04, 0x85, 0x04, 0x84, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90,
  0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x10,
  0x08, 0x40, 0x82, 0x08, 0x08, 0x80, 0x48, 0x02, 0x40, 0x0C, 0x00, 0x40,
  0x05, 0x00, 0x48, 0x04, 0x40, 0x41, 0x02, 0x08, 0x20, 0x22, 0x01, 0x00,
  0x80, 0x60, 0x24, 0x11, 0x04, 0x42, 0x11, 0x02, 0x40, 0xA0, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0xFF, 0x80, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xF0,
  0x92, 0x44, 0x92, 0x44, 0x92, 0x48, 0x0F, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0xF8,
  0x02, 0x01, 0x40, 0x50, 0x24, 0x10, 0x88, 0x22, 0x09, 0x02, 0x80, 0x40,
  0xFF, 0x94, 0x1F, 0x48, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0xC7, 0xD0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x22, 0x0B, 0x65,
  0x05, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x2C, 0x12, 0xF8,
  0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x0F,
  0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x44, 0x36, 0x88, 0x32, 0x02,
  0x40, 0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0xC3, 0xE8, 0x1F,
  0x10, 0x50, 0x28, 0x28, 0x67, 0xC2, 0x01, 0x00, 0x80, 0x20, 0x0F, 0x80,
  0x00, 0xF0, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0xF8, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0xE0, 0x00, 0x1F, 0x48, 0x34, 0x05,
  0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0xC7, 0xD0, 0x04, 0x01,
  0x00, 0x80, 0x43, 0xE0, 0x10, 0x08, 0x08, 0x04, 0x02, 0x21, 0x6D, 0x42,
  0xC1, 0x40, 0xA0, 0x50, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x30, 0x00,
  0x24, 0x44, 0x44, 0x88, 0x88, 0x80, 0x03, 0x00, 0x00, 0x00, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0xE0, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x05, 0x0C, 0x88, 0x48,
  0x28, 0x1C, 0x09, 0x08, 0x84, 0x22, 0x11, 0x04, 0x11, 0x22, 0x22, 0x44,
  0x44, 0x48, 0x88, 0x88, 0x2F, 0x3E, 0xA1, 0x85, 0x82, 0x0A, 0x04, 0x14,
  0x08, 0x28, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x05, 0x04, 0x0A, 0x08,
  0x10, 0x2F, 0xA8, 0x58, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x81, 0x40,
  0xA0, 0x40, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x80, 0x90, 0x43, 0xE0, 0x17, 0xC5, 0x04, 0xC0, 0x90, 0x12, 0x02, 0x40,
  0x50, 0x0A, 0x02, 0x40, 0x4C, 0x11, 0x7C, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x1F, 0x48, 0x34, 0x05, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x20, 0xC7, 0xD0, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x2E, 0xA1,
  0x82, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1F, 0x20, 0x40, 0x20,
  0x10, 0x0C, 0x02, 0x02, 0x02, 0x02, 0xFC, 0x20, 0x82, 0x3F, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x83, 0xC0, 0x40, 0x50, 0x14, 0x05, 0x02, 0x40,
  0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0xC7, 0xD0, 0x81, 0xC0, 0xA0, 0x90,
  0x44, 0x42, 0x21, 0x20, 0xA0, 0x50, 0x30, 0x08, 0x00, 0x82, 0x0C, 0x30,
  0x61, 0x85, 0x12, 0x28, 0x92, 0x48, 0x92, 0x45, 0x14, 0x28, 0xA1, 0x86,
  0x0C, 0x10, 0x40, 0x10, 0x62, 0x08, 0x22, 0x04, 0x80, 0x60, 0x08, 0x02,
  0x80, 0x90, 0x21, 0x08, 0x23, 0x02, 0x00, 0x10, 0x31, 0x02, 0x10, 0x41,
  0x04, 0x08, 0x80, 0x88, 0x09, 0x00, 0x90, 0x0A, 0x00, 0xC0, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x3F, 0x80, 0x06, 0x10, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x41, 0x01, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0C, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x11, 0xC0, 0xF8, 0x83, 0x80,
};

const GFXglyph NotoSans_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 4, 1, -15 },
  { 9, 5, 5, 7, 2, -15 },
  { 13, 12, 15, 13, 1, -15 },
  { 36, 10, 17, 12, 1, -16 },
  { 58, 13, 15, 16, 2, -15 },
  { 83, 12, 15, 14, 1, -15 },
  { 106, 2, 5, 4, 2, -15 },
  { 108, 6, 18, 5, 1, -15 },
  { 122, 6, 18, 5, -1, -15 },
  { 136, 8, 9, 11, 3, -16 },
  { 145, 9, 9, 12, 2, -12 },
  { 156, 3, 5, 4, -1, -2 },
  { 158, 5, 1, 7, 1, -6 },
  { 159, 1, 1, 4, 1, -1 },
  { 160, 9, 15, 6, -1, -15 },
  { 177, 10, 15, 12, 1, -15 },
  { 196, 6, 15, 12, 3, -15 },
  { 208, 11, 15, 12, 0, -15 },
  { 229, 11, 15, 12, 0, -15 },
  { 250, 11, 15, 12, 0, -15 },
  { 271, 10, 15, 12, 1, -15 },
  { 290, 10, 15, 12, 1, -15 },
  { 309, 10, 15, 12, 2, -15 },
  { 328, 10, 15, 12, 1, -15 },
  { 347, 10, 15, 12, 1, -15 },
  { 366, 3, 11, 4, 1, -11 },
  { 371, 5, 14, 4, -1, -11 },
  { 380, 9, 9, 12, 2, -12 },
  { 391, 9, 5, 12, 2, -10 },
  { 397, 9, 9, 12, 2, -12 },
  { 408, 7, 15, 8, 2, -15 },
  { 422, 16, 17, 18, 1, -15 },
  { 456, 11, 15, 11, -1, -15 },
  { 477, 11, 15, 13, 1, -15 },
  { 498, 11, 15, 12, 2, -15 },
  { 519, 12, 15, 14, 1, -15 },
  { 542, 11, 15, 11, 1, -15 },
  { 563, 11, 15, 10, 1, -15 },
  { 584, 12, 15, 14, 2, -15 },
  { 607, 13, 15, 14, 1, -15 },
  { 632, 7, 15, 6, 0, -15 },
  { 646, 9, 19, 5, -4, -15 },
  { 668, 12, 15, 11, 1, -15 },
  { 691, 8, 15, 10, 1, -15 },
  { 706, 16, 15, 17, 1, -15 },
  { 736, 13, 15, 14, 1, -15 },
  { 761, 12, 15, 15, 2, -15 },
  { 784, 11, 15, 12, 1, -15 },
  { 805, 12, 19, 15, 2, -15 },
  { 834, 11, 15, 12, 1, -15 },
  { 855, 11, 15, 10, 0, -15 },
  { 876, 10, 15, 10, 2, -15 },
  { 895, 13, 15, 15, 2, -15 },
  { 920, 11, 15, 11, 2, -15 },
  { 941, 16, 15, 17, 3, -15 },
  { 971, 13, 15, 10, -1, -15 },
  { 996, 10, 15, 10, 2, -15 },
  { 1015, 12, 15, 11, 0, -15 },
  { 1038, 8, 18, 6, 0, -15 },
  { 1056, 3, 15, 6, 2, -15 },
  { 1062, 8, 18, 6, -2, -15 },
  { 1080, 10, 9, 12, 1, -15 },
  { 1092, 8, 1, 8, -2, 2 },
  { 1093, 2, 3, 5, 3, -16 },
  { 1094, 10, 11, 11, 1, -11 },
  { 1108, 10, 16, 12, 1, -16 },
  { 1128, 9, 11, 9, 1, -11 },
  { 1141, 11, 16, 12, 1, -16 },
  { 1163, 9, 11, 10, 1, -11 },
  { 1176, 12, 21, 6, -3, -16 },
  { 1208, 10, 16, 12, 1, -11 },
  { 1228, 9, 16, 12, 1, -16 },
  { 1246, 4, 15, 4, 1, -15 },
  { 1254, 8, 20, 4, -3, -15 },
  { 1274, 9, 16, 9, 1, -16 },
  { 1292, 4, 16, 4, 1, -16 },
  { 1300, 15, 11, 18, 1, -11 },
  { 1321, 9, 11, 12, 1, -11 },
  { 1334, 10, 11, 12, 1, -11 },
  { 1348, 11, 16, 12, 0, -11 },
  { 1370, 10, 16, 12, 1, -11 },
  { 1390, 7, 11, 8, 1, -11 },
  { 1400, 8, 11, 9, 0, -11 },
  { 1411, 6, 14, 6, 1, -14 },
  { 1422, 10, 11, 12, 1, -11 },
  { 1436, 9, 11, 9, 1, -11 },
  { 1449, 13, 11, 14, 1, -11 },
  { 1467, 11, 11, 10, -1, -11 },
  { 1483, 12, 16, 9, -2, -11 },
  { 1507, 9, 11, 9, 0, -11 },
  { 1520, 7, 18, 7, 1, -15 },
  { 1536, 1, 21, 11, 6, -16 },
  { 1539, 7, 18, 7, -1, -15 },
  { 1555, 9, 2, 12, 2, -8 },
};

const GFXfont NotoSans_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_THINITALIC21PT7B_H_
