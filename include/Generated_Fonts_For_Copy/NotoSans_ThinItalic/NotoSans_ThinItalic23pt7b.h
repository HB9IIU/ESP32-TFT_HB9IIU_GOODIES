#ifndef _NOTOSANS_THINITALIC23PT7B_H_
#define _NOTOSANS_THINITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x00, 0x08, 0x9C, 0xA5, 0x29,
  0x50, 0x02, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x3D, 0xFC, 0x21,
  0x01, 0x08, 0x10, 0x80, 0x84, 0x3F, 0xFC, 0x22, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x08, 0x40, 0x01, 0x00, 0xF0, 0x25, 0x89, 0x02, 0x20, 0x44, 0x08,
  0x80, 0xA0, 0x0C, 0x00, 0xE0, 0x12, 0x02, 0x20, 0x84, 0x11, 0x22, 0x43,
  0xF0, 0x08, 0x02, 0x00, 0x18, 0x04, 0x90, 0x24, 0x21, 0x10, 0x84, 0x82,
  0x22, 0x11, 0x08, 0x48, 0x21, 0x2F, 0x89, 0x46, 0x29, 0x17, 0x48, 0x41,
  0x21, 0x08, 0x84, 0x42, 0x12, 0x08, 0x48, 0x22, 0x40, 0xF0, 0x03, 0x80,
  0x11, 0x00, 0x82, 0x02, 0x08, 0x10, 0x20, 0x21, 0x00, 0x88, 0x01, 0xC0,
  0x0A, 0x00, 0xC8, 0x14, 0x10, 0xA0, 0x22, 0x80, 0x92, 0x01, 0x88, 0x06,
  0x20, 0x24, 0x7F, 0x10, 0xFC, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x21, 0x04, 0x21, 0x04, 0x20, 0x04,
  0x02, 0x32, 0x05, 0x01, 0xF8, 0xC0, 0x91, 0x88, 0x02, 0x00, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x25,
  0x29, 0x00, 0xF8, 0x80, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x08, 0x7C, 0x00, 0x19, 0x72,
  0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x03, 0xC0, 0xC2, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFF, 0xC0, 0x03, 0xC0,
  0xC2, 0x10, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x0F, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x48, 0x0C, 0x7F, 0x00,
  0x00, 0x10, 0x02, 0x00, 0x60, 0x0A, 0x01, 0x20, 0x22, 0x04, 0x20, 0x84,
  0x08, 0x41, 0x04, 0x20, 0x44, 0x04, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x0F, 0xE2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0F, 0xC0,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x47, 0xF0,
  0x03, 0xC3, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0xFC, 0xC0, 0xA0,
  0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x7E, 0x00, 0xFF, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x02, 0x00, 0x07, 0x81, 0x08, 0x40, 0x88, 0x12,
  0x02, 0x20, 0x44, 0x10, 0x4C, 0x0E, 0x06, 0x21, 0x02, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x12, 0x04, 0x3F, 0x00, 0x07, 0x81, 0x08, 0x40, 0x90, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x64, 0x34, 0x79, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x08, 0x84, 0x42, 0x00, 0x00, 0xC0, 0xC0,
  0xC1, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x00, 0x3C, 0x42, 0x01, 0x01, 0x01,
  0x01, 0x02, 0x04, 0x08, 0x30, 0x40, 0x40, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x03, 0xFE, 0x01, 0x00, 0x41, 0x80, 0x08, 0x80, 0x02, 0x20, 0xF0, 0x50,
  0x42, 0x14, 0x20, 0x86, 0x10, 0x21, 0x84, 0x10, 0x61, 0x04, 0x28, 0x81,
  0x0A, 0x10, 0xC4, 0x84, 0x52, 0x10, 0xE3, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x0A, 0x00, 0xA0, 0x12, 0x02,
  0x20, 0x22, 0x04, 0x20, 0x42, 0x08, 0x10, 0xFE, 0x10, 0x12, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x18, 0x01, 0x1F, 0xE1, 0x01, 0x10, 0x11, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x63, 0xF8, 0x20, 0x44, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x28, 0x02, 0x80, 0xCF, 0xF0, 0x03, 0xE0, 0x60, 0xC4, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x40,
  0x41, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x05, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x12, 0x00, 0x88, 0x0C, 0x3F,
  0xC0, 0x1F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03,
  0xFC, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0F,
  0xF8, 0x1F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x3F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x03, 0xE0, 0x60, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x0F, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x11,
  0x00, 0x88, 0x04, 0x3F, 0xC0, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x1F, 0xFC, 0x20, 0x08, 0x80, 0x11,
  0x00, 0x42, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x0E,
  0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x78, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x1E, 0x00,
  0x10, 0x18, 0x81, 0x04, 0x10, 0x21, 0x02, 0x10, 0x11, 0x00, 0xB0, 0x06,
  0x80, 0x22, 0x02, 0x10, 0x10, 0x40, 0x82, 0x04, 0x08, 0x40, 0x42, 0x01,
  0x10, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0xFF, 0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x52, 0x40, 0x49, 0x20, 0x28, 0x90, 0x24, 0x48, 0x12, 0x24,
  0x11, 0x22, 0x10, 0x90, 0x88, 0x88, 0x48, 0x44, 0x24, 0x24, 0x14, 0x12,
  0x0C, 0x11, 0x02, 0x08, 0x10, 0x04, 0x60, 0x11, 0x80, 0x45, 0x01, 0x24,
  0x04, 0x88, 0x22, 0x20, 0x88, 0x42, 0x21, 0x09, 0x04, 0x44, 0x09, 0x10,
  0x24, 0x40, 0x52, 0x01, 0x48, 0x02, 0x20, 0x08, 0x03, 0xC0, 0x30, 0xC1,
  0x00, 0x88, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x44, 0x02, 0x10, 0x10,
  0x3F, 0x80, 0x1F, 0xE1, 0x02, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x22, 0x04, 0x3F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x03, 0xC0, 0x30, 0xC1, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x12, 0x00, 0x44, 0x02, 0x10, 0x10, 0x3D, 0x80, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x1F, 0xE1, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x22, 0x0C, 0x3F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x88, 0x08,
  0x80, 0x48, 0x04, 0x03, 0xC0, 0xC3, 0x10, 0x01, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0xFF, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x08,
  0x80, 0x22, 0x01, 0x04, 0x0C, 0x0F, 0xC0, 0x80, 0x18, 0x02, 0x40, 0x24,
  0x04, 0x40, 0x44, 0x08, 0x41, 0x04, 0x10, 0x42, 0x04, 0x20, 0x24, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x30, 0x02, 0x00, 0x80, 0x80, 0xE0, 0x60, 0x28,
  0x18, 0x12, 0x0A, 0x04, 0x82, 0x42, 0x21, 0x10, 0x88, 0x44, 0x22, 0x21,
  0x10, 0x88, 0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x50,
  0x28, 0x18, 0x04, 0x06, 0x01, 0x01, 0x00, 0x08, 0x0C, 0x20, 0x20, 0x41,
  0x01, 0x08, 0x04, 0x40, 0x0A, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x14,
  0x00, 0x88, 0x04, 0x20, 0x20, 0x40, 0x81, 0x04, 0x04, 0x20, 0x08, 0x80,
  0x28, 0x09, 0x02, 0x20, 0x42, 0x10, 0x44, 0x09, 0x01, 0x20, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x0F, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x1F, 0xF8, 0x0F,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x88, 0x44, 0x44, 0x44, 0x22,
  0x22, 0x21, 0x11, 0x0F, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x1F, 0x00, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x88, 0x11, 0x04, 0x11,
  0x02, 0x20, 0x48, 0x0A, 0x00, 0x80, 0xFF, 0x80, 0x89, 0x10, 0x1F, 0xA4,
  0x15, 0x01, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x31,
  0x0A, 0x3E, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x30, 0x59, 0x8C,
  0x11, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x05, 0x00, 0xB0, 0x26,
  0x0C, 0xBE, 0x00, 0x1F, 0xC8, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x00, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x02, 0x21, 0xDA, 0x20, 0x64, 0x02, 0x40, 0x24, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x81, 0x84, 0x28, 0x7C, 0x80, 0x0F, 0x84, 0x12, 0x05,
  0x02, 0x41, 0xBF, 0x88, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFC, 0x00,
  0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x3F, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x18, 0x00, 0x1F, 0xA4, 0x0D, 0x00, 0xA0, 0x14, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x90, 0x31, 0x0A, 0x3E, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x84, 0x0F, 0x00, 0x10, 0x04, 0x01, 0x00, 0x80, 0x23, 0x0B, 0x33, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x80,
  0x80, 0x11, 0x00, 0x02, 0x22, 0x44, 0x44, 0x88, 0x88, 0x80, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x32, 0x10, 0x88, 0x44, 0x12, 0x05, 0x81, 0xA0,
  0x44, 0x21, 0x08, 0x22, 0x08, 0x81, 0x00, 0x11, 0x12, 0x22, 0x22, 0x44,
  0x44, 0x88, 0x88, 0x80, 0x2F, 0x9F, 0x18, 0x30, 0x48, 0x10, 0x28, 0x08,
  0x14, 0x04, 0x0A, 0x04, 0x05, 0x02, 0x03, 0x01, 0x02, 0x80, 0x81, 0x40,
  0x80, 0xA0, 0x40, 0x50, 0x20, 0x40, 0x2F, 0xCC, 0x12, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x1F, 0x84, 0x09,
  0x00, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x11, 0x02,
  0x1F, 0x80, 0x17, 0xE1, 0x82, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x02, 0x40, 0x26, 0x04, 0x60, 0xC5, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x1F, 0xA4, 0x0D, 0x00, 0xA0, 0x14, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x90, 0x31, 0x0A, 0x3E, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x2F, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1F, 0x90, 0x08, 0x04, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x01, 0x00, 0x80, 0x5F, 0xC0, 0x10, 0x40, 0x87, 0xF2, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x1C, 0x00, 0x20, 0x24, 0x05, 0x00,
  0xA0, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x32, 0x0A, 0x3E,
  0x40, 0x80, 0xE0, 0x28, 0x11, 0x04, 0x42, 0x11, 0x04, 0x41, 0x20, 0x48,
  0x14, 0x02, 0x00, 0x80, 0x81, 0x03, 0x06, 0x0A, 0x0C, 0x14, 0x28, 0x48,
  0x50, 0x91, 0x22, 0x22, 0x24, 0x48, 0x50, 0x50, 0xA0, 0xC1, 0x81, 0x03,
  0x02, 0x04, 0x00, 0x10, 0x30, 0x84, 0x08, 0x40, 0x48, 0x05, 0x00, 0x20,
  0x06, 0x00, 0xA0, 0x11, 0x02, 0x10, 0x40, 0x8C, 0x08, 0x08, 0x0C, 0x20,
  0x20, 0x81, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x44, 0x01, 0x20, 0x04,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x03, 0xFC, 0x07, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x40, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x40, 0x30, 0xFF, 0xFF, 0xFE, 0x0E, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0xC0, 0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 6, 7, 3, -16 },
  { 13, 13, 16, 14, 1, -16 },
  { 39, 11, 18, 13, 1, -17 },
  { 64, 14, 17, 18, 2, -17 },
  { 94, 14, 17, 16, 1, -17 },
  { 124, 1, 6, 4, 3, -16 },
  { 125, 6, 20, 6, 1, -16 },
  { 140, 6, 20, 6, -1, -16 },
  { 155, 9, 9, 12, 3, -17 },
  { 166, 10, 10, 13, 2, -13 },
  { 179, 3, 6, 4, -1, -3 },
  { 182, 5, 1, 7, 1, -7 },
  { 183, 1, 1, 5, 1, -1 },
  { 184, 10, 16, 7, -1, -16 },
  { 204, 10, 17, 13, 2, -17 },
  { 226, 5, 16, 13, 4, -16 },
  { 236, 12, 17, 13, 0, -17 },
  { 262, 12, 17, 13, 0, -17 },
  { 288, 12, 17, 13, 0, -17 },
  { 314, 11, 16, 13, 1, -16 },
  { 336, 10, 17, 13, 2, -17 },
  { 358, 10, 16, 13, 3, -16 },
  { 378, 11, 17, 13, 1, -17 },
  { 402, 11, 17, 13, 1, -17 },
  { 426, 3, 12, 5, 1, -12 },
  { 431, 5, 15, 5, -1, -12 },
  { 441, 10, 10, 13, 2, -13 },
  { 454, 10, 6, 13, 2, -11 },
  { 462, 10, 10, 13, 2, -13 },
  { 475, 8, 17, 9, 2, -17 },
  { 492, 18, 18, 19, 1, -16 },
  { 533, 12, 16, 13, -1, -16 },
  { 557, 12, 16, 14, 1, -16 },
  { 581, 13, 17, 14, 2, -17 },
  { 609, 14, 16, 16, 1, -16 },
  { 637, 12, 16, 12, 1, -16 },
  { 661, 12, 16, 11, 1, -16 },
  { 685, 13, 17, 16, 2, -17 },
  { 713, 15, 16, 16, 1, -16 },
  { 743, 7, 16, 6, 0, -16 },
  { 757, 9, 20, 5, -4, -16 },
  { 780, 13, 16, 12, 1, -16 },
  { 806, 8, 16, 11, 1, -16 },
  { 822, 17, 16, 19, 1, -16 },
  { 856, 14, 16, 16, 1, -16 },
  { 884, 14, 17, 16, 2, -17 },
  { 914, 12, 16, 13, 1, -16 },
  { 938, 14, 21, 16, 2, -17 },
  { 975, 12, 16, 13, 1, -16 },
  { 999, 12, 17, 11, 0, -17 },
  { 1025, 11, 16, 11, 2, -16 },
  { 1047, 14, 16, 16, 2, -16 },
  { 1075, 12, 16, 12, 2, -16 },
  { 1099, 18, 16, 19, 3, -16 },
  { 1135, 14, 16, 11, -1, -16 },
  { 1163, 11, 16, 11, 2, -16 },
  { 1185, 13, 16, 12, 0, -16 },
  { 1211, 8, 20, 7, 0, -16 },
  { 1231, 4, 16, 7, 2, -16 },
  { 1239, 9, 20, 7, -2, -16 },
  { 1262, 11, 11, 13, 1, -17 },
  { 1278, 9, 1, 9, -2, 2 },
  { 1280, 3, 4, 5, 3, -18 },
  { 1282, 11, 12, 13, 1, -12 },
  { 1299, 11, 17, 13, 1, -17 },
  { 1323, 10, 12, 10, 1, -12 },
  { 1338, 12, 17, 13, 1, -17 },
  { 1364, 10, 12, 11, 1, -12 },
  { 1379, 13, 24, 6, -3, -18 },
  { 1418, 11, 18, 13, 1, -12 },
  { 1443, 10, 17, 13, 1, -17 },
  { 1465, 4, 17, 5, 1, -17 },
  { 1474, 8, 23, 5, -3, -17 },
  { 1497, 10, 17, 10, 1, -17 },
  { 1519, 4, 17, 5, 1, -17 },
  { 1528, 17, 12, 19, 1, -12 },
  { 1554, 10, 12, 13, 1, -12 },
  { 1569, 11, 12, 13, 1, -12 },
  { 1586, 12, 17, 13, 0, -12 },
  { 1612, 11, 17, 13, 1, -12 },
  { 1636, 8, 12, 9, 1, -12 },
  { 1648, 9, 12, 10, 0, -12 },
  { 1662, 7, 15, 7, 1, -15 },
  { 1676, 11, 12, 13, 1, -12 },
  { 1693, 10, 12, 9, 1, -12 },
  { 1708, 15, 12, 15, 1, -12 },
  { 1731, 12, 12, 10, -1, -12 },
  { 1749, 14, 18, 9, -3, -12 },
  { 1781, 10, 12, 10, 0, -12 },
  { 1796, 8, 20, 8, 1, -16 },
  { 1816, 1, 23, 12, 6, -17 },
  { 1819, 8, 20, 8, -1, -16 },
  { 1839, 10, 2, 13, 2, -9 },
};

const GFXfont NotoSans_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_THINITALIC23PT7B_H_
