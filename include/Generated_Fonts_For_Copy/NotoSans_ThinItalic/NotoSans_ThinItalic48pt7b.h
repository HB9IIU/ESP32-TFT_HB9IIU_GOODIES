#ifndef _NOTOSANS_THINITALIC48PT7B_H_
#define _NOTOSANS_THINITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x60, 0x00, 0x10, 0x66, 0x08, 0x81, 0x10, 0x22, 0x0C, 0x41,
  0x18, 0x22, 0x04, 0x40, 0x88, 0x21, 0x04, 0x40, 0x80, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x08, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x08, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x10,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x0C, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x20, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x04,
  0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1C,
  0x41, 0xC0, 0x60, 0x80, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x08, 0x0C,
  0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80,
  0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x01, 0x88, 0x00, 0x01, 0xD0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x00,
  0x80, 0xC0, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x30, 0x60, 0x21, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0xC0, 0xC1, 0x80, 0x02,
  0x06, 0x02, 0x00, 0x10, 0x10, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x02, 0x02,
  0x00, 0xC0, 0x10, 0x18, 0x03, 0x00, 0xC0, 0x40, 0x0C, 0x06, 0x01, 0x00,
  0x20, 0x10, 0x04, 0x00, 0x80, 0x80, 0x30, 0x02, 0x06, 0x00, 0xC0, 0x08,
  0x30, 0x03, 0x00, 0x60, 0x80, 0x08, 0x01, 0x04, 0x1E, 0x20, 0x04, 0x31,
  0xCE, 0x80, 0x31, 0x8C, 0x0B, 0x00, 0x84, 0x20, 0x34, 0x04, 0x21, 0x00,
  0x58, 0x31, 0x8C, 0x01, 0x3F, 0x8C, 0x20, 0x04, 0x38, 0x20, 0x80, 0x10,
  0x01, 0x06, 0x00, 0x40, 0x0C, 0x10, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x01,
  0x01, 0x00, 0x20, 0x08, 0x04, 0x00, 0x80, 0x60, 0x30, 0x02, 0x01, 0x00,
  0xC0, 0x18, 0x08, 0x03, 0x00, 0x40, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x10,
  0x08, 0x08, 0x00, 0x40, 0x60, 0x40, 0x01, 0x83, 0x03, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x20, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x31, 0x80, 0x30, 0x01, 0x18, 0x00, 0x80, 0x18,
  0x80, 0x02, 0x00, 0x8C, 0x00, 0x18, 0x08, 0x40, 0x00, 0x60, 0xC6, 0x00,
  0x01, 0x04, 0x30, 0x00, 0x04, 0x41, 0x80, 0x00, 0x36, 0x0C, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x68, 0x0C, 0x00, 0x0C, 0x60,
  0x30, 0x00, 0xC1, 0x00, 0xC0, 0x18, 0x04, 0x03, 0xFF, 0x00, 0x30, 0x13,
  0x22, 0x22, 0x64, 0x44, 0x48, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x80, 0x20, 0x0E,
  0x02, 0x00, 0x30, 0x20, 0x00, 0xC4, 0x00, 0x03, 0x40, 0x30, 0x0F, 0xFF,
  0x00, 0xC0, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x43, 0x00, 0x18, 0x10,
  0x03, 0x01, 0x00, 0x60, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x30, 0xC2, 0x18, 0x41, 0x08, 0x21, 0x04, 0x20, 0xFF,
  0xFF, 0xFC, 0xBC, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xE7, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08, 0x18,
  0x00, 0x30, 0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00,
  0x11, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x58, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x34, 0x00,
  0x00, 0xD0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x60, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x0E, 0x03, 0x20, 0x66, 0x18, 0x63, 0x04, 0xC0, 0x48, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x02, 0x00, 0x80, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x78, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x06, 0x02, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00,
  0xC0, 0xF0, 0x03, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x64, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x84, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x10, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x30, 0x04, 0x00, 0x20, 0x08, 0x00, 0x20, 0x10, 0x00, 0x20, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x01,
  0x80, 0xE0, 0x06, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x1F, 0xC0, 0x11, 0xE0, 0xE0, 0x26, 0x00, 0x60, 0xD0, 0x00, 0x41, 0x40,
  0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x46, 0x00, 0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x10, 0x00, 0x40, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7D, 0xE0, 0x01, 0x80, 0x60, 0x04, 0x00, 0x20, 0x10, 0x00,
  0x60, 0x60, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x10, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x30, 0x02, 0x00, 0x30, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x06, 0x00, 0xC0, 0x06, 0x06, 0x00,
  0x06, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x02,
  0x10, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFB, 0xC0, 0x03, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x84,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x28, 0x30, 0x00, 0x90, 0x30, 0x06,
  0x60, 0x3C, 0xF0, 0x80, 0x1F, 0x81, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x0C, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0xC1, 0x80, 0x00, 0x40, 0x0C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x78, 0x20, 0x0C,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x7F, 0x80, 0x23, 0x00, 0x18, 0x0C, 0x03, 0x20, 0x06,
  0x00, 0x40, 0x36, 0x00, 0xC0, 0x0C, 0x03, 0x40, 0x18, 0x00, 0x80, 0x34,
  0x01, 0x00, 0x08, 0x03, 0xC0, 0x30, 0x00, 0x80, 0x3C, 0x02, 0x00, 0x18,
  0x02, 0x80, 0x60, 0x01, 0x00, 0x28, 0x04, 0x00, 0x10, 0x02, 0x80, 0x40,
  0x03, 0x00, 0x68, 0x04, 0x00, 0x20, 0x04, 0x80, 0x40, 0x02, 0x00, 0x48,
  0x04, 0x00, 0x60, 0x0C, 0x80, 0x40, 0x0E, 0x01, 0x88, 0x06, 0x01, 0xA0,
  0x30, 0x80, 0x20, 0x33, 0x06, 0x0C, 0x03, 0x8E, 0x19, 0xC0, 0x40, 0x0F,
  0x80, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0xC0, 0x08, 0x00,
  0x20, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x30, 0x02, 0x00, 0x0C,
  0x01, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x01, 0xFF,
  0xFC, 0x00, 0x60, 0x03, 0x80, 0x10, 0x00, 0x18, 0x04, 0x00, 0x02, 0x01,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x10, 0x00,
  0x06, 0x04, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x40, 0x01, 0xC0, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x02, 0x00, 0x0E, 0x00, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x18, 0x00, 0x02, 0x04,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0x40, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x03, 0x80, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x01, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x3C, 0x00, 0x40, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xFF, 0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x20, 0x0C, 0x00, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFE, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x20, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0xCD, 0x00, 0x00,
  0x09, 0x98, 0x00, 0x00, 0xB0, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x03, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x14, 0x00, 0x00, 0x07, 0x01, 0x40, 0x00, 0x00, 0x50, 0x14, 0x00,
  0x00, 0x0F, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x34, 0x00, 0x00, 0x12, 0x03,
  0x60, 0x00, 0x03, 0x20, 0x22, 0x00, 0x00, 0x22, 0x02, 0x20, 0x00, 0x06,
  0x60, 0x22, 0x00, 0x00, 0x44, 0x06, 0x20, 0x00, 0x08, 0x40, 0x43, 0x00,
  0x01, 0x84, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x41, 0x00, 0x03, 0x0C, 0x04,
  0x10, 0x00, 0x20, 0x80, 0xC1, 0x00, 0x04, 0x08, 0x08, 0x10, 0x00, 0xC0,
  0x80, 0x81, 0x80, 0x08, 0x18, 0x08, 0x08, 0x01, 0x81, 0x81, 0x80, 0x80,
  0x10, 0x10, 0x18, 0x08, 0x02, 0x01, 0x01, 0x00, 0x80, 0x60, 0x10, 0x10,
  0x0C, 0x04, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x04, 0x08, 0x02,
  0x03, 0x00, 0x41, 0x00, 0x20, 0x20, 0x04, 0x30, 0x02, 0x02, 0x00, 0x42,
  0x00, 0x60, 0x20, 0x06, 0x60, 0x04, 0x06, 0x00, 0x24, 0x00, 0x40, 0x40,
  0x02, 0x80, 0x04, 0x04, 0x00, 0x38, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0xC0, 0x50, 0x00, 0x02, 0x01, 0x60, 0x00, 0x08,
  0x0C, 0x80, 0x00, 0x20, 0x22, 0x00, 0x01, 0x80, 0x84, 0x00, 0x04, 0x02,
  0x10, 0x00, 0x10, 0x08, 0x60, 0x00, 0x40, 0x60, 0x80, 0x01, 0x01, 0x03,
  0x00, 0x0C, 0x04, 0x04, 0x00, 0x20, 0x10, 0x10, 0x00, 0x80, 0x40, 0x20,
  0x02, 0x03, 0x00, 0x80, 0x18, 0x08, 0x03, 0x00, 0x60, 0x20, 0x04, 0x01,
  0x00, 0x80, 0x18, 0x04, 0x06, 0x00, 0x20, 0x10, 0x18, 0x00, 0x80, 0xC0,
  0x40, 0x01, 0x03, 0x01, 0x00, 0x04, 0x08, 0x04, 0x00, 0x18, 0x20, 0x30,
  0x00, 0x20, 0x80, 0xC0, 0x00, 0xC6, 0x02, 0x00, 0x01, 0x10, 0x08, 0x00,
  0x04, 0x40, 0x20, 0x00, 0x09, 0x01, 0x80, 0x00, 0x24, 0x04, 0x00, 0x00,
  0xF0, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x40,
  0x01, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00, 0x10, 0x18, 0x00, 0x08, 0x0C,
  0x00, 0x06, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18,
  0x10, 0x00, 0x08, 0x18, 0x00, 0x08, 0x08, 0x00, 0x18, 0x04, 0x00, 0x38,
  0x03, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x60, 0x10,
  0x00, 0x10, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x02,
  0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x30, 0x20, 0x00, 0x10, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x60, 0x08, 0x00, 0x10, 0x04, 0x00,
  0x08, 0x02, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x20, 0x40, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7D, 0xF8, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x80, 0x01, 0x81, 0xC0, 0x0E, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x40,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10,
  0x40, 0x00, 0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x06, 0x00, 0x30, 0x04, 0x00, 0x10, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x80, 0x00,
  0x09, 0x80, 0x00, 0x09, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00,
  0x48, 0x00, 0x0A, 0x00, 0x06, 0x40, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04,
  0xC0, 0x03, 0x18, 0x00, 0x46, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x01, 0x86,
  0x00, 0x21, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x18, 0x20,
  0x04, 0x04, 0x00, 0x81, 0x00, 0x20, 0x20, 0x0C, 0x08, 0x03, 0x01, 0x00,
  0x40, 0x40, 0x10, 0x08, 0x06, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x03, 0x00, 0x80, 0xC0, 0x10, 0x10, 0x04, 0x04, 0x00, 0x81, 0x80,
  0x20, 0x60, 0x04, 0x08, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x08, 0x10, 0x01,
  0x04, 0x00, 0x61, 0x00, 0x08, 0x60, 0x03, 0x08, 0x00, 0x42, 0x00, 0x18,
  0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0xD8,
  0x00, 0x12, 0x00, 0x06, 0x80, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x05, 0x00,
  0x00, 0xC0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00, 0x01, 0x00, 0x18, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x84, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30,
  0x10, 0x00, 0x40, 0x30, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x18, 0x00,
  0x80, 0x20, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00, 0x02, 0x04, 0x00, 0x06,
  0x10, 0x00, 0x04, 0x60, 0x00, 0x09, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x04,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x40, 0x81, 0x03, 0x02, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x28, 0x00, 0x01, 0xA0, 0x00, 0x04, 0xC0, 0x00, 0x21, 0x00, 0x01, 0x84,
  0x00, 0x0C, 0x10, 0x00, 0x20, 0x60, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00,
  0x06, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00, 0x00, 0x88, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0xC6, 0x10, 0x43,
  0x08, 0x21, 0x00, 0x1F, 0x02, 0x01, 0xE7, 0x08, 0x06, 0x01, 0x10, 0x10,
  0x01, 0x20, 0x40, 0x02, 0x41, 0x00, 0x03, 0x86, 0x00, 0x06, 0x08, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x43, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x82, 0x00, 0x07, 0x04,
  0x00, 0x1C, 0x08, 0x00, 0x28, 0x18, 0x00, 0x90, 0x10, 0x06, 0x20, 0x18,
  0x18, 0x80, 0x1F, 0xC1, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x1E,
  0x00, 0x21, 0xE7, 0x00, 0x46, 0x01, 0x01, 0x90, 0x01, 0x02, 0x40, 0x03,
  0x05, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x00, 0x00, 0x62, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x18, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x30, 0x90, 0x00, 0xC1, 0x30, 0x03, 0x02, 0x30, 0x1C, 0x04, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x0C, 0x00, 0x83, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xF0, 0x30, 0x03, 0xCF, 0x08, 0x01, 0x80, 0x62, 0x00, 0x80, 0x04,
  0x80, 0x40, 0x01, 0x60, 0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18,
  0x10, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x10, 0x00, 0x1C, 0x04, 0x00, 0x0A, 0x01, 0x00, 0x06, 0x80, 0x60,
  0x03, 0x20, 0x08, 0x01, 0x88, 0x01, 0x81, 0x84, 0x00, 0x3F, 0xC1, 0x00,
  0x00, 0x3E, 0x00, 0x1E, 0x70, 0x0E, 0x03, 0x03, 0x00, 0x30, 0xC0, 0x02,
  0x30, 0x00, 0x44, 0x00, 0x09, 0x80, 0x03, 0x20, 0x00, 0x4C, 0x00, 0x19,
  0x00, 0x06, 0x20, 0x07, 0x0C, 0xFF, 0x81, 0xFC, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x79, 0xE1,
  0x00, 0xC0, 0x31, 0x01, 0x00, 0x09, 0x02, 0x00, 0x09, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06,
  0x10, 0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x20, 0x00, 0x38, 0x20, 0x00, 0x50, 0x20, 0x00, 0xD0,
  0x30, 0x01, 0x90, 0x10, 0x03, 0x30, 0x0C, 0x0E, 0x20, 0x07, 0xF8, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0xE0, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x7C, 0x01, 0x0F, 0x3C, 0x04, 0x60, 0x18,
  0x32, 0x00, 0x20, 0x90, 0x00, 0x82, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70,
  0x00, 0x31, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x23, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x01, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00,
  0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x02, 0x08,
  0x00, 0x60, 0x40, 0x06, 0x06, 0x00, 0x60, 0x20, 0x06, 0x01, 0x00, 0x60,
  0x08, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x20, 0x60, 0x01, 0x04,
  0x00, 0x08, 0x40, 0x00, 0xC7, 0x00, 0x04, 0x48, 0x00, 0x24, 0x60, 0x01,
  0xC1, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x30, 0x18, 0x00, 0x80, 0xC0, 0x06, 0x04, 0x00, 0x10, 0x20,
  0x00, 0xC1, 0x00, 0x02, 0x00, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x43, 0x9C, 0x07, 0x3C, 0x04, 0xC0, 0x60, 0xC0, 0x60,
  0x98, 0x02, 0x10, 0x02, 0x0B, 0x00, 0x32, 0x00, 0x20, 0xA0, 0x01, 0x40,
  0x02, 0x0C, 0x00, 0x1C, 0x00, 0x31, 0xC0, 0x01, 0x80, 0x02, 0x18, 0x00,
  0x10, 0x00, 0x21, 0x80, 0x03, 0x00, 0x02, 0x10, 0x00, 0x30, 0x00, 0x21,
  0x00, 0x02, 0x00, 0x02, 0x30, 0x00, 0x20, 0x00, 0x62, 0x00, 0x02, 0x00,
  0x04, 0x20, 0x00, 0x60, 0x00, 0x42, 0x00, 0x04, 0x00, 0x04, 0x20, 0x00,
  0x40, 0x00, 0xC6, 0x00, 0x04, 0x00, 0x0C, 0x40, 0x00, 0x40, 0x00, 0x84,
  0x00, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x80, 0x00, 0x8C, 0x00, 0x08, 0x00,
  0x18, 0xC0, 0x00, 0x80, 0x01, 0x08, 0x00, 0x18, 0x00, 0x10, 0x80, 0x01,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x10, 0xF3,
  0xC0, 0x46, 0x01, 0x82, 0x20, 0x02, 0x09, 0x00, 0x08, 0x28, 0x00, 0x30,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00,
  0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x1E,
  0x00, 0xC0, 0x18, 0x08, 0x00, 0x60, 0x80, 0x01, 0x08, 0x00, 0x0C, 0xC0,
  0x00, 0x24, 0x00, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x48,
  0x00, 0x06, 0x60, 0x00, 0x61, 0x00, 0x02, 0x04, 0x00, 0x60, 0x38, 0x06,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x21, 0xE7, 0x00, 0x08,
  0xC0, 0x20, 0x04, 0x40, 0x04, 0x01, 0x20, 0x01, 0x80, 0x50, 0x00, 0x20,
  0x18, 0x00, 0x08, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x03, 0x01, 0xA0, 0x01, 0x80, 0x4C, 0x00, 0xC0, 0x11, 0x80,
  0xE0, 0x04, 0x3F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x84, 0x06,
  0x01, 0x88, 0x10, 0x00, 0x90, 0x40, 0x01, 0x21, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x00,
  0x23, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x06,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC2,
  0x00, 0x03, 0x84, 0x00, 0x0A, 0x08, 0x00, 0x34, 0x18, 0x00, 0xC8, 0x10,
  0x03, 0x30, 0x18, 0x18, 0x40, 0x1F, 0xE0, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x02, 0x1E, 0xC1, 0x18, 0x01, 0x10,
  0x00, 0x90, 0x00, 0x50, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xF3, 0xF0, 0xC0, 0x04, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x18, 0x1F, 0xFC, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x1F,
  0xFF, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x18, 0x00, 0x0C, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x62,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0xC4, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06,
  0x20, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x14, 0x20,
  0x00, 0x70, 0x80, 0x02, 0x82, 0x00, 0x12, 0x0C, 0x00, 0x88, 0x18, 0x0C,
  0x20, 0x3F, 0xC1, 0x80, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x44,
  0x00, 0x0C, 0x40, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x02, 0x00, 0x30,
  0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x18,
  0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00, 0x10, 0x40, 0x01, 0x0C,
  0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xA0, 0x00, 0x0A,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x02, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x68, 0x00, 0x60, 0x01, 0x20, 0x02, 0xC0, 0x04, 0x80, 0x0B,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x18,
  0x30, 0x20, 0x40, 0x40, 0xC1, 0x81, 0x03, 0x03, 0x04, 0x06, 0x08, 0x04,
  0x30, 0x18, 0x60, 0x10, 0x80, 0x21, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x10,
  0x02, 0x20, 0x04, 0xC0, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00, 0x58, 0x00,
  0xB0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x80, 0x80, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x31, 0x80, 0x00, 0x09, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x84, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x02, 0x00, 0x40, 0x01, 0x80, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x40,
  0x00, 0xC0, 0x08, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x30, 0x00, 0x40, 0x04, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x30, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x08, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x80, 0x05, 0x83,
  0x80, 0x38, 0x03, 0x81, 0xA0, 0x01, 0xF8,
};

const GFXglyph NotoSans_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 34, 10, 2, -34 },
  { 40, 11, 12, 15, 5, -34 },
  { 57, 28, 34, 29, 2, -34 },
  { 176, 23, 39, 26, 2, -36 },
  { 289, 30, 36, 37, 4, -35 },
  { 424, 29, 35, 33, 2, -35 },
  { 551, 4, 12, 8, 5, -34 },
  { 557, 13, 42, 12, 2, -34 },
  { 626, 13, 42, 12, -3, -34 },
  { 695, 20, 20, 25, 6, -36 },
  { 745, 22, 22, 27, 4, -28 },
  { 806, 6, 12, 9, -2, -6 },
  { 815, 11, 2, 15, 2, -14 },
  { 818, 2, 3, 10, 2, -3 },
  { 819, 21, 34, 15, -2, -34 },
  { 909, 22, 35, 26, 3, -35 },
  { 1006, 12, 34, 26, 8, -34 },
  { 1057, 24, 35, 26, 0, -35 },
  { 1162, 24, 35, 26, 1, -35 },
  { 1267, 24, 34, 26, 1, -34 },
  { 1369, 24, 34, 26, 2, -34 },
  { 1471, 23, 35, 26, 3, -35 },
  { 1572, 22, 34, 26, 5, -34 },
  { 1666, 23, 35, 26, 2, -35 },
  { 1767, 23, 35, 26, 2, -35 },
  { 1868, 7, 26, 10, 2, -26 },
  { 1891, 11, 32, 10, -2, -26 },
  { 1935, 22, 21, 27, 4, -28 },
  { 1993, 22, 11, 27, 4, -22 },
  { 2024, 22, 21, 27, 4, -28 },
  { 2082, 16, 35, 19, 4, -35 },
  { 2152, 36, 38, 40, 3, -34 },
  { 2323, 26, 34, 26, -2, -34 },
  { 2434, 26, 34, 29, 2, -34 },
  { 2545, 26, 35, 29, 4, -35 },
  { 2659, 29, 34, 33, 2, -34 },
  { 2783, 25, 34, 26, 2, -34 },
  { 2890, 25, 34, 23, 2, -34 },
  { 2997, 28, 35, 33, 4, -35 },
  { 3120, 30, 34, 33, 2, -34 },
  { 3248, 15, 34, 13, 0, -34 },
  { 3312, 19, 42, 11, -8, -34 },
  { 3412, 28, 34, 26, 2, -34 },
  { 3531, 18, 34, 24, 2, -34 },
  { 3608, 36, 34, 39, 2, -34 },
  { 3761, 30, 34, 32, 2, -34 },
  { 3889, 28, 35, 34, 4, -35 },
  { 4012, 25, 34, 27, 2, -34 },
  { 4119, 28, 43, 34, 4, -35 },
  { 4270, 25, 34, 27, 2, -34 },
  { 4377, 23, 35, 24, 1, -35 },
  { 4478, 24, 34, 23, 4, -34 },
  { 4580, 29, 34, 33, 4, -34 },
  { 4704, 24, 34, 26, 5, -34 },
  { 4806, 37, 34, 40, 6, -34 },
  { 4964, 30, 34, 23, -3, -34 },
  { 5092, 23, 34, 23, 5, -34 },
  { 5190, 27, 34, 26, 0, -34 },
  { 5305, 18, 42, 15, 0, -34 },
  { 5400, 7, 34, 15, 5, -34 },
  { 5430, 18, 42, 15, -3, -34 },
  { 5525, 22, 22, 26, 2, -35 },
  { 5586, 18, 1, 18, -4, 5 },
  { 5589, 5, 8, 11, 7, -37 },
  { 5594, 23, 26, 26, 2, -26 },
  { 5669, 23, 36, 27, 2, -36 },
  { 5773, 19, 26, 22, 3, -26 },
  { 5835, 26, 36, 27, 2, -36 },
  { 5952, 19, 26, 24, 3, -26 },
  { 6014, 26, 49, 13, -6, -37 },
  { 6174, 24, 38, 27, 1, -26 },
  { 6288, 22, 36, 27, 2, -36 },
  { 6387, 8, 35, 10, 2, -35 },
  { 6422, 17, 47, 10, -7, -35 },
  { 6522, 21, 36, 21, 2, -36 },
  { 6617, 9, 36, 10, 2, -36 },
  { 6658, 36, 26, 40, 2, -26 },
  { 6775, 22, 26, 27, 2, -26 },
  { 6847, 21, 26, 27, 3, -26 },
  { 6916, 26, 37, 27, -1, -26 },
  { 7037, 23, 37, 27, 2, -26 },
  { 7144, 17, 26, 18, 2, -26 },
  { 7200, 18, 26, 20, 1, -26 },
  { 7259, 14, 32, 15, 2, -32 },
  { 7315, 22, 25, 27, 3, -25 },
  { 7384, 20, 25, 20, 2, -25 },
  { 7447, 30, 25, 31, 3, -25 },
  { 7541, 25, 25, 22, -2, -25 },
  { 7620, 27, 37, 20, -5, -25 },
  { 7745, 22, 25, 21, -1, -25 },
  { 7814, 17, 42, 16, 1, -34 },
  { 7904, 1, 48, 26, 14, -36 },
  { 7910, 17, 42, 16, -2, -34 },
  { 8000, 22, 4, 27, 4, -19 },
};

const GFXfont NotoSans_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_THINITALIC48PT7B_H_
