#ifndef _NOTOSANS_THINITALIC39PT7B_H_
#define _NOTOSANS_THINITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x20, 0x90, 0x88, 0x44, 0x24, 0x12, 0x09,
  0x08, 0x84, 0x42, 0x41, 0x00, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x40, 0x01, 0x01, 0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x3F, 0xFF, 0xFC, 0x02, 0x03,
  0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x40,
  0x00, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x03, 0xFF, 0xFF, 0xE0,
  0x10, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x04,
  0x02, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0xFF, 0x80, 0xC4, 0x30, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10, 0x04, 0x08,
  0x01, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x03, 0x10, 0x00, 0x74, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x13, 0x00, 0x08, 0x60, 0x02, 0x08, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x43,
  0x0C, 0x13, 0x80, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x02, 0x04, 0x30, 0x02, 0x04, 0x08, 0x03, 0x04,
  0x04, 0x01, 0x02, 0x02, 0x01, 0x03, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x40, 0x20, 0x80, 0x20, 0x10, 0xC0, 0x20, 0x08, 0x40,
  0x10, 0x08, 0x47, 0xC8, 0x04, 0x46, 0x36, 0x04, 0x66, 0x09, 0x02, 0x22,
  0x04, 0x82, 0x22, 0x01, 0x3E, 0x21, 0x00, 0x80, 0x31, 0x80, 0xC0, 0x10,
  0x80, 0x40, 0x10, 0x40, 0x20, 0x10, 0x20, 0x10, 0x18, 0x10, 0x08, 0x08,
  0x08, 0x0C, 0x08, 0x04, 0x04, 0x08, 0x02, 0x02, 0x04, 0x01, 0x02, 0x04,
  0x00, 0x82, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x83, 0x00,
  0x04, 0x03, 0x00, 0x08, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x60, 0x02, 0x00, 0x80, 0x02, 0x02, 0x00, 0x04,
  0x18, 0x00, 0x04, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0x88,
  0x00, 0x0C, 0x08, 0x01, 0x30, 0x18, 0x04, 0xC0, 0x10, 0x09, 0x00, 0x10,
  0x24, 0x00, 0x10, 0xC8, 0x00, 0x21, 0x10, 0x00, 0x24, 0x20, 0x00, 0x30,
  0x40, 0x00, 0x60, 0x80, 0x01, 0x40, 0x80, 0x0C, 0x41, 0x80, 0x60, 0x40,
  0xFF, 0x80, 0xC0, 0x24, 0x94, 0x92, 0x50, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x80, 0x80, 0x60,
  0x80, 0x30, 0x80, 0x0D, 0x01, 0x03, 0xFF, 0x03, 0x00, 0x04, 0x80, 0x08,
  0x80, 0x10, 0x40, 0x20, 0x40, 0x40, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x42, 0x21, 0x18, 0x8C, 0x44, 0x00, 0xFF,
  0xC0, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x10, 0x20, 0x02, 0x18,
  0x00, 0x84, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x09, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x30, 0x80, 0x08, 0x10, 0x04,
  0x02, 0x02, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x50, 0x68, 0x32, 0x30, 0x98,
  0x28, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x00, 0x3F, 0x80, 0x0C, 0x04, 0x03, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x70, 0x18, 0x38, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x07, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x43, 0x00, 0x30, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x80,
  0x80, 0x10, 0x10, 0x03, 0x01, 0x00, 0x60, 0x10, 0x0C, 0x01, 0x00, 0x80,
  0x30, 0x10, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x0F, 0xFF, 0xFF, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xF0, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x8F,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0xC0, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x0F, 0xE0, 0x4C, 0x0C, 0x14, 0x00,
  0x8A, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x18, 0xC0,
  0x04, 0x10, 0x02, 0x02, 0x03, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x20, 0x30, 0x08, 0x01, 0x02, 0x00, 0x20, 0x40, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x18, 0x40, 0x02, 0x0C, 0x00, 0x40, 0x80, 0x10, 0x18,
  0x04, 0x01, 0x83, 0x00, 0x09, 0x80, 0x01, 0xC0, 0x01, 0xC6, 0x00, 0x60,
  0x20, 0x30, 0x02, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x02, 0x08, 0x00,
  0xC0, 0xC0, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0xC0, 0x60,
  0x08, 0x20, 0x02, 0x18, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xCC,
  0x00, 0x51, 0x00, 0x28, 0x20, 0x32, 0x07, 0xF0, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x04, 0x30, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x80, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xC1, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x80, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x01, 0x10, 0x01, 0xF0, 0x09, 0x80, 0x30, 0xE0,
  0x48, 0x06, 0x02, 0x02, 0xC0, 0x60, 0x10, 0x14, 0x06, 0x00, 0x80, 0xA0,
  0x20, 0x04, 0x05, 0x02, 0x00, 0x40, 0x30, 0x10, 0x02, 0x01, 0x80, 0x80,
  0x10, 0x0C, 0x04, 0x01, 0x80, 0xE0, 0x20, 0x08, 0x05, 0x01, 0x00, 0xC0,
  0x68, 0x08, 0x06, 0x02, 0x40, 0x40, 0x58, 0x21, 0x01, 0x0C, 0x46, 0x08,
  0x07, 0x81, 0xE0, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x08,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x50, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x02, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00,
  0x20, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00, 0x22, 0x00, 0x01, 0x20,
  0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x10, 0x03, 0xFF,
  0x00, 0x10, 0x07, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x40, 0x01, 0x82,
  0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x82, 0x00, 0x08, 0x30, 0x00, 0x81, 0x00, 0x38, 0x0F, 0xFE, 0x00, 0x40,
  0x0C, 0x02, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x40, 0x00, 0x42, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x18, 0x40, 0x00, 0x86, 0x00, 0x18, 0x20, 0x03, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0x80, 0x30, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x08, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x04, 0x07, 0x80, 0x10,
  0x01, 0x80, 0x20, 0x00, 0x80, 0x40, 0x00, 0x80, 0x80, 0x01, 0x83, 0x00,
  0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x88, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x0C, 0x02, 0x00, 0xF0, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0xF0, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xFF, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x03, 0xFE, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x30, 0x00, 0x10, 0x20, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x30, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x1F, 0xFF,
  0xFC, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x03, 0xF0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x0F,
  0xE0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x86, 0x00, 0x7C, 0x00, 0x02,
  0x00, 0x06, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x20, 0x03, 0x00, 0x80, 0x04, 0x02, 0x00, 0x08, 0x18,
  0x00, 0x10, 0x60, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00,
  0x02, 0x48, 0x00, 0x05, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20, 0x00,
  0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x40, 0x02, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x01, 0x00, 0x40, 0x02, 0x01, 0x80,
  0x06, 0x02, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0x02, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x40, 0x00, 0x0A, 0x0A, 0x00, 0x00, 0x70,
  0x50, 0x00, 0x05, 0x02, 0x80, 0x00, 0x68, 0x34, 0x00, 0x02, 0x41, 0x10,
  0x00, 0x22, 0x08, 0x80, 0x01, 0x20, 0x44, 0x00, 0x11, 0x02, 0x20, 0x01,
  0x88, 0x21, 0x00, 0x08, 0x41, 0x04, 0x00, 0x82, 0x08, 0x20, 0x04, 0x20,
  0x41, 0x00, 0x41, 0x02, 0x08, 0x06, 0x08, 0x20, 0x40, 0x20, 0x41, 0x02,
  0x02, 0x02, 0x08, 0x08, 0x10, 0x20, 0x40, 0x41, 0x01, 0x02, 0x02, 0x18,
  0x08, 0x20, 0x10, 0x80, 0x41, 0x00, 0x88, 0x06, 0x08, 0x04, 0x40, 0x20,
  0x40, 0x14, 0x01, 0x06, 0x00, 0xE0, 0x08, 0x20, 0x06, 0x00, 0x41, 0x00,
  0x20, 0x04, 0x00, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x05, 0x00, 0x01,
  0x05, 0x00, 0x02, 0x05, 0x00, 0x02, 0x04, 0x80, 0x02, 0x0C, 0x80, 0x02,
  0x08, 0x40, 0x02, 0x08, 0x40, 0x04, 0x08, 0x60, 0x04, 0x08, 0x20, 0x04,
  0x18, 0x20, 0x04, 0x10, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x08, 0x20, 0x0C, 0x08, 0x20, 0x04, 0x10, 0x20, 0x04, 0x10,
  0x20, 0x02, 0x10, 0x20, 0x02, 0x10, 0x40, 0x01, 0x10, 0x40, 0x01, 0x20,
  0x40, 0x01, 0xA0, 0x40, 0x00, 0xA0, 0xC0, 0x00, 0xA0, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x60,
  0x20, 0x00, 0x60, 0x80, 0x00, 0x43, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x90,
  0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x60, 0x20, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x20, 0x18, 0x04, 0x00, 0x40, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x02, 0x08, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x41, 0x00, 0x08, 0x10,
  0x03, 0x01, 0xFF, 0xC0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x60, 0x20, 0x00, 0x60, 0x80, 0x00,
  0x43, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x88, 0x00,
  0x01, 0x10, 0x00, 0x04, 0x30, 0x00, 0x18, 0x20, 0x00, 0x60, 0x20, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x20, 0x18, 0x04, 0x00, 0x40, 0x40,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x21, 0x80, 0x06, 0x10, 0x00, 0xC1,
  0x00, 0x18, 0x10, 0x3E, 0x01, 0xFF, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x04, 0x00, 0x40, 0x40, 0x06,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x08, 0x00,
  0x18, 0x00, 0xFF, 0x80, 0x70, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x82, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x04, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x80, 0x20, 0x01, 0x80, 0x18, 0x06, 0x00, 0x0F, 0xFC, 0x00, 0x80,
  0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x84,
  0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x40, 0x04, 0x02, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10,
  0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00,
  0x0E, 0x00, 0x08, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x60, 0x80, 0xC1, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x18, 0x10, 0x20, 0x10, 0x40, 0x40, 0x80, 0x41, 0x01, 0x04,
  0x01, 0x08, 0x04, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x01, 0x00, 0x03, 0x01, 0x00, 0x02,
  0x01, 0x00, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x20, 0x00, 0x40, 0x40, 0x00, 0x20, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x12, 0x00, 0x00, 0x14, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x24, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x02, 0x00, 0x02, 0x01, 0x00, 0x04, 0x01, 0x00,
  0x0C, 0x01, 0x80, 0x18, 0x00, 0x80, 0x10, 0x00, 0x80, 0x20, 0x00, 0x40,
  0x40, 0x00, 0x40, 0x80, 0x00, 0x20, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00,
  0x02, 0x20, 0x00, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x08, 0x01, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x00, 0x8C,
  0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82,
  0x08, 0x20, 0x41, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x40, 0x00, 0x90, 0x00, 0x44, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04,
  0x08, 0x02, 0x02, 0x01, 0x80, 0x40, 0x40, 0x10, 0x20, 0x04, 0x10, 0x01,
  0x04, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0xC0, 0xFF, 0xFC,
  0x88, 0x46, 0x21, 0x00, 0xF8, 0x40, 0xC1, 0x10, 0xC0, 0x24, 0x60, 0x0A,
  0x10, 0x01, 0x88, 0x00, 0x62, 0x00, 0x19, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x62, 0x00, 0x18, 0x80, 0x0A, 0x30, 0x05, 0x04, 0x03, 0x40, 0x81, 0x10,
  0x1F, 0x84, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x87, 0xC0, 0x23, 0x06, 0x04, 0x80, 0x60, 0xA0, 0x04, 0x18, 0x00,
  0x45, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00,
  0x90, 0x00, 0x12, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06,
  0x60, 0x00, 0x8C, 0x00, 0x31, 0x40, 0x04, 0x28, 0x01, 0x04, 0x80, 0xC1,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x07, 0xC1, 0x00,
  0xC1, 0x90, 0x18, 0x02, 0x81, 0x80, 0x14, 0x08, 0x00, 0x60, 0x80, 0x03,
  0x04, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00,
  0x01, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x60,
  0x80, 0x07, 0x04, 0x00, 0x30, 0x30, 0x02, 0x80, 0x80, 0x24, 0x06, 0x06,
  0x20, 0x0F, 0xC3, 0x00, 0x00, 0xF8, 0x03, 0x06, 0x04, 0x02, 0x08, 0x01,
  0x10, 0x01, 0x30, 0x01, 0x20, 0x02, 0x60, 0x02, 0x40, 0x0C, 0x40, 0x70,
  0x7F, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x08, 0x0F, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x18, 0x40, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x10, 0x18, 0x31, 0x06, 0x00,
  0xA0, 0xC0, 0x0A, 0x08, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x18, 0x40, 0x03, 0x06,
  0x00, 0x50, 0x20, 0x09, 0x03, 0x03, 0x10, 0x0F, 0xC2, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x80, 0x30, 0x07, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x0F, 0xC0, 0x8C, 0x18, 0x24, 0x03, 0x0A,
  0x00, 0x43, 0x00, 0x11, 0x40, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x06, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x02, 0x20, 0x00, 0x80, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x30, 0x80, 0x10, 0x20, 0x08, 0x08, 0x04, 0x02,
  0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x8A, 0x00, 0x2C, 0x80, 0x0E, 0x10, 0x03, 0x04, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x20, 0x40, 0x08, 0x20,
  0x01, 0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x04, 0x3E, 0x03, 0xE0,
  0x23, 0x0C, 0x30, 0x40, 0x90, 0x11, 0x80, 0x82, 0x80, 0x28, 0x02, 0x0C,
  0x00, 0xA0, 0x08, 0x50, 0x03, 0x00, 0x31, 0x80, 0x08, 0x00, 0x84, 0x00,
  0x20, 0x02, 0x10, 0x01, 0x80, 0x08, 0x40, 0x04, 0x00, 0x22, 0x00, 0x10,
  0x00, 0x88, 0x00, 0x40, 0x04, 0x20, 0x01, 0x00, 0x10, 0x80, 0x08, 0x00,
  0x42, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80, 0x04, 0x40, 0x02, 0x00, 0x21,
  0x00, 0x08, 0x00, 0x84, 0x00, 0x40, 0x02, 0x10, 0x01, 0x00, 0x08, 0x80,
  0x04, 0x00, 0x60, 0x04, 0x3F, 0x02, 0x30, 0x60, 0x90, 0x0C, 0x28, 0x01,
  0x0C, 0x00, 0x45, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x19, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x02, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0xC0, 0x10, 0x60, 0x02,
  0x10, 0x00, 0x88, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x86, 0x00, 0x40, 0xC0, 0x60,
  0x1F, 0xE0, 0x00, 0x01, 0x0F, 0x80, 0x11, 0x83, 0x00, 0x90, 0x0C, 0x05,
  0x00, 0x20, 0x30, 0x00, 0x82, 0x80, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x60,
  0xA0, 0x02, 0x05, 0x00, 0x20, 0x24, 0x06, 0x02, 0x1F, 0xC0, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8,
  0x20, 0x60, 0xC4, 0x30, 0x05, 0x0C, 0x00, 0xA1, 0x00, 0x0C, 0x40, 0x01,
  0x88, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x28,
  0x80, 0x06, 0x18, 0x01, 0x41, 0x00, 0x48, 0x10, 0x31, 0x01, 0xF8, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x3C,
  0x23, 0x00, 0x90, 0x02, 0x80, 0x0C, 0x00, 0x50, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x00, 0x01,
  0xFC, 0x06, 0x07, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0xC0, 0x30, 0x3F, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x81,
  0xFF, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x0F, 0xC0, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x30, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x18, 0x80, 0x0A, 0x20, 0x06, 0x8C, 0x03, 0x41,
  0x01, 0x90, 0x3F, 0x84, 0x00, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40,
  0x20, 0x40, 0x40, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x21, 0x00, 0x22,
  0x00, 0x26, 0x00, 0x14, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00, 0xD0, 0x05, 0x00, 0x48,
  0x02, 0x80, 0x24, 0x02, 0x40, 0x22, 0x01, 0x20, 0x10, 0x81, 0x10, 0x10,
  0x40, 0x84, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x40, 0x84,
  0x04, 0x20, 0x42, 0x02, 0x20, 0x22, 0x01, 0x10, 0x11, 0x00, 0x90, 0x09,
  0x00, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x20, 0x80, 0x08, 0x10, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x30, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x04, 0x40,
  0x00, 0x90, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x50, 0x00, 0x12, 0x00,
  0x06, 0x20, 0x01, 0x84, 0x00, 0x20, 0x40, 0x08, 0x08, 0x02, 0x00, 0x80,
  0x80, 0x10, 0x20, 0x01, 0x08, 0x00, 0x20, 0x02, 0x00, 0x04, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x04, 0x01, 0x00, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x08,
  0x10, 0x00, 0x20, 0x40, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40,
  0x00, 0x22, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x03, 0xC0, 0x00, 0x7F,
  0x80, 0x60, 0x38, 0x28, 0x01, 0xF0,
};

const GFXglyph NotoSans_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 28, 8, 1, -28 },
  { 29, 9, 10, 12, 4, -28 },
  { 41, 23, 28, 24, 1, -28 },
  { 122, 18, 32, 21, 2, -30 },
  { 194, 25, 28, 30, 3, -28 },
  { 282, 23, 28, 27, 2, -28 },
  { 363, 3, 10, 7, 4, -28 },
  { 367, 11, 34, 9, 1, -28 },
  { 414, 10, 34, 9, -2, -28 },
  { 457, 16, 17, 21, 5, -30 },
  { 491, 18, 18, 22, 3, -23 },
  { 532, 5, 10, 7, -2, -5 },
  { 539, 10, 1, 12, 1, -11 },
  { 541, 2, 2, 8, 1, -2 },
  { 542, 17, 28, 12, -2, -28 },
  { 602, 18, 28, 21, 3, -28 },
  { 665, 10, 28, 21, 6, -28 },
  { 700, 20, 28, 21, 0, -28 },
  { 770, 19, 28, 21, 1, -28 },
  { 837, 20, 28, 21, 1, -28 },
  { 907, 20, 28, 21, 1, -28 },
  { 977, 18, 28, 21, 3, -28 },
  { 1040, 18, 28, 21, 4, -28 },
  { 1103, 19, 28, 21, 2, -28 },
  { 1170, 18, 28, 21, 2, -28 },
  { 1233, 6, 21, 8, 1, -21 },
  { 1249, 9, 26, 8, -2, -21 },
  { 1279, 18, 18, 22, 3, -23 },
  { 1320, 18, 9, 22, 3, -18 },
  { 1341, 18, 18, 22, 3, -23 },
  { 1382, 13, 28, 16, 3, -28 },
  { 1428, 29, 32, 33, 2, -28 },
  { 1544, 21, 28, 21, -2, -28 },
  { 1618, 21, 28, 23, 2, -28 },
  { 1692, 22, 28, 23, 3, -28 },
  { 1769, 23, 28, 26, 2, -28 },
  { 1850, 20, 28, 21, 2, -28 },
  { 1920, 20, 28, 19, 2, -28 },
  { 1990, 23, 28, 27, 3, -28 },
  { 2071, 24, 28, 27, 2, -28 },
  { 2155, 12, 28, 11, 0, -28 },
  { 2197, 16, 35, 9, -7, -28 },
  { 2267, 23, 28, 21, 2, -28 },
  { 2348, 14, 28, 19, 2, -28 },
  { 2397, 29, 28, 31, 2, -28 },
  { 2499, 24, 28, 26, 2, -28 },
  { 2583, 23, 28, 28, 3, -28 },
  { 2664, 20, 28, 22, 2, -28 },
  { 2734, 23, 35, 28, 3, -28 },
  { 2835, 20, 28, 22, 2, -28 },
  { 2905, 19, 28, 19, 1, -28 },
  { 2972, 18, 28, 19, 4, -28 },
  { 3035, 24, 28, 27, 3, -28 },
  { 3119, 20, 28, 21, 4, -28 },
  { 3189, 30, 28, 32, 5, -28 },
  { 3294, 24, 28, 19, -2, -28 },
  { 3378, 19, 28, 19, 4, -28 },
  { 3445, 22, 28, 21, 0, -28 },
  { 3522, 14, 34, 12, 0, -28 },
  { 3582, 6, 28, 12, 4, -28 },
  { 3603, 15, 34, 12, -3, -28 },
  { 3667, 18, 17, 21, 2, -28 },
  { 3706, 14, 1, 14, -3, 4 },
  { 3708, 4, 6, 9, 6, -30 },
  { 3711, 18, 21, 21, 2, -21 },
  { 3759, 19, 30, 22, 1, -30 },
  { 3831, 16, 21, 18, 2, -21 },
  { 3873, 21, 30, 22, 2, -30 },
  { 3952, 16, 21, 19, 2, -21 },
  { 3994, 21, 39, 10, -5, -30 },
  { 4097, 20, 30, 22, 1, -21 },
  { 4172, 18, 30, 22, 1, -30 },
  { 4240, 8, 28, 8, 1, -28 },
  { 4268, 15, 37, 8, -6, -28 },
  { 4338, 18, 30, 17, 1, -30 },
  { 4406, 8, 30, 8, 1, -30 },
  { 4436, 30, 21, 33, 1, -21 },
  { 4515, 18, 21, 22, 1, -21 },
  { 4563, 18, 21, 22, 2, -21 },
  { 4611, 21, 30, 22, -1, -21 },
  { 4690, 19, 30, 22, 2, -21 },
  { 4762, 14, 21, 14, 1, -21 },
  { 4799, 16, 21, 17, 0, -21 },
  { 4841, 11, 26, 12, 2, -26 },
  { 4877, 18, 21, 22, 2, -21 },
  { 4925, 16, 21, 16, 2, -21 },
  { 4967, 25, 21, 25, 2, -21 },
  { 5033, 19, 21, 18, -1, -21 },
  { 5083, 22, 30, 16, -4, -21 },
  { 5166, 18, 21, 17, -1, -21 },
  { 5214, 14, 34, 13, 1, -28 },
  { 5274, 1, 39, 21, 11, -30 },
  { 5279, 14, 34, 13, -2, -28 },
  { 5339, 18, 3, 22, 3, -15 },
};

const GFXfont NotoSans_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_THINITALIC39PT7B_H_
