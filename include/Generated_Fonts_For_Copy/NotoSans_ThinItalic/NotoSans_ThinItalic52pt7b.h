#ifndef _NOTOSANS_THINITALIC52PT7B_H_
#define _NOTOSANS_THINITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x00, 0x30, 0x64, 0x0C, 0x81, 0x10,
  0x26, 0x04, 0xC1, 0x90, 0x32, 0x04, 0x40, 0x98, 0x12, 0x06, 0x40, 0x88,
  0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x02, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x04,
  0x00, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x71, 0x3F, 0x01, 0xC1, 0x02, 0x03, 0x03, 0x00, 0x06, 0x02, 0x00, 0x04,
  0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x10, 0x30, 0x00,
  0x10, 0x10, 0x00, 0x30, 0x18, 0x00, 0x20, 0x18, 0x00, 0x20, 0x10, 0x00,
  0x20, 0x10, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x60, 0x80,
  0x41, 0xC0, 0xE0, 0x47, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x01, 0x83,
  0x00, 0x03, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x80, 0x60, 0x01, 0x80, 0xC0,
  0x10, 0x01, 0x80, 0x40, 0x08, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x20,
  0x02, 0x00, 0xC0, 0x10, 0x01, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x40, 0x08,
  0x00, 0xC0, 0x40, 0x04, 0x00, 0x60, 0x60, 0x02, 0x00, 0x20, 0x60, 0x01,
  0x00, 0x10, 0x20, 0x01, 0x80, 0x18, 0x20, 0x70, 0xC0, 0x0C, 0x30, 0xFE,
  0x60, 0x04, 0x30, 0xC1, 0x90, 0x06, 0x10, 0xC0, 0x48, 0x06, 0x10, 0xC0,
  0x36, 0x02, 0x18, 0x40, 0x19, 0x03, 0x18, 0x60, 0x0C, 0xFE, 0x08, 0x20,
  0x06, 0x0C, 0x0C, 0x30, 0x03, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x0C, 0x08,
  0x00, 0xC0, 0x04, 0x04, 0x00, 0x40, 0x06, 0x06, 0x00, 0x20, 0x06, 0x03,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x60, 0x04, 0x03, 0x00, 0x30, 0x06, 0x01, 0x00, 0x18, 0x02, 0x01, 0x00,
  0x0C, 0x03, 0x01, 0x80, 0x02, 0x03, 0x01, 0x80, 0x01, 0x83, 0x01, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x10, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x43, 0x00, 0x20, 0x01,
  0x8C, 0x00, 0x60, 0x02, 0x30, 0x00, 0x60, 0x08, 0xC0, 0x00, 0x40, 0x31,
  0x80, 0x00, 0x40, 0x42, 0x00, 0x00, 0xC1, 0x84, 0x00, 0x00, 0xC6, 0x18,
  0x00, 0x00, 0x98, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x07, 0x80, 0xC0, 0x00, 0x19, 0x01, 0x80, 0x00, 0x63, 0x01, 0x80,
  0x03, 0x03, 0x01, 0xC0, 0x1C, 0x02, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x32, 0x22, 0x66, 0x44, 0x4C, 0x88, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x60, 0x10, 0x01, 0x80, 0x80, 0x03, 0x04, 0x00, 0x0E, 0x20, 0x00,
  0x1A, 0x03, 0xC0, 0x3F, 0xFC, 0x01, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x10,
  0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x30, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x06, 0x08, 0x30, 0x41,
  0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x70, 0x1C, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x02, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x18,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40,
  0x30, 0x00, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xB0, 0x72, 0x0C, 0x23, 0x82,
  0x60, 0x6C, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0E, 0x01, 0x80, 0x1C, 0x00, 0x60,
  0x08, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x80, 0x30, 0x07, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00,
  0x02, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x40, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x10, 0x18, 0x00, 0x02, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x17,
  0xFE, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x0C, 0x03, 0xC0, 0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x3F, 0x00, 0x61, 0xF7, 0xC0, 0x47, 0x00, 0x60, 0x4C, 0x00, 0x30, 0x58,
  0x00, 0x18, 0xF0, 0x00, 0x18, 0xE0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x08, 0x04, 0x00,
  0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x60, 0x00, 0x30, 0x70, 0x00, 0x06, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x1C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x84, 0x00,
  0x01, 0xC2, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xA0, 0x60, 0x01, 0xB0, 0x18,
  0x03, 0x18, 0x07, 0xFF, 0x08, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x08, 0x01, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x07, 0x06, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x00,
  0x20, 0x07, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0x03, 0x80, 0x70, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x01, 0xFF, 0x80, 0x31, 0x00,
  0x0E, 0x03, 0x80, 0x66, 0x00, 0x30, 0x02, 0x00, 0xC8, 0x00, 0xC0, 0x04,
  0x00, 0xB0, 0x03, 0x00, 0x18, 0x01, 0x60, 0x0C, 0x00, 0x30, 0x02, 0x80,
  0x10, 0x00, 0x40, 0x0D, 0x00, 0x60, 0x00, 0x80, 0x1E, 0x00, 0x80, 0x03,
  0x00, 0x3C, 0x03, 0x00, 0x04, 0x00, 0x50, 0x04, 0x00, 0x08, 0x00, 0xA0,
  0x08, 0x00, 0x30, 0x03, 0x40, 0x10, 0x00, 0x60, 0x06, 0x80, 0x20, 0x00,
  0x80, 0x09, 0x00, 0x40, 0x03, 0x00, 0x32, 0x00, 0x80, 0x0E, 0x00, 0xC4,
  0x01, 0x80, 0x14, 0x01, 0x0C, 0x03, 0x00, 0x4C, 0x06, 0x18, 0x03, 0x03,
  0x08, 0x38, 0x10, 0x03, 0xFC, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00, 0x06, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0x80, 0x18, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x30, 0x01, 0xE0, 0x04,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x04, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x08, 0x00,
  0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0xE0, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC0, 0x40, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0xF8, 0x00, 0x10, 0x00, 0x38, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x1E, 0x00, 0x20, 0x0F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0xFF, 0x18, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xF0,
  0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x0C, 0x3C, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x70, 0x00, 0x00, 0x26,
  0x60, 0x00, 0x01, 0xB0, 0x80, 0x00, 0x07, 0x83, 0x00, 0x00, 0x1C, 0x04,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x04,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x05, 0x00, 0x00, 0x00, 0x50, 0x0A, 0x00, 0x00, 0x01, 0xA0, 0x34, 0x00,
  0x00, 0x02, 0xC0, 0x68, 0x00, 0x00, 0x0D, 0x00, 0x98, 0x00, 0x00, 0x32,
  0x01, 0x30, 0x00, 0x00, 0x44, 0x02, 0x20, 0x00, 0x01, 0x98, 0x0C, 0x40,
  0x00, 0x02, 0x30, 0x18, 0x80, 0x00, 0x0C, 0x40, 0x21, 0x00, 0x00, 0x30,
  0x80, 0x43, 0x00, 0x00, 0x41, 0x00, 0x82, 0x00, 0x01, 0x86, 0x03, 0x04,
  0x00, 0x02, 0x0C, 0x06, 0x08, 0x00, 0x0C, 0x10, 0x08, 0x10, 0x00, 0x10,
  0x20, 0x10, 0x30, 0x00, 0x40, 0x40, 0x60, 0x60, 0x01, 0x81, 0x80, 0xC0,
  0x40, 0x02, 0x03, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x40, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x40, 0x08, 0x0C, 0x01, 0x00, 0x80, 0x10, 0x10,
  0x02, 0x01, 0x00, 0x20, 0x40, 0x0C, 0x06, 0x00, 0x41, 0x80, 0x18, 0x0C,
  0x00, 0xC2, 0x00, 0x20, 0x10, 0x00, 0x8C, 0x00, 0x40, 0x20, 0x01, 0x10,
  0x00, 0x80, 0x40, 0x02, 0x40, 0x03, 0x01, 0x80, 0x05, 0x80, 0x06, 0x03,
  0x00, 0x0E, 0x00, 0x08, 0x04, 0x00, 0x1C, 0x00, 0x10, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x01,
  0xC0, 0x00, 0x02, 0x01, 0x40, 0x00, 0x02, 0x03, 0x40, 0x00, 0x06, 0x03,
  0x60, 0x00, 0x06, 0x02, 0x20, 0x00, 0x04, 0x02, 0x30, 0x00, 0x04, 0x02,
  0x10, 0x00, 0x04, 0x06, 0x18, 0x00, 0x0C, 0x06, 0x08, 0x00, 0x0C, 0x04,
  0x08, 0x00, 0x08, 0x04, 0x0C, 0x00, 0x08, 0x04, 0x04, 0x00, 0x08, 0x0C,
  0x06, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x18, 0x08, 0x03, 0x00, 0x10, 0x08,
  0x01, 0x00, 0x10, 0x18, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0x30, 0x18,
  0x00, 0x80, 0x20, 0x10, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x40, 0x20, 0x30,
  0x00, 0x60, 0x60, 0x30, 0x00, 0x20, 0x60, 0x20, 0x00, 0x20, 0x40, 0x20,
  0x00, 0x30, 0x40, 0x20, 0x00, 0x10, 0x40, 0x60, 0x00, 0x18, 0xC0, 0x60,
  0x00, 0x08, 0xC0, 0x40, 0x00, 0x0C, 0x80, 0x40, 0x00, 0x04, 0x80, 0x40,
  0x00, 0x04, 0x80, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x10, 0x00,
  0x70, 0x04, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x20,
  0x00, 0x0C, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10,
  0x60, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x60,
  0x0F, 0x80, 0x10, 0x00, 0x70, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0x00,
  0x18, 0x03, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x80,
  0x01, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02, 0x01,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x18,
  0x0E, 0x00, 0x38, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x08, 0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x60, 0x18, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x02, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00,
  0x80, 0x08, 0x00, 0x20, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x10, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x04,
  0x40, 0x00, 0x6C, 0x00, 0x0C, 0x40, 0x00, 0x4C, 0x00, 0x08, 0x40, 0x00,
  0xCC, 0x00, 0x18, 0x40, 0x00, 0x8C, 0x00, 0x10, 0x40, 0x01, 0x8C, 0x00,
  0x30, 0x40, 0x01, 0x04, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04,
  0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0x80, 0x60, 0x08, 0x04, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x60, 0x10, 0x04, 0x03, 0x00, 0x60, 0x30,
  0x04, 0x02, 0x00, 0x20, 0x20, 0x06, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04,
  0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x20,
  0x80, 0x06, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x30, 0x00, 0x08, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00, 0x60, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x60, 0x00, 0x60, 0x10, 0x00, 0x60,
  0x08, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x30, 0x00, 0x80, 0x30,
  0x00, 0x60, 0x10, 0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00, 0x04, 0x18,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x04, 0x04,
  0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B,
  0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08,
  0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x02, 0x02,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xE0, 0x86, 0x10, 0xC2, 0x18, 0x61, 0x00, 0x3F, 0x01, 0x00, 0xF1,
  0xC2, 0x03, 0x80, 0x62, 0x06, 0x00, 0x32, 0x0C, 0x00, 0x12, 0x08, 0x00,
  0x1E, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x70, 0x80, 0x00, 0x60, 0x80, 0x00,
  0xE0, 0xC0, 0x01, 0xA0, 0xC0, 0x01, 0x60, 0x40, 0x02, 0x60, 0x60, 0x0C,
  0x40, 0x30, 0x18, 0x40, 0x1F, 0xE0, 0x40, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x7E, 0x00, 0x30, 0xF1, 0xC0, 0x10, 0xC0, 0x30, 0x08, 0x80, 0x0C,
  0x04, 0x80, 0x03, 0x06, 0x80, 0x01, 0x82, 0x80, 0x00, 0x41, 0xC0, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x0A,
  0x00, 0x02, 0x0D, 0x80, 0x03, 0x04, 0x60, 0x07, 0x02, 0x18, 0x0E, 0x01,
  0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xC7,
  0xC0, 0x60, 0x02, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x18, 0x01, 0xE3, 0xC2, 0x00,
  0xE0, 0x0C, 0x40, 0x30, 0x00, 0xC8, 0x0C, 0x00, 0x0B, 0x01, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x04, 0x00, 0x01, 0xC0,
  0x80, 0x00, 0x30, 0x10, 0x00, 0x0A, 0x03, 0x00, 0x03, 0x40, 0x60, 0x00,
  0xC8, 0x04, 0x00, 0x33, 0x00, 0xC0, 0x0C, 0x40, 0x0C, 0x07, 0x08, 0x00,
  0xFF, 0x81, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xCF,
  0x00, 0x70, 0x0C, 0x06, 0x00, 0x20, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x11, 0x00, 0x01, 0x98, 0x00, 0x18,
  0xC0, 0x03, 0x84, 0x00, 0x78, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x02, 0x03, 0x00, 0xE0, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x02, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x07, 0x87, 0x08, 0x03, 0x80, 0x31,
  0x00, 0xC0, 0x03, 0x20, 0x30, 0x00, 0x24, 0x04, 0x00, 0x07, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x10, 0x00, 0x07, 0x02, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x38, 0x0C, 0x00, 0x0D, 0x01, 0x80, 0x03, 0x60, 0x10,
  0x00, 0xCC, 0x03, 0x00, 0x31, 0x00, 0x30, 0x1C, 0x20, 0x03, 0xFE, 0x04,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x07, 0xF0, 0x06, 0x1E, 0x3C, 0x04,
  0x30, 0x0C, 0x04, 0x40, 0x06, 0x04, 0x80, 0x02, 0x0D, 0x00, 0x03, 0x0A,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x10,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40,
  0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x20, 0xC0, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x04, 0x00, 0x40, 0x10, 0x00,
  0x80, 0x40, 0x01, 0x01, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x23, 0xC0, 0x00, 0x4C, 0x80, 0x01, 0xB1, 0x80, 0x02, 0xC1,
  0x00, 0x07, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x0C, 0x01, 0x00, 0x08, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x10,
  0x18, 0x00, 0x30, 0x20, 0x00, 0x20, 0x40, 0x00, 0x60, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x02, 0x07, 0xC0, 0x07, 0xE0, 0x08,
  0x39, 0xE0, 0x3C, 0xF0, 0x11, 0x80, 0x60, 0xC0, 0x30, 0x26, 0x00, 0x43,
  0x00, 0x60, 0x58, 0x00, 0x88, 0x00, 0x41, 0xA0, 0x01, 0xB0, 0x00, 0xC2,
  0x80, 0x03, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x10, 0x00, 0x18, 0x00, 0x08, 0x60, 0x00, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x40, 0x00, 0x21, 0x00, 0x00, 0x80, 0x00, 0xC2, 0x00, 0x03,
  0x00, 0x01, 0x84, 0x00, 0x06, 0x00, 0x02, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x40, 0x00, 0x20, 0x00, 0x30, 0x80, 0x00,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x80, 0x00, 0x86, 0x00, 0x02, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x30, 0x00, 0x10, 0xC0, 0x00, 0x40, 0x00, 0x21, 0x80, 0x00, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x00, 0x01, 0x84, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02,
  0x07, 0xF0, 0x04, 0x1E, 0x3C, 0x04, 0x30, 0x0C, 0x04, 0x40, 0x06, 0x04,
  0x80, 0x02, 0x0D, 0x00, 0x03, 0x0A, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60,
  0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0xE0, 0x01, 0x80, 0x18, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x04, 0x08, 0x00, 0x06, 0x18, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x20, 0x60,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0xFC, 0x00, 0x08, 0x3C, 0x70, 0x00, 0x86, 0x01,
  0x80, 0x09, 0x80, 0x0C, 0x00, 0x90, 0x00, 0x60, 0x1A, 0x00, 0x06, 0x01,
  0x40, 0x00, 0x20, 0x1C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x00, 0xA0,
  0x00, 0x20, 0x1B, 0x00, 0x06, 0x01, 0x98, 0x01, 0xC0, 0x10, 0xC0, 0x70,
  0x01, 0x07, 0xFC, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x80, 0x78, 0x70, 0x80, 0xE0, 0x0C, 0x40, 0xC0, 0x03, 0x20, 0xC0,
  0x00, 0x90, 0x40, 0x00, 0x78, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x07,
  0x08, 0x00, 0x03, 0x04, 0x00, 0x02, 0x83, 0x00, 0x03, 0x41, 0x80, 0x03,
  0x60, 0x40, 0x03, 0x30, 0x30, 0x03, 0x10, 0x0C, 0x07, 0x08, 0x03, 0xFE,
  0x04, 0x00, 0x10, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x02, 0x07, 0xE0, 0x83, 0xC8, 0x10, 0xC0, 0x02, 0x60,
  0x00, 0x48, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x3E, 0x3F, 0x06, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x08, 0x00, 0x20, 0xE0, 0x0C, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x3F,
  0xFF, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x30, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x70, 0x80, 0x00, 0xE0, 0x80, 0x00, 0xA0, 0x80, 0x01, 0x20, 0xC0, 0x03,
  0x20, 0x40, 0x0E, 0x60, 0x70, 0x18, 0x40, 0x1F, 0xE0, 0x40, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x80, 0x00, 0xCC,
  0x00, 0x0C, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x03,
  0x02, 0x00, 0x10, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x10,
  0x0C, 0x00, 0x80, 0x40, 0x04, 0x06, 0x00, 0x30, 0x20, 0x01, 0x82, 0x00,
  0x04, 0x30, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C,
  0x00, 0x03, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0xC0, 0x0C, 0x80, 0x0C,
  0xC0, 0x08, 0x80, 0x08, 0xC0, 0x18, 0x80, 0x18, 0xC0, 0x10, 0xC0, 0x10,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0x40, 0x60, 0x40, 0x60,
  0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x40, 0xC0, 0x40, 0x80, 0x40, 0x80,
  0x41, 0x80, 0x41, 0x80, 0x41, 0x00, 0x41, 0x00, 0x43, 0x00, 0x43, 0x00,
  0x42, 0x00, 0x62, 0x00, 0x46, 0x00, 0x66, 0x00, 0x44, 0x00, 0x64, 0x00,
  0x4C, 0x00, 0x24, 0x00, 0x48, 0x00, 0x2C, 0x00, 0x58, 0x00, 0x28, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x10, 0x40, 0x00, 0x06, 0x20, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x60, 0x00, 0x08,
  0x08, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x40, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x08, 0x00, 0x04,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20,
  0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x0F, 0x9C,
  0x00, 0x01, 0xF8,
};

const GFXglyph NotoSans_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 37, 11, 2, -37 },
  { 43, 11, 13, 16, 6, -37 },
  { 61, 30, 37, 32, 2, -37 },
  { 200, 24, 42, 29, 3, -39 },
  { 326, 33, 39, 40, 4, -38 },
  { 487, 31, 39, 35, 2, -38 },
  { 639, 4, 13, 9, 6, -37 },
  { 646, 14, 45, 13, 2, -37 },
  { 725, 14, 45, 13, -3, -37 },
  { 804, 21, 21, 28, 7, -39 },
  { 860, 24, 24, 30, 4, -30 },
  { 932, 7, 13, 10, -2, -6 },
  { 944, 12, 2, 16, 2, -15 },
  { 947, 2, 3, 11, 2, -3 },
  { 948, 22, 37, 16, -2, -37 },
  { 1050, 24, 39, 29, 3, -38 },
  { 1167, 12, 37, 29, 9, -37 },
  { 1223, 25, 38, 29, 1, -38 },
  { 1342, 26, 39, 29, 1, -38 },
  { 1469, 27, 37, 29, 1, -37 },
  { 1594, 26, 38, 29, 2, -37 },
  { 1718, 24, 39, 29, 4, -38 },
  { 1835, 23, 37, 29, 6, -37 },
  { 1942, 26, 39, 29, 2, -38 },
  { 2069, 25, 39, 29, 2, -38 },
  { 2191, 8, 28, 11, 2, -28 },
  { 2219, 12, 35, 11, -2, -28 },
  { 2272, 24, 23, 30, 4, -30 },
  { 2341, 24, 12, 30, 4, -24 },
  { 2377, 24, 23, 30, 4, -30 },
  { 2446, 18, 38, 21, 4, -38 },
  { 2532, 39, 42, 43, 3, -37 },
  { 2737, 29, 37, 28, -3, -37 },
  { 2872, 27, 37, 31, 3, -37 },
  { 2997, 29, 39, 31, 4, -38 },
  { 3139, 30, 37, 35, 3, -37 },
  { 3278, 26, 37, 28, 3, -37 },
  { 3399, 26, 37, 25, 3, -37 },
  { 3520, 31, 39, 36, 4, -38 },
  { 3672, 32, 37, 35, 3, -37 },
  { 3820, 16, 37, 15, 0, -37 },
  { 3894, 21, 46, 12, -9, -37 },
  { 4015, 30, 37, 28, 3, -37 },
  { 4154, 18, 37, 26, 3, -37 },
  { 4238, 39, 37, 42, 3, -37 },
  { 4419, 32, 37, 35, 3, -37 },
  { 4567, 31, 39, 37, 4, -38 },
  { 4719, 26, 37, 29, 3, -37 },
  { 4840, 31, 47, 37, 4, -38 },
  { 5023, 26, 37, 29, 3, -37 },
  { 5144, 25, 39, 26, 1, -38 },
  { 5266, 25, 37, 25, 5, -37 },
  { 5382, 31, 38, 36, 5, -37 },
  { 5530, 26, 37, 28, 6, -37 },
  { 5651, 40, 37, 43, 6, -37 },
  { 5836, 32, 37, 25, -3, -37 },
  { 5984, 25, 37, 25, 5, -37 },
  { 6100, 30, 37, 28, 0, -37 },
  { 6239, 19, 45, 16, 0, -37 },
  { 6346, 8, 37, 16, 5, -37 },
  { 6383, 20, 45, 16, -4, -37 },
  { 6496, 23, 23, 29, 3, -37 },
  { 6563, 19, 1, 19, -4, 6 },
  { 6566, 5, 8, 12, 8, -40 },
  { 6571, 24, 29, 28, 3, -28 },
  { 6658, 25, 41, 30, 2, -40 },
  { 6787, 21, 29, 24, 3, -28 },
  { 6864, 27, 41, 30, 3, -40 },
  { 7003, 21, 29, 26, 3, -28 },
  { 7080, 28, 52, 14, -7, -40 },
  { 7262, 27, 40, 30, 1, -28 },
  { 7397, 24, 40, 29, 2, -40 },
  { 7517, 9, 37, 11, 2, -37 },
  { 7559, 18, 49, 11, -7, -37 },
  { 7670, 23, 40, 23, 2, -40 },
  { 7785, 9, 40, 11, 2, -40 },
  { 7830, 39, 28, 44, 2, -28 },
  { 7967, 24, 28, 29, 2, -28 },
  { 8051, 24, 29, 29, 3, -28 },
  { 8138, 28, 40, 30, -1, -28 },
  { 8278, 25, 40, 30, 3, -28 },
  { 8403, 19, 28, 19, 2, -28 },
  { 8470, 20, 29, 22, 1, -28 },
  { 8543, 14, 35, 16, 3, -34 },
  { 8605, 24, 28, 29, 3, -27 },
  { 8689, 21, 27, 21, 3, -27 },
  { 8760, 32, 27, 34, 3, -27 },
  { 8868, 26, 27, 24, -2, -27 },
  { 8956, 30, 40, 21, -6, -27 },
  { 9106, 24, 27, 23, -1, -27 },
  { 9187, 19, 45, 17, 1, -37 },
  { 9294, 1, 53, 28, 15, -40 },
  { 9301, 19, 45, 17, -3, -37 },
  { 9408, 24, 5, 30, 4, -21 },
};

const GFXfont NotoSans_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_THINITALIC52PT7B_H_
