#ifndef _NOTOSANS_THINITALIC70PT7B_H_
#define _NOTOSANS_THINITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x10, 0x00,
  0x18, 0x06, 0x30, 0x0C, 0x60, 0x30, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C,
  0x02, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0x84, 0x03,
  0x08, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x21, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x08, 0x0F, 0x00, 0x70, 0x08,
  0x02, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x07,
  0x00, 0xC0, 0x08, 0x1E, 0x00, 0xFF, 0x09, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x08, 0x0C, 0x00, 0x0C, 0x0C, 0x0F, 0xF0, 0xC0, 0x01,
  0x81, 0xC1, 0xE3, 0xCC, 0x00, 0x18, 0x18, 0x38, 0x0C, 0xC0, 0x03, 0x03,
  0x06, 0x00, 0x6C, 0x00, 0x30, 0x60, 0xE0, 0x06, 0xC0, 0x06, 0x0E, 0x0C,
  0x00, 0x66, 0x00, 0xE0, 0xC1, 0x80, 0x02, 0x70, 0x1C, 0x18, 0x18, 0x00,
  0x33, 0x83, 0x83, 0x03, 0x00, 0x03, 0x1F, 0xE0, 0x30, 0x30, 0x00, 0x30,
  0x70, 0x06, 0x02, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x38, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x03, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x03,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x80, 0x30, 0x60, 0x00, 0x00, 0x30, 0x18, 0x10, 0x00, 0x00,
  0x0C, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x87, 0x03, 0x00, 0x00, 0x00, 0x31,
  0x80, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00,
  0x00, 0x1D, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x30, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x30,
  0x01, 0xE0, 0x1F, 0x80, 0x06, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x23, 0x18, 0xC4,
  0x23, 0x18, 0x84, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x00, 0x03, 0x80, 0x20,
  0x00, 0x0E, 0x02, 0x00, 0x00, 0x38, 0x20, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x07, 0x40, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x10, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x67, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x73, 0x00, 0xE3, 0x03, 0x86, 0x07, 0x06, 0x1C, 0x06, 0x38,
  0x06, 0xE0, 0x04, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x78, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x04, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x10, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x1F, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x00,
  0xC1, 0xE0, 0x1E, 0x00, 0x63, 0xC0, 0x03, 0x80, 0x23, 0x80, 0x00, 0x60,
  0x33, 0x00, 0x00, 0x38, 0x1B, 0x00, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x01, 0x87, 0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x0D, 0x81, 0x80, 0x00,
  0x07, 0xC0, 0x30, 0x00, 0x03, 0xB0, 0x0E, 0x00, 0x01, 0xCC, 0x01, 0xC0,
  0x01, 0xC2, 0x00, 0x3C, 0x03, 0xE1, 0x80, 0x03, 0xFF, 0xE0, 0x60, 0x00,
  0x0F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0xFE,
  0x07, 0x80, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x30, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0x1C, 0x00, 0x07, 0x80, 0x04,
  0x00, 0x31, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x13, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x30, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x16, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0x60, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x36, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x60,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x03, 0xC0, 0x02, 0x00, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x06, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x0C, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xCC, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x03, 0xC0, 0x01, 0x8C, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x06, 0x40, 0x06, 0x0C,
  0x00, 0x30, 0x00, 0xC6, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0x38, 0x60, 0x3C,
  0x06, 0x00, 0x0F, 0x0F, 0x03, 0x8F, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00,
  0x3C, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x39, 0x80, 0x00, 0x00, 0x03, 0x38,
  0xE0, 0x00, 0x00, 0x01, 0xB8, 0x30, 0x00, 0x00, 0x01, 0xB0, 0x18, 0x00,
  0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x68, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0x60, 0x03, 0x10, 0x00, 0x00, 0x00,
  0x73, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x84, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x18, 0x60, 0x03, 0x04, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x04, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x10,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x80,
  0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x01, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x11, 0x80, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x03, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x40, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x63, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC0, 0x06, 0x18, 0x00, 0x00, 0x08, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x00, 0x80, 0x20, 0x00, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x80, 0x00, 0x03, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x01, 0x80, 0x00, 0x01, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x01, 0x80, 0x00, 0x01, 0x82, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x03, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x30, 0x00, 0x00, 0x06, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x30, 0x00, 0x00, 0x02, 0x40, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x10, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18,
  0x08, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x20, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x10,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x04, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x10, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xFE, 0x03, 0x00, 0x3E, 0x07, 0x82, 0x00, 0x70, 0x01, 0xC2,
  0x00, 0xE0, 0x00, 0xC6, 0x01, 0x80, 0x00, 0x66, 0x03, 0x00, 0x00, 0x26,
  0x06, 0x00, 0x00, 0x34, 0x0E, 0x00, 0x00, 0x34, 0x0C, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x02, 0xC0, 0xC0, 0x00, 0x06, 0xC0,
  0xC0, 0x00, 0x0C, 0x80, 0x60, 0x00, 0x19, 0x80, 0x60, 0x00, 0x31, 0x80,
  0x30, 0x00, 0x61, 0x80, 0x38, 0x01, 0xC1, 0x00, 0x1E, 0x07, 0x81, 0x00,
  0x07, 0xFE, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x30, 0x7C, 0x0E,
  0x00, 0x08, 0x38, 0x00, 0xE0, 0x06, 0x18, 0x00, 0x18, 0x01, 0x8C, 0x00,
  0x03, 0x00, 0x66, 0x00, 0x00, 0xE0, 0x13, 0x00, 0x00, 0x18, 0x0D, 0x80,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x0C, 0x0B, 0x00, 0x00, 0x06, 0x02,
  0xC0, 0x00, 0x03, 0x01, 0x90, 0x00, 0x01, 0xC0, 0x66, 0x00, 0x00, 0xE0,
  0x18, 0xC0, 0x00, 0x70, 0x04, 0x18, 0x00, 0x78, 0x01, 0x03, 0xC0, 0x78,
  0x00, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x40, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x2F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x01, 0x80, 0x00, 0xF0,
  0x1E, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x60, 0x01, 0xC0, 0x00, 0xE2, 0x00,
  0x18, 0x00, 0x03, 0x30, 0x01, 0x80, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x00,
  0x6C, 0x01, 0xC0, 0x00, 0x01, 0x60, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x3C, 0x01, 0x80, 0x00,
  0x01, 0x40, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x01, 0xB0, 0x03,
  0x00, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x60, 0x00, 0x18,
  0x40, 0x01, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x3C,
  0x0F, 0x81, 0x80, 0x00, 0x7F, 0xF0, 0x08, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x78, 0x60, 0x00, 0x1E,
  0x06, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x03, 0xC0, 0x3E, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x04, 0x00, 0x1E, 0x03, 0xC1, 0x80, 0x0E, 0x00,
  0x1C, 0x30, 0x03, 0x80, 0x01, 0xC4, 0x00, 0xC0, 0x00, 0x18, 0x80, 0x30,
  0x00, 0x01, 0xB0, 0x0C, 0x00, 0x00, 0x36, 0x03, 0x80, 0x00, 0x02, 0xC0,
  0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x03, 0x80, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1E, 0x03, 0x00,
  0x00, 0x02, 0x80, 0x60, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x36, 0x01,
  0x80, 0x00, 0x0C, 0xC0, 0x18, 0x00, 0x03, 0x18, 0x03, 0x00, 0x00, 0xC2,
  0x00, 0x30, 0x00, 0x30, 0xC0, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x78, 0x1F,
  0x03, 0x00, 0x03, 0xFF, 0x80, 0x40, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x02, 0x00,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x60, 0x78, 0x1E, 0x00,
  0x20, 0xE0, 0x03, 0x80, 0x30, 0xC0, 0x00, 0xC0, 0x18, 0xC0, 0x00, 0x30,
  0x0C, 0xC0, 0x00, 0x18, 0x04, 0xC0, 0x00, 0x0C, 0x06, 0xC0, 0x00, 0x02,
  0x03, 0xC0, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x00, 0x80, 0xE0, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x81, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x02, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x18, 0x7C, 0x00, 0x00, 0x31, 0xD8, 0x00, 0x00, 0x67, 0x18, 0x00, 0x00,
  0x98, 0x10, 0x00, 0x01, 0x60, 0x30, 0x00, 0x07, 0x80, 0x20, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x06, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x20,
  0x70, 0x3C, 0x01, 0xE0, 0xF0, 0x01, 0x0E, 0x00, 0x60, 0x1C, 0x01, 0xC0,
  0x18, 0xE0, 0x01, 0x83, 0x80, 0x07, 0x00, 0xCC, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x06, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC0, 0x26, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x18, 0x1E, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x3F, 0xF8, 0x00, 0x20, 0x7C, 0x0F, 0x00, 0x10, 0x70,
  0x01, 0xC0, 0x18, 0x60, 0x00, 0x60, 0x0C, 0x60, 0x00, 0x18, 0x06, 0x60,
  0x00, 0x0C, 0x02, 0x60, 0x00, 0x06, 0x03, 0x60, 0x00, 0x01, 0x01, 0xA0,
  0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x40, 0x70, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x04, 0x0F, 0x81, 0xC0,
  0x00, 0x20, 0xE0, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0x00, 0xCC, 0x00, 0x01, 0xC0, 0x04, 0xC0, 0x00, 0x06, 0x00,
  0x6C, 0x00, 0x00, 0x30, 0x03, 0x40, 0x00, 0x00, 0x80, 0x1E, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0xB0, 0x00,
  0x00, 0xC0, 0x0C, 0x80, 0x00, 0x0E, 0x00, 0x66, 0x00, 0x00, 0xE0, 0x03,
  0x18, 0x00, 0x0E, 0x00, 0x18, 0x60, 0x01, 0xE0, 0x00, 0x81, 0xE0, 0x3C,
  0x00, 0x0C, 0x07, 0xFF, 0x80, 0x00, 0x60, 0x03, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x40, 0x07, 0x80, 0xF0, 0x60, 0x0E, 0x00, 0x1C,
  0x30, 0x0E, 0x00, 0x07, 0x10, 0x0C, 0x00, 0x01, 0x88, 0x0C, 0x00, 0x00,
  0x6C, 0x0C, 0x00, 0x00, 0x36, 0x0E, 0x00, 0x00, 0x0B, 0x06, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x38, 0x20, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x0A, 0x06, 0x00, 0x00, 0x0F, 0x03,
  0x00, 0x00, 0x0D, 0x81, 0x80, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x0C, 0x60,
  0x30, 0x00, 0x0C, 0x20, 0x0C, 0x00, 0x0C, 0x30, 0x03, 0x00, 0x1C, 0x18,
  0x01, 0xE0, 0x3C, 0x0C, 0x00, 0x3F, 0xF8, 0x04, 0x00, 0x03, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x1F, 0xF0, 0x08, 0x1F,
  0x08, 0x02, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x60, 0x70, 0x00, 0x38, 0x07, 0xC0, 0x1E, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x03, 0x00, 0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x01, 0x40, 0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x06, 0xC0, 0xC0,
  0x00, 0x0C, 0xC0, 0xC0, 0x00, 0x1C, 0x80, 0xE0, 0x00, 0x38, 0x80, 0x60,
  0x00, 0x71, 0x80, 0x30, 0x01, 0xC1, 0x80, 0x3C, 0x07, 0x81, 0x80, 0x0F,
  0xFE, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x60, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x16, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x82, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x30,
  0x30, 0x01, 0x80, 0x40, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x60, 0x18, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x10, 0x04, 0x00,
  0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x08, 0x60, 0x00, 0x23, 0x00, 0x00, 0x8C,
  0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x26, 0x00, 0x00, 0xD8, 0x00,
  0x02, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x7C, 0x3C, 0x80, 0x00, 0x1F, 0xF8,
};

const GFXglyph NotoSans_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 13, 51, 15, 2, -50 },
  { 84, 15, 18, 22, 8, -50 },
  { 118, 42, 50, 43, 2, -50 },
  { 381, 32, 57, 39, 4, -53 },
  { 609, 44, 52, 53, 6, -51 },
  { 895, 42, 52, 48, 3, -51 },
  { 1168, 5, 18, 12, 8, -50 },
  { 1180, 20, 61, 17, 2, -50 },
  { 1333, 19, 61, 17, -4, -50 },
  { 1478, 28, 29, 37, 9, -53 },
  { 1580, 32, 32, 40, 5, -41 },
  { 1708, 9, 17, 13, -3, -8 },
  { 1728, 16, 2, 22, 3, -20 },
  { 1732, 4, 5, 15, 2, -4 },
  { 1735, 30, 50, 21, -3, -50 },
  { 1923, 32, 52, 39, 5, -51 },
  { 2131, 16, 50, 39, 12, -50 },
  { 2231, 34, 51, 39, 1, -51 },
  { 2448, 35, 52, 39, 2, -51 },
  { 2676, 36, 50, 39, 1, -50 },
  { 2901, 35, 51, 39, 3, -50 },
  { 3125, 33, 52, 39, 5, -51 },
  { 3340, 31, 50, 39, 8, -50 },
  { 3534, 34, 52, 39, 3, -51 },
  { 3755, 34, 52, 39, 3, -51 },
  { 3976, 11, 38, 15, 2, -37 },
  { 4029, 16, 46, 15, -3, -37 },
  { 4121, 32, 31, 40, 5, -41 },
  { 4245, 32, 16, 40, 5, -33 },
  { 4309, 32, 31, 40, 5, -41 },
  { 4433, 23, 52, 28, 6, -51 },
  { 4583, 52, 55, 58, 4, -49 },
  { 4941, 39, 50, 38, -4, -50 },
  { 5185, 38, 50, 42, 3, -50 },
  { 5423, 38, 52, 42, 6, -51 },
  { 5670, 42, 50, 47, 3, -50 },
  { 5933, 36, 50, 37, 3, -50 },
  { 6158, 36, 50, 34, 3, -50 },
  { 6383, 40, 52, 48, 6, -51 },
  { 6643, 44, 50, 48, 3, -50 },
  { 6918, 21, 50, 20, 1, -50 },
  { 7050, 28, 62, 16, -12, -50 },
  { 7267, 41, 50, 38, 3, -50 },
  { 7524, 26, 50, 34, 3, -50 },
  { 7687, 53, 50, 56, 3, -50 },
  { 8019, 44, 50, 47, 3, -50 },
  { 8294, 41, 52, 50, 6, -51 },
  { 8561, 36, 50, 39, 3, -50 },
  { 8786, 41, 63, 50, 6, -51 },
  { 9109, 36, 50, 39, 3, -50 },
  { 9334, 35, 52, 35, 1, -51 },
  { 9562, 33, 50, 34, 7, -50 },
  { 9769, 43, 51, 48, 6, -50 },
  { 10044, 36, 50, 37, 7, -50 },
  { 10269, 53, 50, 58, 9, -50 },
  { 10601, 43, 50, 34, -4, -50 },
  { 10870, 33, 50, 34, 7, -50 },
  { 11077, 41, 50, 38, -1, -50 },
  { 11334, 27, 61, 21, -1, -50 },
  { 11540, 11, 50, 21, 7, -50 },
  { 11609, 26, 61, 21, -5, -50 },
  { 11808, 32, 31, 39, 3, -50 },
  { 11932, 26, 1, 26, -6, 8 },
  { 11936, 8, 12, 16, 10, -54 },
  { 11948, 32, 39, 38, 4, -38 },
  { 12104, 34, 54, 40, 2, -53 },
  { 12334, 28, 39, 32, 4, -38 },
  { 12471, 37, 54, 40, 4, -53 },
  { 12721, 28, 39, 34, 4, -38 },
  { 12858, 38, 71, 18, -9, -54 },
  { 13196, 35, 55, 40, 2, -38 },
  { 13437, 33, 53, 39, 2, -53 },
  { 13656, 13, 50, 14, 2, -50 },
  { 13738, 25, 67, 14, -10, -50 },
  { 13948, 31, 53, 31, 2, -53 },
  { 14154, 13, 53, 14, 2, -53 },
  { 14241, 53, 38, 59, 2, -38 },
  { 14493, 33, 38, 39, 2, -38 },
  { 14650, 32, 39, 40, 4, -38 },
  { 14806, 37, 54, 40, -1, -38 },
  { 15056, 33, 54, 40, 4, -38 },
  { 15279, 26, 38, 26, 2, -38 },
  { 15403, 27, 39, 30, 1, -38 },
  { 15535, 19, 47, 22, 4, -46 },
  { 15647, 32, 38, 39, 4, -37 },
  { 15799, 29, 37, 29, 3, -37 },
  { 15934, 44, 37, 46, 4, -37 },
  { 16138, 35, 37, 32, -2, -37 },
  { 16300, 40, 54, 29, -8, -37 },
  { 16570, 32, 37, 31, -1, -37 },
  { 16718, 25, 61, 23, 2, -50 },
  { 16909, 1, 70, 37, 20, -53 },
  { 16918, 25, 61, 23, -4, -50 },
  { 17109, 32, 6, 40, 5, -28 },
};

const GFXfont NotoSans_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_THINITALIC70PT7B_H_
