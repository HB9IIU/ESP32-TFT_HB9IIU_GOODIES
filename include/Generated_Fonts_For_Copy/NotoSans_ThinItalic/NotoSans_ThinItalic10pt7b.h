#ifndef _NOTOSANS_THINITALIC10PT7B_H_
#define _NOTOSANS_THINITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x14, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x27, 0xAA,
  0x65, 0x5E, 0x40, 0xE6, 0xAB, 0xBD, 0x35, 0x59, 0xC0, 0x38, 0xA3, 0x98,
  0x96, 0x2F, 0x40, 0xC0, 0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x4A, 0x80,
  0x2A, 0x7E, 0x10, 0x22, 0xF2, 0x20, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x48,
  0x80, 0x79, 0x99, 0x99, 0xE0, 0xD5, 0xA8, 0x78, 0x42, 0x22, 0x23, 0xC0,
  0x78, 0x42, 0x60, 0x87, 0xC0, 0x08, 0xCA, 0x9F, 0x88, 0x40, 0x3A, 0x1C,
  0x10, 0x87, 0xC0, 0x78, 0xE9, 0x99, 0xE0, 0xF8, 0x88, 0x44, 0x22, 0x00,
  0x3A, 0x4A, 0xE8, 0xC5, 0xC0, 0x7A, 0x52, 0x93, 0x87, 0xC0, 0x40, 0x80,
  0x40, 0xA0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4, 0xA8,
  0x20, 0x7D, 0x06, 0xEE, 0x5C, 0xBF, 0xA0, 0x3C, 0x08, 0x51, 0x49, 0x3D,
  0x18, 0x40, 0x3D, 0x14, 0x5E, 0x46, 0x1F, 0x80, 0x7C, 0x21, 0x08, 0x43,
  0xC0, 0x3D, 0x14, 0x51, 0x46, 0x1F, 0x80, 0x3D, 0x04, 0x1E, 0x42, 0x0F,
  0x00, 0x3D, 0x04, 0x1E, 0x42, 0x08, 0x00, 0x7E, 0x08, 0x26, 0x8A, 0x2F,
  0x80, 0x22, 0x85, 0x0B, 0xE4, 0x50, 0xA1, 0x00, 0x25, 0x24, 0xB0, 0x11,
  0x11, 0x12, 0x22, 0xC0, 0x25, 0x25, 0x18, 0x52, 0x48, 0x80, 0x24, 0x44,
  0x48, 0xF0, 0x21, 0x21, 0x62, 0x65, 0x5A, 0x92, 0x92, 0x42, 0xC5, 0x52,
  0xA4, 0xD1, 0xA1, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x2F, 0x00, 0x3D, 0x14,
  0x5E, 0x42, 0x08, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x2D, 0x08, 0x10, 0x3D,
  0x14, 0x5E, 0x52, 0x28, 0x80, 0x7A, 0x10, 0x60, 0x87, 0xC0, 0xF9, 0x10,
  0x84, 0x22, 0x00, 0x86, 0x18, 0x61, 0x8A, 0x2F, 0x00, 0x8C, 0x65, 0x4A,
  0x62, 0x00, 0x91, 0x91, 0xAA, 0xAA, 0xCC, 0x48, 0x88, 0x26, 0x48, 0x60,
  0x82, 0x89, 0x22, 0x00, 0x8C, 0xA8, 0x84, 0x22, 0x00, 0x3C, 0x21, 0x08,
  0x41, 0x0F, 0x00, 0x74, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x94, 0x31, 0x11,
  0x22, 0x22, 0xC0, 0x11, 0x53, 0x90, 0xF0, 0x90, 0xF9, 0x99, 0xE0, 0x22,
  0x14, 0xD4, 0xC6, 0x3E, 0xF8, 0x88, 0xE0, 0x08, 0x5B, 0x29, 0x4A, 0x5C,
  0xF9, 0xE8, 0xE0, 0x19, 0x0C, 0x42, 0x11, 0x08, 0x46, 0x00, 0x7C, 0x63,
  0x1F, 0x0B, 0xC0, 0x22, 0x14, 0xD4, 0xC6, 0x31, 0x05, 0xA8, 0x00, 0x94,
  0x92, 0xC0, 0x22, 0x12, 0xA6, 0x32, 0x92, 0x55, 0x6A, 0x7F, 0x49, 0x89,
  0x91, 0x92, 0x7A, 0x63, 0x18, 0x80, 0xF9, 0x99, 0xE0, 0x7A, 0x63, 0x1F,
  0x42, 0x00, 0xF9, 0x99, 0xE2, 0x20, 0x74, 0x88, 0x80, 0x74, 0x21, 0xE0,
  0xBA, 0xA8, 0x99, 0x99, 0xE0, 0x9C, 0x98, 0x84, 0x00, 0xA7, 0xAA, 0xA4,
  0x90, 0x5B, 0x08, 0xC9, 0x00, 0x4D, 0x23, 0x08, 0x20, 0x8C, 0x00, 0x72,
  0x44, 0xE0, 0x32, 0x44, 0xC4, 0x48, 0x40, 0xFF, 0xC0, 0x31, 0x11, 0x12,
  0x22, 0xC0, 0xF0,
};

const GFXglyph NotoSans_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 6, 7, 8, 1, -7 },
  { 21, 6, 7, 7, 0, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 3, 9, 2, 0, -7 },
  { 32, 3, 9, 2, -1, -7 },
  { 36, 4, 5, 5, 1, -8 },
  { 39, 4, 5, 6, 1, -6 },
  { 42, 1, 2, 2, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 1, 1, 2, 0, -1 },
  { 45, 4, 7, 3, 0, -7 },
  { 49, 4, 7, 6, 1, -7 },
  { 53, 2, 7, 6, 2, -7 },
  { 55, 5, 7, 6, 0, -7 },
  { 60, 5, 7, 6, 0, -7 },
  { 65, 5, 7, 6, 0, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 4, 7, 6, 1, -7 },
  { 79, 5, 7, 6, 1, -7 },
  { 84, 5, 7, 6, 0, -7 },
  { 89, 5, 7, 6, 0, -7 },
  { 94, 2, 5, 2, 0, -5 },
  { 96, 2, 6, 2, 0, -5 },
  { 98, 4, 5, 6, 1, -6 },
  { 101, 4, 3, 6, 1, -5 },
  { 103, 4, 5, 6, 1, -6 },
  { 106, 3, 7, 4, 1, -7 },
  { 109, 7, 8, 8, 1, -7 },
  { 116, 6, 7, 5, -1, -7 },
  { 122, 6, 7, 6, 0, -7 },
  { 128, 5, 7, 6, 1, -7 },
  { 133, 6, 7, 7, 0, -7 },
  { 139, 6, 7, 5, 0, -7 },
  { 145, 6, 7, 5, 0, -7 },
  { 151, 6, 7, 7, 1, -7 },
  { 157, 7, 7, 7, 0, -7 },
  { 164, 3, 7, 3, 0, -7 },
  { 167, 4, 9, 2, -2, -7 },
  { 172, 6, 7, 5, 0, -7 },
  { 178, 4, 7, 5, 0, -7 },
  { 182, 8, 7, 8, 0, -7 },
  { 189, 7, 7, 7, 0, -7 },
  { 196, 6, 7, 7, 1, -7 },
  { 202, 6, 7, 6, 0, -7 },
  { 208, 6, 9, 7, 1, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 5, 7, 5, 0, -7 },
  { 226, 5, 7, 5, 1, -7 },
  { 231, 6, 7, 7, 1, -7 },
  { 237, 5, 7, 5, 1, -7 },
  { 242, 8, 7, 8, 1, -7 },
  { 249, 7, 7, 5, -1, -7 },
  { 256, 5, 7, 5, 1, -7 },
  { 261, 6, 7, 5, 0, -7 },
  { 267, 4, 9, 3, 0, -7 },
  { 272, 2, 7, 3, 1, -7 },
  { 274, 4, 9, 3, -1, -7 },
  { 279, 5, 4, 6, 0, -7 },
  { 282, 4, 1, 4, -1, 1 },
  { 283, 2, 2, 2, 1, -8 },
  { 284, 4, 5, 5, 1, -5 },
  { 287, 5, 8, 6, 0, -8 },
  { 292, 4, 5, 5, 1, -5 },
  { 295, 5, 8, 6, 1, -8 },
  { 300, 4, 5, 5, 1, -5 },
  { 303, 5, 10, 3, -1, -8 },
  { 310, 5, 7, 6, 0, -5 },
  { 315, 5, 8, 6, 0, -8 },
  { 320, 2, 7, 2, 0, -7 },
  { 322, 3, 9, 2, -1, -7 },
  { 326, 5, 8, 4, 0, -8 },
  { 331, 2, 8, 2, 0, -8 },
  { 333, 8, 5, 8, 0, -5 },
  { 338, 5, 5, 6, 0, -5 },
  { 342, 4, 5, 6, 1, -5 },
  { 345, 5, 7, 6, 0, -5 },
  { 350, 4, 7, 6, 1, -5 },
  { 354, 4, 5, 4, 0, -5 },
  { 357, 4, 5, 4, 0, -5 },
  { 360, 2, 7, 3, 1, -7 },
  { 362, 4, 5, 6, 1, -5 },
  { 365, 5, 5, 4, 0, -5 },
  { 369, 6, 5, 7, 1, -5 },
  { 373, 5, 5, 5, 0, -5 },
  { 377, 6, 7, 4, -1, -5 },
  { 383, 4, 5, 4, 0, -5 },
  { 386, 4, 9, 3, 0, -7 },
  { 391, 1, 10, 5, 2, -8 },
  { 393, 4, 9, 3, -1, -7 },
  { 398, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_THINITALIC10PT7B_H_
