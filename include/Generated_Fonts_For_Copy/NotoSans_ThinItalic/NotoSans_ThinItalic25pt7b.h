#ifndef _NOTOSANS_THINITALIC25PT7B_H_
#define _NOTOSANS_THINITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x00, 0x08, 0x4A, 0x63,
  0x19, 0x4A, 0x40, 0x01, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x41,
  0x00, 0x84, 0x1F, 0xFF, 0x82, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00,
  0x82, 0x0F, 0xFB, 0x82, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42,
  0x00, 0x00, 0x80, 0x08, 0x07, 0xE0, 0x91, 0x11, 0x02, 0x10, 0x21, 0x02,
  0x20, 0x12, 0x00, 0xE0, 0x03, 0x80, 0x24, 0x04, 0x40, 0x44, 0x04, 0x40,
  0x44, 0x89, 0x87, 0xE0, 0x08, 0x00, 0x80, 0x1C, 0x02, 0x22, 0x04, 0x42,
  0x08, 0x42, 0x08, 0x82, 0x10, 0x82, 0x20, 0x82, 0x40, 0x82, 0x5E, 0x84,
  0xA1, 0x85, 0x21, 0x7A, 0x41, 0x02, 0x41, 0x04, 0x41, 0x08, 0x42, 0x10,
  0x82, 0x10, 0x82, 0x20, 0x44, 0x40, 0x78, 0x03, 0xE0, 0x08, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x81, 0x01, 0x04, 0x01, 0x10, 0x02, 0xC0, 0x06, 0x00,
  0x32, 0x00, 0x84, 0x0A, 0x04, 0x28, 0x04, 0x50, 0x05, 0x20, 0x0C, 0x40,
  0x18, 0x40, 0xC8, 0x7E, 0x18, 0x5A, 0xA8, 0x06, 0x08, 0x20, 0x82, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x04, 0x08, 0x00, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x18, 0x00, 0x02,
  0x01, 0x08, 0x41, 0x10, 0x34, 0x03, 0xF1, 0x40, 0x90, 0x42, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x25, 0x25, 0x00, 0xFC, 0x80, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00,
  0x0F, 0x82, 0x08, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x0F,
  0xC0, 0x04, 0x72, 0x71, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x80, 0x03, 0xE0, 0x60, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x07, 0xFF, 0x00, 0x07, 0xE1, 0x81,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x80, 0x8F, 0xF0,
  0x00, 0x18, 0x01, 0x40, 0x0C, 0x00, 0xA0, 0x09, 0x00, 0x88, 0x08, 0x40,
  0x84, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x8F, 0xFF, 0x80, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x03, 0xF0, 0x20, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x80, 0x8F, 0xF0, 0x03, 0xF0, 0xC0,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x09, 0xF0, 0xA0, 0x8C, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03, 0xE0,
  0xFF, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x00, 0x07, 0xE0, 0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x20,
  0xCC, 0x03, 0x01, 0xC8, 0x20, 0x44, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x40, 0xC3, 0xF0, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x20, 0x32, 0x05, 0x1F, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x03, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x41,
  0x04, 0x20, 0x00, 0x20, 0x08, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x7E, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x08, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x04, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x70, 0x60, 0x10,
  0x02, 0x04, 0x00, 0x21, 0x00, 0x02, 0x40, 0xF0, 0x50, 0x21, 0x0A, 0x08,
  0x21, 0x42, 0x04, 0x30, 0x80, 0x86, 0x10, 0x20, 0xC2, 0x04, 0x18, 0x41,
  0x85, 0x08, 0x31, 0x10, 0xFB, 0x42, 0x00, 0x10, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01,
  0x40, 0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04, 0x10, 0x20, 0x83, 0xFE,
  0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x40,
  0x0F, 0xE0, 0x20, 0x61, 0x00, 0x84, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00,
  0x88, 0x0C, 0x3F, 0xC0, 0x80, 0x82, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x44, 0x01, 0x10, 0x08, 0x80, 0x43, 0xFE, 0x00, 0x03, 0xF8, 0x30, 0x11,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x10, 0x30, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x0A, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x04, 0x20, 0x10, 0x80, 0xC1,
  0xFE, 0x00, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x3F, 0xE1, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x40, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0xFF,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x03, 0xFC, 0x08, 0x04, 0x60, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFA, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x20, 0x08, 0x20, 0x10, 0x3F, 0xC0,
  0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x20, 0x02, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x08, 0x80, 0x10,
  0x0F, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x3C, 0x00, 0x08, 0x06,
  0x10, 0x10, 0x40, 0x40, 0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0xC0, 0x12,
  0x00, 0x2A, 0x00, 0x64, 0x00, 0x84, 0x02, 0x08, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x40, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x7F, 0xC0, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x50, 0x02,
  0x8A, 0x00, 0x61, 0x40, 0x14, 0x28, 0x02, 0x85, 0x00, 0x91, 0x20, 0x22,
  0x22, 0x04, 0x84, 0x41, 0x10, 0x88, 0x22, 0x21, 0x08, 0x44, 0x22, 0x08,
  0x82, 0x42, 0x10, 0x50, 0x42, 0x0A, 0x08, 0x81, 0x81, 0x10, 0x20, 0x20,
  0x08, 0x01, 0x08, 0x01, 0x14, 0x02, 0x14, 0x02, 0x12, 0x02, 0x12, 0x02,
  0x12, 0x02, 0x21, 0x04, 0x21, 0x04, 0x20, 0x84, 0x20, 0x84, 0x40, 0x48,
  0x40, 0x48, 0x40, 0x48, 0x40, 0x28, 0x40, 0x28, 0x80, 0x10, 0x80, 0x10,
  0x07, 0xF0, 0x10, 0x10, 0x40, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x02, 0x20, 0x08, 0x20, 0x20, 0x3F, 0x80, 0x0F, 0xE0,
  0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x02, 0x20,
  0x31, 0x0E, 0x0F, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x10, 0x40, 0x11, 0x00, 0x24,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x20, 0x08, 0x20, 0x20,
  0x3B, 0x80, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0xE0,
  0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x02, 0x20,
  0x21, 0xFE, 0x08, 0x40, 0x81, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08,
  0x80, 0x44, 0x01, 0x00, 0x07, 0xF0, 0x40, 0x44, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC7, 0xF8, 0x00, 0xFF, 0xF0,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x10, 0x40, 0x40, 0x7F, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x41,
  0x04, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x60,
  0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x01, 0x40, 0x60, 0x28,
  0x12, 0x09, 0x02, 0x41, 0x20, 0x88, 0x24, 0x11, 0x08, 0x84, 0x21, 0x10,
  0x84, 0x42, 0x20, 0x88, 0x44, 0x12, 0x05, 0x02, 0x40, 0xA0, 0x50, 0x18,
  0x0A, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x00, 0x08, 0x02, 0x10,
  0x08, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0x90, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x84, 0x02, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x40, 0x21, 0x00, 0x20, 0x80, 0x14, 0x01, 0x40, 0x24,
  0x04, 0x20, 0x82, 0x08, 0x21, 0x02, 0x20, 0x12, 0x01, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x0F, 0xFC,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x0F, 0x84, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x07, 0xC0, 0x88, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x21, 0x11, 0x11, 0x07, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x3E, 0x00, 0x00, 0x80, 0x18, 0x02,
  0x80, 0x44, 0x04, 0x40, 0x84, 0x10, 0x21, 0x02, 0x20, 0x24, 0x02, 0xC0,
  0x10, 0xFF, 0x80, 0xA5, 0x0F, 0x91, 0x05, 0x20, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x80, 0xC4, 0x18, 0x3E, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x18, 0x26, 0x42, 0x82,
  0x30, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02,
  0xC0, 0x4C, 0x08, 0xBF, 0x00, 0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x0C, 0x20, 0xCD, 0x04, 0x0C,
  0x20, 0x31, 0x00, 0x44, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x20, 0x10, 0x80, 0xC1, 0x05, 0x03, 0xE4, 0x00, 0x1F, 0x90, 0x50, 0x30,
  0x18, 0x0C, 0x33, 0xE1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x07, 0xF0, 0x00,
  0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x90, 0x3F, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0xE0, 0x00, 0x0F, 0xD1, 0x03, 0x20, 0x34, 0x01, 0x40, 0x28,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x14, 0x3E, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x08, 0x20, 0xFC, 0x00, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x43, 0x09, 0x99, 0x41, 0x30, 0x24, 0x04, 0x80,
  0xA0, 0x14, 0x02, 0x80, 0x50, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x00,
  0x11, 0x00, 0x02, 0x22, 0x24, 0x44, 0x44, 0x88, 0x88, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x41, 0xC0,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x48, 0x11, 0x04, 0x21,
  0x04, 0x41, 0x10, 0x24, 0x05, 0x80, 0xC8, 0x11, 0x04, 0x10, 0x82, 0x10,
  0x22, 0x06, 0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88,
  0x80, 0x27, 0xC7, 0xC5, 0x0B, 0x04, 0xC0, 0xC0, 0x90, 0x10, 0x14, 0x02,
  0x02, 0x80, 0x80, 0x90, 0x10, 0x12, 0x02, 0x02, 0x40, 0x40, 0x50, 0x10,
  0x12, 0x02, 0x02, 0x40, 0x40, 0x48, 0x08, 0x08, 0x27, 0xE5, 0x04, 0xC0,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x04, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x40, 0x44, 0x08, 0x3F, 0x00, 0x13, 0xE0,
  0xA0, 0x86, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x98, 0x08, 0xC0, 0x85, 0xF8, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x0F, 0xD1, 0x03, 0x20, 0x34, 0x01, 0x40,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x14, 0x3E,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x27, 0x94,
  0x0C, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x00, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x04, 0xFE, 0x00, 0x10, 0x20, 0x87, 0xF2, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x3C, 0x20, 0x12, 0x01, 0x20,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x80, 0x48, 0x04, 0x80,
  0xC4, 0x14, 0x7E, 0x80, 0x80, 0x60, 0x18, 0x09, 0x04, 0x41, 0x10, 0x84,
  0x21, 0x10, 0x44, 0x0A, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x44, 0x88, 0x48, 0x88, 0x48,
  0x88, 0x50, 0x50, 0x50, 0x50, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0x10,
  0x18, 0x41, 0x02, 0x10, 0x08, 0x80, 0x48, 0x01, 0x80, 0x08, 0x00, 0xA0,
  0x09, 0x00, 0x84, 0x08, 0x20, 0x80, 0x8C, 0x04, 0x00, 0x08, 0x04, 0x20,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x0F,
  0xF8, 0x03, 0x82, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x10, 0x18, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x70, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x03, 0x06, 0x00, 0x78, 0x30, 0xFC,
};

const GFXglyph NotoSans_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 18, 5, 1, -18 },
  { 10, 5, 7, 8, 3, -18 },
  { 15, 15, 18, 15, 1, -18 },
  { 49, 12, 20, 14, 1, -19 },
  { 79, 16, 18, 19, 2, -18 },
  { 115, 15, 18, 17, 1, -18 },
  { 149, 2, 7, 4, 3, -18 },
  { 151, 7, 22, 6, 1, -18 },
  { 171, 7, 22, 6, -2, -18 },
  { 191, 10, 11, 13, 3, -19 },
  { 205, 11, 12, 14, 2, -15 },
  { 222, 3, 6, 5, -1, -3 },
  { 225, 6, 1, 8, 1, -7 },
  { 226, 1, 1, 5, 1, -1 },
  { 227, 11, 18, 8, -1, -18 },
  { 252, 11, 18, 14, 2, -18 },
  { 277, 6, 18, 14, 4, -18 },
  { 291, 13, 18, 14, 0, -18 },
  { 321, 12, 18, 14, 1, -18 },
  { 348, 13, 18, 14, 0, -18 },
  { 378, 12, 18, 14, 1, -18 },
  { 405, 12, 18, 14, 2, -18 },
  { 432, 11, 18, 14, 3, -18 },
  { 457, 12, 18, 14, 1, -18 },
  { 484, 12, 18, 14, 1, -18 },
  { 511, 4, 13, 5, 1, -13 },
  { 518, 6, 16, 5, -1, -13 },
  { 530, 11, 12, 14, 2, -15 },
  { 547, 11, 6, 14, 2, -12 },
  { 556, 11, 12, 14, 2, -15 },
  { 573, 9, 18, 10, 2, -18 },
  { 594, 19, 20, 21, 1, -18 },
  { 642, 13, 18, 14, -1, -18 },
  { 672, 14, 18, 15, 1, -18 },
  { 704, 14, 18, 15, 2, -18 },
  { 736, 15, 18, 17, 1, -18 },
  { 770, 13, 18, 13, 1, -18 },
  { 800, 13, 18, 12, 1, -18 },
  { 830, 15, 18, 17, 2, -18 },
  { 864, 16, 18, 17, 1, -18 },
  { 900, 8, 18, 7, 0, -18 },
  { 918, 10, 22, 6, -4, -18 },
  { 946, 15, 18, 14, 1, -18 },
  { 980, 9, 18, 12, 1, -18 },
  { 1001, 19, 18, 20, 1, -18 },
  { 1044, 16, 18, 17, 1, -18 },
  { 1080, 15, 18, 18, 2, -18 },
  { 1114, 13, 18, 14, 1, -18 },
  { 1144, 15, 22, 18, 2, -18 },
  { 1186, 13, 18, 14, 1, -18 },
  { 1216, 13, 18, 12, 0, -18 },
  { 1246, 12, 18, 12, 2, -18 },
  { 1273, 15, 18, 17, 2, -18 },
  { 1307, 12, 18, 13, 3, -18 },
  { 1334, 19, 18, 21, 3, -18 },
  { 1377, 15, 18, 12, -1, -18 },
  { 1411, 12, 18, 12, 2, -18 },
  { 1438, 14, 18, 13, 0, -18 },
  { 1470, 9, 22, 8, 0, -18 },
  { 1495, 4, 18, 8, 2, -18 },
  { 1504, 10, 22, 8, -2, -18 },
  { 1532, 12, 11, 14, 1, -18 },
  { 1549, 9, 1, 9, -2, 3 },
  { 1551, 2, 4, 6, 4, -19 },
  { 1552, 12, 13, 14, 1, -13 },
  { 1572, 12, 19, 14, 1, -19 },
  { 1601, 10, 13, 11, 1, -13 },
  { 1618, 14, 19, 14, 1, -19 },
  { 1652, 9, 13, 12, 2, -13 },
  { 1667, 13, 25, 7, -3, -19 },
  { 1708, 12, 19, 14, 1, -13 },
  { 1737, 11, 19, 14, 1, -19 },
  { 1764, 4, 18, 5, 1, -18 },
  { 1773, 9, 24, 5, -4, -18 },
  { 1800, 11, 19, 11, 1, -19 },
  { 1827, 4, 19, 5, 1, -19 },
  { 1837, 19, 13, 21, 1, -13 },
  { 1868, 11, 13, 14, 1, -13 },
  { 1886, 12, 13, 14, 1, -13 },
  { 1906, 13, 19, 14, 0, -13 },
  { 1937, 12, 19, 14, 1, -13 },
  { 1966, 9, 13, 9, 1, -13 },
  { 1981, 10, 13, 11, 0, -13 },
  { 1998, 7, 16, 8, 1, -16 },
  { 2012, 12, 13, 14, 1, -13 },
  { 2032, 10, 13, 10, 1, -13 },
  { 2049, 16, 13, 16, 1, -13 },
  { 2075, 13, 13, 11, -1, -13 },
  { 2097, 14, 19, 10, -3, -13 },
  { 2131, 11, 13, 11, 0, -13 },
  { 2149, 9, 22, 8, 1, -18 },
  { 2174, 1, 25, 13, 7, -19 },
  { 2178, 9, 22, 8, -1, -18 },
  { 2203, 11, 2, 14, 2, -10 },
};

const GFXfont NotoSans_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_THINITALIC25PT7B_H_
