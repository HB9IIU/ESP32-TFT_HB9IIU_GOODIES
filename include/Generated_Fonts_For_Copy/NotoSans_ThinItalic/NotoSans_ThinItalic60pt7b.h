#ifndef _NOTOSANS_THINITALIC60PT7B_H_
#define _NOTOSANS_THINITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x10, 0x19, 0x80, 0x8C, 0x0C, 0x60, 0x62, 0x03, 0x10, 0x11, 0x80,
  0x8C, 0x0C, 0x40, 0x62, 0x03, 0x10, 0x11, 0x80, 0x8C, 0x0C, 0x40, 0x62,
  0x02, 0x10, 0x10, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x63,
  0xF0, 0x06, 0x06, 0x02, 0x01, 0xC0, 0x40, 0x00, 0x18, 0x04, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x08,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x20, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x08, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x10, 0x18, 0x0E, 0x03, 0x0F, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x30, 0x1C, 0x38, 0x00, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x03, 0x00, 0x80, 0x18, 0x00, 0x10, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x40, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x08, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x06, 0x00,
  0x20, 0x00, 0x80, 0x60, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x00, 0x10, 0x30, 0x7E, 0x30,
  0x01, 0x83, 0x07, 0x3D, 0x80, 0x0C, 0x10, 0x60, 0x6C, 0x00, 0xC1, 0x86,
  0x01, 0xE0, 0x06, 0x18, 0x60, 0x0D, 0x00, 0x61, 0x82, 0x00, 0x2C, 0x06,
  0x08, 0x30, 0x01, 0x30, 0x60, 0xC1, 0x00, 0x08, 0xFE, 0x0C, 0x18, 0x00,
  0x40, 0x00, 0xC0, 0xC0, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x60, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x80, 0x03, 0x00, 0x30, 0x04, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x00, 0x80, 0x30, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x06, 0x01, 0x80, 0x02, 0x00, 0x30, 0x08, 0x00, 0x10, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x38, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x10,
  0x07, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x02, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x21, 0xC0, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0xC0, 0x01, 0x18, 0x00,
  0x18, 0x00, 0x63, 0x00, 0x01, 0x80, 0x08, 0xC0, 0x00, 0x18, 0x03, 0x10,
  0x00, 0x01, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x10, 0xC0, 0x00, 0x03, 0x06,
  0x18, 0x00, 0x00, 0x31, 0x82, 0x00, 0x00, 0x02, 0x60, 0x40, 0x00, 0x00,
  0x78, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x30, 0x00,
  0x00, 0x6C, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x70, 0x00, 0x0C, 0x0C, 0x07,
  0x00, 0x07, 0x00, 0x80, 0x78, 0x07, 0x80, 0x18, 0x03, 0xFF, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x13, 0x33, 0x22, 0x66, 0x44, 0x4C, 0xC8,
  0x88, 0x00, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x08, 0x00, 0x70, 0x08, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x10,
  0x00, 0x03, 0x90, 0x01, 0x00, 0xD0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0xC8, 0x00, 0x01, 0x88, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x04,
  0x00, 0x1C, 0x06, 0x00, 0x38, 0x02, 0x00, 0x70, 0x03, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30,
  0x60, 0x40, 0xC0, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x32, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x07, 0xC0, 0x33, 0x03, 0x8C, 0x18, 0x21, 0xC1, 0x8C,
  0x06, 0xE0, 0x1A, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x0E, 0x00, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x80, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0,
  0x04, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x0F, 0xFC, 0x00, 0x61,
  0xE0, 0x78, 0x02, 0x38, 0x00, 0xE0, 0x13, 0x00, 0x01, 0x81, 0xB0, 0x00,
  0x0C, 0x0F, 0x00, 0x00, 0x30, 0x50, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04,
  0x38, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x38, 0x00, 0x70, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0F, 0x08, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x1A, 0x06, 0x00, 0x07,
  0x60, 0x30, 0x00, 0xC6, 0x01, 0xC0, 0x78, 0x40, 0x0F, 0xFE, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03,
  0x81, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xE0, 0x38, 0x10, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0x86, 0x00, 0x07, 0x01, 0xE0, 0x0C,
  0x60, 0x00, 0xE0, 0x02, 0x00, 0x23, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x09, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x48, 0x00,
  0xC0, 0x00, 0x40, 0x02, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x16, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xB0, 0x03, 0x00, 0x01, 0x00, 0x0D, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x68, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x16, 0x00, 0x40, 0x00, 0x20, 0x01, 0xB0, 0x02, 0x00, 0x03, 0x00,
  0x0D, 0x80, 0x10, 0x00, 0x18, 0x00, 0x4C, 0x00, 0x80, 0x01, 0xC0, 0x06,
  0x60, 0x04, 0x00, 0x0E, 0x00, 0x63, 0x00, 0x30, 0x00, 0xB0, 0x03, 0x08,
  0x01, 0x80, 0x0D, 0x80, 0x30, 0x40, 0x06, 0x00, 0xC4, 0x03, 0x03, 0x00,
  0x38, 0x1C, 0x30, 0x70, 0x18, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x40, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x07, 0x00, 0x40, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0x70, 0x00, 0x40, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x10, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xC6, 0x00, 0x01,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x10, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xE0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x81,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x08, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x03, 0x1B, 0x00, 0x00, 0x00, 0x46, 0x60, 0x00,
  0x00, 0x09, 0x86, 0x00, 0x00, 0x03, 0x60, 0xC0, 0x00, 0x00, 0x78, 0x0C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xA0,
  0x0D, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x68, 0x00, 0x00, 0x00, 0xD8, 0x02,
  0x40, 0x00, 0x00, 0x06, 0xC0, 0x33, 0x00, 0x00, 0x00, 0x66, 0x01, 0x98,
  0x00, 0x00, 0x02, 0x20, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x62, 0x00,
  0x00, 0x03, 0x18, 0x02, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x30, 0xC0, 0x00,
  0x01, 0x84, 0x01, 0x86, 0x00, 0x00, 0x08, 0x20, 0x0C, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x18, 0x02, 0x04, 0x00, 0x00, 0x60,
  0xC0, 0x30, 0x20, 0x00, 0x06, 0x04, 0x01, 0x81, 0x80, 0x00, 0x20, 0x20,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x02,
  0x01, 0x00, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x00, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0x40, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x80, 0x30, 0x00, 0x81, 0x80, 0x04, 0x01, 0x80, 0x04, 0x08, 0x00, 0x60,
  0x08, 0x00, 0x20, 0xC0, 0x03, 0x00, 0x40, 0x01, 0x8C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x60, 0x00, 0x80, 0x30, 0x00, 0x66, 0x00, 0x04, 0x01, 0x80,
  0x01, 0x20, 0x00, 0x60, 0x08, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x00, 0x80, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x0F, 0x00,
  0x00, 0x01, 0x00, 0x4C, 0x00, 0x00, 0x18, 0x02, 0x60, 0x00, 0x00, 0xC0,
  0x31, 0x00, 0x00, 0x06, 0x01, 0x8C, 0x00, 0x00, 0x20, 0x0C, 0x20, 0x00,
  0x01, 0x00, 0x41, 0x80, 0x00, 0x18, 0x02, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x30, 0x00, 0x06, 0x01, 0x81, 0x80, 0x00, 0x20, 0x0C, 0x04, 0x00, 0x01,
  0x00, 0x40, 0x30, 0x00, 0x18, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x04, 0x01, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x40, 0x06, 0x00, 0x18, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x04, 0x01, 0x80, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x40,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x04,
  0x01, 0x80, 0x00, 0x40, 0x20, 0x08, 0x00, 0x03, 0x03, 0x00, 0x40, 0x00,
  0x08, 0x18, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x30, 0x00, 0x03, 0x04, 0x01,
  0x80, 0x00, 0x08, 0x20, 0x08, 0x00, 0x00, 0x63, 0x00, 0x40, 0x00, 0x01,
  0x18, 0x06, 0x00, 0x00, 0x0C, 0x80, 0x30, 0x00, 0x00, 0x24, 0x01, 0x80,
  0x00, 0x01, 0xA0, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00, 0x01,
  0xC0, 0x10, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x01, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x03, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x03, 0xE0, 0x07,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x80, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x90, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x98, 0x00, 0x03,
  0x10, 0x00, 0x06, 0x60, 0x00, 0x18, 0x40, 0x00, 0x11, 0x80, 0x00, 0x61,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x04, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x20, 0x00, 0x20, 0x60, 0x00, 0x60, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x02, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x20, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80, 0x06, 0x01, 0x80, 0x0C,
  0x02, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x02, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x08, 0x02, 0x00, 0x30,
  0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x40, 0x03, 0x01,
  0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30,
  0x00, 0x20, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x31, 0x80, 0x00, 0x43, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x20, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFE, 0xC1, 0x81, 0x83,
  0x03, 0x02, 0x06, 0x06, 0x04, 0x04, 0x00, 0x0F, 0xF0, 0x30, 0x07, 0x83,
  0x82, 0x00, 0xE0, 0x0C, 0x20, 0x18, 0x00, 0x62, 0x03, 0x00, 0x03, 0x60,
  0x60, 0x00, 0x16, 0x0C, 0x00, 0x01, 0x40, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x01, 0xC1, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x03,
  0x40, 0x60, 0x00, 0x24, 0x06, 0x00, 0x04, 0x40, 0x30, 0x01, 0x8C, 0x03,
  0x00, 0x30, 0x80, 0x1C, 0x0E, 0x08, 0x00, 0xFF, 0x80, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x60, 0xF0, 0xF0,
  0x03, 0x0C, 0x00, 0xC0, 0x11, 0x80, 0x03, 0x00, 0x98, 0x00, 0x18, 0x04,
  0x80, 0x00, 0x60, 0x68, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x08, 0x1C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x02, 0x0F,
  0x00, 0x00, 0x30, 0x58, 0x00, 0x03, 0x02, 0x40, 0x00, 0x30, 0x13, 0x00,
  0x03, 0x01, 0x8C, 0x00, 0x30, 0x0C, 0x38, 0x0F, 0x00, 0x40, 0xFF, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x0F, 0x00,
  0xE0, 0x01, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x07,
  0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x3C, 0x1C, 0x18,
  0x00, 0xE0, 0x06, 0x10, 0x01, 0x80, 0x03, 0x10, 0x03, 0x00, 0x01, 0xB0,
  0x06, 0x00, 0x00, 0xB0, 0x0C, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1B, 0x00,
  0x40, 0x00, 0x32, 0x00, 0x60, 0x00, 0x62, 0x00, 0x30, 0x00, 0xC6, 0x00,
  0x30, 0x01, 0x86, 0x00, 0x1C, 0x07, 0x04, 0x00, 0x0F, 0xFC, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x70, 0x03, 0x80,
  0x30, 0x0C, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0x43, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x64, 0x00, 0x03, 0x88, 0x00, 0x1E, 0x30, 0x03, 0xF0, 0x7F,
  0xFF, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x04, 0x03, 0x80, 0x78, 0x01, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x0C, 0x00, 0x78, 0x38, 0x30, 0x07, 0x00, 0x30, 0x80, 0x30,
  0x00, 0x62, 0x01, 0x80, 0x00, 0xC8, 0x0C, 0x00, 0x01, 0x60, 0x60, 0x00,
  0x07, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xA0, 0x60, 0x00, 0x07, 0x81, 0x80, 0x00, 0x36,
  0x02, 0x00, 0x00, 0x90, 0x0C, 0x00, 0x0C, 0x40, 0x18, 0x00, 0x63, 0x00,
  0x60, 0x03, 0x0C, 0x00, 0xE0, 0x38, 0x20, 0x01, 0xFF, 0x80, 0x80, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x70, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x01, 0xFF, 0x00, 0x30, 0x78, 0x78,
  0x03, 0x0C, 0x00, 0xC0, 0x23, 0x80, 0x06, 0x02, 0x60, 0x00, 0x60, 0x24,
  0x00, 0x02, 0x06, 0x80, 0x00, 0x30, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x04, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x20, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x08,
  0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x00, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x31, 0xB0, 0x00, 0x06, 0x66, 0x00, 0x00, 0x98, 0x60, 0x00, 0x16, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x00, 0x01, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x18, 0x78, 0x70, 0x07,
  0x0F, 0x00, 0xC6, 0x00, 0xC0, 0xE0, 0x1C, 0x04, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0x26, 0x00, 0x18, 0xC0, 0x01, 0x81, 0x60, 0x00, 0x4C, 0x00, 0x0C,
  0x1A, 0x00, 0x02, 0x40, 0x00, 0x60, 0xA0, 0x00, 0x16, 0x00, 0x03, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x00, 0x01, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x01, 0x01, 0xFF, 0x00, 0x30, 0x78, 0x78, 0x03, 0x0C, 0x00,
  0xC0, 0x23, 0x80, 0x06, 0x02, 0x60, 0x00, 0x60, 0x24, 0x00, 0x02, 0x06,
  0x80, 0x00, 0x30, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x02, 0x0E, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x41, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x01,
  0xC0, 0x03, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x60, 0xF0, 0xF0, 0x00, 0x61,
  0x80, 0x18, 0x00, 0x47, 0x00, 0x0C, 0x00, 0x4C, 0x00, 0x0C, 0x00, 0x48,
  0x00, 0x06, 0x00, 0xD0, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x02, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x30, 0x0F, 0x00,
  0x00, 0x60, 0x09, 0x00, 0x00, 0xC0, 0x09, 0x80, 0x01, 0x80, 0x18, 0xC0,
  0x03, 0x00, 0x18, 0x70, 0x1E, 0x00, 0x18, 0x3F, 0xF8, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x18, 0x01, 0xE0,
  0xE0, 0xC0, 0x38, 0x01, 0x84, 0x03, 0x00, 0x06, 0x20, 0x30, 0x00, 0x19,
  0x03, 0x00, 0x00, 0x58, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x0F,
  0x06, 0x00, 0x00, 0xD8, 0x10, 0x00, 0x0C, 0x80, 0xC0, 0x00, 0xC4, 0x03,
  0x00, 0x0C, 0x60, 0x18, 0x00, 0xC3, 0x00, 0x70, 0x1C, 0x10, 0x01, 0xFF,
  0x80, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x01, 0xFC, 0x0C, 0x1E, 0x20, 0x31,
  0xC0, 0x00, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x68, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xE0, 0xFC, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x3C,
  0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0x60, 0xC0, 0x00, 0x34, 0x04, 0x00,
  0x06, 0x40, 0x60, 0x00, 0xC4, 0x07, 0x00, 0x38, 0xC0, 0x38, 0x0E, 0x0C,
  0x00, 0xFF, 0xC0, 0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00, 0x18, 0x02, 0x00, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x10, 0x06,
  0x00, 0x08, 0x03, 0x00, 0x04, 0x03, 0x00, 0x02, 0x01, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x08,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x2C, 0x00, 0x07,
  0x00, 0x01, 0xB0, 0x00, 0x14, 0x00, 0x04, 0xC0, 0x00, 0xD0, 0x00, 0x31,
  0x00, 0x02, 0x40, 0x00, 0x84, 0x00, 0x19, 0x00, 0x06, 0x10, 0x00, 0x44,
  0x00, 0x10, 0x40, 0x03, 0x10, 0x00, 0xC1, 0x00, 0x08, 0x60, 0x03, 0x04,
  0x00, 0x61, 0x80, 0x18, 0x10, 0x01, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x18,
  0x03, 0x01, 0x80, 0x20, 0x20, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x60, 0x18,
  0x04, 0x02, 0x01, 0x80, 0x60, 0x30, 0x08, 0x04, 0x01, 0x81, 0x80, 0x20,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x10, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0xC2,
  0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x98,
  0x00, 0x13, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x60,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x38, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0xE8, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 43, 13, 2, -43 },
  { 61, 13, 16, 19, 7, -43 },
  { 87, 35, 43, 37, 2, -43 },
  { 276, 28, 48, 33, 3, -45 },
  { 444, 37, 44, 46, 5, -43 },
  { 648, 35, 45, 41, 3, -44 },
  { 845, 4, 16, 10, 7, -43 },
  { 853, 17, 52, 15, 2, -43 },
  { 964, 17, 52, 15, -4, -43 },
  { 1075, 24, 25, 32, 8, -45 },
  { 1150, 28, 28, 34, 4, -35 },
  { 1248, 8, 15, 11, -3, -7 },
  { 1263, 14, 1, 19, 2, -17 },
  { 1265, 3, 3, 13, 2, -3 },
  { 1267, 27, 43, 18, -3, -43 },
  { 1413, 28, 45, 33, 4, -44 },
  { 1571, 14, 43, 33, 10, -43 },
  { 1647, 29, 43, 33, 1, -43 },
  { 1803, 31, 44, 33, 1, -43 },
  { 1974, 31, 43, 33, 1, -43 },
  { 2141, 30, 44, 33, 2, -43 },
  { 2306, 29, 45, 33, 4, -44 },
  { 2470, 27, 43, 33, 7, -43 },
  { 2616, 29, 44, 33, 3, -43 },
  { 2776, 28, 44, 33, 3, -43 },
  { 2930, 9, 32, 13, 2, -32 },
  { 2966, 14, 40, 13, -3, -32 },
  { 3036, 27, 27, 34, 5, -35 },
  { 3128, 28, 14, 34, 4, -28 },
  { 3177, 27, 27, 34, 5, -35 },
  { 3269, 20, 43, 24, 5, -43 },
  { 3377, 45, 47, 50, 3, -42 },
  { 3642, 33, 43, 33, -3, -43 },
  { 3820, 32, 43, 36, 3, -43 },
  { 3992, 33, 44, 36, 5, -43 },
  { 4174, 35, 43, 41, 3, -43 },
  { 4363, 31, 43, 32, 3, -43 },
  { 4530, 31, 43, 29, 3, -43 },
  { 4697, 35, 44, 41, 5, -43 },
  { 4890, 38, 43, 41, 3, -43 },
  { 5095, 19, 43, 17, 0, -43 },
  { 5198, 24, 53, 14, -10, -43 },
  { 5357, 35, 43, 33, 3, -43 },
  { 5546, 22, 43, 29, 3, -43 },
  { 5665, 45, 43, 48, 3, -43 },
  { 5907, 37, 43, 40, 3, -43 },
  { 6106, 36, 45, 43, 5, -44 },
  { 6309, 30, 43, 33, 3, -43 },
  { 6471, 36, 54, 43, 5, -44 },
  { 6714, 30, 43, 34, 3, -43 },
  { 6876, 30, 44, 30, 1, -43 },
  { 7041, 29, 43, 29, 6, -43 },
  { 7197, 37, 44, 42, 5, -43 },
  { 7401, 31, 43, 32, 6, -43 },
  { 7568, 46, 43, 50, 7, -43 },
  { 7816, 38, 43, 29, -4, -43 },
  { 8021, 29, 43, 29, 6, -43 },
  { 8177, 34, 43, 32, 0, -43 },
  { 8360, 23, 52, 18, -1, -43 },
  { 8510, 9, 43, 18, 6, -43 },
  { 8559, 22, 52, 18, -4, -43 },
  { 8702, 27, 26, 33, 3, -43 },
  { 8790, 23, 1, 22, -5, 7 },
  { 8793, 7, 10, 14, 9, -46 },
  { 8802, 28, 33, 33, 3, -32 },
  { 8918, 29, 47, 34, 2, -46 },
  { 9089, 24, 33, 27, 3, -32 },
  { 9188, 32, 47, 34, 3, -46 },
  { 9376, 23, 33, 29, 4, -32 },
  { 9471, 33, 60, 16, -8, -46 },
  { 9719, 30, 46, 34, 2, -32 },
  { 9892, 28, 46, 33, 2, -46 },
  { 10053, 11, 43, 12, 2, -43 },
  { 10113, 22, 57, 12, -9, -43 },
  { 10270, 27, 46, 26, 2, -46 },
  { 10426, 11, 46, 12, 2, -46 },
  { 10490, 45, 32, 51, 2, -32 },
  { 10670, 28, 32, 33, 2, -32 },
  { 10782, 28, 33, 34, 3, -32 },
  { 10898, 32, 46, 34, -1, -32 },
  { 11082, 29, 46, 34, 3, -32 },
  { 11249, 22, 32, 22, 2, -32 },
  { 11337, 23, 33, 25, 1, -32 },
  { 11432, 17, 41, 19, 3, -40 },
  { 11520, 28, 33, 33, 3, -32 },
  { 11636, 25, 32, 25, 3, -32 },
  { 11736, 38, 32, 39, 3, -32 },
  { 11888, 30, 32, 27, -2, -32 },
  { 12008, 35, 47, 25, -7, -32 },
  { 12214, 27, 32, 26, -1, -32 },
  { 12322, 21, 52, 20, 2, -43 },
  { 12459, 1, 60, 32, 17, -46 },
  { 12467, 21, 53, 20, -3, -43 },
  { 12607, 27, 5, 34, 5, -24 },
};

const GFXfont NotoSans_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_THINITALIC60PT7B_H_
