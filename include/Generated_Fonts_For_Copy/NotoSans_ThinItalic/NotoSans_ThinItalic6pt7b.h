#ifndef _NOTOSANS_THINITALIC6PT7B_H_
#define _NOTOSANS_THINITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x67, 0xEA, 0x29, 0x3C, 0xB7, 0xF0, 0x76, 0xBF, 0x80,
  0x6A, 0x80, 0xF8, 0x6C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xF0,
  0xF0, 0x65, 0x70, 0x6C, 0xF0, 0x2F, 0x90, 0x68, 0xF0, 0x6A, 0xF0, 0xDA,
  0x6E, 0xF0, 0xF5, 0xF0, 0x20, 0x30, 0x39, 0x80, 0xFC, 0x8F, 0x00, 0x6A,
  0x40, 0x7F, 0xF7, 0x46, 0x00, 0x4E, 0xD0, 0x7E, 0xF0, 0x78, 0x8E, 0x79,
  0x9E, 0x7E, 0x60, 0x7E, 0x40, 0x7A, 0x9F, 0x5F, 0x99, 0x5A, 0x55, 0xC0,
  0x7C, 0xAA, 0x6B, 0x4E, 0xBB, 0x60, 0x5D, 0xAA, 0x79, 0x9F, 0x77, 0x40,
  0x79, 0x9D, 0x20, 0x77, 0xD0, 0xE8, 0xF0, 0xEA, 0xB6, 0xE0, 0xBA, 0x40,
  0xDB, 0xAA, 0x6B, 0x50, 0xEA, 0x69, 0x70, 0xEA, 0x80, 0xF0, 0x56, 0x80,
  0x74, 0xE0, 0x80, 0xF7, 0x80, 0x53, 0xDE, 0xF3, 0x00, 0x2E, 0xDE, 0xFB,
  0x00, 0x25, 0x25, 0x80, 0xF6, 0xF0, 0x4A, 0xDA, 0x70, 0x15, 0xC0, 0x4A,
  0xAC, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90,
  0xE8, 0xDC, 0xEA, 0xB7, 0x80, 0xBA, 0x00, 0xDA, 0xA0, 0xAB, 0x00, 0x56,
  0x4C, 0x6B, 0x00, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_ThinItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 3, 4, 5, 1, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 1, 0, -4 },
  { 14, 1, 5, 1, 0, -4 },
  { 15, 2, 3, 3, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 2, 4, 3, 1, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 1, 3, 1, 0, -3 },
  { 41, 1, 4, 1, 0, -3 },
  { 42, 3, 3, 3, 0, -4 },
  { 44, 3, 2, 3, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 4, 2, 0, -4 },
  { 49, 5, 5, 5, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 4, 4, 4, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 2, 5, 1, -1, -4 },
  { 72, 4, 4, 3, 0, -4 },
  { 74, 2, 4, 3, 0, -4 },
  { 75, 5, 4, 5, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 4, 5, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 2, 4, 3, 1, -4 },
  { 92, 3, 4, 4, 1, -4 },
  { 94, 3, 4, 3, 1, -4 },
  { 96, 4, 4, 5, 1, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 2, 4, 3, 1, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 2, 5, 2, 0, -4 },
  { 105, 1, 4, 2, 1, -4 },
  { 106, 2, 5, 2, 0, -4 },
  { 108, 3, 2, 3, 0, -4 },
  { 109, 3, 1, 2, -1, 0 },
  { 110, 1, 1, 1, 1, -5 },
  { 111, 3, 3, 3, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 3, 3, 3, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 3, 6, 2, -1, -5 },
  { 124, 3, 4, 3, 0, -3 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 1, 4, 1, 0, -4 },
  { 129, 2, 5, 1, -1, -4 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 1, 5, 1, 0, -5 },
  { 134, 5, 3, 5, 0, -3 },
  { 136, 3, 3, 3, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 4, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 2, 3, 2, 0, -3 },
  { 145, 2, 3, 3, 0, -3 },
  { 146, 2, 4, 2, 0, -4 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 3, 2, 0, -3 },
  { 151, 4, 3, 4, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 4, 4, 2, -1, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 2, 5, 2, 0, -4 },
  { 161, 1, 6, 3, 1, -5 },
  { 162, 2, 5, 2, 0, -4 },
  { 164, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ThinItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_THINITALIC6PT7B_H_
