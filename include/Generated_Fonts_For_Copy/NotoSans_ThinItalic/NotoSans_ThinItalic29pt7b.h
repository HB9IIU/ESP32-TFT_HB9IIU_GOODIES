#ifndef _NOTOSANS_THINITALIC29PT7B_H_
#define _NOTOSANS_THINITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x25, 0x14, 0x51, 0x46, 0x28, 0xA2, 0x00, 0x82, 0x00,
  0x41, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x20, 0x08, 0x20,
  0x7F, 0xFF, 0x02, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x81,
  0x00, 0x41, 0x03, 0xFF, 0xF8, 0x10, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04,
  0x10, 0x04, 0x08, 0x02, 0x08, 0x00, 0x00, 0x40, 0x01, 0x00, 0x1E, 0x01,
  0x97, 0x08, 0x40, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x24, 0x00,
  0x50, 0x00, 0xE0, 0x01, 0x40, 0x04, 0xC0, 0x21, 0x00, 0x84, 0x02, 0x10,
  0x08, 0x40, 0x22, 0x39, 0x70, 0x16, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0x00, 0x42, 0x20, 0x10, 0x82, 0x04, 0x10, 0x41, 0x04, 0x08, 0x20,
  0x81, 0x08, 0x10, 0x22, 0x04, 0x08, 0x80, 0x81, 0x13, 0x10, 0x24, 0x8A,
  0x09, 0x21, 0x22, 0x44, 0x13, 0x89, 0x02, 0x02, 0x20, 0x40, 0x84, 0x10,
  0x21, 0x02, 0x04, 0x20, 0x41, 0x04, 0x08, 0x40, 0x82, 0x08, 0x08, 0x46,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xC2, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04,
  0x04, 0x01, 0x01, 0x00, 0x40, 0x80, 0x10, 0x40, 0x02, 0x60, 0x00, 0x60,
  0x00, 0x68, 0x00, 0x62, 0x01, 0x20, 0x40, 0x90, 0x08, 0x24, 0x02, 0x12,
  0x00, 0x48, 0x80, 0x0C, 0x20, 0x03, 0x04, 0x01, 0x41, 0x00, 0x88, 0x3F,
  0xC1, 0x00, 0x55, 0x6A, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x02, 0x00, 0x20, 0x02,
  0x08, 0x40, 0x64, 0x01, 0xCF, 0x07, 0x01, 0xC0, 0x22, 0x04, 0x20, 0x81,
  0x00, 0x10, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x0F, 0xFF, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x32, 0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x20, 0x12, 0x00, 0x90,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x10, 0x81, 0x03,
  0xF0, 0x00, 0x02, 0x1C, 0x53, 0x28, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x00, 0x01, 0xF8, 0x0C,
  0x08, 0x10, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0x30, 0x21, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0x80, 0xFC, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x20, 0x18,
  0x7F, 0x80, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xA0, 0x02, 0x40,
  0x08, 0x80, 0x21, 0x00, 0x84, 0x02, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0x5F, 0xFF, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0x00, 0x3D,
  0xC0, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x84, 0x02, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x47, 0x81, 0x61, 0x8A, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x84, 0x02, 0x10, 0x30, 0x3F, 0x00, 0x7F,
  0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xF0,
  0x18, 0x20, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02,
  0x04, 0x30, 0x09, 0x00, 0x78, 0x06, 0x18, 0x20, 0x11, 0x00, 0x44, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x01, 0x18, 0x08, 0x1F, 0x80, 0x03,
  0xE0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x32, 0x01, 0x44, 0x0A, 0x0F, 0xC8, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x60, 0xFE, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x02, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x3F, 0x10, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x10, 0x03, 0x03, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x00,
  0x90, 0x1E, 0x05, 0x03, 0x0C, 0x28, 0x20, 0x41, 0x82, 0x02, 0x0C, 0x10,
  0x10, 0x61, 0x00, 0x83, 0x08, 0x08, 0x18, 0x40, 0x40, 0xC2, 0x02, 0x0A,
  0x10, 0x30, 0x50, 0x42, 0x8C, 0x81, 0xE3, 0x84, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0x07, 0x00, 0x07, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x82, 0x01, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0xFF,
  0xC1, 0x00, 0x84, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x07, 0xF8, 0x08, 0x06, 0x08, 0x02, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x04, 0x10, 0x18,
  0x1F, 0xF0, 0x20, 0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x30, 0xFF, 0xC0, 0x00, 0xFE,
  0x03, 0x01, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x04, 0x06, 0x02, 0x00, 0x81, 0x00,
  0x20, 0x80, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04,
  0x80, 0x02, 0x40, 0x02, 0x20, 0x02, 0x10, 0x06, 0x08, 0x0C, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xE1, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x21, 0x7F, 0x82, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x01,
  0x80, 0xC1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x0F, 0xE8, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x08,
  0x01, 0x02, 0x00, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x21, 0x00, 0x08, 0x20,
  0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x20, 0x80,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x7F, 0xFE, 0x10, 0x00, 0x82, 0x00,
  0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x41, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x40, 0x0F, 0x81, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x0F, 0x80, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x04,
  0x00, 0x84, 0x00, 0x82, 0x00, 0x81, 0x01, 0x80, 0x81, 0x00, 0x41, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x11, 0x00, 0x0B, 0x00, 0x06, 0x40, 0x06, 0x20,
  0x02, 0x08, 0x01, 0x04, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x04, 0x08, 0x02, 0x08, 0x00, 0x80, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0F,
  0xFE, 0x04, 0x00, 0x04, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x80, 0x05,
  0x0A, 0x00, 0x28, 0x28, 0x00, 0xA1, 0x20, 0x04, 0x84, 0x80, 0x12, 0x11,
  0x00, 0x88, 0x44, 0x04, 0x41, 0x10, 0x11, 0x08, 0x40, 0x84, 0x21, 0x02,
  0x10, 0x84, 0x10, 0x42, 0x08, 0x82, 0x08, 0x22, 0x08, 0x40, 0x90, 0x21,
  0x02, 0x40, 0x84, 0x0A, 0x04, 0x10, 0x30, 0x10, 0x80, 0x40, 0x40, 0x04,
  0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x28, 0x01, 0x0A, 0x00, 0x42, 0x40,
  0x21, 0x10, 0x08, 0x42, 0x02, 0x10, 0x80, 0x84, 0x20, 0x21, 0x04, 0x10,
  0x81, 0x04, 0x20, 0x21, 0x08, 0x08, 0x42, 0x01, 0x10, 0x80, 0x48, 0x40,
  0x12, 0x10, 0x02, 0x84, 0x00, 0xA1, 0x00, 0x10, 0x80, 0x04, 0x00, 0x01,
  0xFC, 0x01, 0x80, 0x80, 0x80, 0x10, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x82, 0x00, 0x40, 0x40, 0x20, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x10, 0x18, 0x20, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x21, 0xFF, 0x82, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x80, 0x80, 0x80, 0x10, 0x40, 0x02,
  0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x82, 0x00, 0x40, 0x40, 0x20,
  0x0F, 0xE0, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x07, 0xF0, 0x10, 0x18, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0xE1, 0xFE,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x20, 0x80, 0x21,
  0x00, 0x42, 0x00, 0x88, 0x00, 0x80, 0x03, 0xF8, 0x30, 0x11, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x20, 0x10, 0xFF, 0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x04,
  0x08, 0x04, 0x03, 0xFC, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x48, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81,
  0x02, 0x02, 0x04, 0x04, 0x10, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00, 0x24,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x20, 0x06,
  0x00, 0x80, 0x28, 0x06, 0x00, 0xA0, 0x18, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x08, 0x41,
  0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x09,
  0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x04, 0x00, 0x40, 0x80, 0x20,
  0x20, 0x08, 0x04, 0x04, 0x01, 0x02, 0x00, 0x41, 0x00, 0x08, 0x80, 0x02,
  0x20, 0x00, 0x90, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x80, 0x01, 0x20,
  0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x08, 0x08, 0x04, 0x02, 0x02,
  0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x80, 0x06, 0x00, 0x28, 0x01,
  0x10, 0x08, 0x40, 0x21, 0x01, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x88,
  0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x84, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x84, 0x1F, 0x00, 0x88, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22,
  0x22, 0x11, 0x11, 0x10, 0x07, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x1F, 0x80, 0x00, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x02,
  0x20, 0x08, 0x40, 0x41, 0x02, 0x04, 0x08, 0x08, 0x40, 0x22, 0x00, 0x90,
  0x02, 0xC0, 0x04, 0xFF, 0xC0, 0x84, 0x23, 0x01, 0xC0, 0x18, 0x91, 0x81,
  0x44, 0x06, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x0C, 0x40, 0x61, 0x01, 0x84, 0x0A, 0x0F, 0xC8, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x0E, 0x04,
  0xC4, 0x14, 0x08, 0xA0, 0x13, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14,
  0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x28, 0x08, 0xA0, 0x62,
  0x7E, 0x00, 0x03, 0xC1, 0x84, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x01, 0xFC,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x01, 0xC2, 0x06, 0x34, 0x18, 0x14, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10,
  0x40, 0x30, 0x40, 0x50, 0x40, 0x90, 0x3F, 0x20, 0x03, 0x01, 0x88, 0x40,
  0x90, 0x14, 0x02, 0x80, 0x60, 0x14, 0x3C, 0xE8, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x18, 0xD1, 0x81, 0x44, 0x03, 0x20,
  0x0D, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20,
  0x04, 0x40, 0x31, 0x01, 0x44, 0x09, 0x0F, 0xC8, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x82, 0x04, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x41, 0x02, 0x62, 0x14, 0x09,
  0x40, 0x4C, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x02, 0x40, 0x10, 0x08, 0x40, 0x00,
  0x00, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x22, 0x02, 0x10,
  0x21, 0x02, 0x08, 0x20, 0x42, 0x02, 0x20, 0x12, 0x01, 0x70, 0x0C, 0x40,
  0x42, 0x02, 0x08, 0x10, 0x41, 0x01, 0x08, 0x08, 0x40, 0x20, 0x08, 0x42,
  0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x40,
  0x01, 0x80, 0x60, 0x48, 0x86, 0x61, 0xC1, 0x20, 0x8A, 0x05, 0x01, 0x30,
  0x08, 0x04, 0x80, 0x60, 0x12, 0x01, 0x00, 0x88, 0x04, 0x02, 0x40, 0x10,
  0x09, 0x00, 0x80, 0x24, 0x02, 0x00, 0x90, 0x08, 0x04, 0x40, 0x20, 0x12,
  0x00, 0x80, 0x48, 0x04, 0x01, 0x20, 0x10, 0x04, 0x00, 0x40, 0x98, 0x85,
  0x02, 0x50, 0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x01, 0x80,
  0x63, 0x0C, 0x04, 0x40, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x11, 0x03, 0x07, 0xE0,
  0x00, 0x38, 0x04, 0xC4, 0x05, 0x02, 0x0A, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x04, 0x28, 0x08, 0x28, 0x18, 0x27, 0xE0, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x18, 0x91, 0x81, 0x44, 0x03, 0x20, 0x0D, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x40, 0x31, 0x01, 0x44, 0x09,
  0x0F, 0xC8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x00, 0x84, 0xC1, 0x40, 0xA0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x01,
  0x40, 0xC3, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x80, 0x87, 0xF0, 0x08,
  0x08, 0x04, 0x02, 0x17, 0xF0, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x1F, 0x00, 0x20, 0x0A, 0x00,
  0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x19, 0x00, 0x88, 0x0C, 0x40, 0xA1, 0xF9, 0x00, 0x80, 0x14,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0x41, 0x02, 0x10, 0x22, 0x02,
  0x20, 0x24, 0x02, 0x40, 0x28, 0x03, 0x00, 0x10, 0x00, 0x80, 0x80, 0xE0,
  0x60, 0x28, 0x18, 0x0A, 0x0A, 0x04, 0x82, 0x41, 0x21, 0x10, 0x88, 0x44,
  0x22, 0x21, 0x10, 0x88, 0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x81, 0x40,
  0xA0, 0x50, 0x30, 0x08, 0x08, 0x02, 0x00, 0x18, 0x06, 0x10, 0x10, 0x10,
  0x40, 0x21, 0x00, 0x24, 0x00, 0x50, 0x00, 0x60, 0x00, 0x80, 0x02, 0x80,
  0x09, 0x00, 0x21, 0x00, 0x82, 0x02, 0x02, 0x08, 0x04, 0x20, 0x04, 0x00,
  0x08, 0x01, 0x04, 0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x04, 0x08, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x00, 0x40, 0xC0,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0xE0, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x01, 0xC0, 0x40, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x30, 0x00, 0x38, 0x02, 0x30, 0x60, 0x7C,
};

const GFXglyph NotoSans_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 8, 9, 3, -21 },
  { 21, 17, 21, 18, 1, -21 },
  { 66, 14, 24, 16, 1, -22 },
  { 108, 19, 21, 22, 2, -21 },
  { 158, 18, 21, 20, 1, -21 },
  { 206, 2, 8, 5, 3, -21 },
  { 208, 8, 26, 7, 1, -21 },
  { 234, 8, 26, 7, -2, -21 },
  { 260, 12, 12, 15, 4, -22 },
  { 278, 14, 13, 17, 2, -17 },
  { 301, 4, 7, 5, -1, -3 },
  { 305, 7, 1, 9, 1, -8 },
  { 306, 1, 2, 6, 1, -2 },
  { 307, 12, 21, 9, -1, -21 },
  { 339, 13, 21, 16, 2, -21 },
  { 374, 7, 21, 16, 5, -21 },
  { 393, 15, 21, 16, 0, -21 },
  { 433, 14, 21, 16, 1, -21 },
  { 470, 15, 21, 16, 0, -21 },
  { 510, 15, 21, 16, 1, -21 },
  { 550, 14, 21, 16, 2, -21 },
  { 587, 13, 21, 16, 3, -21 },
  { 622, 14, 21, 16, 1, -21 },
  { 659, 14, 21, 16, 1, -21 },
  { 696, 4, 15, 6, 1, -15 },
  { 704, 6, 19, 6, -1, -15 },
  { 719, 13, 13, 17, 2, -17 },
  { 741, 14, 7, 17, 2, -14 },
  { 754, 13, 13, 17, 2, -17 },
  { 776, 10, 21, 12, 2, -21 },
  { 803, 21, 23, 24, 2, -20 },
  { 864, 15, 21, 16, -1, -21 },
  { 904, 16, 21, 17, 1, -21 },
  { 946, 16, 21, 17, 2, -21 },
  { 988, 17, 21, 20, 1, -21 },
  { 1033, 15, 21, 16, 1, -21 },
  { 1073, 15, 21, 14, 1, -21 },
  { 1113, 17, 21, 20, 2, -21 },
  { 1158, 19, 21, 20, 1, -21 },
  { 1208, 9, 21, 8, 0, -21 },
  { 1232, 12, 26, 7, -5, -21 },
  { 1271, 17, 21, 16, 1, -21 },
  { 1316, 11, 21, 14, 1, -21 },
  { 1345, 22, 21, 23, 1, -21 },
  { 1403, 18, 21, 20, 1, -21 },
  { 1451, 18, 21, 21, 2, -21 },
  { 1499, 15, 21, 16, 1, -21 },
  { 1539, 18, 26, 21, 2, -21 },
  { 1598, 15, 21, 16, 1, -21 },
  { 1638, 14, 21, 14, 1, -21 },
  { 1675, 14, 21, 14, 3, -21 },
  { 1712, 17, 21, 20, 3, -21 },
  { 1757, 15, 21, 16, 3, -21 },
  { 1797, 22, 21, 24, 4, -21 },
  { 1855, 18, 21, 14, -2, -21 },
  { 1903, 14, 21, 14, 3, -21 },
  { 1940, 17, 21, 16, 0, -21 },
  { 1985, 11, 26, 9, 0, -21 },
  { 2021, 4, 21, 9, 3, -21 },
  { 2032, 11, 26, 9, -2, -21 },
  { 2068, 14, 13, 16, 1, -21 },
  { 2091, 10, 1, 11, -2, 3 },
  { 2093, 4, 4, 7, 4, -22 },
  { 2095, 14, 16, 16, 1, -16 },
  { 2123, 14, 22, 16, 1, -22 },
  { 2162, 11, 16, 13, 2, -16 },
  { 2184, 16, 22, 16, 1, -22 },
  { 2228, 11, 16, 14, 2, -16 },
  { 2250, 16, 29, 8, -4, -22 },
  { 2308, 14, 23, 16, 1, -16 },
  { 2349, 13, 22, 16, 1, -22 },
  { 2385, 5, 21, 6, 1, -21 },
  { 2399, 10, 28, 6, -4, -21 },
  { 2434, 13, 22, 13, 1, -22 },
  { 2470, 5, 22, 6, 1, -22 },
  { 2484, 22, 16, 24, 1, -16 },
  { 2528, 13, 16, 16, 1, -16 },
  { 2554, 13, 16, 16, 2, -16 },
  { 2580, 16, 23, 16, -1, -16 },
  { 2626, 14, 23, 16, 1, -16 },
  { 2667, 10, 16, 11, 1, -16 },
  { 2687, 12, 16, 12, 0, -16 },
  { 2711, 9, 19, 9, 1, -19 },
  { 2733, 13, 15, 16, 2, -15 },
  { 2758, 12, 15, 12, 1, -15 },
  { 2781, 18, 15, 19, 2, -15 },
  { 2815, 15, 15, 13, -1, -15 },
  { 2844, 16, 22, 12, -3, -15 },
  { 2888, 13, 15, 13, 0, -15 },
  { 2913, 10, 26, 9, 1, -21 },
  { 2946, 1, 29, 16, 8, -22 },
  { 2950, 10, 26, 9, -1, -21 },
  { 2983, 13, 3, 17, 2, -12 },
};

const GFXfont NotoSans_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_THINITALIC29PT7B_H_
