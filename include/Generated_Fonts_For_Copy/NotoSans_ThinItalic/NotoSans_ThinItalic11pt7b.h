#ifndef _NOTOSANS_THINITALIC11PT7B_H_
#define _NOTOSANS_THINITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x52, 0xB7, 0x00, 0x14, 0x29, 0xD9, 0x42, 0x9F, 0x92, 0x28,
  0x37, 0x68, 0x82, 0x29, 0x5C, 0x40, 0x63, 0x4A, 0xA5, 0xAD, 0xA6, 0x54,
  0xCE, 0x39, 0x24, 0x8C, 0xE6, 0x58, 0xBE, 0xE0, 0x25, 0x29, 0x24, 0x88,
  0x24, 0x92, 0x49, 0x50, 0xA3, 0xD9, 0x20, 0x21, 0x3E, 0x42, 0x00, 0x70,
  0xE0, 0x80, 0x11, 0x22, 0x44, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x75,
  0x5A, 0x38, 0x10, 0x42, 0x10, 0x84, 0x3E, 0x3C, 0x10, 0x4E, 0x08, 0x10,
  0xBE, 0x04, 0x21, 0x8A, 0x4B, 0xF0, 0x84, 0x3C, 0x84, 0x1C, 0x08, 0x10,
  0xBC, 0x3A, 0x21, 0xE8, 0xC6, 0x5E, 0xF8, 0x44, 0x22, 0x21, 0x10, 0x7C,
  0x62, 0xE9, 0x46, 0x5E, 0x74, 0x63, 0x1F, 0x08, 0x5C, 0x40, 0x20, 0x20,
  0x00, 0xB0, 0x3A, 0x30, 0x70, 0xFF, 0xC0, 0xE0, 0x87, 0xC0, 0xE1, 0x12,
  0x48, 0x08, 0x3E, 0x41, 0x99, 0xA5, 0xC5, 0xC9, 0xB6, 0x80, 0x7C, 0x08,
  0x31, 0x45, 0x3C, 0x94, 0x61, 0x7A, 0x63, 0xD9, 0xC6, 0x3E, 0x3D, 0x08,
  0x20, 0x82, 0x08, 0x1E, 0x79, 0x18, 0x61, 0x86, 0x18, 0xBC, 0x7A, 0x21,
  0xE8, 0x42, 0x1E, 0x7A, 0x21, 0x0F, 0x42, 0x10, 0x3D, 0x08, 0x20, 0x9E,
  0x18, 0x5E, 0x45, 0x18, 0x7F, 0x86, 0x18, 0xA2, 0x24, 0xA4, 0x96, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x26, 0x00, 0x45, 0x2B, 0x30, 0xA2, 0x89, 0x24,
  0x44, 0x88, 0x88, 0x8F, 0x41, 0x41, 0xC2, 0xA6, 0xAA, 0xAA, 0xB2, 0xA2,
  0x45, 0x1A, 0x69, 0x96, 0x59, 0xA2, 0x3D, 0x18, 0x61, 0x86, 0x18, 0x5E,
  0x72, 0x63, 0x1F, 0x42, 0x10, 0x3D, 0x18, 0x61, 0x86, 0x18, 0x5A, 0x10,
  0x40, 0x72, 0x63, 0x1F, 0x4A, 0x52, 0x3D, 0x04, 0x08, 0x10, 0x20, 0xBC,
  0xF9, 0x08, 0x84, 0x21, 0x08, 0x43, 0x06, 0x14, 0x28, 0x50, 0xA2, 0x78,
  0x86, 0x28, 0xA4, 0x92, 0x84, 0x10, 0x88, 0xCC, 0x66, 0x55, 0x2A, 0xA5,
  0x51, 0x11, 0x08, 0x22, 0x48, 0x50, 0xC1, 0x05, 0x12, 0x42, 0x8C, 0x64,
  0xC4, 0x21, 0x08, 0x3C, 0x10, 0x84, 0x21, 0x04, 0x3E, 0x34, 0x44, 0x48,
  0x88, 0x8C, 0xAA, 0x95, 0x31, 0x11, 0x11, 0x22, 0x2C, 0x21, 0x95, 0x18,
  0x80, 0xF0, 0x80, 0x7C, 0xA5, 0x29, 0x70, 0x21, 0x07, 0x91, 0x45, 0x18,
  0xBE, 0x78, 0x88, 0x8F, 0x08, 0x5F, 0x18, 0xCA, 0x5E, 0x79, 0xBC, 0x8F,
  0x1C, 0x83, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x00, 0x3D, 0x18, 0x62,
  0x89, 0xE0, 0x84, 0xE0, 0x22, 0x1E, 0x94, 0xA6, 0x31, 0x45, 0x5A, 0x10,
  0x11, 0x11, 0x22, 0x22, 0xC0, 0x22, 0x12, 0xA6, 0x32, 0x52, 0x55, 0x5A,
  0x3B, 0xA6, 0x52, 0x29, 0x18, 0x94, 0x48, 0x7A, 0x52, 0x98, 0xC4, 0x74,
  0x63, 0x19, 0x78, 0x79, 0x14, 0x51, 0x8B, 0xE8, 0x20, 0x80, 0x7C, 0x63,
  0x29, 0x78, 0x42, 0x20, 0x74, 0x44, 0x88, 0x74, 0x43, 0x1F, 0x9E, 0x49,
  0x20, 0x8C, 0x63, 0x29, 0x78, 0x99, 0xAC, 0xC8, 0xA6, 0x9D, 0x76, 0x92,
  0x40, 0x4A, 0x88, 0xC5, 0x48, 0x45, 0x12, 0x8A, 0x30, 0x82, 0x10, 0x80,
  0x78, 0x88, 0x84, 0x78, 0x12, 0x24, 0xC4, 0x44, 0x84, 0xFF, 0xE0, 0x31,
  0x11, 0x11, 0x22, 0x2C, 0xF8,
};

const GFXglyph NotoSans_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 3, 3, 3, 1, -8 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 5, 9, 6, 1, -8 },
  { 18, 7, 8, 8, 1, -8 },
  { 25, 6, 8, 8, 1, -8 },
  { 31, 1, 3, 2, 1, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 3, 10, 3, -1, -8 },
  { 40, 5, 4, 6, 1, -8 },
  { 43, 5, 5, 6, 1, -6 },
  { 47, 2, 2, 2, -1, -1 },
  { 48, 3, 1, 3, 0, -3 },
  { 49, 1, 1, 2, 0, -1 },
  { 50, 4, 8, 3, 0, -8 },
  { 54, 5, 8, 6, 1, -8 },
  { 59, 2, 8, 6, 2, -8 },
  { 61, 6, 8, 6, 0, -8 },
  { 67, 6, 8, 6, 0, -8 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 5, 8, 6, 1, -8 },
  { 90, 5, 8, 6, 1, -8 },
  { 95, 5, 8, 6, 1, -8 },
  { 100, 5, 8, 6, 1, -8 },
  { 105, 2, 6, 2, 0, -6 },
  { 107, 3, 7, 2, -1, -6 },
  { 110, 5, 4, 6, 1, -6 },
  { 113, 5, 2, 6, 1, -5 },
  { 115, 5, 4, 6, 1, -6 },
  { 118, 4, 8, 4, 1, -8 },
  { 122, 8, 9, 9, 1, -8 },
  { 131, 6, 8, 6, -1, -8 },
  { 137, 5, 8, 7, 1, -8 },
  { 142, 6, 8, 7, 1, -8 },
  { 148, 6, 8, 7, 1, -8 },
  { 154, 5, 8, 6, 1, -8 },
  { 159, 5, 8, 5, 1, -8 },
  { 164, 6, 8, 8, 1, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 3, 8, 3, 0, -8 },
  { 179, 5, 10, 3, -2, -8 },
  { 186, 6, 8, 6, 1, -8 },
  { 192, 4, 8, 5, 1, -8 },
  { 196, 8, 8, 9, 1, -8 },
  { 204, 6, 8, 7, 1, -8 },
  { 210, 6, 8, 8, 1, -8 },
  { 216, 5, 8, 6, 1, -8 },
  { 221, 6, 10, 8, 1, -8 },
  { 229, 5, 8, 6, 1, -8 },
  { 234, 6, 8, 5, 0, -8 },
  { 240, 5, 8, 5, 1, -8 },
  { 245, 7, 8, 8, 1, -8 },
  { 252, 6, 8, 6, 1, -8 },
  { 258, 9, 8, 9, 1, -8 },
  { 267, 7, 8, 5, -1, -8 },
  { 274, 5, 8, 5, 1, -8 },
  { 279, 6, 8, 6, 0, -8 },
  { 285, 4, 10, 3, 0, -8 },
  { 290, 2, 8, 3, 1, -8 },
  { 292, 4, 10, 3, -1, -8 },
  { 297, 5, 5, 6, 1, -8 },
  { 301, 4, 1, 4, -1, 1 },
  { 302, 1, 1, 2, 2, -8 },
  { 303, 5, 6, 6, 1, -6 },
  { 307, 6, 8, 6, 0, -8 },
  { 313, 4, 6, 5, 1, -6 },
  { 316, 5, 8, 6, 1, -8 },
  { 321, 4, 6, 5, 1, -6 },
  { 324, 6, 11, 3, -1, -8 },
  { 333, 6, 9, 6, 0, -6 },
  { 340, 5, 8, 6, 0, -8 },
  { 345, 2, 8, 2, 0, -8 },
  { 347, 4, 11, 2, -2, -8 },
  { 353, 5, 8, 5, 0, -8 },
  { 358, 2, 8, 2, 0, -8 },
  { 360, 9, 6, 9, 0, -6 },
  { 367, 5, 6, 6, 0, -6 },
  { 371, 5, 6, 6, 1, -6 },
  { 375, 6, 9, 6, 0, -6 },
  { 382, 5, 9, 6, 1, -6 },
  { 388, 4, 6, 4, 0, -6 },
  { 391, 4, 6, 5, 0, -6 },
  { 394, 3, 7, 3, 1, -7 },
  { 397, 5, 6, 6, 1, -6 },
  { 401, 4, 6, 5, 1, -6 },
  { 404, 6, 6, 7, 1, -6 },
  { 409, 5, 6, 5, 0, -6 },
  { 413, 6, 9, 5, -1, -6 },
  { 420, 5, 6, 5, 0, -6 },
  { 424, 4, 10, 4, 0, -8 },
  { 429, 1, 11, 6, 3, -8 },
  { 431, 4, 10, 4, -1, -8 },
  { 436, 5, 1, 6, 1, -4 },
};

const GFXfont NotoSans_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_THINITALIC11PT7B_H_
