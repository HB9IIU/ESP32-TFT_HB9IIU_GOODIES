#ifndef _NOTOSANS_THINITALIC44PT7B_H_
#define _NOTOSANS_THINITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x20, 0x90, 0x58, 0x28, 0x34, 0x12, 0x09, 0x04, 0x82, 0x82, 0x41, 0x20,
  0x80, 0x00, 0x18, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x02, 0x00, 0x02,
  0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00,
  0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x10, 0x0F, 0xFF, 0xFF, 0xE0,
  0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x00,
  0x02, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x30, 0x0F, 0xFF, 0xFF, 0xE0, 0x30, 0x08, 0x00, 0x10, 0x04,
  0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02, 0x01,
  0x80, 0x01, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x60, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1E,
  0x00, 0x0F, 0x5F, 0x80, 0xC2, 0x08, 0x18, 0x10, 0x00, 0x81, 0x80, 0x0C,
  0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00,
  0x02, 0x08, 0x00, 0x18, 0x40, 0x00, 0x72, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x09, 0x80, 0x00, 0x43, 0x00, 0x02, 0x08, 0x00, 0x20, 0x60,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x20,
  0x20, 0x01, 0x02, 0x08, 0x08, 0x60, 0x7E, 0x5E, 0x00, 0x3F, 0x80, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x41, 0x8C, 0x00, 0x10, 0x60, 0xC0, 0x04, 0x08,
  0x08, 0x01, 0x82, 0x01, 0x00, 0x20, 0xC0, 0x20, 0x08, 0x10, 0x04, 0x02,
  0x02, 0x00, 0x80, 0xC0, 0x40, 0x10, 0x10, 0x10, 0x02, 0x04, 0x02, 0x00,
  0x41, 0x00, 0x40, 0x10, 0x60, 0x08, 0x02, 0x08, 0x01, 0x00, 0x42, 0x1F,
  0x20, 0x18, 0xC6, 0x14, 0x02, 0x31, 0x03, 0x80, 0x84, 0x60, 0x38, 0x31,
  0x08, 0x05, 0x8C, 0x63, 0x00, 0x9E, 0x18, 0x40, 0x10, 0x02, 0x08, 0x02,
  0x00, 0x83, 0x00, 0x40, 0x30, 0x40, 0x08, 0x04, 0x08, 0x03, 0x01, 0x01,
  0x00, 0x40, 0x40, 0x20, 0x08, 0x18, 0x04, 0x03, 0x02, 0x00, 0x80, 0x40,
  0x80, 0x10, 0x08, 0x20, 0x02, 0x02, 0x0C, 0x00, 0x60, 0x83, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x80, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0x40,
  0x0C, 0x00, 0x18, 0x02, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x11, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x01, 0x80, 0x40, 0x04, 0xC0, 0x18, 0x02, 0x60, 0x03,
  0x01, 0x90, 0x00, 0x40, 0x4C, 0x00, 0x08, 0x22, 0x00, 0x03, 0x18, 0x80,
  0x00, 0x44, 0x20, 0x00, 0x0A, 0x08, 0x00, 0x01, 0x03, 0x00, 0x00, 0xE0,
  0x40, 0x00, 0xC8, 0x18, 0x00, 0x61, 0x03, 0x00, 0x60, 0x60, 0x3F, 0xE0,
  0x0C, 0x25, 0xA4, 0x92, 0x92, 0x00, 0x00, 0x38, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80, 0x40, 0x18, 0x20, 0x03,
  0x08, 0x00, 0x32, 0x00, 0x03, 0xBF, 0xC0, 0x70, 0x00, 0x28, 0x00, 0x11,
  0x00, 0x08, 0x40, 0x0C, 0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x20, 0x86, 0x10, 0xC2, 0x08, 0x41, 0x08, 0x00, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x18, 0x01, 0x80, 0x40, 0x20, 0x02,
  0x04, 0x00, 0x20, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x04, 0x00, 0x30,
  0x40, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xFE, 0x00, 0x00, 0xE0,
  0x3C, 0x19, 0x06, 0x23, 0x04, 0xC1, 0xA0, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF1, 0xC0, 0x0C,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xC1, 0xC0, 0x18, 0x01, 0x81, 0x80, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x06, 0x0E, 0x00, 0x70, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x02, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00,
  0x04, 0x30, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x08, 0x08, 0x00, 0x40,
  0x20, 0x03, 0x01, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x40,
  0x10, 0x01, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00,
  0x02, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x09, 0xF8, 0x00, 0x7C, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x80, 0x03,
  0x03, 0x00, 0x30, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0,
  0xC0, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0xFF, 0x01, 0x98, 0x0C, 0x09, 0x00,
  0x10, 0x50, 0x00, 0x43, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00, 0xC8,
  0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x06, 0x30, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x30, 0x10,
  0x03, 0x00, 0x40, 0x30, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0x87, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x20,
  0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x08, 0x20, 0x00, 0xC1, 0x80, 0x04, 0x04, 0x00, 0x40, 0x10, 0x04, 0x00,
  0xC0, 0xC0, 0x01, 0x98, 0x00, 0x07, 0x00, 0x01, 0xCC, 0x00, 0x30, 0x18,
  0x06, 0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x33, 0x00,
  0x01, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x11,
  0x80, 0x00, 0x84, 0x00, 0x08, 0x10, 0x00, 0x80, 0x60, 0x18, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0x0E, 0x00, 0x60, 0x18, 0x04, 0x00, 0x40,
  0x40, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x63, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0x40, 0x00, 0xE2, 0x00, 0x06, 0x18, 0x00, 0xD0, 0x60, 0x0C,
  0x81, 0xC3, 0x88, 0x03, 0xF0, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x02, 0x01, 0xC0, 0x1F, 0xF8,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x78, 0xE1, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x00, 0x86, 0x00, 0x3F, 0xC0, 0x21, 0x00, 0x30, 0x18, 0x08, 0xC0,
  0x10, 0x04, 0x02, 0x20, 0x08, 0x01, 0x00, 0xD8, 0x04, 0x00, 0x40, 0x34,
  0x03, 0x00, 0x30, 0x09, 0x00, 0x80, 0x08, 0x02, 0x40, 0x60, 0x02, 0x00,
  0x90, 0x10, 0x00, 0x80, 0x2C, 0x04, 0x00, 0x60, 0x1B, 0x01, 0x00, 0x10,
  0x04, 0xC0, 0x40, 0x0C, 0x01, 0x30, 0x10, 0x03, 0x00, 0x84, 0x04, 0x01,
  0x40, 0x61, 0x01, 0x80, 0xD0, 0x30, 0x40, 0x30, 0x66, 0x18, 0x10, 0x07,
  0xE0, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x90, 0x00, 0x01, 0x10, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x04, 0x18, 0x00,
  0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x20, 0x08, 0x00, 0x60, 0x08, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x80, 0x04, 0x01, 0xFF, 0xFC, 0x01, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06,
  0x00, 0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x1C, 0x02,
  0x00, 0x06, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0xE0, 0x0F,
  0xFF, 0x00, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x10, 0x00, 0x10, 0x10,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x07, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x01, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0xC0,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x40, 0x03, 0x80,
  0x10, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x38, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x07, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08,
  0x0F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0xFC, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x80, 0x20, 0x00, 0x40, 0x08, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x80,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x04, 0x02, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x60, 0x00,
  0x02, 0x38, 0x00, 0x00, 0x92, 0x00, 0x00, 0x68, 0xC0, 0x00, 0x14, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x30,
  0x04, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x01, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xA0, 0x00,
  0x00, 0xE0, 0x50, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x00, 0xD0, 0x16, 0x00,
  0x00, 0x48, 0x19, 0x00, 0x00, 0x64, 0x08, 0x80, 0x00, 0x26, 0x04, 0x40,
  0x00, 0x22, 0x02, 0x20, 0x00, 0x31, 0x01, 0x10, 0x00, 0x10, 0x81, 0x84,
  0x00, 0x18, 0x40, 0x82, 0x00, 0x08, 0x60, 0x41, 0x00, 0x08, 0x20, 0x20,
  0x80, 0x0C, 0x10, 0x30, 0x40, 0x04, 0x08, 0x10, 0x20, 0x06, 0x04, 0x08,
  0x08, 0x02, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x03,
  0x01, 0x01, 0x00, 0x81, 0x00, 0x81, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x40,
  0x40, 0x10, 0x80, 0x20, 0x20, 0x08, 0xC0, 0x10, 0x30, 0x04, 0x40, 0x08,
  0x10, 0x02, 0x60, 0x0C, 0x08, 0x01, 0x20, 0x04, 0x04, 0x00, 0x60, 0x02,
  0x02, 0x00, 0x30, 0x01, 0x03, 0x00, 0x10, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x20, 0x70, 0x00, 0x04, 0x0A, 0x00, 0x00, 0x81, 0x40, 0x00, 0x30, 0x24,
  0x00, 0x04, 0x04, 0x80, 0x00, 0x81, 0x98, 0x00, 0x10, 0x21, 0x00, 0x02,
  0x04, 0x30, 0x00, 0xC0, 0x82, 0x00, 0x10, 0x10, 0x40, 0x02, 0x06, 0x04,
  0x00, 0x40, 0x80, 0x80, 0x08, 0x10, 0x18, 0x03, 0x02, 0x01, 0x00, 0x40,
  0xC0, 0x30, 0x08, 0x10, 0x02, 0x01, 0x02, 0x00, 0x40, 0x60, 0x40, 0x04,
  0x08, 0x08, 0x00, 0x81, 0x03, 0x00, 0x18, 0x20, 0x40, 0x01, 0x04, 0x08,
  0x00, 0x21, 0x81, 0x00, 0x02, 0x20, 0x20, 0x00, 0x44, 0x0C, 0x00, 0x04,
  0x81, 0x00, 0x00, 0x90, 0x20, 0x00, 0x1E, 0x04, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x02, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x60, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x60, 0x00,
  0x20, 0x80, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x70,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x40, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x02, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x1C,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x08, 0x00, 0x20,
  0x10, 0x00, 0x60, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x82,
  0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x60,
  0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x02, 0x02, 0x00, 0x18, 0x0C, 0x01,
  0xE0, 0x1F, 0xFE, 0x00, 0x20, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80,
  0x20, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x30, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0x87, 0xC0, 0x60, 0x02, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x01, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x80, 0x20, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x23, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00,
  0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x20, 0x18, 0x00, 0x80,
  0x40, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x40, 0x00, 0xC1, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x24, 0x00,
  0x1C, 0x00, 0x09, 0x00, 0x05, 0x00, 0x04, 0x40, 0x03, 0x40, 0x01, 0x10,
  0x00, 0x90, 0x00, 0xC4, 0x00, 0x24, 0x00, 0x21, 0x00, 0x11, 0x00, 0x18,
  0x40, 0x04, 0x60, 0x04, 0x10, 0x02, 0x08, 0x03, 0x04, 0x00, 0x82, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x06, 0x08, 0x02, 0x0C, 0x01, 0x86,
  0x00, 0x82, 0x00, 0x21, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x08, 0x40, 0x02,
  0x20, 0x02, 0x10, 0x00, 0x98, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x32, 0x00,
  0x0B, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x10, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10,
  0x02, 0x00, 0x02, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x10,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x08, 0xC0,
  0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x40, 0xC0, 0x04, 0x02, 0x00, 0x60,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x02, 0x03, 0x00, 0x10, 0x30, 0x00, 0x81,
  0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0x88, 0x00, 0x06, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x90,
  0x00, 0x11, 0x00, 0x03, 0x10, 0x00, 0x21, 0x80, 0x04, 0x08, 0x00, 0xC0,
  0x80, 0x18, 0x08, 0x01, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00, 0x40, 0x40,
  0x06, 0x08, 0x00, 0x21, 0x80, 0x02, 0x30, 0x00, 0x22, 0x00, 0x03, 0x60,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xC2, 0x18, 0x41, 0x0C, 0x20,
  0x00, 0x3C, 0x00, 0x1E, 0xF1, 0x03, 0x01, 0x90, 0x40, 0x09, 0x08, 0x00,
  0x51, 0x80, 0x06, 0x10, 0x00, 0x62, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00,
  0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x04, 0xC0,
  0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0, 0x02, 0x84,
  0x00, 0x70, 0x40, 0x05, 0x06, 0x01, 0x90, 0x30, 0x31, 0x01, 0xFC, 0x10,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x43, 0xDE, 0x01, 0x18, 0x0C, 0x04, 0x80, 0x10,
  0x14, 0x00, 0x20, 0xA0, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x20,
  0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x03, 0x0C, 0x00, 0x08, 0x50, 0x00, 0x41, 0x40, 0x03, 0x04, 0x80,
  0x18, 0x13, 0x01, 0xC0, 0xC3, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0xF0,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x08, 0x01, 0xE7, 0x08, 0x03, 0x00,
  0x88, 0x04, 0x00, 0x48, 0x08, 0x00, 0x38, 0x18, 0x00, 0x30, 0x10, 0x00,
  0x30, 0x20, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x40, 0x80, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0xC0, 0x01,
  0x40, 0x40, 0x02, 0x80, 0x40, 0x06, 0x80, 0x60, 0x0C, 0x80, 0x30, 0x30,
  0x80, 0x1F, 0xE1, 0x80, 0x00, 0x38, 0x00, 0xF7, 0x01, 0xC0, 0x41, 0x80,
  0x11, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x03, 0x40, 0x01, 0x20,
  0x01, 0x30, 0x03, 0x10, 0x7E, 0x0F, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0xCE, 0x10, 0x18, 0x06, 0x40, 0xC0, 0x09, 0x04, 0x00, 0x14,
  0x30, 0x00, 0x60, 0x80, 0x01, 0x84, 0x00, 0x06, 0x10, 0x00, 0x18, 0xC0,
  0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00,
  0x46, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x01, 0x86,
  0x00, 0x0A, 0x08, 0x00, 0x50, 0x20, 0x03, 0x40, 0xC0, 0x19, 0x01, 0x81,
  0x84, 0x03, 0xFC, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0xC0, 0x18, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x3C, 0x01, 0x0F, 0x78, 0x08, 0xC0, 0x60, 0x48, 0x01, 0x02, 0x80, 0x0C,
  0x28, 0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x86, 0x00,
  0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0x86,
  0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00,
  0x86, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0xC0,
  0x00, 0x80, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0xF8, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x01, 0x04, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x18, 0x00, 0x83,
  0x00, 0x18, 0x60, 0x01, 0x0C, 0x00, 0x11, 0xC0, 0x01, 0x24, 0x00, 0x14,
  0x60, 0x02, 0x82, 0x00, 0x30, 0x30, 0x02, 0x01, 0x00, 0x20, 0x18, 0x02,
  0x00, 0x80, 0x60, 0x0C, 0x04, 0x00, 0x40, 0x40, 0x06, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x02, 0x1D, 0xC0,
  0x77, 0x81, 0x30, 0x10, 0xC0, 0x60, 0xB0, 0x0C, 0xC0, 0x10, 0x50, 0x02,
  0x40, 0x08, 0x50, 0x01, 0x40, 0x04, 0x30, 0x00, 0xC0, 0x02, 0x18, 0x00,
  0x60, 0x01, 0x08, 0x00, 0x20, 0x00, 0x8C, 0x00, 0x10, 0x00, 0x44, 0x00,
  0x18, 0x00, 0x22, 0x00, 0x08, 0x00, 0x31, 0x00, 0x04, 0x00, 0x10, 0x80,
  0x02, 0x00, 0x08, 0xC0, 0x01, 0x00, 0x04, 0x40, 0x01, 0x00, 0x02, 0x20,
  0x00, 0x80, 0x02, 0x10, 0x00, 0x40, 0x01, 0x08, 0x00, 0x20, 0x00, 0x8C,
  0x00, 0x30, 0x00, 0x44, 0x00, 0x10, 0x00, 0x62, 0x00, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x00, 0x11, 0x80, 0x02, 0x00, 0x08, 0x00, 0x07, 0x80, 0x21,
  0xEF, 0x01, 0x18, 0x0C, 0x09, 0x00, 0x20, 0x50, 0x01, 0x85, 0x00, 0x0C,
  0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x18, 0x00, 0x10, 0x00,
  0x1C, 0x00, 0x0F, 0x78, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x08, 0x00, 0x21,
  0x80, 0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00,
  0x0C, 0x60, 0x01, 0x83, 0x00, 0x30, 0x18, 0x0E, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x01, 0x0F, 0x78, 0x01, 0x18, 0x0C, 0x01, 0x20, 0x04, 0x01,
  0x40, 0x02, 0x02, 0x80, 0x02, 0x03, 0x00, 0x02, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x04, 0x08,
  0x00, 0x04, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x14, 0x00, 0x10, 0x14,
  0x00, 0x30, 0x12, 0x00, 0x60, 0x13, 0x01, 0xC0, 0x10, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x38, 0x40, 0xC0,
  0x22, 0x0C, 0x00, 0x90, 0x80, 0x02, 0x8C, 0x00, 0x18, 0x40, 0x00, 0xC4,
  0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80,
  0x00, 0xC4, 0x00, 0x06, 0x30, 0x00, 0x50, 0x80, 0x05, 0x04, 0x00, 0x68,
  0x30, 0x06, 0x40, 0xC0, 0xC2, 0x03, 0xFC, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x04, 0x3F, 0x04, 0x60, 0x04, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x03, 0xCF, 0xC3, 0x00, 0x43, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC4, 0x00, 0x43, 0x00, 0xC0,
  0xFF, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x05,
  0xFF, 0xC1, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x07,
  0xF0, 0x00, 0x08, 0x00, 0x18, 0x40, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00,
  0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0xC0, 0x00, 0x84, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00,
  0x1C, 0x30, 0x00, 0xA0, 0x80, 0x0B, 0x04, 0x00, 0x90, 0x10, 0x18, 0x80,
  0x7F, 0x04, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x00, 0x04,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x80, 0x30, 0x20, 0x08, 0x08,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x10, 0x03, 0x0C,
  0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x14, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x02, 0x40, 0x0A, 0x00, 0x64, 0x00, 0xA0, 0x04, 0x40, 0x12, 0x00,
  0x44, 0x01, 0x20, 0x08, 0x40, 0x22, 0x00, 0x84, 0x02, 0x20, 0x10, 0x40,
  0x43, 0x01, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04,
  0x20, 0x11, 0x80, 0x44, 0x01, 0x10, 0x06, 0xC0, 0x13, 0x00, 0x28, 0x01,
  0xA0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x20, 0x02,
  0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x31, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x60, 0x00, 0x10, 0x80, 0x00, 0xC3, 0x00,
  0x06, 0x04, 0x00, 0x30, 0x18, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x20,
  0x01, 0x01, 0x00, 0x06, 0x08, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x80, 0x10, 0x00, 0x40, 0x10,
  0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x0E, 0x03,
  0x80, 0xA0, 0x07, 0xF8,
};

const GFXglyph NotoSans_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 31, 9, 1, -31 },
  { 36, 9, 11, 14, 5, -31 },
  { 49, 25, 31, 27, 2, -31 },
  { 146, 21, 36, 24, 2, -33 },
  { 241, 27, 33, 34, 4, -32 },
  { 353, 26, 32, 30, 2, -32 },
  { 457, 3, 11, 8, 5, -31 },
  { 462, 13, 38, 11, 1, -31 },
  { 524, 13, 38, 11, -3, -31 },
  { 586, 18, 18, 23, 6, -33 },
  { 627, 21, 21, 25, 3, -26 },
  { 683, 6, 11, 8, -2, -5 },
  { 692, 10, 2, 14, 2, -13 },
  { 695, 3, 2, 9, 1, -2 },
  { 696, 19, 31, 13, -2, -31 },
  { 770, 20, 32, 24, 3, -32 },
  { 850, 11, 31, 24, 7, -31 },
  { 893, 22, 32, 24, 0, -32 },
  { 981, 22, 32, 24, 1, -32 },
  { 1069, 22, 32, 24, 1, -32 },
  { 1157, 22, 31, 24, 2, -31 },
  { 1243, 21, 32, 24, 3, -32 },
  { 1327, 20, 31, 24, 5, -31 },
  { 1405, 21, 32, 24, 2, -32 },
  { 1489, 21, 32, 24, 2, -32 },
  { 1573, 7, 23, 9, 1, -23 },
  { 1594, 10, 29, 9, -2, -23 },
  { 1631, 21, 20, 25, 3, -26 },
  { 1684, 21, 10, 25, 3, -21 },
  { 1711, 21, 20, 25, 3, -26 },
  { 1764, 15, 32, 18, 4, -32 },
  { 1824, 34, 35, 37, 2, -31 },
  { 1973, 24, 32, 24, -2, -32 },
  { 2069, 24, 31, 26, 2, -31 },
  { 2162, 24, 32, 26, 4, -32 },
  { 2258, 26, 31, 30, 2, -31 },
  { 2359, 23, 31, 24, 2, -31 },
  { 2449, 23, 31, 21, 2, -31 },
  { 2539, 25, 32, 30, 4, -32 },
  { 2639, 28, 31, 30, 2, -31 },
  { 2748, 14, 31, 12, 0, -31 },
  { 2803, 17, 39, 10, -7, -31 },
  { 2886, 26, 31, 24, 2, -31 },
  { 2987, 16, 31, 22, 2, -31 },
  { 3049, 33, 31, 35, 2, -31 },
  { 3177, 27, 31, 30, 2, -31 },
  { 3282, 26, 32, 32, 4, -32 },
  { 3386, 23, 31, 25, 2, -31 },
  { 3476, 26, 39, 32, 4, -32 },
  { 3603, 23, 31, 25, 2, -31 },
  { 3693, 21, 32, 22, 1, -32 },
  { 3777, 21, 31, 21, 4, -31 },
  { 3859, 26, 31, 30, 4, -31 },
  { 3960, 22, 31, 24, 5, -31 },
  { 4046, 34, 31, 36, 5, -31 },
  { 4178, 28, 31, 22, -3, -31 },
  { 4287, 21, 31, 21, 4, -31 },
  { 4369, 25, 31, 24, 0, -31 },
  { 4466, 16, 38, 13, 0, -31 },
  { 4542, 7, 31, 13, 4, -31 },
  { 4570, 16, 38, 13, -3, -31 },
  { 4646, 20, 20, 24, 2, -32 },
  { 4696, 17, 1, 16, -4, 5 },
  { 4699, 5, 7, 10, 6, -34 },
  { 4704, 20, 24, 24, 2, -24 },
  { 4764, 22, 33, 25, 1, -33 },
  { 4855, 18, 24, 20, 2, -24 },
  { 4909, 24, 33, 25, 2, -33 },
  { 5008, 17, 24, 22, 3, -24 },
  { 5059, 24, 45, 12, -6, -34 },
  { 5194, 22, 35, 25, 1, -24 },
  { 5291, 21, 33, 24, 1, -33 },
  { 5378, 9, 32, 9, 1, -32 },
  { 5414, 16, 43, 9, -6, -32 },
  { 5500, 20, 33, 19, 1, -33 },
  { 5583, 9, 33, 9, 1, -33 },
  { 5621, 33, 24, 37, 1, -24 },
  { 5720, 21, 24, 24, 1, -24 },
  { 5783, 20, 24, 25, 2, -24 },
  { 5843, 24, 34, 25, -1, -24 },
  { 5945, 21, 34, 25, 2, -24 },
  { 6035, 16, 24, 16, 1, -24 },
  { 6083, 17, 24, 19, 1, -24 },
  { 6134, 13, 29, 14, 2, -29 },
  { 6182, 21, 23, 24, 2, -23 },
  { 6243, 18, 23, 18, 2, -23 },
  { 6295, 28, 23, 29, 2, -23 },
  { 6376, 22, 23, 20, -1, -23 },
  { 6440, 25, 34, 18, -5, -23 },
  { 6547, 20, 23, 19, -1, -23 },
  { 6605, 16, 38, 14, 1, -31 },
  { 6681, 2, 44, 24, 12, -33 },
  { 6692, 15, 38, 14, -2, -31 },
  { 6764, 21, 3, 25, 3, -17 },
};

const GFXfont NotoSans_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_THINITALIC44PT7B_H_
