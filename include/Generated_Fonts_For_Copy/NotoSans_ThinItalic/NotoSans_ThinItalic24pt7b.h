#ifndef _NOTOSANS_THINITALIC24PT7B_H_
#define _NOTOSANS_THINITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x40, 0x00, 0x80, 0x4C, 0x65,
  0x29, 0x48, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x08, 0x04, 0x21, 0xFF,
  0xF0, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x08, 0x3F, 0xFC, 0x10,
  0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x01, 0x00, 0x20, 0x3F,
  0x88, 0x82, 0x10, 0x44, 0x08, 0x80, 0x90, 0x0A, 0x00, 0xE0, 0x12, 0x02,
  0x20, 0x44, 0x08, 0x82, 0x14, 0x4C, 0x7C, 0x01, 0x00, 0x20, 0x00, 0x3C,
  0x04, 0x84, 0x11, 0x08, 0x44, 0x10, 0x88, 0x22, 0x10, 0x48, 0x21, 0x22,
  0x42, 0x5B, 0x85, 0x42, 0xB4, 0x84, 0x89, 0x08, 0x24, 0x10, 0x88, 0x22,
  0x10, 0x44, 0x21, 0x10, 0x42, 0x40, 0x78, 0x07, 0xE0, 0x20, 0x80, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x21, 0x00, 0x58, 0x01, 0x80, 0x1A, 0x00, 0x84,
  0x14, 0x08, 0x60, 0x22, 0x80, 0x4A, 0x00, 0xC8, 0x02, 0x10, 0x34, 0x3F,
  0x08, 0x6A, 0xA0, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x04, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x81,
  0x0C, 0x00, 0x04, 0x01, 0x08, 0x41, 0x90, 0x1F, 0xC2, 0x03, 0x41, 0x10,
  0x42, 0x00, 0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x25, 0x25, 0x00, 0xFC, 0x80,
  0x00, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x82,
  0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x44, 0x10, 0x7C, 0x00, 0x0C, 0xD4,
  0xA2, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x40, 0x07,
  0xE0, 0x81, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFF,
  0xC0, 0x0F, 0xC3, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x1F, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0xFF, 0x00, 0x00, 0x10, 0x01, 0x80, 0x14, 0x01, 0x20, 0x12, 0x01,
  0x10, 0x10, 0x81, 0x04, 0x10, 0x20, 0x82, 0x08, 0x10, 0x80, 0x8B, 0xFF,
  0x80, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xF0, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x03, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0xFF, 0x00, 0x07, 0xE1, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x13, 0x85, 0x8C, 0xC0, 0x90, 0x0A, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x20, 0x24, 0x08, 0x7E, 0x00, 0xFF, 0xC0, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0x02, 0x10, 0x11,
  0x01, 0x10, 0x11, 0x02, 0x08, 0x40, 0x58, 0x0F, 0x03, 0x08, 0x40, 0x48,
  0x04, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x0F, 0xC1, 0x02,
  0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x20, 0x61, 0x1A,
  0x0E, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFC, 0x00, 0x24,
  0x00, 0x00, 0x00, 0x08, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x44,
  0x21, 0x10, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x02, 0x00, 0x00, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x04, 0x18, 0x20, 0x40, 0x40, 0x40, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFE,
  0x01, 0x80, 0x40, 0x80, 0x08, 0x40, 0x01, 0x20, 0x00, 0x48, 0x3F, 0x14,
  0x10, 0x45, 0x08, 0x21, 0x84, 0x08, 0x61, 0x02, 0x18, 0x41, 0x06, 0x10,
  0x41, 0x84, 0x30, 0xA0, 0x92, 0xC4, 0x18, 0x41, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40,
  0x12, 0x01, 0x10, 0x08, 0x40, 0x82, 0x04, 0x10, 0x40, 0x87, 0xFC, 0x20,
  0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x01, 0x80, 0x08, 0x0F, 0xE0, 0x80,
  0xC4, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x47, 0xDC, 0x21, 0xC1,
  0x01, 0x10, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x90, 0x08, 0xFF,
  0x80, 0x07, 0xF8, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x40, 0x41, 0x00, 0x84, 0x01,
  0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00,
  0x50, 0x02, 0x40, 0x09, 0x00, 0x44, 0x02, 0x20, 0x30, 0xFF, 0x00, 0x0F,
  0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFF,
  0x80, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x3F, 0xC2, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x00, 0x07, 0xFC, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xF2, 0x00, 0x28, 0x00, 0xA0, 0x04,
  0x80, 0x12, 0x00, 0x44, 0x01, 0x08, 0x04, 0x1F, 0xE0, 0x08, 0x02, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x44, 0x00, 0x88, 0x01, 0x1F, 0xFE,
  0x20, 0x04, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x04, 0x40, 0x08, 0x80, 0x10, 0x0F, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xF0, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0xF0,
  0x00, 0x08, 0x0C, 0x40, 0x41, 0x02, 0x04, 0x10, 0x10, 0x80, 0x84, 0x02,
  0x60, 0x0B, 0x00, 0x32, 0x00, 0x88, 0x04, 0x10, 0x10, 0x40, 0x40, 0x81,
  0x02, 0x04, 0x04, 0x20, 0x10, 0x80, 0x60, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0xFF, 0x80, 0x08, 0x00, 0x46, 0x00, 0x31, 0x80, 0x14, 0x50, 0x05,
  0x14, 0x02, 0x89, 0x00, 0xA2, 0x40, 0x48, 0x90, 0x22, 0x24, 0x08, 0x88,
  0x84, 0x44, 0x21, 0x11, 0x08, 0x84, 0x42, 0x41, 0x10, 0x90, 0x44, 0x18,
  0x22, 0x06, 0x08, 0x81, 0x02, 0x00, 0x08, 0x02, 0x30, 0x04, 0x50, 0x08,
  0xA0, 0x21, 0x40, 0x44, 0x40, 0x88, 0x81, 0x10, 0x82, 0x21, 0x08, 0x41,
  0x11, 0x02, 0x22, 0x04, 0x44, 0x04, 0x88, 0x0A, 0x10, 0x0C, 0x40, 0x18,
  0x80, 0x10, 0x07, 0xF0, 0x60, 0x22, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80,
  0x0A, 0x00, 0x44, 0x01, 0x08, 0x08, 0x1F, 0xC0, 0x0F, 0xE1, 0x01, 0x10,
  0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x43, 0xE8, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x07, 0xF0,
  0x60, 0x22, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x01,
  0x08, 0x08, 0x1D, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x0F,
  0xE1, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20,
  0xC3, 0xF0, 0x41, 0x04, 0x08, 0x40, 0x84, 0x08, 0x40, 0x48, 0x04, 0x80,
  0x40, 0x07, 0xF0, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0xFF, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x00, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x20, 0x3F,
  0x80, 0x80, 0x38, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08,
  0x10, 0x82, 0x04, 0x20, 0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x50, 0x02,
  0x00, 0x20, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12, 0x11, 0x08, 0x84, 0x42, 0x22,
  0x11, 0x08, 0x84, 0x42, 0x41, 0x20, 0x90, 0x28, 0x28, 0x0C, 0x0A, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x08, 0x06, 0x10, 0x10, 0x10, 0x40,
  0x20, 0x80, 0x42, 0x00, 0x48, 0x00, 0xA0, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x12, 0x00, 0x44, 0x01, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x10,
  0x80, 0x20, 0x80, 0x14, 0x02, 0x40, 0x44, 0x08, 0x20, 0x82, 0x10, 0x22,
  0x02, 0x40, 0x14, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x0F, 0x84,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x0F, 0x80, 0x88, 0x44,
  0x44, 0x42, 0x22, 0x22, 0x21, 0x11, 0x10, 0x07, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x0F, 0x80, 0x01, 0x00, 0x50, 0x0A, 0x02,
  0x40, 0x84, 0x20, 0x84, 0x11, 0x01, 0x40, 0x38, 0x04, 0xFF, 0x80, 0xA4,
  0x0F, 0x22, 0x14, 0x81, 0xA0, 0x34, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x12, 0x06, 0x21, 0x43, 0xC8, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x4F, 0x0A, 0x11, 0x81, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x60, 0x16, 0x02, 0xC0, 0x97, 0xE0, 0x0F, 0x84, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x3F, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x07, 0x88, 0x41, 0x44,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x18, 0x41, 0x41, 0xF4, 0x00, 0x07, 0x86, 0x12, 0x04, 0x81, 0x40,
  0x50, 0x67, 0xE2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x07, 0xE0, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x1C, 0x00, 0x0F, 0x91, 0x05, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC4, 0x14, 0x3E, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x08, 0x20, 0x7C, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x4F, 0x8A, 0x09, 0x81, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x24,
  0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x10, 0x10, 0x00, 0x22, 0x22,
  0x44, 0x44, 0x48, 0x88, 0x80, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x12,
  0x08, 0x84, 0x22, 0x11, 0x04, 0x81, 0x60, 0x64, 0x11, 0x08, 0x22, 0x08,
  0x81, 0x20, 0x40, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44, 0x88, 0x88,
  0x27, 0x87, 0x8A, 0x16, 0x13, 0x05, 0x04, 0x81, 0x81, 0x40, 0x40, 0x50,
  0x10, 0x14, 0x04, 0x09, 0x02, 0x02, 0x40, 0x80, 0xA0, 0x20, 0x28, 0x08,
  0x0A, 0x02, 0x04, 0x81, 0x01, 0x00, 0x27, 0xC5, 0x04, 0xC0, 0x90, 0x14,
  0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x08,
  0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0A, 0x01, 0x20, 0x43, 0xF0, 0x13, 0xC1, 0x42, 0x18, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x60, 0x26, 0x04,
  0x5F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F,
  0x11, 0x05, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x48, 0x04, 0x80, 0xC4, 0x14, 0x3E, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x23, 0x28, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xCC, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0xFE, 0x00, 0x10, 0x20,
  0x87, 0xF2, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x3C,
  0x20, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02, 0x80,
  0x50, 0x12, 0x06, 0x41, 0x47, 0xC8, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x41,
  0x10, 0x84, 0x21, 0x10, 0x48, 0x12, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x81,
  0x03, 0x02, 0x06, 0x0C, 0x14, 0x14, 0x28, 0x48, 0x50, 0x91, 0x22, 0x22,
  0x24, 0x48, 0x50, 0x90, 0xA1, 0x41, 0x82, 0x82, 0x02, 0x04, 0x04, 0x00,
  0x10, 0x11, 0x02, 0x08, 0x40, 0x84, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60,
  0x09, 0x01, 0x10, 0x20, 0x84, 0x08, 0xC0, 0x40, 0x08, 0x04, 0x20, 0x10,
  0x80, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40,
  0x0A, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xFF, 0x00, 0x07,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x0E,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x02, 0x03, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x70, 0x11, 0x84, 0x0D,
  0x00,
};

const GFXglyph NotoSans_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 5, 6, 7, 3, -17 },
  { 14, 14, 17, 15, 1, -17 },
  { 44, 11, 19, 13, 1, -18 },
  { 71, 15, 17, 18, 2, -17 },
  { 103, 14, 17, 16, 1, -17 },
  { 133, 2, 6, 4, 3, -17 },
  { 135, 6, 21, 6, 1, -17 },
  { 151, 7, 21, 6, -2, -17 },
  { 170, 10, 10, 13, 3, -18 },
  { 183, 11, 11, 14, 2, -14 },
  { 199, 3, 6, 4, -1, -3 },
  { 202, 6, 1, 7, 1, -7 },
  { 203, 1, 1, 5, 1, -1 },
  { 204, 10, 17, 7, -1, -17 },
  { 226, 11, 17, 13, 2, -17 },
  { 250, 6, 17, 13, 4, -17 },
  { 263, 12, 17, 13, 0, -17 },
  { 289, 12, 17, 13, 1, -17 },
  { 315, 13, 17, 13, 0, -17 },
  { 343, 12, 17, 13, 1, -17 },
  { 369, 11, 17, 13, 2, -17 },
  { 393, 10, 17, 13, 3, -17 },
  { 415, 12, 17, 13, 1, -17 },
  { 441, 12, 17, 13, 1, -17 },
  { 467, 3, 13, 5, 1, -13 },
  { 472, 5, 16, 5, -1, -13 },
  { 482, 11, 11, 14, 2, -14 },
  { 498, 11, 5, 14, 2, -11 },
  { 505, 11, 11, 14, 2, -14 },
  { 521, 8, 17, 10, 2, -17 },
  { 538, 18, 19, 20, 1, -17 },
  { 581, 13, 17, 13, -1, -17 },
  { 609, 13, 17, 14, 1, -17 },
  { 637, 13, 17, 14, 2, -17 },
  { 665, 14, 17, 16, 1, -17 },
  { 695, 12, 17, 13, 1, -17 },
  { 721, 12, 17, 12, 1, -17 },
  { 747, 14, 17, 17, 2, -17 },
  { 777, 15, 17, 16, 1, -17 },
  { 809, 8, 17, 7, 0, -17 },
  { 826, 10, 21, 6, -4, -17 },
  { 853, 14, 17, 13, 1, -17 },
  { 883, 9, 17, 12, 1, -17 },
  { 903, 18, 17, 19, 1, -17 },
  { 942, 15, 17, 16, 1, -17 },
  { 974, 14, 17, 17, 2, -17 },
  { 1004, 12, 17, 13, 1, -17 },
  { 1030, 14, 21, 17, 2, -17 },
  { 1067, 12, 17, 13, 1, -17 },
  { 1093, 12, 17, 12, 0, -17 },
  { 1119, 12, 17, 12, 2, -17 },
  { 1145, 15, 17, 17, 2, -17 },
  { 1177, 12, 17, 13, 3, -17 },
  { 1203, 18, 17, 20, 3, -17 },
  { 1242, 15, 17, 12, -1, -17 },
  { 1274, 12, 17, 12, 2, -17 },
  { 1300, 14, 17, 13, 0, -17 },
  { 1330, 9, 21, 7, 0, -17 },
  { 1354, 4, 17, 7, 2, -17 },
  { 1363, 9, 21, 7, -2, -17 },
  { 1387, 11, 10, 13, 1, -17 },
  { 1401, 9, 1, 9, -2, 2 },
  { 1403, 2, 3, 5, 4, -18 },
  { 1404, 11, 13, 13, 1, -13 },
  { 1422, 11, 18, 14, 1, -18 },
  { 1447, 10, 13, 11, 1, -13 },
  { 1464, 13, 18, 14, 1, -18 },
  { 1494, 10, 13, 12, 1, -13 },
  { 1511, 13, 24, 6, -3, -18 },
  { 1550, 12, 19, 14, 1, -13 },
  { 1579, 11, 18, 13, 1, -18 },
  { 1604, 4, 17, 5, 1, -17 },
  { 1613, 8, 23, 5, -3, -17 },
  { 1636, 10, 18, 11, 1, -18 },
  { 1659, 4, 18, 5, 1, -18 },
  { 1668, 18, 13, 20, 1, -13 },
  { 1698, 11, 13, 13, 1, -13 },
  { 1716, 11, 13, 14, 1, -13 },
  { 1734, 12, 19, 14, 0, -13 },
  { 1763, 12, 19, 14, 1, -13 },
  { 1792, 8, 13, 9, 1, -13 },
  { 1805, 10, 13, 10, 0, -13 },
  { 1822, 7, 16, 7, 1, -16 },
  { 1836, 11, 13, 13, 1, -13 },
  { 1854, 10, 13, 10, 1, -13 },
  { 1871, 15, 13, 16, 1, -13 },
  { 1896, 12, 13, 11, -1, -13 },
  { 1916, 14, 19, 10, -3, -13 },
  { 1950, 10, 13, 10, 0, -13 },
  { 1967, 8, 21, 8, 1, -17 },
  { 1988, 1, 24, 13, 7, -18 },
  { 1991, 8, 21, 8, -1, -17 },
  { 2012, 11, 3, 14, 2, -10 },
};

const GFXfont NotoSans_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_THINITALIC24PT7B_H_
