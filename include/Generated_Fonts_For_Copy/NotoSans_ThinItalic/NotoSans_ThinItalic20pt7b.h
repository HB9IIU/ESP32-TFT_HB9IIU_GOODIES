#ifndef _NOTOSANS_THINITALIC20PT7B_H_
#define _NOTOSANS_THINITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x52, 0x01, 0x00, 0x4A, 0xA5, 0x29, 0x00, 0x04,
  0x41, 0x08, 0x22, 0x04, 0x47, 0xFE, 0x21, 0x04, 0x40, 0x88, 0x21, 0x1F,
  0xD8, 0x88, 0x11, 0x04, 0x20, 0x88, 0x00, 0x02, 0x05, 0x85, 0x24, 0x82,
  0x41, 0x20, 0x90, 0x30, 0x0E, 0x04, 0x82, 0x41, 0x21, 0x27, 0xE0, 0x40,
  0x20, 0x78, 0x38, 0x44, 0x84, 0x48, 0x88, 0x89, 0x08, 0xA6, 0x8A, 0x99,
  0x51, 0x69, 0x10, 0x91, 0x12, 0x12, 0x21, 0x42, 0x2C, 0x1C, 0x07, 0x00,
  0x88, 0x10, 0x41, 0x04, 0x10, 0x81, 0x10, 0x0E, 0x01, 0x80, 0x24, 0x14,
  0x22, 0x81, 0x28, 0x14, 0x80, 0x88, 0x14, 0x7E, 0x20, 0x5A, 0x80, 0x08,
  0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xC0, 0x18, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x08, 0x10, 0x90,
  0x77, 0x18, 0x68, 0x88, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x29, 0x48, 0xF0, 0x80, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x00, 0x07, 0x06, 0x22, 0x08, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x10, 0x83, 0xC0, 0x19, 0x72, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x20, 0x1F, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x3F, 0xE0,
  0x1F, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x03, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x40, 0x09, 0xFE, 0x00, 0x00, 0x40, 0x18, 0x05,
  0x01, 0x20, 0x48, 0x11, 0x04, 0x21, 0x04, 0x40, 0x9F, 0xFC, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x1F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x1F, 0x00,
  0x30, 0x04, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02, 0x3F, 0x00, 0x03, 0xC3,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x05, 0xE1, 0x84, 0x40, 0xA0, 0x28, 0x0A,
  0x02, 0x81, 0x10, 0x43, 0xE0, 0x7F, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x00, 0x1F, 0x88, 0x12,
  0x04, 0x81, 0x20, 0x84, 0xC0, 0xC0, 0xC8, 0x41, 0x20, 0x28, 0x0A, 0x04,
  0x81, 0x1F, 0x80, 0x1F, 0x10, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x47,
  0x1C, 0x80, 0x80, 0x40, 0x40, 0x47, 0xC0, 0x24, 0x00, 0x00, 0x02, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x00, 0x01, 0x10, 0x88, 0x40, 0x00, 0x81, 0x87,
  0x0C, 0x08, 0x02, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x00,
  0xFC, 0x10, 0x41, 0x04, 0x21, 0x08, 0x42, 0x08, 0x00, 0x02, 0x00, 0x07,
  0xF8, 0x10, 0x08, 0x40, 0x09, 0x00, 0x14, 0x3E, 0x28, 0x84, 0x62, 0x08,
  0xC4, 0x11, 0x88, 0x43, 0x10, 0x8A, 0x23, 0x14, 0x39, 0xC4, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x20, 0x44,
  0x08, 0x82, 0x10, 0x42, 0x1F, 0xC4, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x00,
  0x40, 0x1F, 0xC4, 0x04, 0x80, 0x90, 0x12, 0x04, 0x41, 0x0F, 0xC2, 0x04,
  0x40, 0x48, 0x09, 0x01, 0x40, 0x48, 0x19, 0xFC, 0x00, 0x1F, 0xE4, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x7E, 0x00, 0x1F, 0xC2, 0x02, 0x20, 0x22, 0x01, 0x20,
  0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x81,
  0x8F, 0xE0, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xF1, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x3F, 0x80, 0x1F, 0xC8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x1F, 0xE4, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x1E, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x24, 0x08, 0x7F, 0x00, 0x10, 0x09,
  0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0xFF, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x20, 0x1C, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x23, 0x80, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10,
  0xF0, 0x10, 0x32, 0x04, 0x21, 0x82, 0x20, 0x24, 0x02, 0x80, 0x58, 0x06,
  0x40, 0x44, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x1F, 0xC0, 0x10,
  0x02, 0x60, 0x0C, 0xA0, 0x29, 0x40, 0x62, 0x81, 0x45, 0x02, 0x92, 0x09,
  0x24, 0x22, 0x44, 0x48, 0x89, 0x11, 0x12, 0x24, 0x28, 0x48, 0x60, 0x90,
  0x42, 0x00, 0x10, 0x13, 0x01, 0x28, 0x12, 0x81, 0x24, 0x12, 0x42, 0x42,
  0x24, 0x22, 0x42, 0x24, 0x12, 0x41, 0x48, 0x0C, 0x80, 0xC8, 0x04, 0x07,
  0x01, 0x8C, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x1F, 0x88,
  0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x09, 0xFC, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x07, 0x01, 0x8C, 0x20, 0x24, 0x02, 0x40, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44,
  0x08, 0x3B, 0x00, 0x40, 0x04, 0x00, 0x30, 0x1F, 0x88, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x14, 0x19, 0xF8, 0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20,
  0x20, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x01, 0x3F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x00, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x81, 0x07, 0xE0, 0x80, 0x60,
  0x28, 0x0A, 0x04, 0x81, 0x10, 0x84, 0x21, 0x10, 0x44, 0x12, 0x04, 0x81,
  0x40, 0x60, 0x08, 0x00, 0x80, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84,
  0x84, 0x84, 0x44, 0x88, 0x48, 0x88, 0x48, 0x90, 0x50, 0x90, 0x50, 0x90,
  0x50, 0xA0, 0x60, 0xA0, 0x40, 0x40, 0x40, 0x40, 0x10, 0x10, 0x82, 0x08,
  0x40, 0x48, 0x04, 0x80, 0x50, 0x02, 0x00, 0x60, 0x09, 0x01, 0x10, 0x11,
  0x02, 0x08, 0x40, 0x88, 0x04, 0x80, 0xE0, 0x44, 0x11, 0x08, 0x44, 0x11,
  0x02, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x00, 0x1F,
  0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x01, 0xFF, 0x00, 0x1E, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0, 0x92, 0x44,
  0x92, 0x48, 0x92, 0x40, 0x1E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0xF0, 0x02, 0x03, 0x02, 0x42, 0x21,
  0x11, 0x05, 0x03, 0x01, 0xFF, 0x94, 0x1E, 0x90, 0xD0, 0x28, 0x18, 0x0C,
  0x0A, 0x05, 0x02, 0x83, 0x42, 0x9E, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02,
  0xF2, 0x85, 0x82, 0x81, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x16, 0x0A, 0xF8,
  0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x21, 0xE4, 0x42, 0x90, 0x22, 0x04, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x88, 0x11, 0x06, 0x1F, 0x40, 0x0E, 0x31, 0x41, 0x41,
  0x82, 0xFC, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x01, 0xE0, 0x20, 0x08, 0x01,
  0x00, 0xF8, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x70, 0x00, 0x1E,
  0x48, 0x54, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0xC7,
  0xD0, 0x04, 0x02, 0x00, 0x80, 0x43, 0xE0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0xF2, 0x85, 0x82, 0x81, 0x40, 0xA0, 0x60, 0x50, 0x28, 0x14, 0x0A, 0x04,
  0x20, 0x14, 0x92, 0x52, 0x49, 0x00, 0x02, 0x00, 0x00, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x23, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x0A, 0x09, 0x18, 0x90, 0x50, 0x38, 0x12, 0x11,
  0x08, 0x44, 0x22, 0x08, 0x24, 0x92, 0x92, 0x4A, 0x49, 0x20, 0x2E, 0x3C,
  0xA2, 0x85, 0x86, 0x0A, 0x04, 0x14, 0x10, 0x28, 0x20, 0xA0, 0x41, 0x40,
  0x82, 0x82, 0x05, 0x04, 0x0A, 0x08, 0x20, 0x2F, 0x28, 0x58, 0x28, 0x14,
  0x0A, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x40, 0x1E, 0x10, 0xD0, 0x28,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0x9F, 0x80, 0x17, 0x8A, 0x13,
  0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x98, 0x29, 0xF2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x1E, 0x48, 0x54, 0x09, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x04, 0x81, 0x20, 0xC7, 0xD0, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x2E, 0xA1, 0x82, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1F,
  0x20, 0x40, 0x40, 0x20, 0x18, 0x04, 0x02, 0x02, 0x02, 0xFC, 0x20, 0x8F,
  0xD0, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x40, 0xA0, 0x50, 0x28,
  0x14, 0x0C, 0x0A, 0x05, 0x02, 0x83, 0x42, 0x9E, 0x80, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x48, 0x48, 0x50, 0x50, 0x60, 0x40, 0x82, 0x0C, 0x10, 0xA1,
  0x85, 0x14, 0x48, 0xA2, 0x49, 0x22, 0x49, 0x14, 0x30, 0xA1, 0x82, 0x08,
  0x10, 0x40, 0x10, 0x44, 0x11, 0x08, 0x24, 0x0A, 0x01, 0x00, 0xC0, 0x48,
  0x22, 0x10, 0x4C, 0x10, 0x10, 0x22, 0x04, 0x41, 0x08, 0x21, 0x08, 0x11,
  0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x3F, 0x80, 0x0E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x80, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0xC0,
  0xF0, 0xC7, 0x80,
};

const GFXglyph NotoSans_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 4, 1, -14 },
  { 7, 5, 5, 6, 2, -14 },
  { 11, 11, 14, 12, 1, -14 },
  { 31, 9, 16, 11, 1, -15 },
  { 49, 12, 14, 15, 2, -14 },
  { 70, 12, 15, 14, 1, -15 },
  { 93, 2, 5, 3, 2, -14 },
  { 95, 5, 17, 5, 1, -14 },
  { 106, 5, 17, 5, -1, -14 },
  { 117, 8, 8, 11, 3, -15 },
  { 125, 10, 10, 11, 1, -12 },
  { 138, 3, 5, 4, -1, -2 },
  { 140, 4, 1, 6, 1, -6 },
  { 141, 1, 1, 4, 1, -1 },
  { 142, 9, 14, 6, -1, -14 },
  { 158, 10, 15, 11, 1, -15 },
  { 177, 5, 14, 11, 3, -14 },
  { 186, 10, 14, 11, 0, -14 },
  { 204, 11, 14, 11, 0, -14 },
  { 224, 11, 14, 11, 0, -14 },
  { 244, 10, 14, 11, 1, -14 },
  { 262, 10, 15, 11, 1, -15 },
  { 281, 9, 14, 11, 2, -14 },
  { 297, 10, 14, 11, 1, -14 },
  { 315, 9, 14, 11, 1, -14 },
  { 331, 3, 11, 4, 1, -11 },
  { 336, 5, 14, 4, -1, -11 },
  { 345, 9, 9, 11, 2, -12 },
  { 356, 10, 4, 11, 1, -9 },
  { 361, 9, 9, 11, 2, -12 },
  { 372, 6, 14, 8, 2, -14 },
  { 383, 15, 16, 17, 1, -14 },
  { 413, 11, 14, 11, -1, -14 },
  { 433, 11, 14, 12, 1, -14 },
  { 453, 11, 14, 12, 2, -14 },
  { 473, 12, 14, 14, 1, -14 },
  { 494, 10, 14, 11, 1, -14 },
  { 512, 10, 14, 10, 1, -14 },
  { 530, 11, 14, 14, 2, -14 },
  { 550, 13, 14, 14, 1, -14 },
  { 573, 6, 14, 6, 0, -14 },
  { 584, 8, 17, 5, -3, -14 },
  { 601, 12, 14, 11, 1, -14 },
  { 622, 7, 14, 10, 1, -14 },
  { 635, 15, 14, 16, 1, -14 },
  { 662, 12, 14, 13, 1, -14 },
  { 683, 12, 15, 14, 2, -15 },
  { 706, 10, 14, 11, 1, -14 },
  { 724, 12, 18, 14, 2, -15 },
  { 751, 10, 14, 11, 1, -14 },
  { 769, 10, 14, 10, 0, -14 },
  { 787, 10, 14, 10, 2, -14 },
  { 805, 12, 14, 14, 2, -14 },
  { 826, 10, 14, 11, 2, -14 },
  { 844, 16, 14, 17, 2, -14 },
  { 872, 12, 14, 10, -1, -14 },
  { 893, 10, 14, 10, 2, -14 },
  { 911, 11, 14, 11, 0, -14 },
  { 931, 7, 17, 6, 0, -14 },
  { 946, 3, 14, 6, 2, -14 },
  { 952, 7, 17, 6, -1, -14 },
  { 967, 9, 8, 11, 1, -14 },
  { 976, 8, 1, 7, -2, 2 },
  { 977, 2, 3, 5, 3, -15 },
  { 978, 9, 11, 11, 1, -11 },
  { 991, 9, 15, 11, 1, -15 },
  { 1008, 8, 11, 9, 1, -11 },
  { 1019, 11, 15, 11, 1, -15 },
  { 1040, 8, 11, 10, 1, -11 },
  { 1051, 11, 20, 5, -3, -15 },
  { 1079, 10, 16, 11, 1, -11 },
  { 1099, 9, 15, 11, 1, -15 },
  { 1116, 3, 14, 4, 1, -14 },
  { 1122, 7, 19, 4, -3, -14 },
  { 1139, 9, 15, 9, 1, -15 },
  { 1156, 3, 15, 4, 1, -15 },
  { 1162, 15, 11, 17, 1, -11 },
  { 1183, 9, 11, 11, 1, -11 },
  { 1196, 9, 11, 11, 1, -11 },
  { 1209, 10, 16, 11, 0, -11 },
  { 1229, 10, 16, 11, 1, -11 },
  { 1249, 7, 11, 7, 1, -11 },
  { 1259, 8, 11, 8, 0, -11 },
  { 1270, 6, 13, 6, 1, -13 },
  { 1280, 9, 11, 11, 1, -11 },
  { 1293, 8, 11, 8, 1, -11 },
  { 1304, 13, 11, 13, 1, -11 },
  { 1322, 10, 11, 9, -1, -11 },
  { 1336, 11, 16, 8, -2, -11 },
  { 1358, 9, 11, 9, 0, -11 },
  { 1371, 7, 17, 7, 1, -14 },
  { 1386, 1, 20, 11, 5, -15 },
  { 1389, 7, 17, 7, -1, -14 },
  { 1404, 9, 2, 11, 2, -8 },
};

const GFXfont NotoSans_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_THINITALIC20PT7B_H_
