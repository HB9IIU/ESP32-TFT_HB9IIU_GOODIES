#ifndef _NOTOSANS_THINITALIC27PT7B_H_
#define _NOTOSANS_THINITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x20, 0x00, 0x00,
  0x20, 0x45, 0x14, 0xA2, 0x8A, 0x28, 0x80, 0x01, 0x04, 0x01, 0x08, 0x02,
  0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x3F, 0xFF, 0x04, 0x10, 0x04,
  0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFC, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x20, 0x80, 0x20, 0x80, 0x20, 0x80, 0x00, 0xC0, 0x04,
  0x01, 0xFE, 0x11, 0x01, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x68, 0x00, 0xE0, 0x04, 0x80, 0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04,
  0x46, 0x2C, 0x0F, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x09,
  0x00, 0x88, 0x40, 0x88, 0x20, 0x84, 0x10, 0x42, 0x08, 0x42, 0x04, 0x41,
  0x02, 0x40, 0x82, 0x27, 0x41, 0x24, 0x61, 0x24, 0x29, 0x24, 0x11, 0x12,
  0x08, 0x11, 0x04, 0x10, 0x82, 0x10, 0x81, 0x08, 0x41, 0x08, 0x20, 0x88,
  0x08, 0x8C, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x10, 0x04, 0x08, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x04, 0x10, 0x04, 0x20, 0x02, 0xC0, 0x03, 0x00,
  0x0D, 0x00, 0x30, 0x81, 0x40, 0x41, 0x40, 0x42, 0x80, 0x24, 0x80, 0x14,
  0x80, 0x08, 0x80, 0x18, 0x40, 0x64, 0x3F, 0x82, 0x56, 0xA8, 0x02, 0x08,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x06, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02, 0x00, 0x43, 0x08, 0x11, 0x01,
  0xC6, 0x0F, 0x02, 0x80, 0x90, 0x21, 0x08, 0x20, 0x04, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x24, 0xA5, 0x00, 0xFC, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x00, 0x03, 0x80, 0xC6, 0x10, 0x12, 0x01, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03, 0xE0, 0x06, 0x34,
  0x8E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x80, 0x00, 0xE0, 0x0C, 0x60, 0xC0, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x3F, 0xF8, 0x01, 0xC0, 0x71, 0x84, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x7E, 0x00, 0x70, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x20, 0x11, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x02, 0x80, 0x12, 0x00, 0x88, 0x04, 0x20, 0x11, 0x00,
  0x84, 0x04, 0x10, 0x20, 0x41, 0x01, 0x08, 0x08, 0x40, 0x23, 0xFF, 0xF0,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x09, 0xC0, 0x38,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x22, 0x03, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x18, 0x41, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x4F, 0x85, 0x82, 0x30,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02,
  0x10, 0x20, 0x7E, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x31,
  0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x21, 0x02, 0x04, 0x60,
  0x1C, 0x03, 0x20, 0x20, 0x86, 0x02, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x01, 0x10, 0x10, 0x7F, 0x00, 0x01, 0xC0, 0x31, 0x02, 0x04, 0x20,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x0A,
  0x31, 0xA0, 0x31, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x41, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x20, 0x84, 0x10, 0x80, 0x00,
  0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x02, 0x00, 0x10, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x16, 0x30,
  0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x80,
  0x1C, 0x02, 0x01, 0x00, 0x08, 0x10, 0x00, 0x21, 0x00, 0x01, 0x10, 0x1E,
  0x04, 0x81, 0x0C, 0x28, 0x10, 0x41, 0x41, 0x02, 0x0A, 0x10, 0x10, 0x60,
  0x81, 0x03, 0x04, 0x08, 0x28, 0x40, 0x41, 0x41, 0x06, 0x11, 0x08, 0x50,
  0x88, 0x3C, 0x78, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x05, 0x00, 0x14,
  0x00, 0x90, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x83, 0xFE, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x40, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x0F, 0xF8, 0x10, 0x08, 0x20, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x84, 0x01, 0x08, 0x04, 0x3F, 0xF0, 0x40, 0x60, 0x80, 0x21,
  0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80,
  0x43, 0xFF, 0x00, 0x00, 0x68, 0x07, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x08, 0x04, 0x08, 0x02, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x08, 0x40, 0x10, 0x40, 0x60, 0xFF, 0x80, 0x0F, 0xFC, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x1F, 0xF0, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0xFF, 0xC2, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x78, 0x03, 0x87, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x7C, 0x80, 0x82, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x40,
  0x04, 0x40, 0x08, 0x20, 0x08, 0x1F, 0xF0, 0x08, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x3F, 0xFD, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x02, 0x00,
  0x0F, 0x81, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x3E, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x03, 0x07, 0x80, 0x08, 0x03, 0x08, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x60, 0x10, 0x80, 0x11, 0x00, 0x12, 0x00, 0x26,
  0x00, 0x29, 0x00, 0x31, 0x00, 0x20, 0x80, 0x20, 0x80, 0x40, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20, 0x80, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0F, 0xFC, 0x0C, 0x00, 0x18,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x28, 0x00, 0xA1, 0x40, 0x05, 0x09, 0x00,
  0x48, 0x48, 0x04, 0x82, 0x40, 0x24, 0x22, 0x02, 0x21, 0x10, 0x11, 0x08,
  0x41, 0x10, 0x42, 0x10, 0x82, 0x10, 0x84, 0x20, 0x88, 0x21, 0x04, 0x41,
  0x08, 0x24, 0x10, 0x40, 0xC0, 0x82, 0x06, 0x04, 0x20, 0x20, 0x20, 0x08,
  0x00, 0x86, 0x00, 0x43, 0x00, 0x22, 0x40, 0x21, 0x20, 0x10, 0x88, 0x08,
  0x44, 0x04, 0x22, 0x02, 0x20, 0x82, 0x10, 0x41, 0x08, 0x10, 0x84, 0x08,
  0x42, 0x02, 0x42, 0x01, 0x21, 0x00, 0x90, 0x80, 0x28, 0x40, 0x14, 0x20,
  0x04, 0x20, 0x02, 0x00, 0x00, 0xD0, 0x07, 0x0C, 0x08, 0x02, 0x10, 0x02,
  0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x0F, 0xE0, 0x0F, 0xF0, 0x20, 0x20,
  0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x20, 0x08,
  0x80, 0xC3, 0xFC, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0xD0, 0x07, 0x0C, 0x08, 0x02,
  0x10, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x1E, 0xE0, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x0F, 0xF0, 0x20, 0x20,
  0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x20, 0x10,
  0x81, 0x83, 0xF8, 0x08, 0x20, 0x20, 0x41, 0x01, 0x04, 0x04, 0x10, 0x08,
  0x40, 0x21, 0x00, 0x88, 0x01, 0x00, 0x01, 0xC0, 0x71, 0xC4, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x21, 0xFE, 0x00, 0xFF, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x88, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x40, 0x10, 0x10, 0x10,
  0x07, 0xF0, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x02, 0x40,
  0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20,
  0x22, 0x00, 0x90, 0x05, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xA0, 0x18, 0x05, 0x01, 0x40, 0x48, 0x09, 0x02, 0x40,
  0x88, 0x11, 0x04, 0x41, 0x08, 0x22, 0x08, 0x42, 0x10, 0x82, 0x10, 0x84,
  0x11, 0x04, 0x40, 0x88, 0x22, 0x04, 0x81, 0x20, 0x24, 0x09, 0x01, 0x40,
  0x50, 0x0A, 0x02, 0x80, 0x60, 0x14, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x04, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x10, 0x80, 0x08,
  0x40, 0x02, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x50, 0x00,
  0x24, 0x00, 0x22, 0x00, 0x20, 0x80, 0x20, 0x40, 0x20, 0x20, 0x20, 0x08,
  0x10, 0x04, 0x30, 0x01, 0x00, 0x80, 0x1C, 0x01, 0x20, 0x08, 0x80, 0x84,
  0x08, 0x20, 0x80, 0x84, 0x04, 0x40, 0x24, 0x01, 0x20, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x0F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFF, 0xC0,
  0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0x80, 0x88, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x11, 0x10, 0x07, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xC0, 0x00, 0xC0, 0x0A, 0x00,
  0x50, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x82, 0x02, 0x20, 0x11, 0x00,
  0x90, 0x03, 0x00, 0x10, 0xFF, 0xC0, 0x91, 0x12, 0x03, 0x80, 0x62, 0x44,
  0x0A, 0x40, 0x62, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0xC4, 0x0C, 0x20, 0xA0, 0xF9, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x47, 0x02, 0xC4, 0x28, 0x11,
  0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x40,
  0x12, 0x01, 0x30, 0x09, 0x40, 0x89, 0xF0, 0x00, 0x03, 0xC1, 0x84, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0xE1, 0x06, 0x34, 0x10, 0x18, 0x40, 0x30,
  0x80, 0x62, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x21, 0x00, 0xC1, 0x01, 0x82, 0x0D, 0x03, 0xE2, 0x00, 0x03, 0x03, 0x33,
  0x05, 0x01, 0x40, 0x60, 0x18, 0x1B, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x10, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x63, 0x44, 0x06,
  0x40, 0x32, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0xA0,
  0x09, 0x00, 0x44, 0x06, 0x20, 0xD0, 0xF8, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x11, 0xC1, 0x62, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x40, 0x18, 0x00, 0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10,
  0x84, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0xF0, 0x00, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x11, 0x02, 0x20, 0x42,
  0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0xC0, 0x54, 0x06, 0x20, 0x42, 0x08,
  0x10, 0x81, 0x08, 0x08, 0x80, 0x80, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x00, 0x01, 0x81, 0xC1, 0x66,
  0x22, 0x28, 0x24, 0x13, 0x02, 0x81, 0x20, 0x10, 0x12, 0x01, 0x01, 0x20,
  0x20, 0x14, 0x02, 0x01, 0x40, 0x20, 0x24, 0x02, 0x02, 0x40, 0x40, 0x28,
  0x04, 0x02, 0x80, 0x40, 0x28, 0x04, 0x04, 0x80, 0x80, 0x40, 0x01, 0xC1,
  0x62, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x40, 0x03, 0x80, 0x63,
  0x04, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C,
  0x00, 0xA0, 0x04, 0x80, 0x24, 0x02, 0x20, 0x20, 0xFC, 0x00, 0x00, 0xE0,
  0x2C, 0x41, 0x40, 0x86, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x04, 0x60, 0x11, 0x40, 0x84, 0xF8,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x03,
  0x80, 0x63, 0x44, 0x06, 0x40, 0x32, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0xC4, 0x06, 0x20, 0xD0, 0xF8, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x17, 0xCA,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x06, 0x83, 0x0C, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x02, 0x00, 0x40, 0x09, 0x01, 0x1F,
  0xC0, 0x10, 0x10, 0x10, 0x10, 0x6F, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x78, 0x20, 0x09, 0x00, 0x48, 0x04,
  0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x24, 0x01, 0x20,
  0x19, 0x01, 0x44, 0x14, 0x1F, 0x20, 0x80, 0x30, 0x09, 0x01, 0x20, 0x44,
  0x08, 0x82, 0x10, 0x42, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x00,
  0x40, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x50, 0x48, 0x28, 0x24, 0x24,
  0x22, 0x12, 0x11, 0x11, 0x10, 0x90, 0x88, 0x48, 0x48, 0x28, 0x24, 0x14,
  0x14, 0x0C, 0x06, 0x06, 0x02, 0x02, 0x01, 0x00, 0x18, 0x0C, 0x20, 0x40,
  0x42, 0x01, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x05, 0x00,
  0x22, 0x01, 0x08, 0x08, 0x10, 0x40, 0x42, 0x00, 0x80, 0x08, 0x02, 0x10,
  0x04, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10,
  0x02, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x0E, 0x00,
  0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xF8, 0x03, 0x82,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x18, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x30, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x83, 0x80, 0x78, 0x08, 0x71, 0x00, 0xE0,
};

const GFXglyph NotoSans_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 8, 3, -19 },
  { 19, 16, 19, 17, 1, -19 },
  { 57, 13, 22, 15, 1, -20 },
  { 93, 17, 20, 21, 2, -20 },
  { 136, 16, 20, 18, 1, -20 },
  { 176, 2, 7, 5, 3, -19 },
  { 178, 7, 23, 7, 1, -19 },
  { 199, 8, 23, 7, -2, -19 },
  { 222, 11, 11, 14, 3, -20 },
  { 238, 12, 13, 15, 2, -16 },
  { 258, 3, 6, 5, -1, -3 },
  { 261, 6, 1, 8, 1, -8 },
  { 262, 1, 1, 6, 1, -1 },
  { 263, 12, 19, 8, -1, -19 },
  { 292, 12, 20, 15, 2, -20 },
  { 322, 7, 19, 15, 4, -19 },
  { 339, 14, 20, 15, 0, -20 },
  { 374, 13, 20, 15, 1, -20 },
  { 407, 14, 19, 15, 0, -19 },
  { 441, 14, 19, 15, 1, -19 },
  { 475, 13, 20, 15, 2, -20 },
  { 508, 12, 19, 15, 3, -19 },
  { 537, 13, 20, 15, 1, -20 },
  { 570, 13, 20, 15, 1, -20 },
  { 603, 4, 14, 6, 1, -14 },
  { 610, 6, 17, 6, -1, -14 },
  { 623, 12, 12, 15, 2, -16 },
  { 641, 12, 7, 15, 2, -13 },
  { 652, 12, 12, 15, 2, -16 },
  { 670, 9, 20, 11, 2, -20 },
  { 693, 21, 21, 23, 1, -19 },
  { 749, 14, 19, 15, -1, -19 },
  { 783, 15, 19, 16, 1, -19 },
  { 819, 15, 20, 16, 2, -20 },
  { 857, 16, 19, 18, 1, -19 },
  { 895, 14, 19, 14, 1, -19 },
  { 929, 14, 19, 13, 1, -19 },
  { 963, 16, 20, 19, 2, -20 },
  { 1003, 17, 19, 18, 1, -19 },
  { 1044, 9, 19, 8, 0, -19 },
  { 1066, 11, 24, 6, -5, -19 },
  { 1099, 16, 19, 15, 1, -19 },
  { 1137, 10, 19, 13, 1, -19 },
  { 1161, 21, 19, 22, 1, -19 },
  { 1211, 17, 19, 18, 1, -19 },
  { 1252, 16, 20, 19, 2, -20 },
  { 1292, 14, 19, 15, 1, -19 },
  { 1326, 16, 25, 19, 2, -20 },
  { 1376, 14, 19, 15, 1, -19 },
  { 1410, 13, 20, 13, 1, -20 },
  { 1443, 13, 19, 13, 3, -19 },
  { 1474, 17, 19, 19, 2, -19 },
  { 1515, 13, 19, 14, 3, -19 },
  { 1546, 21, 19, 22, 3, -19 },
  { 1596, 17, 19, 13, -2, -19 },
  { 1637, 13, 19, 13, 3, -19 },
  { 1668, 15, 19, 15, 0, -19 },
  { 1704, 10, 23, 8, 0, -19 },
  { 1733, 4, 19, 8, 3, -19 },
  { 1743, 10, 23, 8, -2, -19 },
  { 1772, 13, 12, 15, 1, -19 },
  { 1792, 10, 1, 10, -2, 3 },
  { 1794, 3, 5, 6, 4, -21 },
  { 1796, 13, 15, 15, 1, -15 },
  { 1821, 13, 21, 15, 1, -21 },
  { 1856, 11, 15, 12, 1, -15 },
  { 1877, 15, 21, 15, 1, -21 },
  { 1917, 10, 15, 13, 2, -15 },
  { 1936, 15, 27, 7, -4, -21 },
  { 1987, 13, 21, 15, 1, -15 },
  { 2022, 12, 21, 15, 1, -21 },
  { 2054, 5, 19, 6, 1, -19 },
  { 2066, 10, 25, 6, -4, -19 },
  { 2098, 12, 21, 12, 1, -21 },
  { 2130, 5, 21, 6, 1, -21 },
  { 2144, 20, 15, 23, 1, -15 },
  { 2182, 12, 15, 15, 1, -15 },
  { 2205, 13, 15, 15, 1, -15 },
  { 2230, 14, 21, 15, 0, -15 },
  { 2267, 13, 21, 15, 1, -15 },
  { 2302, 10, 14, 10, 1, -14 },
  { 2320, 11, 15, 11, 0, -15 },
  { 2341, 8, 18, 8, 1, -18 },
  { 2359, 13, 14, 15, 1, -14 },
  { 2382, 11, 14, 11, 1, -14 },
  { 2402, 17, 14, 18, 1, -14 },
  { 2432, 14, 14, 12, -1, -14 },
  { 2457, 15, 21, 11, -3, -14 },
  { 2497, 12, 14, 12, 0, -14 },
  { 2518, 9, 23, 9, 1, -19 },
  { 2544, 1, 28, 14, 7, -21 },
  { 2548, 9, 23, 9, -1, -19 },
  { 2574, 12, 3, 15, 2, -11 },
};

const GFXfont NotoSans_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_THINITALIC27PT7B_H_
