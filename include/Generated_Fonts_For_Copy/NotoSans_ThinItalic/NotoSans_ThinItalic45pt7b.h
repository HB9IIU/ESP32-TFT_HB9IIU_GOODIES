#ifndef _NOTOSANS_THINITALIC45PT7B_H_
#define _NOTOSANS_THINITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x40, 0x90, 0x44, 0x11, 0x04, 0x41,
  0x20, 0x48, 0x20, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00, 0x10, 0x04, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x08,
  0x00, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x00, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x20, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x01, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x06,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x07, 0xFE,
  0x00, 0xE2, 0x0C, 0x0C, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x60,
  0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00,
  0x18, 0x40, 0x00, 0x62, 0x00, 0x01, 0xD0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x46, 0x00, 0x02, 0x18, 0x00, 0x10, 0x60, 0x00, 0x81, 0x00,
  0x0C, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81,
  0x00, 0x08, 0x18, 0x40, 0x43, 0x83, 0xFA, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x08, 0x30, 0x00, 0x81,
  0x01, 0x00, 0x18, 0x30, 0x10, 0x03, 0x02, 0x01, 0x80, 0x20, 0x60, 0x18,
  0x04, 0x04, 0x01, 0x80, 0xC0, 0x40, 0x10, 0x18, 0x0C, 0x01, 0x01, 0x00,
  0xC0, 0x10, 0x20, 0x08, 0x01, 0x06, 0x00, 0x80, 0x10, 0x40, 0x08, 0x02,
  0x08, 0x38, 0x80, 0x21, 0x0F, 0xC8, 0x06, 0x31, 0x82, 0x80, 0x42, 0x30,
  0x3C, 0x0C, 0x42, 0x03, 0x41, 0x88, 0x40, 0x17, 0xF1, 0x84, 0x01, 0x08,
  0x10, 0x80, 0x10, 0x02, 0x08, 0x03, 0x00, 0x60, 0x80, 0x30, 0x0C, 0x18,
  0x02, 0x00, 0x81, 0x80, 0x20, 0x10, 0x10, 0x02, 0x03, 0x01, 0x00, 0x60,
  0x60, 0x10, 0x04, 0x04, 0x01, 0x00, 0x40, 0x80, 0x18, 0x08, 0x18, 0x01,
  0x81, 0x81, 0x00, 0x08, 0x30, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20,
  0x0C, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x10, 0x00, 0x60, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x30, 0x10, 0x01, 0x8C, 0x03, 0x00, 0x23, 0x00, 0x20, 0x0C, 0xC0,
  0x02, 0x01, 0x10, 0x00, 0x60, 0x66, 0x00, 0x06, 0x08, 0x80, 0x00, 0x42,
  0x10, 0x00, 0x04, 0x82, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x0C, 0x0C, 0x00,
  0x02, 0x80, 0x80, 0x00, 0x88, 0x18, 0x00, 0x61, 0x81, 0xC0, 0x30, 0x10,
  0x0F, 0xF8, 0x01, 0x00, 0x32, 0x22, 0x44, 0x44, 0x48, 0x80, 0x00, 0x18,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x80, 0x40, 0x30, 0x10, 0x03, 0x04, 0x00, 0x32, 0x00,
  0x02, 0x81, 0xC0, 0x7F, 0x80, 0x18, 0x00, 0x09, 0x00, 0x0C, 0x40, 0x06,
  0x08, 0x03, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x20, 0x86, 0x10, 0xC2, 0x08,
  0x41, 0x08, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x40, 0x60, 0x03, 0x02, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x03, 0x10,
  0x00, 0x18, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01,
  0xA0, 0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00,
  0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00,
  0x21, 0x80, 0x03, 0x04, 0x00, 0x30, 0x20, 0x01, 0x00, 0x80, 0x10, 0x06,
  0x03, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x14, 0x0C, 0x83, 0x31, 0x84,
  0x60, 0xB0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x60, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0x00, 0x60, 0x38, 0x00, 0x60,
  0x20, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x60, 0x70, 0x03, 0x80, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x40, 0x00,
  0x0C, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x10, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x01, 0x00, 0x04, 0x02,
  0x00, 0x10, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40,
  0x18, 0x00, 0x80, 0x60, 0x01, 0x00, 0x80, 0x06, 0x02, 0x00, 0x08, 0x08,
  0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x82, 0x00, 0x0C, 0x0C, 0x00, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7D, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x3E, 0x00,
  0x8F, 0x3C, 0x0C, 0xC0, 0x30, 0x48, 0x00, 0xC2, 0x80, 0x02, 0x18, 0x00,
  0x09, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x01,
  0x84, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x08, 0x03, 0x01, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0x80, 0x0C, 0x03, 0x00, 0x40, 0x06, 0x03, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10,
  0x00, 0x20, 0x60, 0x00, 0x80, 0x80, 0x04, 0x03, 0x00, 0x20, 0x06, 0x03,
  0x00, 0x0C, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0E, 0x18, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0x41, 0x80, 0x01, 0x84, 0x00,
  0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x02, 0x00, 0x18, 0x06,
  0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x18,
  0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x10, 0x10, 0x00, 0x20, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x31, 0x00, 0x00, 0xC4,
  0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00,
  0x06, 0x18, 0x00, 0x28, 0x20, 0x03, 0x40, 0x40, 0x19, 0x00, 0xFF, 0x84,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x20, 0x1C, 0x00, 0xFF, 0xC0, 0x00,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x7F, 0xE1, 0x80, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x0F, 0x80, 0x11, 0x80, 0x1E, 0x3C,
  0x04, 0x40, 0x0C, 0x02, 0x01, 0x20, 0x04, 0x00, 0x80, 0x48, 0x02, 0x00,
  0x60, 0x16, 0x01, 0x00, 0x10, 0x05, 0x00, 0xC0, 0x04, 0x01, 0x40, 0x20,
  0x01, 0x00, 0x50, 0x08, 0x00, 0xC0, 0x14, 0x06, 0x00, 0x20, 0x0D, 0x01,
  0x00, 0x08, 0x02, 0xC0, 0x40, 0x06, 0x00, 0xB0, 0x10, 0x01, 0x80, 0x6C,
  0x04, 0x00, 0xE0, 0x11, 0x01, 0x80, 0x38, 0x08, 0x40, 0x20, 0x12, 0x06,
  0x10, 0x0C, 0x18, 0x87, 0x06, 0x01, 0xF8, 0x1F, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x40, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x50, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x90, 0x00, 0x01, 0x10, 0x00, 0x01, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x06, 0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00,
  0x10, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x20, 0x04, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x04, 0x01, 0xFF, 0xFE, 0x03,
  0x00, 0x02, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80, 0x00, 0x01, 0x01,
  0xFF, 0xF0, 0x01, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x02, 0x02,
  0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x08, 0x00, 0x38, 0x08, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x08,
  0x00, 0x60, 0x18, 0x00, 0x10, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20,
  0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x20, 0x40, 0x00, 0xC0, 0x40, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08,
  0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x04, 0x00, 0x06, 0x00, 0x80, 0x03, 0x80, 0x10, 0x07, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xC8, 0x00, 0x40, 0x32, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x38,
  0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x10, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x30,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0xFC,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x30, 0x01, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x30, 0x00, 0x20, 0x0C, 0x00,
  0x30, 0x02, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x18, 0x00, 0x00, 0x8A, 0x00,
  0x00, 0x24, 0xC0, 0x00, 0x0A, 0x10, 0x00, 0x07, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x02,
  0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x06, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x18, 0x04, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0A, 0x00, 0x00, 0x0A, 0x02, 0xC0, 0x00,
  0x06, 0x80, 0x90, 0x00, 0x01, 0x20, 0x24, 0x00, 0x00, 0xD8, 0x19, 0x00,
  0x00, 0x24, 0x04, 0x40, 0x00, 0x11, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x46,
  0x00, 0x02, 0x10, 0x10, 0x80, 0x01, 0x8C, 0x0C, 0x20, 0x00, 0x42, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x82, 0x00, 0x18, 0x20, 0x20, 0xC0, 0x04, 0x08,
  0x08, 0x10, 0x03, 0x06, 0x06, 0x04, 0x00, 0x81, 0x01, 0x01, 0x00, 0x40,
  0x40, 0x40, 0x40, 0x30, 0x10, 0x10, 0x10, 0x08, 0x0C, 0x0C, 0x06, 0x06,
  0x02, 0x02, 0x00, 0x81, 0x00, 0x80, 0x80, 0x20, 0x80, 0x20, 0x20, 0x08,
  0x60, 0x08, 0x08, 0x02, 0x10, 0x06, 0x06, 0x00, 0x8C, 0x01, 0x01, 0x00,
  0x32, 0x00, 0x40, 0x40, 0x05, 0x00, 0x10, 0x10, 0x01, 0xC0, 0x04, 0x04,
  0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x01, 0x03, 0x80, 0x00, 0x30, 0x28, 0x00, 0x02, 0x02, 0x40,
  0x00, 0x20, 0x24, 0x00, 0x02, 0x02, 0x60, 0x00, 0x20, 0x62, 0x00, 0x06,
  0x04, 0x30, 0x00, 0x40, 0x41, 0x00, 0x04, 0x04, 0x10, 0x00, 0x40, 0x40,
  0x80, 0x0C, 0x0C, 0x08, 0x00, 0x80, 0x80, 0xC0, 0x08, 0x08, 0x04, 0x00,
  0x80, 0x80, 0x60, 0x08, 0x08, 0x02, 0x01, 0x81, 0x80, 0x20, 0x10, 0x10,
  0x01, 0x01, 0x01, 0x00, 0x10, 0x10, 0x10, 0x01, 0x81, 0x03, 0x00, 0x08,
  0x30, 0x20, 0x00, 0xC2, 0x02, 0x00, 0x04, 0x20, 0x20, 0x00, 0x42, 0x02,
  0x00, 0x02, 0x60, 0x60, 0x00, 0x24, 0x04, 0x00, 0x03, 0x40, 0x40, 0x00,
  0x14, 0x04, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x08, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0x38, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x02, 0x00, 0xE0, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x20,
  0x20, 0x00, 0x60, 0x40, 0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x30, 0xC0,
  0x00, 0x41, 0x00, 0x01, 0x82, 0x00, 0x06, 0x04, 0x00, 0x18, 0x08, 0x00,
  0xC0, 0x3F, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x60, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x02, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x20, 0x20, 0x00,
  0x60, 0x40, 0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41,
  0x00, 0x01, 0x02, 0x00, 0x04, 0x04, 0x00, 0x30, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x40, 0x18, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x40, 0x10, 0x00, 0x80, 0x20, 0x01, 0x80, 0x40, 0x01,
  0x01, 0x80, 0x02, 0x02, 0x00, 0x06, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0,
  0x1C, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x30, 0x03, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x13, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x18, 0x10,
  0x00, 0x40, 0x40, 0x03, 0x01, 0x80, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x08, 0x0C, 0x00,
  0x20, 0x20, 0x00, 0xC1, 0x80, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10,
  0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x03, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x30, 0x40, 0x10, 0x20, 0x08, 0x10, 0x04, 0x08, 0x06, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x20, 0x08,
  0x10, 0x04, 0x18, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00,
  0x21, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x10, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x10,
  0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x64, 0x00,
  0x01, 0x18, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x03, 0x00, 0x08,
  0x04, 0x00, 0x40, 0x10, 0x03, 0x00, 0x40, 0x08, 0x00, 0x80, 0x40, 0x02,
  0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0x40, 0x00, 0x42, 0x00, 0x01, 0x18,
  0x00, 0x06, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0xFE, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x01,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x28,
  0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x01,
  0x82, 0x00, 0x08, 0x10, 0x00, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0xC0, 0x60, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00,
  0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xFF, 0xFF, 0x80,
  0x86, 0x10, 0x43, 0x08, 0x20, 0x00, 0x7E, 0x08, 0x0C, 0x0C, 0x41, 0x80,
  0x26, 0x08, 0x00, 0xA0, 0x80, 0x05, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC4,
  0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00,
  0xC4, 0x00, 0x04, 0x60, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x05, 0x04, 0x00, 0x48,
  0x10, 0x04, 0x80, 0xC0, 0xC4, 0x03, 0xFC, 0x20, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0xFC, 0x01, 0x0C, 0x0C, 0x04, 0xC0, 0x10, 0x16, 0x00, 0x20, 0x50,
  0x00, 0x82, 0x80, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00,
  0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0xC4,
  0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x0C, 0x00,
  0x04, 0x30, 0x00, 0x21, 0x40, 0x01, 0x85, 0x00, 0x0C, 0x12, 0x00, 0x60,
  0x46, 0x03, 0x03, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x38, 0x0C, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x7F, 0x04,
  0x01, 0x81, 0x8C, 0x02, 0x00, 0x48, 0x04, 0x00, 0x28, 0x08, 0x00, 0x28,
  0x10, 0x00, 0x18, 0x10, 0x00, 0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10,
  0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40,
  0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x40, 0x40, 0x03, 0x40, 0x40, 0x06, 0x40,
  0x20, 0x0C, 0x80, 0x30, 0x18, 0x80, 0x1F, 0xE0, 0x80, 0x00, 0xFE, 0x00,
  0xE0, 0xC0, 0x60, 0x08, 0x30, 0x02, 0x18, 0x00, 0xCC, 0x00, 0x32, 0x00,
  0x09, 0x80, 0x02, 0x40, 0x01, 0x90, 0x01, 0xCC, 0x01, 0xC3, 0xFF, 0x80,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x40, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x11, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x82, 0x01, 0x81, 0x84, 0x04, 0x00, 0x90, 0x10, 0x00, 0xA0,
  0x40, 0x01, 0x41, 0x00, 0x01, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00,
  0x01, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x20, 0xC0, 0x00, 0xC1, 0x80, 0x02, 0x81, 0x00, 0x0D, 0x02, 0x00, 0x36,
  0x02, 0x00, 0xC8, 0x06, 0x03, 0x10, 0x07, 0xF8, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x0C, 0x00, 0xF0,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x83, 0xF8, 0x08, 0x60,
  0x60, 0x4C, 0x01, 0x82, 0xC0, 0x04, 0x14, 0x00, 0x21, 0x40, 0x01, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01,
  0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x31, 0x00,
  0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x31,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x06, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x9C, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x40, 0x40, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x60, 0x08, 0x0C, 0x00, 0x81, 0x80, 0x08, 0x30,
  0x01, 0x86, 0x00, 0x10, 0xC0, 0x01, 0x14, 0x00, 0x12, 0x40, 0x01, 0x42,
  0x00, 0x28, 0x20, 0x03, 0x01, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x00, 0x40, 0x40, 0x06, 0x04, 0x00, 0x20, 0x40, 0x03, 0x0C,
  0x00, 0x10, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x00, 0x04, 0x1F, 0x80, 0x7F, 0x01, 0x18, 0x30,
  0x30, 0x60, 0x4C, 0x02, 0x30, 0x0C, 0x16, 0x00, 0x88, 0x01, 0x07, 0x00,
  0x24, 0x00, 0x42, 0x80, 0x0E, 0x00, 0x10, 0xC0, 0x03, 0x80, 0x04, 0x30,
  0x00, 0xC0, 0x01, 0x08, 0x00, 0x30, 0x00, 0x42, 0x00, 0x08, 0x00, 0x31,
  0x80, 0x02, 0x00, 0x08, 0x40, 0x00, 0x80, 0x02, 0x10, 0x00, 0x40, 0x00,
  0x84, 0x00, 0x10, 0x00, 0x23, 0x00, 0x04, 0x00, 0x18, 0x80, 0x01, 0x00,
  0x04, 0x20, 0x00, 0xC0, 0x01, 0x08, 0x00, 0x20, 0x00, 0x42, 0x00, 0x08,
  0x00, 0x11, 0x80, 0x02, 0x00, 0x0C, 0x40, 0x00, 0x80, 0x02, 0x10, 0x00,
  0x60, 0x00, 0x84, 0x00, 0x10, 0x00, 0x23, 0x00, 0x04, 0x00, 0x18, 0x04,
  0x0F, 0xE0, 0x21, 0x81, 0x81, 0x30, 0x06, 0x0B, 0x00, 0x10, 0x50, 0x00,
  0x85, 0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40,
  0x00, 0xC6, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08,
  0xC0, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x08, 0xC0, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18,
  0x00, 0x18, 0x00, 0x7F, 0x00, 0x0C, 0x06, 0x00, 0x80, 0x18, 0x18, 0x00,
  0x60, 0x80, 0x01, 0x08, 0x00, 0x0C, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20,
  0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x01,
  0xA0, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x32, 0x00,
  0x01, 0x10, 0x00, 0x18, 0x80, 0x01, 0x82, 0x00, 0x08, 0x18, 0x01, 0x80,
  0x60, 0x18, 0x01, 0xFF, 0x00, 0x01, 0x03, 0xF0, 0x01, 0x0C, 0x0C, 0x01,
  0x30, 0x04, 0x01, 0x60, 0x02, 0x01, 0x40, 0x02, 0x02, 0x80, 0x01, 0x03,
  0x00, 0x01, 0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x0C,
  0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x08, 0x1C, 0x00, 0x18, 0x14, 0x00, 0x30, 0x12, 0x00, 0x60, 0x11,
  0x80, 0xC0, 0x10, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x04, 0x06, 0x06, 0x10, 0x20, 0x04, 0x81, 0x00, 0x0A, 0x08, 0x00,
  0x28, 0x40, 0x00, 0x61, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x11,
  0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x23, 0x00,
  0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03,
  0x0C, 0x00, 0x1C, 0x10, 0x00, 0xD0, 0x40, 0x02, 0xC0, 0x80, 0x32, 0x03,
  0x01, 0x88, 0x07, 0xF8, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x04, 0x1F, 0x82,
  0x18, 0x01, 0x30, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x50, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFE, 0x03, 0x01, 0xC2, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x44, 0x00, 0x43, 0x00,
  0x60, 0xFF, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x01, 0xFF, 0xE1, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x3F, 0x80, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02,
  0x30, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00,
  0x06, 0x30, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46,
  0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00,
  0xC2, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x05, 0x04, 0x00, 0x48, 0x20,
  0x04, 0x40, 0x80, 0xC6, 0x03, 0xFC, 0x20, 0x80, 0x00, 0x78, 0x00, 0x09,
  0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x83,
  0x00, 0x20, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02,
  0x03, 0x00, 0x40, 0x40, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x10, 0x80, 0x02,
  0x30, 0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x02, 0x00, 0x1A, 0x00, 0x30, 0x00, 0x90,
  0x01, 0x80, 0x0C, 0x80, 0x1C, 0x00, 0x44, 0x00, 0xA0, 0x06, 0x20, 0x0D,
  0x80, 0x21, 0x00, 0x44, 0x03, 0x08, 0x06, 0x20, 0x10, 0x40, 0x21, 0x01,
  0x82, 0x03, 0x08, 0x08, 0x10, 0x10, 0x40, 0x40, 0x81, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x80, 0x82, 0x01, 0x04, 0x04, 0x10, 0x0C, 0x40,
  0x31, 0x00, 0x62, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x09, 0x00, 0x24,
  0x00, 0x50, 0x01, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x20, 0x20, 0x01, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x06, 0x02, 0x00,
  0x08, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x60, 0x00, 0x08, 0x80,
  0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x20, 0x06,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x30, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x08, 0x00, 0x10, 0x02,
  0x00, 0x04, 0x00, 0x80, 0x02, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x18, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x02, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00, 0x70, 0x0E, 0x0D,
  0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 32, 9, 1, -32 },
  { 37, 10, 11, 14, 5, -32 },
  { 51, 26, 32, 28, 2, -32 },
  { 155, 21, 37, 25, 2, -34 },
  { 253, 28, 34, 34, 4, -33 },
  { 372, 27, 33, 31, 2, -33 },
  { 484, 4, 11, 8, 5, -32 },
  { 490, 13, 39, 11, 1, -32 },
  { 554, 13, 39, 11, -3, -32 },
  { 618, 18, 19, 24, 6, -34 },
  { 661, 21, 20, 26, 3, -26 },
  { 714, 6, 11, 8, -2, -5 },
  { 723, 10, 1, 14, 2, -13 },
  { 725, 3, 2, 9, 1, -2 },
  { 726, 20, 32, 14, -2, -32 },
  { 806, 21, 33, 25, 3, -33 },
  { 893, 11, 32, 25, 7, -32 },
  { 937, 23, 33, 25, 0, -33 },
  { 1032, 23, 33, 25, 1, -33 },
  { 1127, 23, 32, 25, 1, -32 },
  { 1219, 22, 32, 25, 2, -32 },
  { 1307, 21, 33, 25, 3, -33 },
  { 1394, 20, 32, 25, 5, -32 },
  { 1474, 22, 33, 25, 2, -33 },
  { 1565, 22, 33, 25, 2, -33 },
  { 1656, 7, 24, 9, 1, -24 },
  { 1677, 10, 30, 9, -2, -24 },
  { 1715, 21, 20, 26, 3, -26 },
  { 1768, 21, 10, 26, 3, -21 },
  { 1795, 21, 20, 26, 3, -26 },
  { 1848, 15, 33, 18, 4, -33 },
  { 1910, 34, 36, 38, 2, -32 },
  { 2063, 24, 32, 25, -2, -32 },
  { 2159, 24, 32, 27, 2, -32 },
  { 2255, 24, 33, 27, 4, -33 },
  { 2354, 27, 32, 30, 2, -32 },
  { 2462, 23, 32, 24, 2, -32 },
  { 2554, 23, 32, 22, 2, -32 },
  { 2646, 26, 33, 31, 4, -33 },
  { 2754, 28, 32, 31, 2, -32 },
  { 2866, 14, 32, 13, 0, -32 },
  { 2922, 18, 40, 10, -8, -32 },
  { 3012, 26, 32, 24, 2, -32 },
  { 3116, 17, 32, 22, 2, -32 },
  { 3184, 34, 32, 36, 2, -32 },
  { 3320, 28, 32, 30, 2, -32 },
  { 3432, 26, 33, 32, 4, -33 },
  { 3540, 23, 32, 25, 2, -32 },
  { 3632, 26, 41, 32, 4, -33 },
  { 3766, 23, 32, 25, 2, -32 },
  { 3858, 22, 33, 22, 1, -33 },
  { 3949, 22, 32, 22, 4, -32 },
  { 4037, 27, 32, 31, 4, -32 },
  { 4145, 22, 32, 24, 5, -32 },
  { 4233, 34, 32, 37, 6, -32 },
  { 4369, 28, 32, 22, -3, -32 },
  { 4481, 22, 32, 22, 4, -32 },
  { 4569, 26, 32, 24, 0, -32 },
  { 4673, 17, 39, 14, 0, -32 },
  { 4756, 7, 32, 14, 4, -32 },
  { 4784, 17, 39, 14, -3, -32 },
  { 4867, 21, 19, 25, 2, -32 },
  { 4917, 17, 1, 17, -4, 5 },
  { 4920, 5, 7, 10, 7, -34 },
  { 4925, 21, 24, 25, 2, -24 },
  { 4988, 22, 34, 26, 1, -34 },
  { 5082, 19, 24, 20, 2, -24 },
  { 5139, 24, 34, 26, 2, -34 },
  { 5241, 18, 24, 22, 3, -24 },
  { 5295, 25, 45, 12, -6, -34 },
  { 5436, 23, 35, 26, 1, -24 },
  { 5537, 21, 34, 25, 1, -34 },
  { 5627, 9, 32, 9, 1, -32 },
  { 5663, 16, 43, 9, -6, -32 },
  { 5749, 20, 34, 20, 1, -34 },
  { 5834, 9, 34, 9, 1, -34 },
  { 5873, 34, 24, 38, 1, -24 },
  { 5975, 21, 24, 25, 1, -24 },
  { 6038, 21, 24, 25, 2, -24 },
  { 6101, 24, 34, 26, -1, -24 },
  { 6203, 22, 34, 26, 2, -24 },
  { 6297, 17, 24, 17, 1, -24 },
  { 6348, 17, 24, 19, 1, -24 },
  { 6399, 13, 30, 14, 2, -30 },
  { 6448, 21, 24, 25, 2, -24 },
  { 6511, 19, 24, 18, 2, -24 },
  { 6568, 29, 24, 29, 2, -24 },
  { 6655, 22, 24, 20, -1, -24 },
  { 6721, 26, 35, 18, -5, -24 },
  { 6835, 21, 24, 20, -1, -24 },
  { 6898, 16, 39, 15, 1, -32 },
  { 6976, 1, 45, 24, 13, -34 },
  { 6982, 16, 39, 15, -2, -32 },
  { 7060, 21, 4, 26, 3, -18 },
};

const GFXfont NotoSans_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_THINITALIC45PT7B_H_
