#ifndef _NOTOSANS_THINITALIC7PT7B_H_
#define _NOTOSANS_THINITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x37, 0x5E, 0xA0, 0x34, 0x25, 0xE0, 0xDE, 0xB5,
  0xB0, 0x75, 0x6B, 0xF0, 0xC0, 0x6A, 0xA0, 0x55, 0xA0, 0xDD, 0x00, 0x5D,
  0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x79, 0x99, 0xE0, 0xD5, 0x80, 0x71,
  0x24, 0xE0, 0x71, 0x61, 0xE0, 0x32, 0x6F, 0x20, 0x74, 0x21, 0xE0, 0x74,
  0xB9, 0xE0, 0xE9, 0x48, 0x75, 0x69, 0xE0, 0x79, 0xF1, 0xE0, 0x90, 0x98,
  0x71, 0x80, 0xE0, 0xC7, 0x00, 0xDA, 0x00, 0x7A, 0xDD, 0x75, 0xA9, 0xC0,
  0x2D, 0xDA, 0x75, 0xA9, 0xF0, 0xF2, 0x4E, 0x75, 0x99, 0xF0, 0x74, 0xA8,
  0xE0, 0x74, 0xE8, 0x80, 0xF8, 0xA9, 0xE0, 0x4A, 0x6F, 0x29, 0x00, 0x56,
  0x80, 0x25, 0x25, 0x80, 0x56, 0x4A, 0x90, 0x4A, 0x4E, 0x45, 0x2B, 0xAA,
  0xA8, 0x4A, 0x6B, 0x69, 0x00, 0xF9, 0x99, 0xE0, 0x75, 0xF8, 0x80, 0xF9,
  0x99, 0xA4, 0x75, 0xEA, 0x90, 0x78, 0x42, 0xE0, 0xEA, 0x48, 0x99, 0x9A,
  0xE0, 0xB7, 0x48, 0xAF, 0x6D, 0x2A, 0x00, 0x56, 0x4A, 0xA0, 0xBA, 0x48,
  0x72, 0x44, 0xE0, 0x6A, 0x49, 0x00, 0xF8, 0x24, 0x93, 0x80, 0x25, 0x90,
  0xE0, 0x80, 0x79, 0x9E, 0x47, 0x99, 0xE0, 0x72, 0x70, 0x17, 0x99, 0xE0,
  0x77, 0x70, 0x36, 0x44, 0x44, 0x80, 0x79, 0x9E, 0x2C, 0x4E, 0xDA, 0x5A,
  0x80, 0x25, 0x24, 0xA0, 0x4F, 0x6A, 0x5A, 0x80, 0x7C, 0xEB, 0x50, 0x76,
  0xD0, 0x69, 0x9E, 0x79, 0x9E, 0x88, 0x79, 0x9E, 0x22, 0x72, 0x40, 0x71,
  0xF0, 0x7A, 0xC0, 0x99, 0x9E, 0xB7, 0x40, 0xAF, 0x5D, 0x40, 0xA9, 0x50,
  0x55, 0x64, 0x48, 0x65, 0x60, 0x69, 0x49, 0x00, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 1, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 4, 5, 5, 1, -5 },
  { 13, 4, 5, 5, 0, -5 },
  { 16, 1, 2, 1, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 4, 1, -5 },
  { 23, 3, 3, 4, 1, -4 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 1, 0, -1 },
  { 28, 3, 5, 2, 0, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 2, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 1, 4, 1, 0, -4 },
  { 59, 1, 5, 1, 0, -4 },
  { 60, 3, 3, 4, 1, -4 },
  { 62, 3, 1, 4, 1, -3 },
  { 63, 3, 3, 4, 1, -4 },
  { 65, 2, 5, 3, 1, -5 },
  { 67, 6, 6, 6, 0, -5 },
  { 72, 3, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 4, 5, 5, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 3, 0, -5 },
  { 88, 4, 5, 5, 1, -5 },
  { 91, 5, 5, 5, 0, -5 },
  { 95, 2, 5, 2, 0, -5 },
  { 97, 3, 6, 2, -1, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 6, 5, 6, 0, -5 },
  { 109, 5, 5, 5, 0, -5 },
  { 113, 4, 5, 5, 1, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 6, 5, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 3, 0, -5 },
  { 128, 3, 5, 3, 1, -5 },
  { 130, 4, 5, 5, 1, -5 },
  { 133, 3, 5, 4, 1, -5 },
  { 135, 5, 5, 6, 1, -5 },
  { 139, 4, 5, 3, 0, -5 },
  { 142, 3, 5, 3, 1, -5 },
  { 144, 4, 5, 4, 0, -5 },
  { 147, 3, 6, 2, 0, -5 },
  { 150, 1, 5, 2, 1, -5 },
  { 151, 3, 6, 2, -1, -5 },
  { 154, 4, 3, 4, 0, -5 },
  { 156, 3, 1, 3, -1, 0 },
  { 157, 1, 1, 2, 1, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 4, 7, 2, -1, -5 },
  { 174, 4, 6, 4, 0, -4 },
  { 177, 3, 5, 4, 0, -5 },
  { 179, 2, 5, 1, 0, -5 },
  { 181, 3, 7, 1, -1, -5 },
  { 184, 3, 5, 3, 0, -5 },
  { 186, 2, 5, 1, 0, -5 },
  { 188, 5, 4, 6, 0, -4 },
  { 191, 3, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 6, 4, 0, -4 },
  { 198, 4, 6, 4, 0, -4 },
  { 201, 3, 4, 3, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 2, 5, 2, 0, -5 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 5, 4, 5, 0, -4 },
  { 214, 3, 4, 3, 0, -4 },
  { 216, 4, 6, 3, -1, -4 },
  { 219, 3, 4, 3, 0, -4 },
  { 221, 3, 6, 2, 0, -5 },
  { 224, 1, 7, 4, 2, -5 },
  { 225, 2, 6, 2, 0, -5 },
  { 227, 3, 1, 4, 1, -3 },
};

const GFXfont NotoSans_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_THINITALIC7PT7B_H_
