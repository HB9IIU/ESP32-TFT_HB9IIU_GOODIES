#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ThinItalic
// Headers: 67

#include "NotoSans_ThinItalic6pt7b.h"
#include "NotoSans_ThinItalic7pt7b.h"
#include "NotoSans_ThinItalic8pt7b.h"
#include "NotoSans_ThinItalic9pt7b.h"
#include "NotoSans_ThinItalic10pt7b.h"
#include "NotoSans_ThinItalic11pt7b.h"
#include "NotoSans_ThinItalic12pt7b.h"
#include "NotoSans_ThinItalic13pt7b.h"
#include "NotoSans_ThinItalic14pt7b.h"
#include "NotoSans_ThinItalic15pt7b.h"
#include "NotoSans_ThinItalic16pt7b.h"
#include "NotoSans_ThinItalic17pt7b.h"
#include "NotoSans_ThinItalic18pt7b.h"
#include "NotoSans_ThinItalic19pt7b.h"
#include "NotoSans_ThinItalic20pt7b.h"
#include "NotoSans_ThinItalic21pt7b.h"
#include "NotoSans_ThinItalic22pt7b.h"
#include "NotoSans_ThinItalic23pt7b.h"
#include "NotoSans_ThinItalic24pt7b.h"
#include "NotoSans_ThinItalic25pt7b.h"
#include "NotoSans_ThinItalic26pt7b.h"
#include "NotoSans_ThinItalic27pt7b.h"
#include "NotoSans_ThinItalic28pt7b.h"
#include "NotoSans_ThinItalic29pt7b.h"
#include "NotoSans_ThinItalic30pt7b.h"
#include "NotoSans_ThinItalic31pt7b.h"
#include "NotoSans_ThinItalic32pt7b.h"
#include "NotoSans_ThinItalic33pt7b.h"
#include "NotoSans_ThinItalic34pt7b.h"
#include "NotoSans_ThinItalic35pt7b.h"
#include "NotoSans_ThinItalic36pt7b.h"
#include "NotoSans_ThinItalic37pt7b.h"
#include "NotoSans_ThinItalic38pt7b.h"
#include "NotoSans_ThinItalic39pt7b.h"
#include "NotoSans_ThinItalic40pt7b.h"
#include "NotoSans_ThinItalic41pt7b.h"
#include "NotoSans_ThinItalic42pt7b.h"
#include "NotoSans_ThinItalic43pt7b.h"
#include "NotoSans_ThinItalic44pt7b.h"
#include "NotoSans_ThinItalic45pt7b.h"
#include "NotoSans_ThinItalic46pt7b.h"
#include "NotoSans_ThinItalic47pt7b.h"
#include "NotoSans_ThinItalic48pt7b.h"
#include "NotoSans_ThinItalic49pt7b.h"
#include "NotoSans_ThinItalic50pt7b.h"
#include "NotoSans_ThinItalic51pt7b.h"
#include "NotoSans_ThinItalic52pt7b.h"
#include "NotoSans_ThinItalic53pt7b.h"
#include "NotoSans_ThinItalic54pt7b.h"
#include "NotoSans_ThinItalic55pt7b.h"
#include "NotoSans_ThinItalic56pt7b.h"
#include "NotoSans_ThinItalic57pt7b.h"
#include "NotoSans_ThinItalic58pt7b.h"
#include "NotoSans_ThinItalic59pt7b.h"
#include "NotoSans_ThinItalic60pt7b.h"
#include "NotoSans_ThinItalic61pt7b.h"
#include "NotoSans_ThinItalic62pt7b.h"
#include "NotoSans_ThinItalic63pt7b.h"
#include "NotoSans_ThinItalic64pt7b.h"
#include "NotoSans_ThinItalic65pt7b.h"
#include "NotoSans_ThinItalic66pt7b.h"
#include "NotoSans_ThinItalic67pt7b.h"
#include "NotoSans_ThinItalic68pt7b.h"
#include "NotoSans_ThinItalic69pt7b.h"
#include "NotoSans_ThinItalic70pt7b.h"
#include "NotoSans_ThinItalic71pt7b.h"
#include "NotoSans_ThinItalic72pt7b.h"
