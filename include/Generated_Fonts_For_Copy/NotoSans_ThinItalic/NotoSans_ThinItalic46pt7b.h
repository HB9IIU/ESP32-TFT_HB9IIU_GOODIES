#ifndef _NOTOSANS_THINITALIC46PT7B_H_
#define _NOTOSANS_THINITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x30, 0x48, 0x32, 0x0C, 0x82, 0x20, 0x90, 0x24, 0x19,
  0x04, 0x41, 0x10, 0x48, 0x12, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x20, 0x08, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08,
  0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x40, 0x1F, 0xFF, 0xFF, 0xF0, 0x04,
  0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0,
  0x10, 0x04, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x02,
  0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE0,
  0x03, 0x88, 0xF0, 0x18, 0x60, 0x80, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10,
  0x10, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20,
  0x00, 0x40, 0x80, 0x01, 0x82, 0x00, 0x03, 0x90, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x05, 0x80, 0x00, 0x31, 0x80, 0x00, 0x83, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x18, 0x00, 0x20, 0x20, 0x01, 0x80, 0x80, 0x04, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x06, 0x08, 0x0C, 0x30, 0x1F,
  0xEF, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x61,
  0x80, 0x02, 0x06, 0x06, 0x00, 0x20, 0x20, 0x10, 0x03, 0x02, 0x00, 0x80,
  0x10, 0x10, 0x04, 0x01, 0x01, 0x80, 0x20, 0x10, 0x08, 0x01, 0x01, 0x80,
  0x40, 0x08, 0x08, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x04, 0x0C, 0x01, 0x00,
  0x20, 0xC0, 0x08, 0x01, 0x04, 0x00, 0x40, 0x18, 0x43, 0xE2, 0x00, 0x86,
  0x30, 0x90, 0x04, 0x63, 0x02, 0x80, 0x42, 0x30, 0x16, 0x06, 0x21, 0x00,
  0x98, 0x63, 0x18, 0x06, 0x7C, 0x30, 0x80, 0x30, 0x01, 0x04, 0x01, 0x00,
  0x10, 0x60, 0x08, 0x01, 0x82, 0x00, 0x40, 0x08, 0x10, 0x02, 0x00, 0x80,
  0x80, 0x10, 0x08, 0x04, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x40, 0x08, 0x06, 0x06, 0x00, 0x40, 0x20, 0x60, 0x02, 0x02, 0x02,
  0x00, 0x18, 0x30, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x04,
  0x00, 0x08, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x10, 0x03, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x8C, 0x01, 0x00, 0x32, 0x00, 0x10, 0x04, 0xC0, 0x03,
  0x01, 0x90, 0x00, 0x20, 0x26, 0x00, 0x02, 0x08, 0xC0, 0x00, 0x63, 0x10,
  0x00, 0x06, 0xC2, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0xC0, 0x80, 0x00, 0xC8, 0x18, 0x00, 0x60, 0x81, 0xC0, 0x38, 0x18, 0x0F,
  0xFC, 0x01, 0x80, 0x32, 0x22, 0x24, 0x44, 0x44, 0x88, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x01, 0x80, 0x80, 0x1C, 0x10, 0x00,
  0xC2, 0x00, 0x06, 0x40, 0x20, 0x37, 0xFC, 0x03, 0x00, 0x01, 0xA0, 0x00,
  0x64, 0x00, 0x18, 0x40, 0x06, 0x08, 0x01, 0x80, 0x80, 0x60, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x0C, 0x30, 0x86, 0x10, 0xC2, 0x08, 0x41, 0x08, 0x00,
  0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x04, 0x00,
  0x20, 0x60, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x01, 0x10,
  0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x1E, 0x00,
  0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x02, 0x30, 0x00,
  0x21, 0x80, 0x03, 0x04, 0x00, 0x10, 0x30, 0x01, 0x00, 0x80, 0x18, 0x03,
  0x03, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x18, 0x0D, 0x03, 0x21, 0x84,
  0xE1, 0xB0, 0x24, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x30, 0x03, 0x00, 0x10,
  0x04, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x08, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80,
  0x01, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x20, 0x00, 0x30, 0x70, 0x01, 0x80, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x60, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x01, 0x84,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x20, 0x00, 0x60, 0x40, 0x01, 0x80, 0x80,
  0x02, 0x01, 0x00, 0x08, 0x06, 0x00, 0x20, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x00, 0xC0, 0x02, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x04, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x20, 0x00, 0xC0, 0x70, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x83,
  0xF8, 0x02, 0x30, 0x18, 0x1B, 0x00, 0x30, 0x58, 0x00, 0x61, 0xC0, 0x00,
  0x86, 0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x8C, 0x00,
  0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06, 0x03, 0x00, 0x30,
  0x06, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x40, 0x03, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00,
  0x30, 0x20, 0x00, 0x80, 0xC0, 0x04, 0x01, 0x00, 0x20, 0x03, 0x03, 0x00,
  0x06, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xEC, 0x00, 0x0E, 0x0C, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x10, 0x20, 0x00, 0x61, 0x80, 0x00, 0x84, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x30,
  0x00, 0x08, 0x40, 0x00, 0x61, 0x80, 0x01, 0x02, 0x00, 0x18, 0x06, 0x01,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x80, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x01, 0xC4, 0x00, 0x06,
  0x18, 0x00, 0x28, 0x30, 0x03, 0x20, 0x60, 0x39, 0x80, 0x7F, 0x84, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x20, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x60, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x3F,
  0xC0, 0x12, 0x00, 0x30, 0x18, 0x04, 0x80, 0x30, 0x06, 0x01, 0x40, 0x18,
  0x01, 0x00, 0x50, 0x04, 0x00, 0x40, 0x1C, 0x02, 0x00, 0x10, 0x06, 0x00,
  0x80, 0x0C, 0x01, 0x80, 0x40, 0x02, 0x00, 0x60, 0x10, 0x00, 0x80, 0x38,
  0x04, 0x00, 0x20, 0x0A, 0x03, 0x00, 0x18, 0x02, 0x80, 0xC0, 0x04, 0x01,
  0xA0, 0x30, 0x03, 0x00, 0x48, 0x0C, 0x00, 0xC0, 0x32, 0x01, 0x00, 0x50,
  0x18, 0x80, 0x40, 0x24, 0x0C, 0x20, 0x0C, 0x30, 0x86, 0x0C, 0x01, 0xF8,
  0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x18, 0x00,
  0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x80, 0x3E, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00,
  0x60, 0x30, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x60, 0x40, 0x00, 0x60, 0x60, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x1F,
  0xFF, 0x80, 0x08, 0x03, 0xE0, 0x04, 0x00, 0x18, 0x06, 0x00, 0x02, 0x02,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10,
  0x60, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00, 0x03,
  0x80, 0x80, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x1C, 0x01, 0xC0, 0x38, 0x00, 0x20, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x1F, 0x00, 0x04,
  0x00, 0x38, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x04, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x70,
  0x02, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x7C, 0x03, 0x80, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x7F, 0xF2, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x02, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x18, 0x30, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x01, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x04, 0x1C, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x10, 0x04, 0x00, 0x04, 0x00, 0x80, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x02,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x60, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x45, 0x80, 0x00, 0x0B, 0x10, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70,
  0x20, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00,
  0x04, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x04, 0x00,
  0x80, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xA0, 0x34, 0x00, 0x00, 0x34, 0x04,
  0x80, 0x00, 0x05, 0x80, 0x90, 0x00, 0x01, 0x30, 0x12, 0x00, 0x00, 0x64,
  0x06, 0x40, 0x00, 0x08, 0x80, 0xCC, 0x00, 0x03, 0x10, 0x10, 0x80, 0x00,
  0x46, 0x02, 0x10, 0x00, 0x10, 0x80, 0x42, 0x00, 0x02, 0x10, 0x18, 0x40,
  0x00, 0x82, 0x02, 0x0C, 0x00, 0x30, 0x40, 0x40, 0x80, 0x04, 0x18, 0x08,
  0x10, 0x01, 0x02, 0x01, 0x02, 0x00, 0x20, 0x40, 0x60, 0x40, 0x08, 0x08,
  0x08, 0x08, 0x03, 0x01, 0x01, 0x01, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x40, 0x80, 0x20, 0x20, 0x08,
  0x30, 0x0C, 0x04, 0x01, 0x04, 0x01, 0x80, 0x80, 0x31, 0x00, 0x20, 0x30,
  0x02, 0x20, 0x04, 0x06, 0x00, 0x48, 0x00, 0x80, 0x80, 0x0B, 0x00, 0x30,
  0x10, 0x01, 0x40, 0x04, 0x02, 0x00, 0x30, 0x00, 0x80, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x04, 0x03, 0x80, 0x00, 0x20, 0x34, 0x00, 0x01, 0x01, 0x20, 0x00, 0x18,
  0x08, 0x80, 0x00, 0x80, 0x44, 0x00, 0x04, 0x06, 0x30, 0x00, 0x20, 0x30,
  0x80, 0x01, 0x01, 0x06, 0x00, 0x18, 0x08, 0x10, 0x00, 0x80, 0x40, 0x80,
  0x04, 0x06, 0x02, 0x00, 0x20, 0x20, 0x10, 0x01, 0x01, 0x00, 0xC0, 0x18,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x18, 0x04, 0x06, 0x00, 0x40, 0x20, 0x20,
  0x02, 0x03, 0x01, 0x00, 0x08, 0x10, 0x08, 0x00, 0x40, 0x80, 0x40, 0x03,
  0x04, 0x06, 0x00, 0x08, 0x20, 0x20, 0x00, 0x63, 0x01, 0x00, 0x01, 0x10,
  0x08, 0x00, 0x08, 0x80, 0xC0, 0x00, 0x24, 0x06, 0x00, 0x01, 0x20, 0x20,
  0x00, 0x0F, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x18, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x64, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x30, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x70,
  0x07, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0xF0,
  0x01, 0x00, 0x0C, 0x01, 0x00, 0x04, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0x30, 0x08, 0x01, 0xC0,
  0x1F, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x64, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x08, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0x00, 0xF0, 0x01, 0x00,
  0x0C, 0x01, 0x00, 0x06, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00,
  0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0xE0, 0x0F, 0xFF, 0x80, 0x18, 0x06,
  0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x01, 0x00, 0x20, 0x01, 0x80, 0x20, 0x00, 0x80, 0x20, 0x00,
  0xC0, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0x40, 0x00, 0x60, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x03, 0x80,
  0x70, 0x18, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x30, 0x01, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x88,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80,
  0x00, 0x81, 0x00, 0x02, 0x02, 0x00, 0x04, 0x06, 0x00, 0x10, 0x04, 0x00,
  0x60, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x18,
  0x00, 0x80, 0x20, 0x01, 0x00, 0x80, 0x03, 0x01, 0x00, 0x02, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x48, 0x00, 0x14, 0x00, 0x09, 0x00, 0x06, 0x80, 0x03, 0x20, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x32, 0x00, 0x18, 0x80, 0x04, 0x60, 0x02, 0x10,
  0x01, 0x8C, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x02,
  0x08, 0x01, 0x02, 0x00, 0x81, 0x80, 0x60, 0x40, 0x10, 0x30, 0x08, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30, 0x08, 0x08,
  0x04, 0x04, 0x01, 0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x10, 0x20, 0x04,
  0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x41, 0x00, 0x10, 0x80, 0x08, 0x20,
  0x02, 0x10, 0x01, 0x88, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x80, 0x02,
  0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x05, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x02, 0x04,
  0x00, 0x0C, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x40, 0x10, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x20, 0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x81,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60, 0x00, 0x04, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x81, 0x02, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10, 0x30,
  0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81,
  0x02, 0x06, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00,
  0x19, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x83, 0x00, 0x0C, 0x08,
  0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x60, 0x18, 0x06, 0x00, 0x40, 0x20,
  0x02, 0x03, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x00, 0x02, 0x10, 0x00, 0x11,
  0x80, 0x00, 0x88, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x86,
  0x10, 0x43, 0x08, 0x20, 0x00, 0x3E, 0x04, 0x03, 0xDE, 0x20, 0x30, 0x0C,
  0x81, 0x80, 0x12, 0x0C, 0x00, 0x28, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x70, 0x40,
  0x02, 0x81, 0x80, 0x12, 0x02, 0x00, 0xC8, 0x0C, 0x0C, 0x20, 0x0F, 0xE1,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x1E, 0x00, 0x30, 0xE7, 0x00,
  0x46, 0x01, 0x80, 0x98, 0x01, 0x01, 0x40, 0x03, 0x03, 0x80, 0x02, 0x0A,
  0x00, 0x04, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80,
  0x00, 0x63, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x43, 0x00, 0x01,
  0x06, 0x00, 0x06, 0x1C, 0x00, 0x08, 0x2C, 0x00, 0x20, 0x48, 0x00, 0x80,
  0x8C, 0x06, 0x03, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7D, 0xF0, 0x70,
  0x04, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x10,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x81, 0x00, 0x1E, 0xF0, 0x80, 0x30, 0x04, 0x40, 0x30, 0x01, 0x20, 0x30,
  0x00, 0xF0, 0x10, 0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08,
  0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x02, 0x00, 0x06,
  0x01, 0x00, 0x05, 0x00, 0xC0, 0x04, 0x80, 0x20, 0x0C, 0x40, 0x18, 0x0C,
  0x20, 0x03, 0xF8, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x79, 0xC0, 0x30, 0x08,
  0x10, 0x03, 0x08, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0x80, 0x03, 0x60,
  0x00, 0x90, 0x00, 0x64, 0x00, 0x73, 0x00, 0xF0, 0xFF, 0xE0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60, 0x18, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x30, 0x40, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF7, 0x84, 0x07, 0x00, 0x88, 0x18,
  0x00, 0x90, 0x60, 0x01, 0xA0, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x41, 0x00, 0x03, 0x02,
  0x00, 0x0A, 0x06, 0x00, 0x24, 0x04, 0x00, 0x88, 0x0C, 0x06, 0x30, 0x07,
  0xF0, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x01, 0x00, 0x18, 0x03, 0xC0, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x7C, 0x01, 0x87, 0xBC, 0x04, 0x60, 0x18, 0x13, 0x00,
  0x20, 0x58, 0x00, 0xC1, 0xC0, 0x03, 0x0A, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00,
  0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x0C, 0x20, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x00, 0x01,
  0x80, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x21, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x02, 0x0C, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00, 0x60,
  0x10, 0x06, 0x00, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x40, 0x60, 0x02, 0x06,
  0x00, 0x10, 0x60, 0x00, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x45, 0x00, 0x02,
  0x44, 0x00, 0x14, 0x20, 0x01, 0xC0, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x01, 0x80, 0x10, 0x08, 0x00, 0x40, 0x40,
  0x02, 0x02, 0x00, 0x08, 0x30, 0x00, 0x60, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x00, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0xC7, 0xB8, 0x0E, 0x70, 0x11, 0x81, 0x86, 0x03,
  0x02, 0x40, 0x19, 0x80, 0x30, 0x50, 0x01, 0x20, 0x02, 0x0C, 0x00, 0x28,
  0x00, 0x42, 0x80, 0x07, 0x00, 0x08, 0x60, 0x00, 0xC0, 0x01, 0x0C, 0x00,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x00, 0x0C, 0x20, 0x00, 0xC0, 0x01, 0x0C,
  0x00, 0x10, 0x00, 0x21, 0x00, 0x02, 0x00, 0x04, 0x20, 0x00, 0x40, 0x00,
  0x84, 0x00, 0x18, 0x00, 0x31, 0x80, 0x02, 0x00, 0x04, 0x20, 0x00, 0x40,
  0x00, 0x84, 0x00, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00, 0x06, 0x10, 0x00,
  0x60, 0x00, 0x86, 0x00, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00, 0x02, 0x10,
  0x00, 0x20, 0x00, 0x42, 0x00, 0x04, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x00, 0x07, 0xC0, 0x18, 0x7B, 0xC0, 0x46, 0x01, 0x81, 0x30, 0x02,
  0x05, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0xA0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00,
  0x18, 0x40, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x10,
  0x80, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00,
  0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x40, 0x00, 0x3C,
  0x00, 0x1E, 0x78, 0x07, 0x00, 0xC0, 0xC0, 0x06, 0x18, 0x00, 0x23, 0x00,
  0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04,
  0xC0, 0x00, 0x84, 0x00, 0x18, 0x60, 0x03, 0x03, 0x00, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xC3, 0x9C, 0x00, 0x46, 0x01, 0x80, 0x26,
  0x00, 0x40, 0x16, 0x00, 0x30, 0x0E, 0x00, 0x08, 0x0A, 0x00, 0x04, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01,
  0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0x80, 0xB0, 0x00, 0x80, 0x48, 0x00,
  0x80, 0x23, 0x01, 0x80, 0x10, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xDE, 0x10,
  0x38, 0x04, 0x41, 0x80, 0x09, 0x0C, 0x00, 0x34, 0x20, 0x00, 0x61, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x30,
  0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0A, 0x10, 0x00,
  0x30, 0x40, 0x01, 0x41, 0x80, 0x09, 0x02, 0x00, 0x44, 0x0C, 0x06, 0x30,
  0x0F, 0xE0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x07, 0x03,
  0x1F, 0xC1, 0x18, 0x00, 0x98, 0x00, 0x58, 0x00, 0x38, 0x00, 0x28, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xEF, 0xC3, 0x00, 0x23, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x22, 0x00, 0x31, 0x80, 0x30, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x01, 0xFF, 0xE1, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x1F, 0x80, 0x10, 0x00,
  0x18, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10,
  0x00, 0x18, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x03,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00,
  0x03, 0x10, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00, 0x0C, 0x20, 0x00, 0xA1,
  0x00, 0x0F, 0x08, 0x00, 0xD0, 0x60, 0x0C, 0x81, 0x81, 0xC4, 0x07, 0xF8,
  0x20, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00,
  0x10, 0x80, 0x06, 0x18, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x03, 0x00, 0x60, 0x40, 0x04, 0x18,
  0x00, 0x82, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x44, 0x00, 0x09, 0x80,
  0x00, 0xA0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x02,
  0x00, 0x0A, 0x00, 0x38, 0x00, 0x90, 0x01, 0x40, 0x04, 0x80, 0x1A, 0x00,
  0x64, 0x00, 0x90, 0x02, 0x20, 0x0C, 0x80, 0x31, 0x00, 0x44, 0x01, 0x08,
  0x06, 0x20, 0x18, 0x40, 0x21, 0x00, 0x82, 0x03, 0x08, 0x0C, 0x10, 0x10,
  0x40, 0x40, 0x81, 0x83, 0x06, 0x04, 0x08, 0x08, 0x20, 0x20, 0xC0, 0x41,
  0x01, 0x84, 0x02, 0x10, 0x0C, 0x40, 0x10, 0x80, 0x22, 0x00, 0x88, 0x01,
  0x20, 0x04, 0x40, 0x09, 0x00, 0x24, 0x00, 0x50, 0x01, 0x20, 0x02, 0x80,
  0x0A, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x07, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0x23, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x24, 0x00, 0x00, 0x44, 0x00, 0x00, 0x82,
  0x00, 0x01, 0x82, 0x00, 0x03, 0x01, 0x00, 0x06, 0x01, 0x00, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x00, 0xC0, 0x20, 0x00, 0x40, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x08, 0x00, 0x18, 0x02,
  0x00, 0x04, 0x00, 0x80, 0x02, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x01, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x10, 0x06, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x20, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x1F, 0xC0, 0x05, 0x81, 0xC0, 0x38, 0x01, 0xE3, 0x00, 0x00, 0xF0,
};

const GFXglyph NotoSans_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 10, 12, 14, 5, -33 },
  { 54, 27, 33, 28, 2, -33 },
  { 166, 22, 38, 25, 2, -35 },
  { 271, 29, 34, 35, 4, -33 },
  { 395, 27, 33, 31, 2, -33 },
  { 507, 4, 12, 8, 5, -33 },
  { 513, 13, 40, 11, 1, -33 },
  { 578, 13, 40, 11, -3, -33 },
  { 643, 19, 19, 24, 6, -35 },
  { 689, 22, 21, 26, 3, -27 },
  { 747, 6, 11, 8, -2, -5 },
  { 756, 11, 1, 14, 2, -13 },
  { 758, 3, 2, 10, 1, -2 },
  { 759, 20, 33, 14, -2, -33 },
  { 842, 21, 33, 25, 3, -33 },
  { 929, 11, 33, 25, 8, -33 },
  { 975, 23, 33, 25, 0, -33 },
  { 1070, 23, 33, 25, 1, -33 },
  { 1165, 23, 33, 25, 1, -33 },
  { 1260, 23, 33, 25, 2, -33 },
  { 1355, 22, 33, 25, 3, -33 },
  { 1446, 21, 33, 25, 5, -33 },
  { 1533, 22, 33, 25, 2, -33 },
  { 1624, 22, 33, 25, 2, -33 },
  { 1715, 8, 24, 10, 1, -24 },
  { 1739, 11, 30, 10, -2, -24 },
  { 1781, 22, 21, 26, 3, -27 },
  { 1839, 22, 10, 26, 3, -21 },
  { 1867, 22, 21, 26, 3, -27 },
  { 1925, 15, 33, 19, 4, -33 },
  { 1987, 34, 36, 38, 3, -32 },
  { 2140, 25, 33, 25, -2, -33 },
  { 2244, 25, 33, 28, 2, -33 },
  { 2348, 25, 33, 27, 4, -33 },
  { 2452, 27, 33, 31, 2, -33 },
  { 2564, 24, 33, 25, 2, -33 },
  { 2663, 24, 33, 22, 2, -33 },
  { 2762, 27, 33, 32, 4, -33 },
  { 2874, 29, 33, 31, 2, -33 },
  { 2994, 15, 33, 13, 0, -33 },
  { 3056, 19, 41, 11, -8, -33 },
  { 3154, 27, 33, 25, 2, -33 },
  { 3266, 17, 33, 23, 2, -33 },
  { 3337, 35, 33, 37, 2, -33 },
  { 3482, 29, 33, 31, 2, -33 },
  { 3602, 27, 33, 33, 4, -33 },
  { 3714, 24, 33, 26, 2, -33 },
  { 3813, 27, 41, 33, 4, -33 },
  { 3952, 24, 33, 26, 2, -33 },
  { 4051, 22, 33, 23, 1, -33 },
  { 4142, 23, 33, 22, 4, -33 },
  { 4237, 28, 33, 32, 4, -33 },
  { 4353, 23, 33, 25, 5, -33 },
  { 4448, 35, 33, 38, 6, -33 },
  { 4593, 29, 33, 23, -3, -33 },
  { 4713, 23, 33, 22, 4, -33 },
  { 4808, 26, 33, 25, 0, -33 },
  { 4916, 17, 40, 14, 0, -33 },
  { 5001, 7, 33, 14, 5, -33 },
  { 5030, 17, 40, 14, -3, -33 },
  { 5115, 21, 20, 25, 2, -33 },
  { 5168, 17, 1, 17, -4, 5 },
  { 5171, 5, 7, 10, 7, -35 },
  { 5176, 22, 25, 25, 2, -25 },
  { 5245, 23, 35, 26, 1, -35 },
  { 5346, 18, 25, 21, 3, -25 },
  { 5403, 25, 35, 26, 2, -35 },
  { 5513, 18, 25, 23, 3, -25 },
  { 5570, 25, 46, 12, -6, -35 },
  { 5714, 23, 36, 26, 1, -25 },
  { 5818, 22, 35, 25, 1, -35 },
  { 5915, 9, 33, 10, 1, -33 },
  { 5953, 17, 44, 10, -7, -33 },
  { 6047, 21, 35, 20, 1, -35 },
  { 6139, 9, 35, 10, 1, -35 },
  { 6179, 35, 25, 39, 1, -25 },
  { 6289, 22, 25, 25, 1, -25 },
  { 6358, 20, 25, 26, 3, -25 },
  { 6421, 25, 36, 26, -1, -25 },
  { 6534, 22, 36, 26, 2, -25 },
  { 6633, 17, 25, 17, 1, -25 },
  { 6687, 17, 25, 19, 1, -25 },
  { 6741, 13, 30, 14, 2, -30 },
  { 6790, 21, 24, 25, 3, -24 },
  { 6853, 19, 24, 19, 2, -24 },
  { 6910, 29, 24, 30, 2, -24 },
  { 6997, 24, 24, 21, -2, -24 },
  { 7069, 26, 35, 19, -5, -24 },
  { 7183, 21, 24, 20, -1, -24 },
  { 7246, 17, 40, 15, 1, -33 },
  { 7331, 1, 46, 25, 13, -35 },
  { 7337, 16, 40, 15, -2, -33 },
  { 7417, 22, 4, 26, 3, -18 },
};

const GFXfont NotoSans_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_THINITALIC46PT7B_H_
