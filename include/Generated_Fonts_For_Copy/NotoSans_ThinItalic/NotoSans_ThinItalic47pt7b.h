#ifndef _NOTOSANS_THINITALIC47PT7B_H_
#define _NOTOSANS_THINITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x60, 0x70, 0x00, 0x10, 0x4C, 0x12, 0x04, 0x83, 0x20, 0x88, 0x26,
  0x09, 0x02, 0x41, 0x90, 0x44, 0x12, 0x04, 0x81, 0x00, 0x00, 0x04, 0x01,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x0F, 0xFF,
  0xFF, 0xF0, 0x04, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x10,
  0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x18,
  0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x06, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x07, 0x80, 0x01, 0xFB, 0xE0, 0x1C, 0x20, 0xC0,
  0xC0, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x01,
  0x00, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x40, 0x80, 0x01, 0x82, 0x00,
  0x03, 0x08, 0x00, 0x07, 0x20, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x43, 0x00, 0x03, 0x06, 0x00, 0x08, 0x08, 0x00, 0x20,
  0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0x60,
  0x01, 0x01, 0x00, 0x04, 0x18, 0x30, 0x10, 0xC0, 0x7F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x31, 0x80, 0x01, 0x02,
  0x06, 0x00, 0x10, 0x20, 0x10, 0x01, 0x83, 0x00, 0x80, 0x18, 0x10, 0x04,
  0x00, 0x80, 0x80, 0x20, 0x08, 0x08, 0x01, 0x00, 0xC0, 0x40, 0x08, 0x0C,
  0x02, 0x00, 0x40, 0x40, 0x30, 0x02, 0x04, 0x01, 0x80, 0x30, 0x60, 0x08,
  0x01, 0x06, 0x00, 0x40, 0x08, 0x20, 0x02, 0x00, 0x42, 0x1F, 0xD0, 0x04,
  0x31, 0x82, 0x80, 0x21, 0x18, 0x1E, 0x02, 0x10, 0x80, 0x50, 0x31, 0x08,
  0x02, 0xC3, 0x18, 0x40, 0x13, 0xE0, 0x86, 0x00, 0x80, 0x08, 0x20, 0x04,
  0x00, 0xC1, 0x00, 0x20, 0x0C, 0x18, 0x01, 0x00, 0x40, 0xC0, 0x18, 0x04,
  0x04, 0x00, 0xC0, 0x60, 0x20, 0x04, 0x06, 0x01, 0x00, 0x20, 0x20, 0x08,
  0x03, 0x02, 0x00, 0x40, 0x10, 0x30, 0x02, 0x01, 0x83, 0x00, 0x18, 0x08,
  0x10, 0x00, 0x61, 0x81, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x08, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x80,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x03, 0x10, 0x03, 0x00,
  0x22, 0x00, 0x18, 0x06, 0x60, 0x00, 0x80, 0x44, 0x00, 0x04, 0x08, 0xC0,
  0x00, 0x61, 0x8C, 0x00, 0x02, 0x10, 0xC0, 0x00, 0x12, 0x08, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x40, 0x60, 0x00, 0x62, 0x02,
  0x00, 0x0C, 0x30, 0x18, 0x07, 0x01, 0x00, 0xFF, 0xC0, 0x0C, 0x13, 0x22,
  0x22, 0x64, 0x44, 0x48, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x01,
  0x80, 0x40, 0x18, 0x10, 0x00, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x68, 0x7C,
  0x03, 0xF8, 0x00, 0xE0, 0x00, 0x34, 0x00, 0x0C, 0x40, 0x02, 0x08, 0x00,
  0x80, 0x80, 0x60, 0x10, 0x08, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x30, 0x86, 0x10,
  0xC2, 0x08, 0x41, 0x08, 0x00, 0xFF, 0xE0, 0x4F, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0x83, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x08,
  0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x04, 0x40,
  0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x04,
  0x30, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x06, 0x06, 0x00, 0x30, 0x0C,
  0x01, 0x80, 0x18, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x20, 0x1C, 0x07,
  0x83, 0x20, 0xC4, 0x60, 0x98, 0x14, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0x04, 0x00, 0x80, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x38, 0x01, 0xC0, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00,
  0xC0, 0xE0, 0x03, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00, 0x60,
  0x10, 0x00, 0x40, 0x10, 0x00, 0x80, 0x30, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x20, 0x08, 0x00, 0x20, 0x18, 0x00, 0x60, 0x30, 0x00,
  0x40, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0xFF, 0x80, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x40, 0x01, 0xC0, 0xE0, 0x0E, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x08, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x03, 0x80, 0x08, 0x7F, 0xE0, 0x13, 0x80,
  0x60, 0x6C, 0x00, 0x60, 0xB0, 0x00, 0x41, 0xC0, 0x00, 0xC3, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x18, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00, 0x08,
  0x80, 0x00, 0x31, 0x00, 0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04,
  0x00, 0x04, 0x08, 0x00, 0x18, 0x08, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18,
  0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00,
  0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x40, 0x10, 0x01,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x70, 0x00, 0x1B, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xCC, 0x00, 0x1C, 0x06, 0x00, 0x60, 0x06, 0x01, 0x00, 0x06, 0x04,
  0x00, 0x04, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x08, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x18, 0x00, 0x60, 0x18, 0x03, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x60, 0x00, 0x80, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x18, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x00, 0x31,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18,
  0x00, 0x14, 0x10, 0x00, 0x58, 0x10, 0x03, 0x20, 0x18, 0x1C, 0x40, 0x1F,
  0xE1, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x80, 0x30, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x60, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xE0, 0x38, 0x38, 0x20, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0x42,
  0x00, 0x07, 0xC0, 0x08, 0xC0, 0x07, 0x9F, 0x01, 0x90, 0x03, 0x80, 0x40,
  0x16, 0x00, 0xC0, 0x08, 0x02, 0x80, 0x30, 0x01, 0x00, 0x50, 0x04, 0x00,
  0x60, 0x0E, 0x01, 0x00, 0x08, 0x01, 0x80, 0x20, 0x01, 0x00, 0x70, 0x0C,
  0x00, 0x20, 0x0E, 0x01, 0x00, 0x0C, 0x01, 0x40, 0x20, 0x01, 0x00, 0x28,
  0x04, 0x00, 0x20, 0x0D, 0x00, 0x80, 0x0C, 0x01, 0x20, 0x10, 0x01, 0x80,
  0x64, 0x02, 0x00, 0x70, 0x08, 0x80, 0x40, 0x1A, 0x03, 0x10, 0x0C, 0x06,
  0x40, 0xC2, 0x00, 0xC3, 0x8C, 0x70, 0x60, 0x07, 0xC0, 0xF8, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x10, 0x00, 0x40, 0x0F, 0xFF, 0xE0, 0x08, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x40, 0x01, 0x80, 0x20,
  0x00, 0x20, 0x10, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x18, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x04, 0x00, 0x38, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0xC0, 0x40, 0x07, 0x80, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0x81, 0xF0, 0x07, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0x00,
  0x0E, 0x00, 0x10, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x70, 0x04, 0x00, 0x1C, 0x00, 0x40, 0x1F, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0xF8, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x0F, 0xFE, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x20, 0x06, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x0F, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x81, 0x80, 0x1F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x20, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x09, 0x90, 0x00,
  0x00, 0xB1, 0x80, 0x00, 0x0E, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x00, 0x02, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x20, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x14, 0x00, 0x00, 0x0A, 0x01, 0x40, 0x00, 0x01, 0xA0,
  0x34, 0x00, 0x00, 0x16, 0x02, 0x40, 0x00, 0x02, 0x40, 0x24, 0x00, 0x00,
  0x64, 0x02, 0x60, 0x00, 0x04, 0x40, 0x22, 0x00, 0x00, 0xCC, 0x06, 0x20,
  0x00, 0x08, 0xC0, 0x42, 0x00, 0x01, 0x08, 0x04, 0x20, 0x00, 0x30, 0x80,
  0x43, 0x00, 0x02, 0x08, 0x0C, 0x10, 0x00, 0x61, 0x80, 0xC1, 0x00, 0x04,
  0x10, 0x08, 0x10, 0x00, 0x81, 0x00, 0x81, 0x00, 0x18, 0x10, 0x08, 0x10,
  0x01, 0x01, 0x01, 0x81, 0x80, 0x30, 0x30, 0x10, 0x08, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x20, 0x30, 0x08, 0x18, 0x06, 0x02, 0x00, 0xC1, 0x00, 0x40, 0x20, 0x04,
  0x20, 0x04, 0x02, 0x00, 0x46, 0x00, 0x40, 0x60, 0x04, 0x40, 0x0C, 0x06,
  0x00, 0x4C, 0x00, 0xC0, 0x40, 0x06, 0x80, 0x08, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x40, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x02, 0x03, 0x80, 0x00,
  0x10, 0x14, 0x00, 0x01, 0x81, 0xB0, 0x00, 0x08, 0x08, 0x80, 0x00, 0x40,
  0x44, 0x00, 0x02, 0x02, 0x30, 0x00, 0x30, 0x10, 0x80, 0x01, 0x81, 0x86,
  0x00, 0x08, 0x08, 0x10, 0x00, 0x40, 0x40, 0xC0, 0x02, 0x02, 0x02, 0x00,
  0x30, 0x30, 0x10, 0x01, 0x01, 0x80, 0xC0, 0x08, 0x08, 0x02, 0x00, 0x40,
  0x40, 0x18, 0x02, 0x02, 0x00, 0x40, 0x30, 0x30, 0x03, 0x01, 0x01, 0x00,
  0x08, 0x08, 0x08, 0x00, 0x40, 0x40, 0x40, 0x03, 0x02, 0x02, 0x00, 0x08,
  0x30, 0x30, 0x00, 0x61, 0x01, 0x00, 0x01, 0x08, 0x08, 0x00, 0x0C, 0x40,
  0x40, 0x00, 0x26, 0x06, 0x00, 0x01, 0x30, 0x30, 0x00, 0x0D, 0x01, 0x00,
  0x00, 0x28, 0x08, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xC0, 0x03,
  0x00, 0x10, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0x00, 0x1C, 0x01, 0x00,
  0x06, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03, 0x02, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x08, 0x00, 0x70, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x18, 0x02, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0x00, 0x1C, 0x01, 0x00, 0x06, 0x01, 0x00,
  0x02, 0x03, 0x00, 0x03, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x04, 0x00, 0x03, 0x04, 0x00,
  0x03, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x08, 0x00,
  0x38, 0x08, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x18, 0x02, 0x00, 0x18, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x30, 0x00,
  0x80, 0x20, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x60, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x30, 0xC0, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x78, 0x07, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x08, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x60, 0x00, 0xC0,
  0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x08, 0x00,
  0x10, 0x18, 0x00, 0x10, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04,
  0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x03, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x30, 0x80, 0x04, 0x20, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x20,
  0xC0, 0x08, 0x20, 0x04, 0x04, 0x01, 0x02, 0x00, 0x40, 0x40, 0x10, 0x20,
  0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x04, 0x04,
  0x03, 0x01, 0x00, 0x40, 0x40, 0x10, 0x30, 0x04, 0x0C, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x60,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x02, 0x00, 0x01, 0x00, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x01, 0x80, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x28, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x40, 0x00,
  0x21, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00,
  0xC0, 0x0C, 0x01, 0x00, 0x60, 0x04, 0x01, 0x00, 0x10, 0x08, 0x00, 0x60,
  0x60, 0x00, 0x81, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x13, 0x00,
  0x00, 0x48, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x81, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x81, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02,
  0x06, 0x04, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x60, 0x40, 0x03, 0x01, 0x80, 0x08, 0x02,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x20, 0x08, 0x00, 0x40, 0x40, 0x01, 0x03,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x23, 0x00, 0x00, 0x98, 0x00,
  0x02, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xC0, 0x86, 0x10, 0x43, 0x08, 0x21,
  0x00, 0x7F, 0x04, 0x07, 0x03, 0x10, 0x30, 0x04, 0xC1, 0x80, 0x0A, 0x0C,
  0x00, 0x28, 0x60, 0x00, 0xE1, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x21,
  0x00, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x50, 0x40, 0x03, 0x41, 0x80, 0x1B,
  0x02, 0x00, 0xC8, 0x0C, 0x06, 0x20, 0x0F, 0xE0, 0x80, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x63, 0x03, 0x80, 0x8C,
  0x01, 0x01, 0x20, 0x01, 0x02, 0x80, 0x02, 0x06, 0x00, 0x06, 0x1C, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x04, 0x38, 0x00, 0x18, 0x48, 0x00, 0x60, 0x98, 0x01, 0x81, 0x18,
  0x0E, 0x06, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x70, 0x08, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x40, 0x1C, 0x0C, 0x60, 0x18, 0x01,
  0x20, 0x18, 0x00, 0x50, 0x18, 0x00, 0x28, 0x18, 0x00, 0x1C, 0x08, 0x00,
  0x06, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x60,
  0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x01, 0x00, 0x02, 0x80, 0x80, 0x02, 0x40, 0x60, 0x02, 0x40,
  0x10, 0x02, 0x20, 0x0C, 0x06, 0x10, 0x01, 0xFE, 0x08, 0x00, 0x00, 0x7F,
  0x00, 0x30, 0x30, 0x18, 0x03, 0x06, 0x00, 0x20, 0x80, 0x06, 0x20, 0x00,
  0xCC, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0xC8, 0x00, 0x31, 0x00, 0x18,
  0x60, 0x7C, 0x0F, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x38, 0x40, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC1, 0x00, 0xE0, 0x61, 0x01, 0x80, 0x12, 0x03, 0x00,
  0x0A, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x0A, 0x08, 0x00, 0x06, 0x18, 0x00,
  0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x20, 0x00,
  0x50, 0x20, 0x00, 0xB0, 0x30, 0x01, 0xA0, 0x10, 0x03, 0x20, 0x18, 0x0C,
  0x20, 0x07, 0xF8, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x80, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x83, 0xF8, 0x06, 0x30,
  0x18, 0x11, 0x80, 0x20, 0x48, 0x00, 0xC1, 0x40, 0x01, 0x07, 0x00, 0x04,
  0x38, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x61, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x03, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80,
  0x30, 0x04, 0x03, 0x00, 0x60, 0x30, 0x02, 0x03, 0x00, 0x10, 0x30, 0x00,
  0x83, 0x00, 0x04, 0x20, 0x00, 0x63, 0x00, 0x02, 0x2C, 0x00, 0x12, 0x20,
  0x00, 0xA1, 0x80, 0x06, 0x04, 0x00, 0x60, 0x30, 0x02, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x18,
  0x10, 0x00, 0x41, 0x80, 0x03, 0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x02,
  0x1F, 0xC0, 0x3F, 0x80, 0x63, 0x06, 0x06, 0x0C, 0x04, 0x40, 0x30, 0x80,
  0x20, 0x48, 0x01, 0x10, 0x02, 0x05, 0x00, 0x12, 0x00, 0x30, 0x60, 0x01,
  0x40, 0x01, 0x0E, 0x00, 0x14, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x80, 0x01, 0x00, 0x02, 0x08, 0x00, 0x10, 0x00,
  0x21, 0x80, 0x03, 0x00, 0x02, 0x10, 0x00, 0x20, 0x00, 0x61, 0x00, 0x02,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x00, 0x41, 0x00, 0x02, 0x00, 0x04, 0x30,
  0x00, 0x60, 0x00, 0x42, 0x00, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x40, 0x00,
  0x82, 0x00, 0x04, 0x00, 0x08, 0x60, 0x00, 0x40, 0x00, 0x84, 0x00, 0x0C,
  0x00, 0x18, 0x40, 0x00, 0x80, 0x01, 0x84, 0x00, 0x08, 0x00, 0x10, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x0F, 0xE0, 0x18, 0xC0, 0x60, 0x46, 0x00,
  0x81, 0x20, 0x03, 0x05, 0x00, 0x04, 0x1C, 0x00, 0x10, 0xE0, 0x00, 0x43,
  0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0x86, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x04,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x60,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0xC0, 0x00,
  0x60, 0x00, 0xFF, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0x61,
  0x80, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x40, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x01,
  0x20, 0x00, 0x19, 0x00, 0x00, 0x8C, 0x00, 0x0C, 0x20, 0x00, 0xC1, 0x80,
  0x0C, 0x07, 0x01, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x83, 0xF8, 0x00, 0xC7,
  0x07, 0x00, 0x46, 0x00, 0x80, 0x24, 0x00, 0x20, 0x14, 0x00, 0x10, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x81, 0xC0, 0x00,
  0xC0, 0x90, 0x00, 0xC0, 0x4C, 0x00, 0xC0, 0x23, 0x01, 0xC0, 0x10, 0xFF,
  0x80, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x82, 0x03, 0x81, 0x84, 0x0C, 0x00, 0x90, 0x30, 0x00, 0xA0,
  0xC0, 0x01, 0x43, 0x00, 0x02, 0x84, 0x00, 0x03, 0x18, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x82, 0x00, 0x05, 0x04, 0x00, 0x16,
  0x0C, 0x00, 0x68, 0x08, 0x01, 0x90, 0x18, 0x0C, 0x20, 0x0F, 0xF0, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x02, 0x0F, 0xC1, 0x8C,
  0x00, 0x46, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x01, 0x80, 0x70, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x88, 0x00, 0xC3, 0x00, 0x60, 0x7F,
  0xF0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x07, 0xFF, 0xC3, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x08,
  0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x33, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x23, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x61, 0x00,
  0x07, 0x08, 0x00, 0x28, 0x40, 0x02, 0x43, 0x00, 0x66, 0x0C, 0x06, 0x20,
  0x3F, 0xC1, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00,
  0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x60, 0x01, 0x06, 0x00, 0x20, 0x20,
  0x06, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x03,
  0x01, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00,
  0x10, 0x80, 0x01, 0x90, 0x00, 0x09, 0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xA0, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x48, 0x00, 0xA0, 0x02,
  0x40, 0x09, 0x00, 0x22, 0x00, 0xC8, 0x01, 0x10, 0x04, 0x40, 0x18, 0x80,
  0x63, 0x00, 0x84, 0x02, 0x08, 0x0C, 0x20, 0x30, 0x40, 0x41, 0x01, 0x02,
  0x06, 0x08, 0x18, 0x10, 0x20, 0x60, 0x80, 0x83, 0x03, 0x0C, 0x04, 0x10,
  0x18, 0x40, 0x21, 0x80, 0x46, 0x01, 0x08, 0x02, 0x20, 0x0C, 0xC0, 0x13,
  0x00, 0x64, 0x00, 0x90, 0x01, 0x20, 0x05, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0x50, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x01, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x00, 0x40, 0x20, 0x00, 0x40, 0x40, 0x00, 0x60,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0x33, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x00, 0x06, 0x01,
  0x80, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x20, 0x00,
  0x60, 0xC0, 0x00, 0x20, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x18, 0x02,
  0x00, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x08, 0x00, 0x10, 0x01, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00, 0x08,
  0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x08, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x08, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xFE,
  0x00, 0x70, 0x1C, 0x07, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 10, 13, 15, 5, -34 },
  { 57, 27, 34, 29, 2, -34 },
  { 172, 22, 39, 26, 2, -36 },
  { 280, 29, 35, 36, 4, -34 },
  { 407, 28, 34, 32, 2, -34 },
  { 526, 4, 13, 8, 5, -34 },
  { 533, 14, 41, 11, 1, -34 },
  { 605, 13, 41, 11, -3, -34 },
  { 672, 19, 20, 25, 6, -36 },
  { 720, 21, 21, 27, 4, -27 },
  { 776, 6, 11, 9, -2, -5 },
  { 785, 11, 1, 15, 2, -13 },
  { 787, 3, 3, 10, 1, -3 },
  { 789, 20, 34, 14, -2, -34 },
  { 874, 22, 34, 26, 3, -34 },
  { 968, 11, 34, 26, 8, -34 },
  { 1015, 24, 34, 26, 0, -34 },
  { 1117, 24, 34, 26, 1, -34 },
  { 1219, 24, 34, 26, 1, -34 },
  { 1321, 23, 34, 26, 2, -34 },
  { 1419, 23, 34, 26, 3, -34 },
  { 1517, 21, 34, 26, 5, -34 },
  { 1607, 23, 34, 26, 2, -34 },
  { 1705, 23, 34, 26, 2, -34 },
  { 1803, 8, 25, 10, 1, -25 },
  { 1828, 11, 31, 10, -2, -25 },
  { 1871, 21, 22, 27, 4, -28 },
  { 1929, 21, 11, 27, 4, -22 },
  { 1958, 21, 22, 27, 4, -28 },
  { 2016, 16, 34, 19, 4, -34 },
  { 2084, 35, 37, 39, 3, -33 },
  { 2246, 25, 34, 26, -2, -34 },
  { 2353, 25, 34, 28, 2, -34 },
  { 2460, 26, 34, 28, 4, -34 },
  { 2571, 28, 34, 32, 2, -34 },
  { 2690, 24, 34, 25, 2, -34 },
  { 2792, 24, 34, 23, 2, -34 },
  { 2894, 27, 34, 32, 4, -34 },
  { 3009, 30, 34, 32, 2, -34 },
  { 3137, 15, 34, 13, 0, -34 },
  { 3201, 19, 42, 11, -8, -34 },
  { 3301, 28, 34, 26, 2, -34 },
  { 3420, 17, 34, 23, 2, -34 },
  { 3493, 36, 34, 38, 2, -34 },
  { 3646, 29, 34, 32, 2, -34 },
  { 3770, 28, 34, 34, 4, -34 },
  { 3889, 24, 34, 26, 2, -34 },
  { 3991, 28, 42, 34, 4, -34 },
  { 4138, 24, 34, 26, 2, -34 },
  { 4240, 23, 34, 23, 1, -34 },
  { 4338, 23, 34, 23, 4, -34 },
  { 4436, 29, 34, 33, 4, -34 },
  { 4560, 24, 34, 25, 5, -34 },
  { 4662, 36, 34, 39, 6, -34 },
  { 4815, 30, 34, 23, -3, -34 },
  { 4943, 22, 34, 23, 5, -34 },
  { 5037, 27, 34, 25, 0, -34 },
  { 5152, 17, 41, 14, 0, -34 },
  { 5240, 7, 34, 14, 5, -34 },
  { 5270, 17, 41, 14, -3, -34 },
  { 5358, 22, 21, 26, 2, -34 },
  { 5416, 18, 1, 17, -4, 5 },
  { 5419, 5, 8, 11, 7, -36 },
  { 5424, 22, 25, 26, 2, -25 },
  { 5493, 23, 36, 27, 1, -36 },
  { 5597, 19, 25, 21, 3, -25 },
  { 5657, 25, 36, 27, 2, -36 },
  { 5770, 19, 25, 23, 3, -25 },
  { 5830, 25, 47, 12, -6, -36 },
  { 5977, 24, 36, 27, 1, -25 },
  { 6085, 22, 36, 26, 1, -36 },
  { 6184, 9, 34, 10, 1, -34 },
  { 6223, 17, 45, 10, -7, -34 },
  { 6319, 21, 36, 21, 1, -36 },
  { 6414, 9, 36, 10, 1, -36 },
  { 6455, 36, 25, 40, 1, -25 },
  { 6568, 22, 25, 26, 1, -25 },
  { 6637, 21, 25, 27, 3, -25 },
  { 6703, 25, 36, 27, -1, -25 },
  { 6816, 23, 36, 27, 2, -25 },
  { 6920, 18, 25, 17, 1, -25 },
  { 6977, 18, 25, 20, 1, -25 },
  { 7034, 14, 31, 15, 2, -31 },
  { 7089, 21, 25, 26, 3, -25 },
  { 7155, 20, 25, 19, 2, -25 },
  { 7218, 29, 25, 31, 3, -25 },
  { 7309, 24, 25, 21, -2, -25 },
  { 7384, 27, 36, 19, -5, -25 },
  { 7506, 21, 25, 20, -1, -25 },
  { 7572, 17, 41, 15, 1, -34 },
  { 7660, 1, 47, 25, 13, -36 },
  { 7666, 16, 41, 15, -2, -34 },
  { 7748, 21, 4, 27, 4, -19 },
};

const GFXfont NotoSans_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_THINITALIC47PT7B_H_
