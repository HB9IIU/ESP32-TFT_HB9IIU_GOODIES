#ifndef _NOTOSANS_THINITALIC28PT7B_H_
#define _NOTOSANS_THINITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x00, 0x00,
  0x21, 0x00, 0x45, 0x14, 0x51, 0x8A, 0x28, 0x80, 0x01, 0x04, 0x01, 0x04,
  0x01, 0x04, 0x01, 0x04, 0x02, 0x08, 0x02, 0x08, 0x3F, 0xFF, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE,
  0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x80, 0x20, 0x80,
  0x00, 0x40, 0x02, 0x00, 0xFC, 0x19, 0x11, 0x08, 0x08, 0x40, 0x42, 0x02,
  0x20, 0x11, 0x00, 0x48, 0x01, 0xC0, 0x03, 0x80, 0x22, 0x01, 0x08, 0x08,
  0x40, 0x42, 0x02, 0x20, 0x21, 0x31, 0x20, 0x5A, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x00, 0x1E, 0x00, 0x88, 0x40, 0x42, 0x10, 0x21, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x11, 0x02, 0x04, 0x40, 0x82, 0x27, 0xA0, 0x92,
  0x14, 0x49, 0x05, 0xE2, 0x41, 0x01, 0x20, 0x40, 0x88, 0x10, 0x42, 0x04,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x08, 0x22, 0x02, 0x11, 0x80, 0x78, 0x01,
  0xF0, 0x01, 0x04, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x40, 0x08, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x06, 0x20, 0x04, 0x10,
  0x14, 0x04, 0x12, 0x01, 0x0A, 0x00, 0x49, 0x00, 0x28, 0x80, 0x08, 0x40,
  0x0A, 0x10, 0x19, 0x07, 0xF0, 0x40, 0x55, 0xA8, 0x03, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x06, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02, 0x00, 0x82, 0x10,
  0x62, 0x03, 0x40, 0x17, 0xC3, 0x00, 0xA0, 0x62, 0x10, 0x40, 0x04, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF,
  0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x24,
  0xA5, 0x20, 0xFE, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x07, 0xE0,
  0x40, 0x84, 0x04, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x44, 0x02, 0x10, 0x20, 0x7E, 0x00, 0x04, 0x72, 0x71, 0x84, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x03, 0xF8,
  0x10, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x60,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x3F, 0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x88, 0x04, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x50, 0x01, 0x20, 0x04, 0x80, 0x11, 0x00, 0x42, 0x01, 0x04, 0x02,
  0x08, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82, 0x01, 0x08, 0x04, 0x3F, 0xFF,
  0x80, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFC,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x3F, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x88, 0x04, 0x1F, 0xE0, 0x01, 0xF8, 0x30,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x4F, 0xC5,
  0x81, 0x30, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80,
  0x24, 0x02, 0x10, 0x20, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x42, 0x01, 0x10, 0x04,
  0x40, 0x10, 0x80, 0x82, 0x04, 0x06, 0x60, 0x0E, 0x00, 0xCC, 0x0C, 0x08,
  0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x11, 0x00, 0x44, 0x06,
  0x0F, 0xE0, 0x07, 0xE0, 0x20, 0x41, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x61, 0x02, 0x83, 0xF2, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x3F,
  0x80, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x04, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00,
  0x00, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x00, 0x7F, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x0C, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x09, 0x01, 0xF8, 0x28, 0x30, 0x41,
  0x82, 0x02, 0x0C, 0x10, 0x20, 0x61, 0x01, 0x03, 0x08, 0x08, 0x28, 0x40,
  0x41, 0x42, 0x04, 0x0A, 0x10, 0x60, 0x90, 0x86, 0x88, 0x83, 0xC7, 0x84,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x40,
  0x04, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x08, 0x10,
  0x10, 0x40, 0x20, 0xFF, 0xC2, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x02,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x07, 0xF8, 0x10, 0x08, 0x20, 0x08,
  0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x18, 0x3F,
  0xC0, 0x80, 0x41, 0x00, 0x42, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x08, 0x80, 0x11, 0x00, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x04, 0x06, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x10, 0x80,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04,
  0x20, 0x0C, 0x10, 0x18, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x3F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0x00, 0x42, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x1F, 0x90, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x10,
  0x02, 0x0C, 0x01, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x04, 0x20, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x04,
  0x10, 0x01, 0x07, 0xFF, 0xC2, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08,
  0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00,
  0x42, 0x00, 0x10, 0x0F, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x1F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0xF8,
  0x00, 0x08, 0x01, 0x84, 0x01, 0x02, 0x01, 0x01, 0x03, 0x00, 0x82, 0x00,
  0x82, 0x00, 0x42, 0x00, 0x22, 0x00, 0x12, 0x00, 0x12, 0x80, 0x0E, 0x40,
  0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x04, 0x10, 0x03, 0x00, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x7F, 0xF0,
  0x04, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x50, 0xA0,
  0x04, 0x89, 0x00, 0x28, 0x48, 0x02, 0x42, 0x40, 0x12, 0x12, 0x01, 0x11,
  0x08, 0x10, 0x88, 0x40, 0x88, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84,
  0x11, 0x04, 0x41, 0x08, 0x12, 0x08, 0x40, 0xA0, 0x42, 0x05, 0x02, 0x10,
  0x30, 0x11, 0x01, 0x01, 0x00, 0x08, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x08,
  0x28, 0x02, 0x0A, 0x00, 0x84, 0x40, 0x21, 0x10, 0x10, 0x44, 0x04, 0x10,
  0x81, 0x08, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x20, 0x22, 0x08, 0x08,
  0x84, 0x02, 0x21, 0x00, 0x48, 0x40, 0x14, 0x10, 0x03, 0x04, 0x00, 0xC2,
  0x00, 0x10, 0x03, 0xFC, 0x02, 0x01, 0x02, 0x00, 0x42, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x04,
  0x40, 0x04, 0x10, 0x02, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x10,
  0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02,
  0x10, 0x04, 0x20, 0x10, 0x81, 0x81, 0xFC, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xFC, 0x02, 0x01, 0x02, 0x00, 0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x04, 0x40, 0x04, 0x10,
  0x02, 0x0C, 0x06, 0x01, 0xDC, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x07, 0xF0, 0x10, 0x18, 0x20, 0x10, 0x40,
  0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x08, 0x20, 0x30,
  0xFF, 0x81, 0x04, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0x80, 0x07, 0xF8, 0x40, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x31, 0xFE, 0x00, 0xFF, 0xF8, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x11, 0x00, 0x08, 0x40,
  0x08, 0x20, 0x04, 0x08, 0x0C, 0x03, 0xF8, 0x00, 0x80, 0x06, 0x00, 0x28,
  0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x41,
  0x02, 0x04, 0x10, 0x10, 0x40, 0x42, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00,
  0x28, 0x00, 0xA0, 0x03, 0x00, 0x08, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x28, 0x03, 0x00, 0x90, 0x14, 0x04, 0x40, 0x50, 0x11, 0x02, 0x40, 0x44,
  0x09, 0x02, 0x10, 0x44, 0x08, 0x41, 0x10, 0x41, 0x08, 0x41, 0x04, 0x21,
  0x08, 0x11, 0x02, 0x20, 0x44, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x04, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x10, 0x08, 0x08, 0x01,
  0x04, 0x00, 0x42, 0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x41, 0x00,
  0x20, 0x40, 0x10, 0x08, 0x08, 0x02, 0x02, 0x00, 0x43, 0x00, 0x10, 0x80,
  0x0C, 0x00, 0xA0, 0x08, 0x80, 0x44, 0x04, 0x20, 0x40, 0x82, 0x04, 0x20,
  0x22, 0x01, 0x20, 0x05, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xF0,
  0x07, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xE0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x42,
  0x22, 0x22, 0x11, 0x11, 0x07, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x07,
  0xE0, 0x00, 0x40, 0x06, 0x00, 0x48, 0x04, 0x40, 0x22, 0x02, 0x10, 0x20,
  0x41, 0x02, 0x10, 0x11, 0x00, 0x48, 0x03, 0x80, 0x10, 0xFF, 0xC0, 0x88,
  0x90, 0x07, 0xC8, 0x41, 0x44, 0x06, 0x40, 0x32, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0xC4, 0x0A, 0x20, 0x90,
  0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x4F, 0x82, 0x82, 0x28, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0xB0, 0x09, 0x40, 0x89, 0xF8,
  0x00, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0F, 0xE0, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x81, 0xF9, 0x04,
  0x0A, 0x10, 0x14, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02,
  0x20, 0x04, 0x40, 0x08, 0x80, 0x31, 0x00, 0x41, 0x01, 0x82, 0x05, 0x03,
  0xF2, 0x00, 0x07, 0x83, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0xA0, 0x67,
  0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x03,
  0xF0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x07, 0xE4, 0x20, 0x51, 0x01,
  0x48, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x03, 0x20, 0x08, 0x40, 0x61, 0x02, 0x83, 0xF2, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x83, 0x01, 0xF0, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x4F, 0x82, 0x82, 0x28,
  0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x0E, 0x00, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x11, 0x02, 0x20, 0x42, 0x08, 0x21,
  0x02, 0x20, 0x24, 0x04, 0xC0, 0x72, 0x04, 0x20, 0x41, 0x08, 0x10, 0x80,
  0x88, 0x08, 0x80, 0x40, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x00, 0x13, 0xE1, 0xF0, 0xA1, 0x10, 0x8A,
  0x05, 0x02, 0x60, 0x30, 0x12, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40,
  0x28, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x90, 0x08, 0x05, 0x00,
  0x80, 0x28, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x80, 0x13, 0xE0,
  0xA0, 0x8A, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x48, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x05, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x80, 0x0F,
  0xC1, 0x02, 0x20, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x09, 0xF0,
  0x28, 0x21, 0x40, 0x46, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x60, 0x11, 0x40, 0x84, 0xFC,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x00, 0x07, 0xE4, 0x20, 0x51, 0x01, 0x48, 0x02, 0x20, 0x09, 0x00, 0x24,
  0x00, 0x90, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x08, 0x40, 0x61,
  0x02, 0x83, 0xF2, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x13, 0xC5, 0x02, 0x80, 0xC0, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F,
  0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x05, 0x01, 0x1F, 0xC0, 0x10, 0x10, 0x10, 0x7F,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x78, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0x80, 0xC8, 0x34, 0x7C,
  0x40, 0x80, 0x18, 0x02, 0x40, 0x24, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04,
  0x10, 0x22, 0x02, 0x20, 0x24, 0x02, 0x80, 0x28, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x50, 0x50, 0x28, 0x28, 0x24, 0x24,
  0x12, 0x12, 0x11, 0x11, 0x08, 0x88, 0x48, 0x48, 0x24, 0x24, 0x14, 0x14,
  0x0A, 0x0C, 0x06, 0x06, 0x03, 0x02, 0x01, 0x00, 0x10, 0x04, 0x20, 0x20,
  0x81, 0x01, 0x08, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x40, 0x03, 0x00,
  0x12, 0x00, 0x88, 0x04, 0x10, 0x20, 0x41, 0x00, 0x88, 0x02, 0x00, 0x08,
  0x01, 0x08, 0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x04,
  0x10, 0x04, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x03, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x05, 0x01, 0x80, 0x80, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x7C, 0x0C,
  0x1F, 0x80,
};

const GFXglyph NotoSans_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 6, 7, 9, 3, -20 },
  { 20, 16, 20, 17, 1, -20 },
  { 60, 13, 23, 15, 1, -21 },
  { 98, 18, 20, 21, 2, -20 },
  { 143, 17, 20, 19, 1, -20 },
  { 186, 2, 7, 5, 3, -20 },
  { 188, 8, 24, 7, 1, -20 },
  { 212, 8, 24, 7, -2, -20 },
  { 236, 11, 12, 15, 4, -21 },
  { 253, 13, 13, 16, 2, -16 },
  { 275, 3, 7, 5, -1, -3 },
  { 278, 7, 1, 9, 1, -8 },
  { 279, 1, 2, 6, 1, -2 },
  { 280, 12, 20, 9, -1, -20 },
  { 310, 13, 20, 15, 2, -20 },
  { 343, 6, 20, 15, 5, -20 },
  { 358, 14, 20, 15, 0, -20 },
  { 393, 14, 20, 15, 1, -20 },
  { 428, 15, 20, 15, 0, -20 },
  { 466, 14, 20, 15, 1, -20 },
  { 501, 13, 20, 15, 2, -20 },
  { 534, 13, 20, 15, 3, -20 },
  { 567, 14, 20, 15, 1, -20 },
  { 602, 14, 20, 15, 1, -20 },
  { 637, 4, 15, 6, 1, -15 },
  { 645, 6, 19, 6, -1, -15 },
  { 660, 13, 12, 16, 2, -16 },
  { 680, 13, 6, 16, 2, -13 },
  { 690, 13, 12, 16, 2, -16 },
  { 710, 10, 20, 11, 2, -20 },
  { 735, 21, 23, 23, 2, -20 },
  { 796, 15, 20, 15, -1, -20 },
  { 834, 15, 20, 17, 1, -20 },
  { 872, 16, 20, 17, 2, -20 },
  { 912, 17, 20, 19, 1, -20 },
  { 955, 15, 20, 15, 1, -20 },
  { 993, 15, 20, 14, 1, -20 },
  { 1031, 17, 20, 19, 2, -20 },
  { 1074, 18, 20, 19, 1, -20 },
  { 1119, 9, 20, 8, 0, -20 },
  { 1142, 11, 25, 6, -5, -20 },
  { 1177, 17, 20, 15, 1, -20 },
  { 1220, 11, 20, 14, 1, -20 },
  { 1248, 21, 20, 23, 1, -20 },
  { 1301, 18, 20, 19, 1, -20 },
  { 1346, 17, 20, 20, 2, -20 },
  { 1389, 15, 20, 16, 1, -20 },
  { 1427, 17, 25, 20, 2, -20 },
  { 1481, 15, 20, 16, 1, -20 },
  { 1519, 13, 20, 14, 1, -20 },
  { 1552, 13, 20, 14, 3, -20 },
  { 1585, 17, 20, 19, 2, -20 },
  { 1628, 14, 20, 15, 3, -20 },
  { 1663, 22, 20, 23, 3, -20 },
  { 1718, 18, 20, 14, -2, -20 },
  { 1763, 13, 20, 14, 3, -20 },
  { 1796, 16, 20, 15, 0, -20 },
  { 1836, 10, 24, 8, 0, -20 },
  { 1866, 4, 20, 9, 3, -20 },
  { 1876, 11, 24, 8, -2, -20 },
  { 1909, 13, 12, 15, 1, -20 },
  { 1929, 10, 1, 10, -2, 3 },
  { 1931, 3, 4, 6, 4, -21 },
  { 1933, 13, 15, 15, 1, -15 },
  { 1958, 13, 21, 16, 1, -21 },
  { 1993, 11, 15, 13, 2, -15 },
  { 2014, 15, 21, 16, 1, -21 },
  { 2054, 11, 15, 14, 2, -15 },
  { 2075, 16, 28, 7, -4, -21 },
  { 2131, 14, 22, 16, 1, -15 },
  { 2170, 13, 21, 15, 1, -21 },
  { 2205, 5, 20, 6, 1, -20 },
  { 2218, 10, 27, 6, -4, -20 },
  { 2252, 12, 21, 12, 1, -21 },
  { 2284, 5, 21, 6, 1, -21 },
  { 2298, 21, 15, 24, 1, -15 },
  { 2338, 13, 15, 15, 1, -15 },
  { 2363, 12, 15, 16, 2, -15 },
  { 2386, 14, 22, 16, 0, -15 },
  { 2425, 14, 22, 16, 1, -15 },
  { 2464, 10, 15, 10, 1, -15 },
  { 2483, 11, 15, 12, 0, -15 },
  { 2504, 8, 18, 9, 1, -18 },
  { 2522, 12, 15, 15, 2, -15 },
  { 2545, 12, 15, 11, 1, -15 },
  { 2568, 17, 15, 18, 2, -15 },
  { 2600, 14, 15, 13, -1, -15 },
  { 2627, 16, 22, 11, -3, -15 },
  { 2671, 12, 15, 12, 0, -15 },
  { 2694, 10, 24, 9, 1, -20 },
  { 2724, 1, 28, 15, 8, -21 },
  { 2728, 10, 24, 9, -1, -20 },
  { 2758, 13, 2, 16, 2, -11 },
};

const GFXfont NotoSans_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_THINITALIC28PT7B_H_
