#ifndef _NOTOSANS_THINITALIC50PT7B_H_
#define _NOTOSANS_THINITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x18, 0x00, 0x10, 0x22, 0x04, 0x40, 0x98, 0x33,
  0x04, 0x40, 0x88, 0x11, 0x02, 0x60, 0x88, 0x11, 0x02, 0x20, 0x4C, 0x18,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x08, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20,
  0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x18, 0x02, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x10, 0x06, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x02, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x70, 0x83, 0x81, 0x81, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x01, 0x80, 0x02, 0x02, 0x00, 0x06, 0x04, 0x00, 0x06, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x07, 0x60, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x02, 0x70, 0x00, 0x04, 0x30, 0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x60, 0x00, 0xC1, 0x81, 0x81, 0x0E,
  0x01, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x0C, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x30, 0x00, 0x40, 0xC0, 0x20, 0x01,
  0x01, 0x00, 0x40, 0x06, 0x06, 0x00, 0x80, 0x18, 0x08, 0x01, 0x00, 0x20,
  0x10, 0x02, 0x00, 0xC0, 0x60, 0x04, 0x03, 0x00, 0x80, 0x08, 0x04, 0x01,
  0x00, 0x10, 0x10, 0x02, 0x00, 0x20, 0x60, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x01, 0x02, 0x00, 0x30, 0x02, 0x08, 0x3C, 0x60, 0x0C, 0x30, 0xEE, 0xC0,
  0x10, 0xC6, 0x07, 0x80, 0x61, 0x08, 0x05, 0x00, 0x84, 0x30, 0x0B, 0x03,
  0x18, 0x40, 0x13, 0x1C, 0x61, 0x80, 0x23, 0xE0, 0x82, 0x00, 0x40, 0x02,
  0x0C, 0x00, 0x80, 0x0C, 0x18, 0x01, 0x00, 0x30, 0x20, 0x02, 0x00, 0x40,
  0x40, 0x04, 0x01, 0x80, 0x80, 0x18, 0x06, 0x03, 0x00, 0x20, 0x08, 0x06,
  0x00, 0x40, 0x20, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x02, 0x03, 0x00, 0x30,
  0x04, 0x04, 0x00, 0x60, 0x10, 0x10, 0x00, 0x40, 0x60, 0x60, 0x00, 0xC1,
  0x81, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC0, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x23, 0x00, 0x0C, 0x01, 0x88,
  0x00, 0x10, 0x04, 0x60, 0x00, 0x20, 0x21, 0x00, 0x00, 0xC1, 0x8C, 0x00,
  0x01, 0x0C, 0x30, 0x00, 0x02, 0x20, 0xC0, 0x00, 0x0D, 0x03, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x40, 0x60, 0x00, 0x31,
  0x80, 0xC0, 0x03, 0x82, 0x01, 0xC0, 0x38, 0x04, 0x03, 0xFF, 0x80, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x11, 0x13, 0x32, 0x22, 0x64, 0x44, 0xC0, 0x00,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x20, 0x08,
  0x03, 0xC0, 0xC0, 0x03, 0x04, 0x00, 0x06, 0x20, 0x00, 0x09, 0x01, 0xC0,
  0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x0A, 0x00, 0x01, 0x88, 0x00, 0x18, 0x40,
  0x01, 0x83, 0x00, 0x18, 0x08, 0x03, 0x80, 0x60, 0x08, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x10, 0xC2, 0x18, 0x41, 0x0C, 0x21, 0x84, 0x20, 0xFF, 0xF0, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x60, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00, 0xC1, 0x00, 0x00, 0x86,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80,
  0x00, 0x13, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x04,
  0xC0, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x01, 0x8C,
  0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x30, 0x00, 0x60, 0x20,
  0x01, 0x80, 0x60, 0x06, 0x00, 0x70, 0x38, 0x00, 0x3F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x07, 0x00, 0xD0, 0x33, 0x06, 0x21, 0x82, 0x30,
  0x2C, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x20, 0x20, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x30, 0x3C,
  0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x90, 0x00, 0x01, 0x88, 0x00, 0x01, 0x84, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x10, 0x00,
  0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x02, 0x00,
  0xC0, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x40,
  0x40, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x0E, 0x01, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x21, 0xE3, 0xC0, 0x23, 0x00,
  0x60, 0x2C, 0x00, 0x30, 0x78, 0x00, 0x18, 0x50, 0x00, 0x08, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60, 0x20, 0x00,
  0xC0, 0x10, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x18,
  0x01, 0x80, 0x10, 0x00, 0x40, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C,
  0x00, 0x04, 0x04, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0x20, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x08, 0x00, 0x0E, 0x0C, 0x00, 0x1A, 0x06, 0x00, 0x76,
  0x03, 0x81, 0xC4, 0x00, 0xFF, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x38, 0x00, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x0C, 0x18, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0x83, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x1E, 0x06, 0x08, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x1F, 0xFC,
  0x02, 0x20, 0x03, 0x80, 0xC0, 0x13, 0x00, 0x30, 0x02, 0x00, 0x90, 0x03,
  0x00, 0x10, 0x05, 0x80, 0x30, 0x01, 0x80, 0x28, 0x03, 0x00, 0x08, 0x01,
  0x40, 0x10, 0x00, 0x40, 0x0E, 0x01, 0x80, 0x06, 0x00, 0x70, 0x08, 0x00,
  0x20, 0x03, 0x00, 0x40, 0x01, 0x00, 0x38, 0x06, 0x00, 0x08, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x0A, 0x01, 0x80, 0x04, 0x00, 0xD0, 0x0C, 0x00, 0x60,
  0x04, 0x80, 0x60, 0x03, 0x00, 0x64, 0x03, 0x00, 0x28, 0x06, 0x20, 0x08,
  0x03, 0x60, 0x21, 0x80, 0x60, 0x31, 0x06, 0x0C, 0x01, 0xFE, 0x0F, 0xE0,
  0x20, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x10, 0x10, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x20, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x08, 0x00,
  0x08, 0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x40,
  0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x10, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x70, 0x04, 0x01, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xE0, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x08, 0x00, 0x0E, 0x01, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x38,
  0x01, 0x00, 0x03, 0x80, 0x04, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x04, 0x03, 0xFF, 0xFE, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x70,
  0x0F, 0x80, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xF9, 0x80, 0x03, 0xFF, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x01, 0xC0, 0x07,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0x00, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x03,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x78, 0x00, 0x00, 0x66, 0x40,
  0x00, 0x03, 0x43, 0x00, 0x00, 0x14, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x06, 0x00, 0x10, 0x00, 0x10, 0x00, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x0E, 0x01, 0x60, 0x00, 0x00, 0x68, 0x04, 0x80, 0x00,
  0x01, 0x20, 0x12, 0x00, 0x00, 0x0D, 0x80, 0x48, 0x00, 0x00, 0x26, 0x03,
  0x20, 0x00, 0x01, 0x90, 0x08, 0xC0, 0x00, 0x0C, 0x40, 0x23, 0x00, 0x00,
  0x21, 0x00, 0x84, 0x00, 0x01, 0x8C, 0x06, 0x10, 0x00, 0x04, 0x20, 0x18,
  0x40, 0x00, 0x30, 0x80, 0x41, 0x00, 0x01, 0x82, 0x01, 0x06, 0x00, 0x04,
  0x08, 0x04, 0x08, 0x00, 0x30, 0x60, 0x30, 0x20, 0x00, 0x81, 0x00, 0xC0,
  0x80, 0x06, 0x04, 0x02, 0x02, 0x00, 0x30, 0x10, 0x08, 0x0C, 0x00, 0x80,
  0xC0, 0x20, 0x30, 0x06, 0x03, 0x01, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x06, 0x00, 0x80, 0x40, 0x10, 0x10, 0x06,
  0x03, 0x00, 0x60, 0xC0, 0x18, 0x0C, 0x01, 0x82, 0x00, 0x40, 0x20, 0x02,
  0x18, 0x01, 0x00, 0x80, 0x08, 0xC0, 0x04, 0x02, 0x00, 0x22, 0x00, 0x30,
  0x18, 0x00, 0x98, 0x00, 0x80, 0x60, 0x03, 0x40, 0x02, 0x01, 0x00, 0x07,
  0x00, 0x08, 0x04, 0x00, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x08,
  0x0E, 0x00, 0x00, 0x30, 0x16, 0x00, 0x00, 0x60, 0x24, 0x00, 0x00, 0x80,
  0x4C, 0x00, 0x01, 0x00, 0x88, 0x00, 0x02, 0x03, 0x18, 0x00, 0x0C, 0x04,
  0x10, 0x00, 0x18, 0x08, 0x20, 0x00, 0x20, 0x10, 0x60, 0x00, 0x40, 0x60,
  0x40, 0x00, 0x80, 0xC0, 0xC0, 0x03, 0x01, 0x00, 0x80, 0x04, 0x02, 0x01,
  0x80, 0x08, 0x04, 0x01, 0x00, 0x10, 0x18, 0x02, 0x00, 0x60, 0x30, 0x06,
  0x00, 0xC0, 0x40, 0x04, 0x01, 0x00, 0x80, 0x0C, 0x02, 0x01, 0x00, 0x08,
  0x04, 0x06, 0x00, 0x18, 0x18, 0x0C, 0x00, 0x10, 0x30, 0x10, 0x00, 0x20,
  0x40, 0x20, 0x00, 0x60, 0x80, 0xC0, 0x00, 0x41, 0x01, 0x80, 0x00, 0xC6,
  0x02, 0x00, 0x00, 0x8C, 0x04, 0x00, 0x01, 0x90, 0x08, 0x00, 0x01, 0x20,
  0x30, 0x00, 0x02, 0x40, 0x60, 0x00, 0x07, 0x80, 0x80, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x20, 0x10,
  0x00, 0x0C, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x20, 0x40, 0x00, 0x18, 0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x08, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x0C,
  0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00,
  0x10, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x20, 0x08,
  0x00, 0x08, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x10,
  0x10, 0x00, 0x06, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0xC0, 0x01, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x80, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x04, 0x02, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x60, 0x08, 0x00, 0x10, 0x02, 0x00,
  0x0C, 0x00, 0x80, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x01,
  0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x18, 0x10, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x88, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x0B, 0x00, 0x00, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0x80, 0x00, 0x4C, 0x00, 0x05, 0x00, 0x01, 0x98, 0x00,
  0x1A, 0x00, 0x02, 0x10, 0x00, 0x26, 0x00, 0x0C, 0x20, 0x00, 0xCC, 0x00,
  0x10, 0x40, 0x01, 0x18, 0x00, 0x60, 0x80, 0x06, 0x30, 0x00, 0x81, 0x00,
  0x08, 0x20, 0x01, 0x02, 0x00, 0x30, 0x40, 0x04, 0x04, 0x00, 0x40, 0x80,
  0x08, 0x08, 0x01, 0x81, 0x00, 0x30, 0x10, 0x02, 0x02, 0x00, 0x40, 0x20,
  0x04, 0x04, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x0C, 0x01, 0x00, 0x80, 0x20, 0x10, 0x02, 0x01, 0x00, 0x40, 0x60, 0x04,
  0x06, 0x00, 0x80, 0x80, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x18, 0x30, 0x03,
  0x04, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00,
  0xC2, 0x00, 0x18, 0x40, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00,
  0x22, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x0B, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00,
  0x05, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x20, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x40, 0x00, 0x08, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0x40,
  0x00, 0x0C, 0x40, 0x00, 0x18, 0x60, 0x00, 0x10, 0x20, 0x00, 0x20, 0x20,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x10, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x08, 0x02, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x04, 0x03, 0xFE, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x02,
  0x02, 0x02, 0x02, 0x03, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x40, 0x06, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x20, 0x01, 0x00, 0x80, 0x02, 0x03, 0x00, 0x04, 0x0C,
  0x00, 0x0C, 0x10, 0x00, 0x08, 0x60, 0x00, 0x11, 0x80, 0x00, 0x32, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC1, 0x82,
  0x0C, 0x10, 0x20, 0xC1, 0x00, 0x3F, 0x02, 0x01, 0xC7, 0x08, 0x0C, 0x01,
  0x10, 0x30, 0x01, 0x20, 0xC0, 0x02, 0x43, 0x00, 0x03, 0x84, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00,
  0x07, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x28, 0x30, 0x00, 0x90, 0x20, 0x03,
  0x20, 0x60, 0x0C, 0xC0, 0x60, 0x61, 0x00, 0x7F, 0x82, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x07,
  0xC0, 0x04, 0x1C, 0x70, 0x04, 0x60, 0x18, 0x04, 0xC0, 0x0C, 0x0D, 0x80,
  0x06, 0x0B, 0x00, 0x02, 0x0A, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00,
  0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x10, 0x50, 0x00, 0x30, 0xD0, 0x00, 0x60, 0x88, 0x00,
  0xC0, 0x8E, 0x03, 0x80, 0x83, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0x1F, 0x03, 0x80, 0x10, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0xFC, 0x0C, 0x00,
  0xF3, 0xC2, 0x00, 0xC0, 0x18, 0x80, 0x60, 0x03, 0x20, 0x30, 0x00, 0x58,
  0x18, 0x00, 0x0E, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x07,
  0x02, 0x00, 0x03, 0x80, 0x80, 0x00, 0xA0, 0x30, 0x00, 0x48, 0x04, 0x00,
  0x22, 0x01, 0x80, 0x31, 0x00, 0x30, 0x18, 0x40, 0x07, 0xF8, 0x10, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x3C, 0x01, 0x80, 0x60, 0x60,
  0x02, 0x04, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x33, 0x00, 0x03, 0x20,
  0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0xC4, 0x00, 0x38, 0x40, 0x3E, 0x0F,
  0xFF, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x40,
  0x0F, 0x3C, 0x20, 0x0C, 0x01, 0x88, 0x06, 0x00, 0x32, 0x03, 0x00, 0x04,
  0x81, 0x80, 0x00, 0xE0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x08, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x30,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x70, 0x20, 0x00, 0x18, 0x08, 0x00, 0x0A, 0x03, 0x00, 0x04, 0x80, 0x40,
  0x02, 0x60, 0x18, 0x03, 0x18, 0x03, 0x01, 0x84, 0x00, 0x7F, 0x81, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x3F, 0x00, 0x41, 0xE7, 0x80, 0x8C, 0x01, 0x81, 0x30, 0x01, 0x06, 0xC0,
  0x02, 0x0B, 0x00, 0x06, 0x14, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x31, 0x80, 0x00, 0x43, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42,
  0x00, 0x01, 0x8C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x10, 0x00, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x08, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0x04, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x40, 0x06, 0x03, 0x00, 0x30, 0x08, 0x01, 0x80, 0x20, 0x0C, 0x00,
  0x80, 0x40, 0x02, 0x02, 0x00, 0x18, 0x10, 0x00, 0x40, 0x80, 0x01, 0x04,
  0x00, 0x04, 0x30, 0x00, 0x33, 0x40, 0x00, 0x99, 0x80, 0x02, 0xC2, 0x00,
  0x0E, 0x0C, 0x00, 0x30, 0x10, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x40, 0x04, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0x80, 0x01, 0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x04, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x21, 0xCF, 0x01, 0xC7, 0x01,
  0x18, 0x0C, 0x18, 0x0C, 0x09, 0x00, 0x21, 0x00, 0x30, 0x90, 0x01, 0x90,
  0x01, 0x85, 0x00, 0x05, 0x80, 0x04, 0x28, 0x00, 0x38, 0x00, 0x21, 0x80,
  0x01, 0x80, 0x01, 0x08, 0x00, 0x1C, 0x00, 0x08, 0xC0, 0x00, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x00, 0x06, 0x20, 0x00, 0x20, 0x00, 0x21, 0x00, 0x01,
  0x00, 0x01, 0x18, 0x00, 0x08, 0x00, 0x08, 0xC0, 0x00, 0xC0, 0x00, 0xC4,
  0x00, 0x04, 0x00, 0x06, 0x20, 0x00, 0x20, 0x00, 0x21, 0x00, 0x01, 0x00,
  0x01, 0x18, 0x00, 0x18, 0x00, 0x08, 0x80, 0x00, 0xC0, 0x00, 0xC4, 0x00,
  0x04, 0x00, 0x04, 0x20, 0x00, 0x20, 0x00, 0x21, 0x00, 0x01, 0x00, 0x01,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x80, 0x00, 0x80, 0x00, 0xC4, 0x00, 0x04,
  0x00, 0x04, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x07, 0xE0, 0x08, 0x3C,
  0xF0, 0x11, 0x80, 0x30, 0x26, 0x00, 0x20, 0xD8, 0x00, 0x41, 0x60, 0x00,
  0xC2, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x31, 0x80,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x0C, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xE3, 0xC0, 0x0E, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x60, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x18, 0x00, 0x04, 0x10, 0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x10, 0x71, 0xC0, 0x02, 0x30, 0x0C, 0x00, 0x4C, 0x00, 0xC0,
  0x1B, 0x00, 0x0C, 0x02, 0xC0, 0x00, 0x80, 0x50, 0x00, 0x10, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x04,
  0x02, 0x80, 0x01, 0x80, 0xD0, 0x00, 0x60, 0x11, 0x00, 0x18, 0x02, 0x38,
  0x0E, 0x00, 0x41, 0xFF, 0x00, 0x18, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0x00, 0xF3, 0xC2, 0x03, 0x00, 0x62, 0x06, 0x00, 0x32, 0x0C, 0x00,
  0x12, 0x18, 0x00, 0x0E, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x70, 0x80, 0x00,
  0xE0, 0x80, 0x00, 0xA0, 0xC0, 0x01, 0x20, 0x40, 0x02, 0x60, 0x60, 0x0C,
  0x60, 0x30, 0x18, 0x40, 0x1F, 0xE0, 0x40, 0x03, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x81, 0x0F, 0x70,
  0x46, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x78,
  0xFC, 0x18, 0x00, 0x84, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x80, 0x06, 0x1C, 0x01, 0x80, 0xFF, 0xC0,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x7F, 0xFE, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x84, 0x00, 0x07,
  0x08, 0x00, 0x1C, 0x10, 0x00, 0x68, 0x30, 0x01, 0x90, 0x60, 0x06, 0x20,
  0x60, 0x38, 0xC0, 0x7F, 0xC1, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1A,
  0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00,
  0x60, 0x80, 0x02, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x10, 0x08,
  0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x40,
  0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x11,
  0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x40, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0A, 0x00, 0x1C, 0x00, 0x34, 0x00, 0x28, 0x00, 0x48, 0x00, 0xD0,
  0x01, 0x90, 0x01, 0x20, 0x02, 0x20, 0x06, 0x60, 0x0C, 0x40, 0x08, 0xC0,
  0x10, 0xC0, 0x30, 0x80, 0x61, 0x80, 0x41, 0x00, 0x83, 0x01, 0x82, 0x03,
  0x06, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x10, 0x40, 0x20, 0x40, 0x20, 0x80, 0x61, 0x00, 0x42, 0x00, 0xC2, 0x00,
  0x84, 0x01, 0x8C, 0x01, 0x10, 0x01, 0x10, 0x02, 0x20, 0x02, 0x60, 0x04,
  0x80, 0x04, 0x80, 0x0B, 0x00, 0x0B, 0x00, 0x14, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x04, 0x01, 0x80, 0x03, 0x00, 0x80, 0x00, 0x80, 0x80, 0x00, 0x40, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x10, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x60, 0x01, 0x80, 0x20,
  0x00, 0x40, 0x20, 0x00, 0x30, 0x60, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x08, 0x00, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xE3, 0xC0,
  0x07, 0x00, 0xE0, 0x34, 0x00, 0x7F, 0xC0, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 36, 11, 2, -36 },
  { 42, 11, 13, 16, 5, -36 },
  { 60, 29, 36, 31, 2, -36 },
  { 191, 23, 41, 28, 3, -38 },
  { 309, 31, 37, 38, 4, -36 },
  { 453, 30, 37, 34, 2, -36 },
  { 592, 4, 13, 9, 5, -36 },
  { 599, 14, 44, 12, 2, -36 },
  { 676, 14, 44, 12, -3, -36 },
  { 753, 21, 21, 27, 6, -38 },
  { 809, 23, 23, 29, 4, -29 },
  { 876, 6, 12, 9, -2, -6 },
  { 885, 12, 1, 16, 2, -14 },
  { 887, 2, 3, 11, 2, -3 },
  { 888, 22, 36, 15, -2, -36 },
  { 987, 23, 37, 28, 3, -36 },
  { 1094, 12, 36, 28, 8, -36 },
  { 1148, 25, 36, 28, 0, -36 },
  { 1261, 25, 37, 28, 1, -36 },
  { 1377, 25, 36, 28, 1, -36 },
  { 1490, 25, 37, 28, 2, -36 },
  { 1606, 24, 37, 28, 3, -36 },
  { 1717, 22, 36, 28, 6, -36 },
  { 1816, 25, 37, 28, 2, -36 },
  { 1932, 24, 37, 28, 2, -36 },
  { 2043, 7, 27, 11, 2, -27 },
  { 2067, 11, 33, 11, -2, -27 },
  { 2113, 23, 22, 29, 4, -29 },
  { 2177, 23, 11, 29, 4, -23 },
  { 2209, 23, 22, 29, 4, -29 },
  { 2273, 17, 36, 20, 4, -36 },
  { 2350, 37, 40, 42, 3, -35 },
  { 2535, 28, 36, 27, -3, -36 },
  { 2661, 27, 36, 30, 2, -36 },
  { 2783, 28, 37, 30, 4, -36 },
  { 2913, 30, 36, 34, 2, -36 },
  { 3048, 26, 36, 27, 2, -36 },
  { 3165, 26, 36, 24, 2, -36 },
  { 3282, 29, 37, 35, 4, -36 },
  { 3417, 32, 36, 34, 2, -36 },
  { 3561, 16, 36, 14, 0, -36 },
  { 3633, 21, 45, 12, -9, -36 },
  { 3752, 29, 36, 27, 2, -36 },
  { 3883, 19, 36, 25, 2, -36 },
  { 3969, 38, 36, 40, 2, -36 },
  { 4140, 31, 36, 34, 2, -36 },
  { 4280, 30, 37, 36, 4, -36 },
  { 4419, 26, 36, 28, 2, -36 },
  { 4536, 30, 45, 36, 4, -36 },
  { 4705, 26, 36, 28, 2, -36 },
  { 4822, 24, 37, 25, 1, -36 },
  { 4933, 24, 36, 24, 5, -36 },
  { 5041, 31, 37, 35, 4, -36 },
  { 5185, 26, 36, 27, 5, -36 },
  { 5302, 39, 36, 41, 6, -36 },
  { 5478, 31, 36, 24, -3, -36 },
  { 5618, 24, 36, 24, 5, -36 },
  { 5726, 29, 36, 27, 0, -36 },
  { 5857, 18, 44, 15, 0, -36 },
  { 5956, 8, 36, 15, 5, -36 },
  { 5992, 19, 44, 15, -4, -36 },
  { 6097, 23, 22, 28, 2, -36 },
  { 6161, 19, 2, 19, -4, 5 },
  { 6166, 6, 8, 11, 7, -38 },
  { 6172, 23, 28, 27, 3, -27 },
  { 6253, 24, 39, 28, 2, -38 },
  { 6370, 20, 28, 23, 3, -27 },
  { 6440, 26, 39, 28, 3, -38 },
  { 6567, 20, 28, 25, 3, -27 },
  { 6637, 28, 50, 13, -7, -38 },
  { 6812, 26, 39, 28, 1, -27 },
  { 6939, 23, 38, 28, 2, -38 },
  { 7049, 9, 36, 10, 2, -36 },
  { 7090, 18, 48, 10, -7, -36 },
  { 7198, 22, 38, 22, 2, -38 },
  { 7303, 9, 38, 10, 2, -38 },
  { 7346, 37, 27, 42, 2, -27 },
  { 7471, 23, 27, 28, 2, -27 },
  { 7549, 23, 28, 28, 3, -27 },
  { 7630, 27, 39, 28, -1, -27 },
  { 7762, 24, 39, 28, 3, -27 },
  { 7879, 18, 27, 19, 2, -27 },
  { 7940, 19, 28, 21, 1, -27 },
  { 8007, 14, 34, 15, 3, -33 },
  { 8067, 23, 27, 28, 3, -26 },
  { 8145, 21, 26, 21, 2, -26 },
  { 8214, 31, 26, 33, 3, -26 },
  { 8315, 25, 26, 23, -2, -26 },
  { 8397, 29, 38, 21, -6, -26 },
  { 8535, 23, 26, 22, -1, -26 },
  { 8610, 18, 44, 16, 1, -36 },
  { 8709, 1, 50, 27, 14, -38 },
  { 8716, 18, 44, 16, -3, -36 },
  { 8815, 23, 5, 29, 4, -20 },
};

const GFXfont NotoSans_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_THINITALIC50PT7B_H_
