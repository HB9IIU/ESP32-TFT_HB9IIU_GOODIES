#ifndef _NOTOSANS_THINITALIC58PT7B_H_
#define _NOTOSANS_THINITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x18,
  0xC0, 0xC4, 0x04, 0x20, 0x23, 0x03, 0x18, 0x18, 0x80, 0x84, 0x04, 0x20,
  0x23, 0x03, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x23, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x10, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0x93, 0xF0, 0x03, 0x82, 0x07, 0x01, 0xC0, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60,
  0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00,
  0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC1,
  0x00, 0x00, 0x1C, 0x20, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x87, 0x00, 0x00, 0x10,
  0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x04, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x18, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x30, 0x08, 0x38, 0x07, 0xF1, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0C, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x30, 0x00, 0x30, 0x08, 0x03, 0x00, 0x02, 0x01, 0x80, 0x10, 0x00, 0x60,
  0x30, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x01, 0x80, 0x20, 0x01, 0x00,
  0x10, 0x06, 0x00, 0x10, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60, 0x04, 0x00,
  0x10, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0xC1, 0xF8, 0xC0, 0x04, 0x18, 0x70, 0xEC, 0x00,
  0xC1, 0x0E, 0x06, 0xC0, 0x08, 0x30, 0xC0, 0x3C, 0x01, 0x86, 0x18, 0x03,
  0x40, 0x30, 0xC3, 0x00, 0x36, 0x06, 0x08, 0x30, 0x03, 0x3F, 0xC1, 0x82,
  0x00, 0x31, 0xF0, 0x30, 0x60, 0x03, 0x00, 0x06, 0x06, 0x00, 0x30, 0x00,
  0x40, 0x40, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x80, 0x02, 0x00, 0x60, 0x08,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x06, 0x01, 0x80, 0x08, 0x00, 0x40, 0x18,
  0x00, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x00, 0x80, 0x60, 0x00, 0x80, 0x18,
  0x04, 0x00, 0x0C, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x06,
  0x0E, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x18, 0x00, 0x04, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x02, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x38, 0x40, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x40, 0x00, 0x86, 0x00, 0x18,
  0x00, 0x63, 0x00, 0x03, 0x00, 0x11, 0x80, 0x00, 0x60, 0x0C, 0x40, 0x00,
  0x08, 0x02, 0x30, 0x00, 0x03, 0x01, 0x8C, 0x00, 0x00, 0x60, 0xC2, 0x00,
  0x00, 0x08, 0x60, 0x80, 0x00, 0x03, 0x30, 0x20, 0x00, 0x00, 0x68, 0x08,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x60,
  0x10, 0x00, 0x01, 0x8C, 0x06, 0x00, 0x01, 0xC1, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x1C, 0x01, 0xE0, 0x0C, 0x01, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x10, 0x84, 0x23, 0x00,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x08, 0x00, 0x1C, 0x08, 0x00, 0x06, 0x08, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x70, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x04, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x02, 0x00,
  0x18, 0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x0D, 0x80, 0xE6, 0x06, 0x18, 0x70, 0x43, 0x01, 0x38, 0x0C, 0x80,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03,
  0x80, 0x7C, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x07,
  0xFE, 0x00, 0x21, 0xE0, 0x38, 0x02, 0x30, 0x00, 0xC0, 0x66, 0x00, 0x06,
  0x06, 0x80, 0x00, 0x20, 0x50, 0x00, 0x03, 0x07, 0x00, 0x00, 0x10, 0xE0,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x8C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xF0, 0x80,
  0x00, 0x34, 0x18, 0x00, 0x0C, 0x81, 0x80, 0x03, 0x30, 0x18, 0x01, 0xC6,
  0x01, 0xE3, 0xE0, 0x80, 0x0F, 0xF0, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x80, 0x1C, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x07, 0x03, 0x80, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFB, 0xE0, 0xE0, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x21, 0x80, 0x01, 0xC0, 0x70, 0x03,
  0x18, 0x00, 0x70, 0x01, 0x00, 0x31, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x30,
  0x01, 0x80, 0x03, 0x00, 0x32, 0x00, 0x30, 0x00, 0x20, 0x03, 0x60, 0x02,
  0x00, 0x06, 0x00, 0x36, 0x00, 0x60, 0x00, 0x60, 0x03, 0x60, 0x04, 0x00,
  0x04, 0x00, 0x34, 0x00, 0xC0, 0x00, 0x40, 0x02, 0x40, 0x0C, 0x00, 0x0C,
  0x00, 0x2C, 0x00, 0x80, 0x00, 0xC0, 0x06, 0xC0, 0x18, 0x00, 0x08, 0x00,
  0x6C, 0x01, 0x80, 0x01, 0x80, 0x04, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xCC,
  0x01, 0x80, 0x03, 0x80, 0x0C, 0xC0, 0x18, 0x00, 0x38, 0x01, 0x8C, 0x01,
  0x80, 0x07, 0x80, 0x10, 0xC0, 0x08, 0x00, 0xD8, 0x03, 0x04, 0x00, 0xC0,
  0x19, 0x80, 0x60, 0x40, 0x06, 0x03, 0x0C, 0x1C, 0x06, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x60, 0x00, 0xF0, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0F, 0x00, 0x60, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x01, 0xF0, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x40, 0x00, 0x07, 0x00, 0x10, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x0F, 0x80,
  0x03, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x02, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE2, 0x00, 0x01,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0xE7, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x01, 0x98,
  0xC0, 0x00, 0x00, 0xD8, 0x60, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x18, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x02, 0x80, 0x00, 0x00, 0x07, 0x80, 0x58,
  0x00, 0x00, 0x00, 0xB0, 0x0B, 0x00, 0x00, 0x00, 0x34, 0x03, 0x60, 0x00,
  0x00, 0x0C, 0x80, 0x64, 0x00, 0x00, 0x01, 0xB0, 0x0C, 0x80, 0x00, 0x00,
  0x66, 0x01, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x23, 0x00, 0x00, 0x03, 0x10,
  0x0C, 0x60, 0x00, 0x00, 0xC2, 0x01, 0x84, 0x00, 0x00, 0x18, 0xC0, 0x20,
  0x80, 0x00, 0x06, 0x18, 0x04, 0x10, 0x00, 0x00, 0x83, 0x01, 0x82, 0x00,
  0x00, 0x30, 0x40, 0x30, 0x60, 0x00, 0x0C, 0x08, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x80, 0x80, 0x00, 0x60, 0x60, 0x10, 0x10, 0x00, 0x08, 0x08,
  0x06, 0x02, 0x00, 0x03, 0x01, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x20, 0x18,
  0x0C, 0x00, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x00, 0x80, 0x20, 0x18, 0x02, 0x00, 0x30, 0x04, 0x03, 0x00, 0x40, 0x04,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x08, 0x01, 0x80, 0x60, 0x06,
  0x01, 0x00, 0x10, 0x08, 0x00, 0x80, 0x60, 0x02, 0x03, 0x00, 0x10, 0x0C,
  0x00, 0x40, 0x40, 0x06, 0x01, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x20, 0x01,
  0x86, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x01, 0x80, 0x02, 0x30,
  0x00, 0x40, 0x30, 0x00, 0x44, 0x00, 0x18, 0x04, 0x00, 0x09, 0x80, 0x03,
  0x00, 0x80, 0x01, 0xE0, 0x00, 0x40, 0x30, 0x00, 0x38, 0x00, 0x08, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x0A, 0x00, 0x00, 0x06, 0x00, 0xB0, 0x00, 0x00, 0x60, 0x19, 0x00,
  0x00, 0x06, 0x01, 0x98, 0x00, 0x00, 0x40, 0x18, 0x80, 0x00, 0x04, 0x01,
  0x0C, 0x00, 0x00, 0xC0, 0x10, 0xC0, 0x00, 0x0C, 0x03, 0x04, 0x00, 0x00,
  0xC0, 0x30, 0x60, 0x00, 0x08, 0x02, 0x02, 0x00, 0x00, 0x80, 0x20, 0x30,
  0x00, 0x18, 0x06, 0x01, 0x00, 0x01, 0x80, 0x60, 0x18, 0x00, 0x10, 0x06,
  0x01, 0x80, 0x01, 0x00, 0x40, 0x08, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x02,
  0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x80, 0x03, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x18, 0x00, 0x08, 0x04,
  0x01, 0x00, 0x00, 0xC0, 0xC0, 0x10, 0x00, 0x04, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x80, 0x30, 0x00, 0x06, 0x08, 0x02, 0x00, 0x00, 0x20, 0x80, 0x20,
  0x00, 0x03, 0x18, 0x06, 0x00, 0x00, 0x11, 0x80, 0x60, 0x00, 0x01, 0x90,
  0x06, 0x00, 0x00, 0x09, 0x00, 0x40, 0x00, 0x00, 0xD0, 0x04, 0x00, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x06,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0x38, 0x01, 0x00, 0x00, 0xE0, 0x08, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x06,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x3E,
  0x00, 0x30, 0x00, 0x38, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x60, 0x01, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x0E, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x40, 0x00, 0x40, 0x06,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x80, 0x00, 0x09,
  0x80, 0x00, 0x16, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x04, 0x20,
  0x00, 0x0D, 0x80, 0x00, 0x61, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x60, 0x00, 0x30, 0x40, 0x00, 0x23, 0x00, 0x01, 0x82, 0x00, 0x03,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x82,
  0x00, 0x04, 0x04, 0x00, 0x08, 0x10, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x80,
  0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60, 0x20, 0x01,
  0x00, 0x40, 0x02, 0x01, 0x00, 0x18, 0x03, 0x00, 0x30, 0x08, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x80, 0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x40, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20,
  0x01, 0x80, 0x80, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00,
  0x20, 0x40, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x08,
  0x20, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x02, 0x18,
  0x00, 0x04, 0x60, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00,
  0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x26, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x80, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3,
  0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0x0F,
  0x08, 0x03, 0x00, 0x31, 0x01, 0xC0, 0x02, 0x20, 0x70, 0x00, 0x6C, 0x0C,
  0x00, 0x05, 0x83, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x2C, 0x08, 0x00, 0x0D, 0x01, 0x80, 0x03,
  0x20, 0x30, 0x00, 0xC4, 0x03, 0x00, 0x31, 0x80, 0x38, 0x18, 0x20, 0x03,
  0xFE, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x03, 0x07, 0x0F, 0x00, 0x21,
  0xC0, 0x18, 0x02, 0x30, 0x00, 0xC0, 0x66, 0x00, 0x04, 0x06, 0xC0, 0x00,
  0x60, 0x58, 0x00, 0x02, 0x05, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0x58, 0x00, 0x06, 0x04, 0x80,
  0x00, 0x60, 0x4C, 0x00, 0x1C, 0x0C, 0x60, 0x03, 0x80, 0xC3, 0x80, 0xE0,
  0x08, 0x1F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0xE0, 0x02, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x0F,
  0x00, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xFE, 0x06, 0x00, 0x1E, 0x0E, 0x0C, 0x00, 0x60, 0x07, 0x10, 0x03, 0x80,
  0x02, 0x20, 0x06, 0x00, 0x06, 0xC0, 0x18, 0x00, 0x05, 0x80, 0x60, 0x00,
  0x0F, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xA0, 0x18, 0x00, 0x02, 0xC0, 0x10,
  0x00, 0x0D, 0x00, 0x30, 0x00, 0x32, 0x00, 0x60, 0x00, 0xC4, 0x00, 0x60,
  0x07, 0x08, 0x00, 0x70, 0x38, 0x30, 0x00, 0x7F, 0xC0, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xE0, 0x07, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x02, 0x30, 0x00, 0x04, 0x40, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00,
  0x01, 0xC4, 0x00, 0x07, 0x18, 0x00, 0x78, 0x30, 0x1F, 0xC0, 0x7F, 0xF8,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x02, 0x01, 0xC0, 0x38, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x81, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x18, 0x01, 0xE0, 0xE0, 0xC0, 0x18,
  0x01, 0xC4, 0x03, 0x80, 0x02, 0x20, 0x18, 0x00, 0x19, 0x01, 0x80, 0x00,
  0x58, 0x18, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0xA0, 0x60, 0x00, 0x0B, 0x01, 0x00, 0x00,
  0xD0, 0x0C, 0x00, 0x0C, 0x80, 0x60, 0x00, 0xC4, 0x01, 0x80, 0x1C, 0x60,
  0x07, 0x03, 0x83, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x03, 0xFC, 0x00, 0xC1,
  0xE3, 0xC0, 0x10, 0xE0, 0x0C, 0x02, 0x30, 0x00, 0xC0, 0xCC, 0x00, 0x08,
  0x1B, 0x00, 0x01, 0x02, 0xC0, 0x00, 0x30, 0x50, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x10, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x10, 0x08, 0x00, 0x18, 0x02, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00,
  0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x18, 0x90, 0x00, 0x04, 0x46, 0x00, 0x01, 0x20, 0x80, 0x00, 0xF0, 0x30,
  0x00, 0x38, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x20, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x08, 0x01,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x00, 0x03, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x41,
  0xC3, 0xC0, 0x78, 0xF0, 0x08, 0x60, 0x18, 0x18, 0x03, 0x01, 0x38, 0x01,
  0x86, 0x00, 0x30, 0x64, 0x00, 0x11, 0x80, 0x06, 0x0D, 0x00, 0x02, 0x60,
  0x00, 0x41, 0x60, 0x00, 0x48, 0x00, 0x08, 0x28, 0x00, 0x0B, 0x00, 0x01,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x21, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x86, 0x00, 0x00, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x10, 0x00, 0x06, 0x00, 0x00, 0x86, 0x00, 0x00, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x43, 0x00, 0x00, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x60, 0x00, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x21, 0x80, 0x00, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0x01, 0xFE, 0x00, 0x40, 0xF1, 0xE0, 0x08,
  0x70, 0x06, 0x01, 0x18, 0x00, 0x60, 0x66, 0x00, 0x04, 0x0D, 0x80, 0x00,
  0x81, 0x60, 0x00, 0x18, 0x28, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x01, 0x80, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x3F, 0x80, 0x00, 0x81, 0xC3, 0xC0, 0x01, 0x0E, 0x00,
  0xC0, 0x02, 0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x80, 0x1B, 0x00, 0x01,
  0x80, 0x2C, 0x00, 0x01, 0x00, 0x50, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x60, 0x16, 0x00, 0x01, 0x80, 0x24, 0x00, 0x03, 0x00, 0x4C, 0x00,
  0x1C, 0x01, 0x8C, 0x00, 0x70, 0x03, 0x0E, 0x03, 0x80, 0x04, 0x0F, 0xFC,
  0x00, 0x08, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x30, 0x07, 0x83, 0x83, 0x00,
  0xC0, 0x0E, 0x20, 0x38, 0x00, 0x22, 0x03, 0x00, 0x03, 0x20, 0x60, 0x00,
  0x16, 0x0C, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x16, 0x04, 0x00, 0x03, 0x40, 0x60,
  0x00, 0x64, 0x06, 0x00, 0x0C, 0x40, 0x30, 0x03, 0x8C, 0x01, 0xC0, 0xE0,
  0xC0, 0x0F, 0xFC, 0x08, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x03, 0x03, 0xF8, 0x10, 0x78, 0xC0, 0x86, 0x00, 0x04, 0x60,
  0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0x81, 0xF0, 0x30, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x80, 0x01, 0x83, 0xC0, 0x1C, 0x03, 0xFF,
  0xC0, 0x00, 0x68, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x40, 0x3F, 0xC0, 0x04, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x18, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x3C, 0x18, 0x00,
  0x0D, 0x83, 0x00, 0x03, 0x20, 0x30, 0x00, 0xC4, 0x06, 0x00, 0x30, 0x80,
  0x70, 0x1C, 0x30, 0x07, 0xFE, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x20, 0x01,
  0x80, 0x20, 0x03, 0x00, 0x30, 0x02, 0x00, 0x30, 0x06, 0x00, 0x30, 0x04,
  0x00, 0x10, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00, 0x08, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x09, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x1E,
  0x00, 0x03, 0x00, 0x01, 0xB0, 0x00, 0x18, 0x00, 0x0D, 0x80, 0x01, 0xC0,
  0x00, 0xCC, 0x00, 0x0A, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00, 0x61, 0x00,
  0x04, 0xC0, 0x03, 0x08, 0x00, 0x66, 0x00, 0x10, 0x40, 0x06, 0x30, 0x01,
  0x82, 0x00, 0x31, 0x80, 0x08, 0x10, 0x03, 0x0C, 0x00, 0xC0, 0x80, 0x18,
  0x20, 0x04, 0x04, 0x01, 0x81, 0x00, 0x60, 0x20, 0x08, 0x08, 0x02, 0x01,
  0x00, 0xC0, 0x40, 0x30, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x60, 0x60, 0x18,
  0x18, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x00, 0xC1,
  0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x86, 0x00, 0x30, 0x80, 0x04, 0x20,
  0x00, 0x8C, 0x00, 0x23, 0x00, 0x04, 0x40, 0x01, 0x18, 0x00, 0x26, 0x00,
  0x09, 0x80, 0x01, 0x20, 0x00, 0x4C, 0x00, 0x0B, 0x00, 0x03, 0x40, 0x00,
  0x50, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x18, 0x04,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x05, 0x80, 0x3C, 0x01, 0xE0,
  0x01, 0xE1, 0xC8, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 41, 12, 2, -41 },
  { 58, 13, 15, 18, 6, -41 },
  { 83, 34, 41, 36, 2, -41 },
  { 258, 27, 47, 32, 3, -44 },
  { 417, 36, 43, 44, 5, -42 },
  { 611, 34, 43, 40, 3, -42 },
  { 794, 5, 15, 10, 6, -41 },
  { 804, 16, 50, 14, 2, -41 },
  { 904, 17, 50, 14, -4, -41 },
  { 1011, 24, 24, 31, 7, -44 },
  { 1083, 27, 27, 33, 4, -34 },
  { 1175, 8, 14, 11, -3, -7 },
  { 1189, 14, 1, 18, 2, -16 },
  { 1191, 3, 3, 12, 2, -3 },
  { 1193, 26, 41, 18, -3, -41 },
  { 1327, 27, 43, 32, 4, -42 },
  { 1473, 14, 41, 32, 10, -41 },
  { 1545, 28, 42, 32, 1, -42 },
  { 1692, 29, 43, 32, 1, -42 },
  { 1848, 30, 42, 32, 1, -42 },
  { 2006, 29, 42, 32, 2, -41 },
  { 2159, 28, 43, 32, 4, -42 },
  { 2310, 26, 41, 32, 7, -41 },
  { 2444, 28, 43, 32, 3, -42 },
  { 2595, 27, 43, 32, 3, -42 },
  { 2741, 9, 31, 12, 2, -31 },
  { 2776, 14, 38, 12, -3, -31 },
  { 2843, 27, 26, 33, 4, -34 },
  { 2931, 27, 13, 33, 4, -27 },
  { 2975, 27, 26, 33, 4, -34 },
  { 3063, 19, 42, 23, 5, -42 },
  { 3163, 44, 46, 48, 3, -41 },
  { 3416, 32, 42, 32, -3, -42 },
  { 3584, 31, 41, 35, 3, -41 },
  { 3743, 32, 43, 34, 5, -42 },
  { 3915, 34, 41, 39, 3, -41 },
  { 4090, 29, 41, 31, 3, -41 },
  { 4239, 29, 41, 28, 3, -41 },
  { 4388, 34, 43, 40, 5, -42 },
  { 4571, 36, 41, 40, 3, -41 },
  { 4756, 18, 41, 16, 0, -41 },
  { 4849, 23, 51, 13, -10, -41 },
  { 4996, 33, 41, 32, 3, -41 },
  { 5166, 21, 41, 28, 3, -41 },
  { 5274, 43, 41, 47, 3, -41 },
  { 5495, 36, 41, 39, 3, -41 },
  { 5680, 34, 43, 42, 5, -42 },
  { 5863, 29, 41, 32, 3, -41 },
  { 6012, 34, 52, 42, 5, -42 },
  { 6233, 29, 41, 33, 3, -41 },
  { 6382, 29, 43, 29, 1, -42 },
  { 6538, 28, 41, 28, 5, -41 },
  { 6682, 35, 42, 40, 5, -41 },
  { 6866, 29, 41, 31, 6, -41 },
  { 7015, 45, 41, 48, 7, -41 },
  { 7246, 36, 41, 28, -3, -41 },
  { 7431, 28, 41, 28, 6, -41 },
  { 7575, 33, 41, 31, 0, -41 },
  { 7745, 22, 50, 18, -1, -41 },
  { 7883, 9, 41, 18, 6, -41 },
  { 7930, 22, 50, 18, -4, -41 },
  { 8068, 26, 26, 32, 3, -42 },
  { 8153, 22, 2, 22, -5, 6 },
  { 8159, 6, 9, 13, 9, -44 },
  { 8166, 27, 32, 32, 3, -31 },
  { 8274, 28, 45, 33, 2, -44 },
  { 8432, 24, 32, 26, 3, -31 },
  { 8528, 31, 45, 33, 3, -44 },
  { 8703, 23, 32, 28, 4, -31 },
  { 8795, 32, 58, 15, -8, -44 },
  { 9027, 29, 45, 33, 2, -31 },
  { 9191, 27, 44, 32, 2, -44 },
  { 9340, 11, 42, 12, 2, -42 },
  { 9398, 21, 56, 12, -8, -42 },
  { 9545, 26, 44, 25, 2, -44 },
  { 9688, 11, 44, 12, 2, -44 },
  { 9749, 43, 31, 49, 2, -31 },
  { 9916, 27, 31, 32, 2, -31 },
  { 10021, 27, 32, 33, 3, -31 },
  { 10129, 31, 44, 33, -1, -31 },
  { 10300, 28, 44, 33, 3, -31 },
  { 10454, 21, 31, 21, 2, -31 },
  { 10536, 22, 32, 25, 1, -31 },
  { 10624, 16, 39, 18, 3, -38 },
  { 10702, 27, 32, 32, 3, -31 },
  { 10810, 24, 31, 24, 3, -31 },
  { 10903, 37, 31, 38, 3, -31 },
  { 11047, 29, 31, 26, -2, -31 },
  { 11160, 34, 45, 24, -7, -31 },
  { 11352, 26, 31, 25, -1, -31 },
  { 11453, 20, 50, 19, 2, -41 },
  { 11578, 2, 58, 31, 16, -44 },
  { 11593, 21, 50, 19, -3, -41 },
  { 11725, 27, 5, 33, 4, -23 },
};

const GFXfont NotoSans_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_THINITALIC58PT7B_H_
