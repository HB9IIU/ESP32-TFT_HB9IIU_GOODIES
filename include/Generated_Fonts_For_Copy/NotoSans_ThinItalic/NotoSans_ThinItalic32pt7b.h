#ifndef _NOTOSANS_THINITALIC32PT7B_H_
#define _NOTOSANS_THINITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x45, 0x14, 0x61, 0x86, 0x28,
  0xA2, 0x00, 0x40, 0x80, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08,
  0x20, 0x02, 0x04, 0x00, 0x40, 0x81, 0xFF, 0xFF, 0x01, 0x04, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02,
  0x07, 0xFF, 0xFC, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x08, 0x10, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x1E, 0x01, 0x97, 0x08, 0x40, 0x42, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80,
  0x42, 0x01, 0x90, 0x03, 0x40, 0x03, 0x80, 0x05, 0x80, 0x21, 0x00, 0x84,
  0x02, 0x08, 0x08, 0x20, 0x21, 0x01, 0x04, 0x04, 0x63, 0xFE, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x62, 0x10, 0x04, 0x20,
  0x80, 0x84, 0x08, 0x10, 0x40, 0x82, 0x08, 0x08, 0x20, 0x80, 0x84, 0x08,
  0x10, 0x80, 0x81, 0x08, 0x08, 0x11, 0x1C, 0x82, 0x26, 0x28, 0x24, 0x41,
  0x84, 0x48, 0x17, 0x88, 0x81, 0x01, 0x10, 0x10, 0x21, 0x01, 0x02, 0x10,
  0x20, 0x41, 0x02, 0x08, 0x10, 0x21, 0x01, 0x04, 0x10, 0x10, 0x42, 0x01,
  0x08, 0x40, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x40, 0x08, 0x08, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02,
  0x18, 0x00, 0x2C, 0x00, 0x06, 0x00, 0x03, 0x20, 0x00, 0x84, 0x02, 0x60,
  0x40, 0x48, 0x04, 0x0A, 0x00, 0x82, 0x40, 0x08, 0x90, 0x00, 0xA2, 0x00,
  0x0C, 0x20, 0x03, 0x04, 0x00, 0x90, 0x40, 0x61, 0x07, 0xF0, 0x30, 0x56,
  0xAA, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x18, 0x18, 0x00, 0x01, 0x00, 0x08, 0x00, 0x41, 0x84, 0x02,
  0x20, 0x0D, 0x00, 0x1F, 0xE0, 0xC0, 0x09, 0x00, 0x88, 0x18, 0x40, 0x81,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x12, 0x22, 0x44, 0x88,
  0xFF, 0x70, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x0C, 0x10, 0x20,
  0x10, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x84, 0x02, 0x04, 0x08,
  0x07, 0xE0, 0x00, 0x01, 0x07, 0x09, 0x32, 0xC2, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x00, 0xFC, 0x03, 0x02, 0x04, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xFC,
  0x01, 0xF8, 0x06, 0x06, 0x08, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x80, 0x30, 0x7F, 0xC0, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0x20, 0x01, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x03,
  0xFF, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x17, 0xC0, 0x18, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x80, 0x20, 0x7F, 0xC0, 0x00, 0xFE, 0x02,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x8F, 0xC1, 0x60, 0x43, 0x00, 0x4C, 0x00, 0x98, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01,
  0x04, 0x0C, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC,
  0x02, 0x02, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x02, 0x04, 0x04, 0x02, 0x18, 0x01, 0xE0, 0x03, 0x40, 0x0C, 0x30,
  0x30, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x1F, 0xE0, 0x01, 0xF8, 0x06, 0x04,
  0x0C, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x03, 0x20, 0x02, 0x10, 0x06, 0x18, 0x1A, 0x07, 0xE2,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x80, 0xFF, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0xC0, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0x10, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x02, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x0E, 0x80, 0x00, 0xF0, 0x60, 0x01,
  0x00, 0x18, 0x06, 0x00, 0x04, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x1F, 0xC1, 0x40, 0x60, 0x81, 0x40, 0x80, 0x81, 0x81,
  0x00, 0x81, 0x81, 0x00, 0x81, 0x82, 0x01, 0x01, 0x82, 0x01, 0x02, 0x82,
  0x01, 0x02, 0x82, 0x03, 0x02, 0x82, 0x02, 0x04, 0x82, 0x05, 0x08, 0x81,
  0x19, 0x30, 0x80, 0xE0, 0xC0, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x02, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x04, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xE0, 0x40, 0x08, 0x10, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x21, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00,
  0x1C, 0x00, 0x04, 0x0F, 0xF8, 0x04, 0x03, 0x02, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x10, 0x02, 0x10, 0x03,
  0x0F, 0xDE, 0x04, 0x1E, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84,
  0x01, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0x80, 0x41, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x02, 0x03, 0x80, 0x80, 0x10,
  0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x48, 0x00, 0x22,
  0x00, 0x10, 0x80, 0x18, 0x20, 0x18, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x10, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7F, 0xA0, 0x00,
  0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x11,
  0x00, 0x08, 0x60, 0x02, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x42, 0x00, 0x04, 0x3F, 0xFF,
  0x42, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x00, 0x07, 0xC0, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0x80,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x08, 0x80, 0x70, 0x00, 0x08, 0x00, 0x42, 0x00,
  0x60, 0x80, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x01, 0x02, 0x00,
  0x43, 0x00, 0x11, 0x80, 0x08, 0x80, 0x02, 0x60, 0x00, 0xA4, 0x00, 0x31,
  0x00, 0x08, 0x20, 0x04, 0x08, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x08,
  0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0A, 0x12, 0x00, 0x0A, 0x12,
  0x00, 0x12, 0x12, 0x00, 0x24, 0x12, 0x00, 0x24, 0x12, 0x00, 0x44, 0x22,
  0x00, 0x44, 0x21, 0x00, 0x84, 0x21, 0x01, 0x08, 0x21, 0x01, 0x08, 0x21,
  0x02, 0x08, 0x41, 0x02, 0x08, 0x41, 0x04, 0x10, 0x40, 0x88, 0x10, 0x40,
  0x88, 0x10, 0x80, 0x90, 0x10, 0x80, 0x90, 0x10, 0x80, 0xA0, 0x20, 0x80,
  0x40, 0x20, 0x80, 0x40, 0x20, 0x08, 0x00, 0x21, 0x80, 0x04, 0x30, 0x00,
  0x85, 0x00, 0x11, 0x20, 0x02, 0x24, 0x00, 0x84, 0x40, 0x10, 0x88, 0x02,
  0x10, 0x80, 0x44, 0x10, 0x08, 0x81, 0x02, 0x10, 0x20, 0x42, 0x04, 0x08,
  0x40, 0x41, 0x10, 0x08, 0x42, 0x00, 0x88, 0x40, 0x11, 0x08, 0x01, 0x22,
  0x00, 0x24, 0x40, 0x05, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x00, 0x80,
  0x01, 0xFC, 0x00, 0xC0, 0x60, 0x20, 0x02, 0x08, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x04, 0x20, 0x01, 0x06,
  0x00, 0x60, 0x60, 0x10, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x08, 0x0C, 0x08,
  0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x08, 0x3F, 0xE0, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x60, 0x20, 0x02,
  0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x05,
  0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x04, 0x20, 0x01, 0x06, 0x00, 0x60, 0x60, 0x10, 0x03, 0xFC, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x0F, 0xF0, 0x08, 0x0C, 0x08, 0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x38,
  0x3F, 0xC0, 0x20, 0x40, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08, 0x03, 0xFC,
  0x08, 0x04, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x10, 0x0C, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x00, 0x02, 0x20,
  0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x02, 0x04, 0x00, 0x80, 0xC0, 0x20, 0x07, 0xF8, 0x00, 0x80, 0x01, 0xC0,
  0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20,
  0x80, 0x10, 0x40, 0x10, 0x20, 0x10, 0x08, 0x08, 0x04, 0x08, 0x02, 0x04,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x08,
  0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00, 0x90, 0x05, 0x00, 0x48, 0x02,
  0x80, 0x24, 0x02, 0x40, 0x22, 0x01, 0x20, 0x11, 0x01, 0x10, 0x10, 0x80,
  0x88, 0x08, 0x40, 0x84, 0x08, 0x20, 0x42, 0x04, 0x10, 0x40, 0x84, 0x08,
  0x20, 0x42, 0x02, 0x20, 0x22, 0x01, 0x10, 0x11, 0x00, 0x90, 0x08, 0x80,
  0x48, 0x04, 0x80, 0x24, 0x02, 0x40, 0x14, 0x01, 0x40, 0x0A, 0x00, 0xA0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x10, 0x20, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x01, 0x01, 0x00, 0x08,
  0x10, 0x00, 0x82, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x05, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x10, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x40, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x01, 0x00, 0x80, 0x03, 0x80, 0x02,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x10, 0x80, 0x10, 0x80, 0x11, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xC0, 0x84, 0x20, 0x84, 0x21, 0x08, 0x21, 0x08, 0x42,
  0x10, 0x42, 0x10, 0x84, 0x10, 0x84, 0x20, 0x07, 0xF0, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x0F,
  0xC0, 0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x48, 0x02, 0x10, 0x08, 0x40,
  0x41, 0x02, 0x04, 0x08, 0x08, 0x40, 0x22, 0x00, 0x90, 0x01, 0x40, 0x06,
  0x00, 0x10, 0xFF, 0xF0, 0x91, 0x22, 0x40, 0x07, 0xE4, 0x20, 0x51, 0x01,
  0x48, 0x03, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x01, 0x48, 0x06, 0x10, 0x48, 0x3E,
  0x20, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0xFC, 0x12, 0x04, 0x28, 0x04, 0x60, 0x08, 0x80, 0x13,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x94, 0x03, 0x24, 0x0C, 0x47, 0xE0, 0x07, 0xF8,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x0F, 0xC4, 0x08, 0x12, 0x08, 0x05, 0x08,
  0x01, 0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x20, 0x06, 0x10, 0x02, 0x08, 0x03, 0x04, 0x02,
  0x81, 0x02, 0x40, 0x7E, 0x20, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x14,
  0x00, 0xA0, 0x09, 0x00, 0x90, 0x38, 0xFC, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x04, 0x1F, 0xC0, 0x00, 0x0F, 0x80,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x07, 0xF8, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x03, 0xF1, 0x04, 0x09, 0x08, 0x05, 0x10,
  0x06, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40, 0x28, 0x20,
  0x48, 0x1F, 0x88, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0xC1, 0x80, 0x1C, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0xFC, 0x12, 0x04,
  0x28, 0x04, 0x60, 0x08, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10,
  0x02, 0x20, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x08, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x08, 0x80, 0x70, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x01, 0x10,
  0x08, 0x40, 0x41, 0x02, 0x04, 0x10, 0x21, 0x80, 0x88, 0x02, 0x40, 0x0A,
  0x80, 0x51, 0x01, 0x84, 0x04, 0x08, 0x10, 0x20, 0x40, 0x42, 0x01, 0x08,
  0x02, 0x20, 0x08, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x11, 0xF0, 0x7E,
  0x12, 0x08, 0x82, 0x14, 0x05, 0x01, 0x18, 0x06, 0x01, 0x10, 0x04, 0x01,
  0x30, 0x04, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x02,
  0x20, 0x08, 0x02, 0x40, 0x08, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x04,
  0x40, 0x10, 0x04, 0x80, 0x10, 0x04, 0x80, 0x10, 0x04, 0x80, 0x20, 0x04,
  0x11, 0xF8, 0x24, 0x08, 0x50, 0x08, 0xC0, 0x11, 0x00, 0x26, 0x00, 0x48,
  0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x10, 0x07, 0xF0, 0x20, 0x21,
  0x00, 0x88, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x01, 0x10, 0x18,
  0x3F, 0x80, 0x04, 0x7E, 0x02, 0x40, 0x81, 0x40, 0x20, 0xC0, 0x10, 0x40,
  0x08, 0x60, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0xA0, 0x18, 0x48, 0x18,
  0x23, 0xF0, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE2, 0x10, 0x24, 0x40, 0x29, 0x00,
  0x64, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x24, 0x00, 0xC8, 0x01, 0x10, 0x06, 0x20, 0x14, 0x20, 0x48, 0x3F,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x11, 0xF1, 0x20, 0x14, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x07, 0xF0, 0xC0, 0x44, 0x00, 0x20, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x90, 0x08, 0x7F, 0x80, 0x10, 0x08, 0x04, 0x02,
  0x0F, 0xF9, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0x80, 0x20, 0x02, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x06, 0x20, 0x14,
  0x40, 0xD0, 0x7E, 0x20, 0x80, 0x1C, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x04,
  0x40, 0x22, 0x02, 0x08, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0x88, 0x04,
  0x40, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x80, 0x40, 0x18, 0x04,
  0x02, 0x80, 0xC0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82,
  0x20, 0x88, 0x22, 0x10, 0x84, 0x21, 0x08, 0x82, 0x20, 0x88, 0x22, 0x09,
  0x02, 0x40, 0x90, 0x24, 0x0A, 0x01, 0x80, 0xA0, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x00, 0x08, 0x01, 0x08, 0x02, 0x04, 0x04, 0x04, 0x08, 0x02,
  0x10, 0x02, 0x20, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02,
  0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10, 0x80,
  0x08, 0x02, 0x00, 0x60, 0x40, 0x08, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x30, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x38, 0x01, 0x00, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x06, 0x00,
  0x70, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x0F, 0x00, 0x3C, 0x00, 0x86, 0x06,
  0x03, 0xF0,
};

const GFXglyph NotoSans_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 6, 8, 10, 4, -23 },
  { 25, 19, 23, 20, 1, -23 },
  { 80, 14, 26, 18, 2, -24 },
  { 126, 20, 23, 24, 3, -23 },
  { 184, 19, 23, 22, 1, -23 },
  { 239, 2, 8, 6, 4, -23 },
  { 241, 9, 28, 8, 1, -23 },
  { 273, 9, 28, 8, -2, -23 },
  { 305, 13, 13, 17, 4, -24 },
  { 327, 15, 15, 18, 2, -19 },
  { 356, 4, 8, 6, -1, -4 },
  { 360, 8, 1, 10, 1, -9 },
  { 361, 2, 2, 7, 1, -2 },
  { 362, 14, 23, 10, -1, -23 },
  { 403, 15, 23, 18, 2, -23 },
  { 447, 8, 23, 18, 5, -23 },
  { 470, 16, 23, 18, 0, -23 },
  { 516, 16, 23, 18, 1, -23 },
  { 562, 17, 23, 18, 0, -23 },
  { 611, 16, 23, 18, 1, -23 },
  { 657, 15, 23, 18, 2, -23 },
  { 701, 14, 23, 18, 4, -23 },
  { 742, 16, 23, 18, 1, -23 },
  { 788, 16, 23, 18, 1, -23 },
  { 834, 5, 17, 7, 1, -17 },
  { 845, 7, 21, 7, -1, -17 },
  { 864, 15, 15, 18, 2, -19 },
  { 893, 15, 7, 18, 2, -15 },
  { 907, 15, 15, 18, 2, -19 },
  { 936, 10, 23, 13, 3, -23 },
  { 965, 24, 26, 27, 2, -23 },
  { 1043, 18, 23, 18, -2, -23 },
  { 1095, 17, 23, 19, 2, -23 },
  { 1144, 17, 23, 19, 3, -23 },
  { 1193, 18, 23, 22, 2, -23 },
  { 1245, 16, 23, 17, 2, -23 },
  { 1291, 16, 23, 16, 2, -23 },
  { 1337, 18, 23, 22, 3, -23 },
  { 1389, 20, 23, 22, 2, -23 },
  { 1447, 10, 23, 9, 0, -23 },
  { 1476, 12, 29, 7, -5, -23 },
  { 1520, 18, 23, 17, 2, -23 },
  { 1572, 11, 23, 16, 2, -23 },
  { 1604, 24, 23, 26, 2, -23 },
  { 1673, 19, 23, 22, 2, -23 },
  { 1728, 19, 23, 23, 3, -23 },
  { 1783, 16, 23, 18, 2, -23 },
  { 1829, 19, 28, 23, 3, -23 },
  { 1896, 16, 23, 18, 2, -23 },
  { 1942, 15, 23, 16, 1, -23 },
  { 1986, 15, 23, 16, 3, -23 },
  { 2030, 19, 23, 22, 3, -23 },
  { 2085, 17, 23, 17, 3, -23 },
  { 2134, 25, 23, 26, 4, -23 },
  { 2206, 20, 23, 16, -2, -23 },
  { 2264, 16, 23, 16, 3, -23 },
  { 2310, 18, 23, 17, 0, -23 },
  { 2362, 12, 28, 10, 0, -23 },
  { 2404, 5, 23, 10, 3, -23 },
  { 2419, 12, 28, 10, -2, -23 },
  { 2461, 14, 14, 18, 2, -23 },
  { 2486, 12, 1, 12, -3, 3 },
  { 2488, 3, 6, 7, 5, -25 },
  { 2491, 14, 17, 18, 2, -17 },
  { 2521, 15, 24, 18, 1, -24 },
  { 2566, 13, 17, 14, 2, -17 },
  { 2594, 17, 24, 18, 2, -24 },
  { 2645, 13, 17, 16, 2, -17 },
  { 2673, 17, 32, 8, -4, -24 },
  { 2741, 16, 25, 18, 1, -17 },
  { 2791, 15, 24, 18, 1, -24 },
  { 2836, 6, 23, 7, 1, -23 },
  { 2854, 12, 31, 7, -5, -23 },
  { 2901, 14, 24, 14, 1, -24 },
  { 2943, 6, 24, 7, 1, -24 },
  { 2961, 24, 17, 27, 1, -17 },
  { 3012, 15, 17, 18, 1, -17 },
  { 3044, 14, 17, 18, 2, -17 },
  { 3074, 17, 24, 18, -1, -17 },
  { 3125, 15, 24, 18, 2, -17 },
  { 3170, 12, 17, 12, 1, -17 },
  { 3196, 13, 17, 14, 0, -17 },
  { 3224, 9, 21, 10, 2, -21 },
  { 3248, 15, 17, 18, 2, -17 },
  { 3280, 13, 17, 13, 2, -17 },
  { 3308, 20, 17, 21, 2, -17 },
  { 3351, 16, 17, 15, -1, -17 },
  { 3385, 19, 25, 13, -4, -17 },
  { 3445, 14, 17, 14, 0, -17 },
  { 3475, 11, 28, 10, 1, -23 },
  { 3514, 1, 32, 17, 9, -24 },
  { 3518, 12, 28, 10, -2, -23 },
  { 3560, 15, 3, 18, 2, -13 },
};

const GFXfont NotoSans_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_THINITALIC32PT7B_H_
