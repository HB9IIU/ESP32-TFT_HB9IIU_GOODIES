#ifndef _NOTOSANS_THINITALIC64PT7B_H_
#define _NOTOSANS_THINITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x00,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01,
  0x88, 0x04, 0x20, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x40, 0x21, 0x00,
  0x8C, 0x06, 0x30, 0x10, 0x80, 0x40, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xF5, 0xFE, 0x00, 0x3C, 0x10, 0x1C, 0x01, 0xC0, 0xC0, 0x10, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x20, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00,
  0x1E, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0x20, 0x18, 0x08, 0x01,
  0x81, 0xC0, 0x3E, 0x06, 0x1E, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x01, 0xE7, 0x80,
  0x00, 0x08, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x00, 0x40, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x40, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x01,
  0x81, 0x81, 0xF0, 0xC0, 0x01, 0x83, 0x07, 0xFC, 0xC0, 0x03, 0x06, 0x0E,
  0x06, 0x40, 0x03, 0x06, 0x18, 0x06, 0x40, 0x06, 0x0C, 0x38, 0x03, 0x60,
  0x06, 0x18, 0x30, 0x03, 0x60, 0x0C, 0x10, 0x60, 0x03, 0x30, 0x18, 0x30,
  0x60, 0x01, 0x3C, 0x70, 0x60, 0xC0, 0x01, 0x0F, 0xE0, 0xC0, 0xC0, 0x01,
  0x00, 0x00, 0xC0, 0x80, 0x03, 0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x06, 0x01, 0x00,
  0x03, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x18, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0xE0, 0x01, 0x00, 0x00, 0x87, 0x00, 0x06, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x00,
  0x60, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x40, 0x00, 0x01, 0x80, 0xC3,
  0x00, 0x00, 0x03, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x30, 0x00, 0x00,
  0x19, 0x80, 0xC0, 0x00, 0x00, 0x36, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x00,
  0xC6, 0x01, 0x80, 0x00, 0x06, 0x18, 0x03, 0x00, 0x00, 0x70, 0x30, 0x07,
  0x00, 0x07, 0x00, 0x60, 0x0F, 0x00, 0xF8, 0x01, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4,
  0x23, 0x18, 0xC4, 0x23, 0x18, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x60, 0x03, 0xC0, 0x10, 0x00, 0x3C, 0x04, 0x00, 0x03,
  0x81, 0x00, 0x00, 0x38, 0x40, 0x00, 0x03, 0x30, 0x07, 0x00, 0x39, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0x30, 0x00, 0x38, 0x04, 0x00, 0x1C,
  0x01, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xA0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0x20,
  0x1C, 0xC0, 0x61, 0x83, 0x83, 0x0C, 0x06, 0x70, 0x09, 0x80, 0x32, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x20,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x40, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x7F,
  0xF8, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x01, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x3F, 0xE0, 0x00, 0x81, 0xFF, 0xF0, 0x03, 0x0E, 0x00, 0x70, 0x06,
  0x70, 0x00, 0x30, 0x09, 0x80, 0x00, 0x30, 0x16, 0x00, 0x00, 0x60, 0x78,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x07, 0x08, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x06, 0x81, 0x80, 0x00,
  0x36, 0x03, 0x00, 0x03, 0x98, 0x0E, 0x00, 0x1C, 0x40, 0x0F, 0x07, 0xC3,
  0x00, 0x1F, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x04, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0x0F, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0xFF, 0x80, 0x06, 0x18, 0x00, 0x0F, 0x83,
  0xE0, 0x02, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x02, 0x30, 0x00, 0x70, 0x00,
  0x40, 0x03, 0x30, 0x00, 0xE0, 0x00, 0x40, 0x03, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x00, 0x00,
  0x80, 0x03, 0x40, 0x03, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x02, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0xC0, 0x0C, 0x00, 0x01,
  0x00, 0x06, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x06, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x80, 0x08, 0x00, 0x06,
  0x00, 0x0C, 0x80, 0x08, 0x00, 0x06, 0x00, 0x08, 0x80, 0x08, 0x00, 0x0E,
  0x00, 0x18, 0x80, 0x08, 0x00, 0x0E, 0x00, 0x30, 0x80, 0x0C, 0x00, 0x1E,
  0x00, 0x30, 0xC0, 0x0C, 0x00, 0x36, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x62,
  0x00, 0xC0, 0xC0, 0x07, 0x01, 0xC3, 0x03, 0x80, 0xC0, 0x03, 0xEF, 0x81,
  0xDF, 0x00, 0x60, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x03,
  0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0xE0, 0x02, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x18, 0x00, 0x07, 0x80, 0x06, 0x00, 0x00, 0x70, 0x01, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x3C, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x0F, 0x80, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00,
  0x10, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x03, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xE3, 0x00, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0xF0, 0x00, 0x00, 0x03, 0x1D, 0x80, 0x00, 0x00, 0x19,
  0xC6, 0x00, 0x00, 0x00, 0xD8, 0x30, 0x00, 0x00, 0x05, 0x80, 0xC0, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x48, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x48, 0x00, 0x00, 0x00, 0x36, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x8C, 0x00, 0x00, 0x01, 0x8C, 0x01, 0x84, 0x00,
  0x00, 0x01, 0x8C, 0x01, 0x84, 0x00, 0x00, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x08, 0x01, 0x86, 0x00, 0x00, 0x06, 0x08, 0x01, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x03, 0x02, 0x00,
  0x00, 0x18, 0x18, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x10, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x00,
  0x00, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x18, 0x00, 0x40,
  0x30, 0x00, 0x80, 0x10, 0x00, 0x40, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x40, 0x01, 0x80, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x61,
  0x80, 0x01, 0x00, 0x30, 0x00, 0x61, 0x80, 0x01, 0x00, 0x20, 0x00, 0x23,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x22, 0x00, 0x03, 0x00, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x78, 0x00, 0x00, 0x06, 0x00, 0x48, 0x00, 0x00, 0x06, 0x00, 0x4C, 0x00,
  0x00, 0x06, 0x00, 0xCC, 0x00, 0x00, 0x04, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x01, 0x83,
  0x00, 0x00, 0x08, 0x01, 0x81, 0x00, 0x00, 0x08, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x01, 0x81, 0x80, 0x00, 0x18, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x30, 0x02, 0x00, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x00,
  0x40, 0x0C, 0x00, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x80, 0x18, 0x00, 0x01, 0x01, 0x80, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x18, 0x00, 0x00, 0x81, 0x80, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x30, 0x00,
  0x00, 0xC1, 0x00, 0x30, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x30, 0x00, 0x00, 0x23, 0x00, 0x20, 0x00, 0x00, 0x33, 0x00, 0x60,
  0x00, 0x00, 0x12, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00,
  0x1E, 0x00, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x04, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x20, 0x00, 0x10, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x08, 0x00, 0x06, 0x08, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01,
  0x80, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x30, 0x00,
  0xC0, 0x10, 0x00, 0x60, 0x18, 0x00, 0x60, 0x08, 0x00, 0x20, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x08, 0x00, 0xC0,
  0x08, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x10, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x02, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x36, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x60, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x00, 0x0F, 0xFC, 0x0C, 0x00,
  0xF0, 0x38, 0x20, 0x07, 0x00, 0x30, 0x80, 0x30, 0x00, 0x62, 0x01, 0x80,
  0x00, 0x98, 0x0C, 0x00, 0x03, 0x60, 0x60, 0x00, 0x05, 0x03, 0x00, 0x00,
  0x14, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x00, 0xD0,
  0x18, 0x00, 0x06, 0xC0, 0x60, 0x00, 0x13, 0x00, 0x80, 0x00, 0xCC, 0x03,
  0x00, 0x0E, 0x20, 0x06, 0x00, 0x60, 0x80, 0x0E, 0x07, 0x06, 0x00, 0x1F,
  0xF0, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0xC0, 0x01, 0x83, 0xC1,
  0xE0, 0x02, 0x0C, 0x00, 0xE0, 0x04, 0x70, 0x00, 0xE0, 0x19, 0x80, 0x00,
  0xC0, 0x36, 0x00, 0x00, 0xC0, 0x48, 0x00, 0x01, 0x80, 0xA0, 0x00, 0x01,
  0x03, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x04, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x20, 0x70, 0x00,
  0x00, 0xC1, 0xA0, 0x00, 0x03, 0x03, 0x40, 0x00, 0x0C, 0x06, 0xC0, 0x00,
  0x38, 0x08, 0xC0, 0x00, 0xE0, 0x10, 0xC0, 0x03, 0x80, 0x60, 0xE0, 0x3C,
  0x00, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x1E, 0x03, 0xC0, 0x38, 0x00, 0x20, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x20, 0x0F, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x3E, 0x0F, 0x06, 0x00,
  0x1C, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x0C, 0x40, 0x06, 0x00, 0x01, 0xB0,
  0x03, 0x00, 0x00, 0x6C, 0x01, 0x80, 0x00, 0x0B, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x10, 0x00, 0x01, 0xA0, 0x06, 0x00, 0x00,
  0xC8, 0x01, 0x80, 0x00, 0x26, 0x00, 0x20, 0x00, 0x39, 0x80, 0x0C, 0x00,
  0x1C, 0x60, 0x01, 0x80, 0x0C, 0x10, 0x00, 0x38, 0x1E, 0x04, 0x00, 0x07,
  0xFE, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x0F, 0x00, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x63, 0x00, 0x00, 0xE1, 0x80, 0x01, 0xE0, 0x80, 0x0F, 0xC0, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x30,
  0x07, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x70, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x00, 0x1F,
  0x07, 0x83, 0x00, 0x38, 0x00, 0xC3, 0x00, 0x60, 0x00, 0x62, 0x00, 0xC0,
  0x00, 0x32, 0x01, 0x80, 0x00, 0x36, 0x03, 0x00, 0x00, 0x16, 0x06, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0xE0, 0x20, 0x00, 0x03, 0x40, 0x30, 0x00, 0x02, 0x40, 0x30, 0x00,
  0x04, 0xC0, 0x10, 0x00, 0x1C, 0xC0, 0x18, 0x00, 0x38, 0xC0, 0x0C, 0x00,
  0x60, 0x80, 0x07, 0x03, 0xC1, 0x80, 0x03, 0xFF, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x3F, 0xF0, 0x01, 0x83,
  0xC1, 0xE0, 0x04, 0x18, 0x01, 0xC0, 0x11, 0xC0, 0x01, 0x80, 0xCC, 0x00,
  0x06, 0x03, 0x60, 0x00, 0x08, 0x09, 0x00, 0x00, 0x20, 0x2C, 0x00, 0x00,
  0xC1, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x04, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0x0D, 0x80, 0x00, 0x08, 0xCC, 0x00, 0x00, 0xCC, 0x30, 0x00, 0x06, 0xC1,
  0x80, 0x00, 0x2C, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x81, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0x07, 0x87, 0x80, 0x38, 0x3C, 0x01, 0x0E, 0x01, 0xC0, 0xE0,
  0x0E, 0x01, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x03, 0x30, 0x00, 0x63, 0x00,
  0x03, 0x03, 0x60, 0x00, 0x66, 0x00, 0x03, 0x02, 0xC0, 0x00, 0x26, 0x00,
  0x03, 0x02, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x07, 0x80, 0x00, 0x28, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xC0, 0x04,
  0x0F, 0x07, 0x80, 0x10, 0x60, 0x07, 0x00, 0x47, 0x00, 0x06, 0x03, 0x30,
  0x00, 0x18, 0x0D, 0x80, 0x00, 0x20, 0x24, 0x00, 0x00, 0x80, 0xB0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x20, 0x70, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x1F, 0xF0, 0x00, 0x08, 0x1E, 0x0F, 0x00, 0x02, 0x0C, 0x00, 0xE0, 0x00,
  0x8E, 0x00, 0x1C, 0x00, 0x66, 0x00, 0x03, 0x00, 0x1B, 0x00, 0x00, 0x60,
  0x04, 0x80, 0x00, 0x18, 0x01, 0x60, 0x00, 0x02, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x08, 0x07, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x34, 0x00, 0x00, 0x60, 0x0D, 0x00, 0x00,
  0x30, 0x03, 0x60, 0x00, 0x1C, 0x00, 0x8C, 0x00, 0x0E, 0x00, 0x21, 0x80,
  0x07, 0x00, 0x18, 0x38, 0x0F, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x01, 0x80,
  0x1E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x06, 0x00, 0x7C, 0x1E, 0x0C, 0x01,
  0xC0, 0x06, 0x18, 0x06, 0x00, 0x06, 0x20, 0x18, 0x00, 0x06, 0x40, 0x60,
  0x00, 0x0D, 0x81, 0x80, 0x00, 0x0B, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x81, 0x00, 0x00, 0x1A, 0x03,
  0x00, 0x00, 0x64, 0x06, 0x00, 0x00, 0xD8, 0x04, 0x00, 0x07, 0x30, 0x0C,
  0x00, 0x1C, 0x60, 0x0C, 0x00, 0x60, 0x80, 0x0E, 0x07, 0x81, 0x00, 0x0F,
  0xFC, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0xFE, 0x02, 0x07, 0x84, 0x04, 0x38, 0x00, 0x08, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x90, 0x00, 0x01, 0x40, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x0F, 0xC0, 0xE0, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x82, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xF8, 0x03, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x20, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x07,
  0x04, 0x00, 0x00, 0x78, 0x20, 0x00, 0x02, 0x81, 0x00, 0x00, 0x34, 0x08,
  0x00, 0x03, 0x20, 0x60, 0x00, 0x33, 0x03, 0x00, 0x03, 0x18, 0x0C, 0x00,
  0x70, 0x80, 0x38, 0x0E, 0x04, 0x00, 0xFF, 0xE0, 0x60, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0x40, 0x03, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x40, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xA0, 0x00, 0x0C,
  0x00, 0x01, 0x90, 0x00, 0x06, 0x00, 0x00, 0xC8, 0x00, 0x07, 0x00, 0x00,
  0xC4, 0x00, 0x02, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x60, 0x00, 0x61, 0x00,
  0x01, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x30, 0x60, 0x00, 0x8C,
  0x00, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x00, 0x0C,
  0x0C, 0x00, 0x60, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x40, 0x06, 0x03, 0x00,
  0x30, 0x30, 0x02, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x08, 0x0C, 0x01, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x40, 0x40, 0x02, 0x06,
  0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x08,
  0x30, 0x00, 0x41, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x18, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x40,
  0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x01, 0xA0, 0x00, 0x0B,
  0x00, 0x00, 0xF0, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x08, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x38,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0B, 0xC1, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0xE1, 0xE8, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph NotoSans_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 12, 47, 13, 2, -46 },
  { 72, 14, 17, 20, 7, -46 },
  { 102, 38, 46, 39, 2, -46 },
  { 321, 30, 53, 35, 3, -49 },
  { 520, 40, 47, 49, 5, -46 },
  { 755, 38, 47, 44, 3, -46 },
  { 979, 5, 17, 11, 7, -46 },
  { 990, 18, 56, 15, 2, -46 },
  { 1116, 18, 56, 15, -4, -46 },
  { 1242, 26, 26, 34, 8, -48 },
  { 1327, 29, 29, 36, 5, -37 },
  { 1433, 9, 15, 12, -3, -7 },
  { 1450, 16, 1, 20, 2, -18 },
  { 1452, 3, 4, 13, 2, -3 },
  { 1454, 28, 46, 20, -3, -46 },
  { 1615, 30, 47, 35, 4, -46 },
  { 1792, 15, 46, 35, 11, -46 },
  { 1879, 31, 46, 35, 1, -46 },
  { 2058, 33, 47, 35, 1, -46 },
  { 2252, 33, 46, 35, 1, -46 },
  { 2442, 32, 47, 35, 2, -46 },
  { 2630, 31, 47, 35, 4, -46 },
  { 2813, 29, 46, 35, 7, -46 },
  { 2980, 31, 47, 35, 3, -46 },
  { 3163, 30, 47, 35, 3, -46 },
  { 3340, 10, 35, 13, 2, -34 },
  { 3384, 15, 42, 13, -3, -34 },
  { 3463, 29, 29, 36, 5, -38 },
  { 3569, 29, 15, 36, 5, -30 },
  { 3624, 29, 29, 36, 5, -38 },
  { 3730, 22, 47, 26, 5, -46 },
  { 3860, 48, 51, 53, 4, -45 },
  { 4166, 35, 46, 35, -3, -46 },
  { 4368, 34, 46, 38, 3, -46 },
  { 4564, 36, 47, 38, 5, -46 },
  { 4776, 38, 46, 43, 3, -46 },
  { 4995, 33, 46, 34, 3, -46 },
  { 5185, 33, 46, 31, 3, -46 },
  { 5375, 38, 47, 44, 5, -46 },
  { 5599, 40, 46, 44, 3, -46 },
  { 5829, 19, 46, 18, 1, -46 },
  { 5939, 26, 57, 15, -11, -46 },
  { 6125, 37, 46, 35, 3, -46 },
  { 6338, 23, 46, 31, 3, -46 },
  { 6471, 48, 46, 52, 3, -46 },
  { 6747, 40, 46, 43, 3, -46 },
  { 6977, 38, 47, 46, 5, -46 },
  { 7201, 33, 46, 36, 3, -46 },
  { 7391, 38, 57, 46, 5, -46 },
  { 7662, 33, 46, 36, 3, -46 },
  { 7852, 32, 47, 32, 1, -46 },
  { 8040, 31, 46, 31, 6, -46 },
  { 8219, 38, 47, 44, 6, -46 },
  { 8443, 32, 46, 34, 7, -46 },
  { 8627, 49, 46, 53, 8, -46 },
  { 8909, 40, 46, 31, -4, -46 },
  { 9139, 31, 46, 31, 6, -46 },
  { 9318, 38, 46, 34, -1, -46 },
  { 9537, 25, 56, 19, -1, -46 },
  { 9712, 10, 46, 20, 6, -46 },
  { 9770, 25, 56, 19, -5, -46 },
  { 9945, 29, 28, 35, 3, -46 },
  { 10047, 24, 2, 24, -5, 7 },
  { 10053, 8, 10, 14, 9, -49 },
  { 10063, 30, 35, 35, 3, -34 },
  { 10195, 31, 50, 36, 2, -49 },
  { 10389, 25, 35, 29, 4, -34 },
  { 10499, 34, 50, 36, 3, -49 },
  { 10712, 25, 35, 31, 4, -34 },
  { 10822, 34, 64, 17, -8, -49 },
  { 11094, 32, 49, 36, 2, -34 },
  { 11290, 30, 49, 35, 2, -49 },
  { 11474, 12, 46, 13, 2, -46 },
  { 11543, 23, 61, 13, -9, -46 },
  { 11719, 29, 49, 28, 2, -49 },
  { 11897, 12, 49, 13, 2, -49 },
  { 11971, 48, 34, 54, 2, -34 },
  { 12175, 30, 34, 35, 2, -34 },
  { 12303, 29, 35, 36, 4, -34 },
  { 12430, 34, 49, 36, -1, -34 },
  { 12639, 31, 49, 36, 3, -34 },
  { 12829, 23, 34, 24, 2, -34 },
  { 12927, 25, 35, 27, 1, -34 },
  { 13037, 18, 43, 20, 3, -42 },
  { 13134, 29, 35, 35, 4, -34 },
  { 13261, 26, 34, 26, 3, -34 },
  { 13372, 41, 34, 42, 3, -34 },
  { 13547, 32, 34, 29, -2, -34 },
  { 13683, 36, 50, 26, -7, -34 },
  { 13908, 29, 34, 28, -1, -34 },
  { 14032, 22, 56, 21, 2, -46 },
  { 14186, 2, 64, 34, 18, -49 },
  { 14202, 23, 56, 21, -3, -46 },
  { 14363, 29, 5, 36, 5, -25 },
};

const GFXfont NotoSans_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_THINITALIC64PT7B_H_
