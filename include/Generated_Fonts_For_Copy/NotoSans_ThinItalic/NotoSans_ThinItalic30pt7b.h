#ifndef _NOTOSANS_THINITALIC30PT7B_H_
#define _NOTOSANS_THINITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84,
  0x10, 0x00, 0x00, 0x20, 0xC0, 0x22, 0x89, 0x12, 0x24, 0x50, 0xA2, 0x00,
  0x00, 0x83, 0x00, 0x20, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00,
  0x41, 0x03, 0xFF, 0xFC, 0x08, 0x20, 0x02, 0x08, 0x01, 0x02, 0x00, 0x40,
  0x80, 0x10, 0x40, 0x04, 0x10, 0x3F, 0xFF, 0xC0, 0x82, 0x00, 0x20, 0x80,
  0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x0F, 0xF0, 0x88, 0x08, 0x40, 0x82, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x04, 0x40, 0x1C, 0x00, 0x38, 0x01, 0x20, 0x08,
  0x80, 0x42, 0x04, 0x10, 0x20, 0x81, 0x08, 0x08, 0x8E, 0x78, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x80, 0x24, 0x10, 0x11,
  0x04, 0x08, 0x81, 0x04, 0x20, 0x41, 0x08, 0x10, 0x82, 0x04, 0x40, 0x81,
  0x10, 0x20, 0x89, 0xE8, 0x24, 0x86, 0x12, 0x41, 0x88, 0x90, 0x5C, 0x48,
  0x10, 0x22, 0x04, 0x10, 0x81, 0x04, 0x20, 0x42, 0x08, 0x11, 0x02, 0x08,
  0x80, 0x82, 0x20, 0x21, 0x10, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x43, 0x00,
  0x20, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10,
  0x20, 0x02, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0x32, 0x00, 0x10, 0x40,
  0x48, 0x08, 0x14, 0x02, 0x09, 0x00, 0x44, 0x80, 0x09, 0x20, 0x02, 0x88,
  0x00, 0x41, 0x00, 0x28, 0x60, 0x31, 0x07, 0xF0, 0x60, 0x29, 0x25, 0x20,
  0x03, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x02, 0x00, 0x20, 0x02, 0x08, 0x20, 0x62, 0x01,
  0x40, 0x0F, 0xF0, 0xC0, 0x12, 0x02, 0x20, 0xC1, 0x00, 0x10, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x0F, 0xFF,
  0xC0, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x32,
  0x24, 0x48, 0x80, 0xFE, 0xB0, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x40, 0x80, 0x84, 0x02, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88,
  0x02, 0x10, 0x10, 0x40, 0x80, 0xFC, 0x00, 0x06, 0x34, 0x8E, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x00, 0x00, 0xF0, 0x06, 0x18, 0x10, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x0C, 0x10,
  0x60, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x1F, 0x00, 0x43, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x88, 0x02, 0x0F,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x24, 0x00, 0x44, 0x00, 0x84, 0x01, 0x04, 0x02, 0x08, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20, 0x10, 0x7F, 0xFF, 0x80, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x07, 0xFE,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x1F, 0xC0, 0x20, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x44, 0x03, 0x07,
  0xF8, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x3F, 0x05, 0x03, 0x28, 0x04, 0xC0,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x01, 0x10,
  0x08, 0x40, 0x40, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x06, 0x10, 0x10, 0x10,
  0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x08, 0x04,
  0x60, 0x07, 0x00, 0x32, 0x01, 0x83, 0x04, 0x02, 0x10, 0x02, 0x20, 0x04,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x82, 0x02, 0x03, 0xF8, 0x00,
  0x01, 0xE0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x10, 0x80, 0xE0, 0x82,
  0x40, 0xF9, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x1F, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x18, 0x06, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x04, 0x08, 0x10, 0x40, 0x82, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x0F, 0x06, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x0E,
  0x01, 0x80, 0x40, 0x01, 0x02, 0x00, 0x02, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x14, 0x03, 0xF0, 0x50, 0x30, 0x41, 0x41, 0x01, 0x06, 0x08, 0x04, 0x18,
  0x20, 0x20, 0x60, 0x80, 0x81, 0x84, 0x02, 0x06, 0x10, 0x10, 0x28, 0x40,
  0x40, 0xA1, 0x02, 0x84, 0x82, 0x12, 0x22, 0x07, 0x86, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x7E, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02,
  0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x40, 0x20, 0x7F, 0xF0, 0x20, 0x08, 0x20, 0x04, 0x10, 0x02,
  0x10, 0x01, 0x10, 0x00, 0x48, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x08, 0x07,
  0xFE, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10,
  0x01, 0x10, 0x02, 0x10, 0x04, 0x1F, 0xF8, 0x10, 0x18, 0x20, 0x04, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40,
  0x08, 0x40, 0x30, 0xFF, 0xC0, 0x00, 0x7C, 0x03, 0x83, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x81, 0x01, 0xC0, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0x81, 0xC1, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x0F, 0xE8, 0x00, 0x14, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x02, 0x20, 0x01, 0x08, 0x00, 0x82, 0x00, 0xC0, 0xFF, 0x80,
  0x04, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04,
  0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x83, 0xFF, 0xF0,
  0x40, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x0C,
  0x00, 0x20, 0x07, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0xF8, 0x00, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x04, 0x00, 0xC1, 0x00,
  0x40, 0x80, 0x60, 0x20, 0x20, 0x08, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00,
  0x42, 0x00, 0x13, 0x00, 0x05, 0x40, 0x01, 0x90, 0x00, 0xC2, 0x00, 0x20,
  0x80, 0x08, 0x10, 0x02, 0x04, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x04,
  0x04, 0x01, 0x01, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0F,
  0xFE, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x28, 0x00, 0x28, 0x50, 0x00,
  0xA0, 0xA0, 0x01, 0x41, 0x40, 0x04, 0x84, 0x40, 0x09, 0x08, 0x80, 0x24,
  0x11, 0x00, 0x88, 0x22, 0x01, 0x10, 0x44, 0x04, 0x21, 0x08, 0x08, 0x42,
  0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x44, 0x08, 0x40,
  0x88, 0x10, 0x81, 0x20, 0x41, 0x01, 0x80, 0x82, 0x03, 0x01, 0x0C, 0x04,
  0x02, 0x00, 0x04, 0x00, 0x21, 0x80, 0x04, 0x28, 0x00, 0x85, 0x00, 0x20,
  0x90, 0x04, 0x12, 0x00, 0x84, 0x20, 0x10, 0x84, 0x04, 0x10, 0x80, 0x82,
  0x08, 0x10, 0x41, 0x02, 0x10, 0x10, 0x42, 0x02, 0x10, 0x40, 0x22, 0x08,
  0x04, 0x41, 0x00, 0x48, 0x40, 0x09, 0x08, 0x01, 0x41, 0x00, 0x18, 0x20,
  0x03, 0x0C, 0x00, 0x20, 0x01, 0xF0, 0x03, 0x06, 0x02, 0x00, 0x82, 0x00,
  0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x01, 0x08, 0x01, 0x82, 0x01,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10,
  0x18, 0x3F, 0xC0, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0x06, 0x02, 0x00, 0x82, 0x00, 0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20,
  0x01, 0x08, 0x01, 0x82, 0x01, 0x80, 0xF7, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x04, 0x02, 0x08,
  0x02, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x0C, 0x10, 0x70, 0x2F, 0xC0, 0x20, 0x40, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x08, 0xC0,
  0x08, 0x00, 0xE0, 0x18, 0x30, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x80, 0x43, 0xFE, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x10, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x01, 0x81,
  0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x81,
  0x02, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x24,
  0x00, 0x48, 0x00, 0xA0, 0x00, 0x80, 0x01, 0x00, 0x00, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0A, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x09, 0x00, 0x90,
  0x12, 0x02, 0x20, 0x44, 0x04, 0x40, 0x88, 0x10, 0x81, 0x10, 0x21, 0x04,
  0x20, 0x82, 0x08, 0x21, 0x04, 0x20, 0x44, 0x08, 0x40, 0x88, 0x11, 0x01,
  0x20, 0x22, 0x02, 0x40, 0x48, 0x04, 0x80, 0x90, 0x0A, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x60, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x01, 0x08,
  0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x50, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x20,
  0x80, 0x06, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x20, 0x81, 0x02, 0x08,
  0x08, 0x20, 0x11, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x1F, 0x80, 0x84, 0x20,
  0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x20, 0x80,
  0x07, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x80,
  0x00, 0x20, 0x01, 0x80, 0x0A, 0x00, 0x24, 0x01, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x88, 0x01, 0x40, 0x07, 0x00,
  0x10, 0xFF, 0xF0, 0x84, 0x22, 0x10, 0x07, 0xC8, 0xC1, 0x48, 0x06, 0x80,
  0x34, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x06, 0x40, 0x52, 0x05, 0x0F, 0xC8, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x7C, 0x16, 0x08,
  0x60, 0x12, 0x80, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0xA0, 0x12, 0x80, 0x89, 0xFC,
  0x00, 0x07, 0xF1, 0x80, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03,
  0xF8, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x03, 0xE2, 0x18, 0x24, 0x40, 0x29, 0x00, 0x22, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0xC4, 0x03, 0x08, 0x0A, 0x10, 0x24, 0x1F, 0x88, 0x00, 0x07, 0xC0, 0x82,
  0x10, 0x12, 0x01, 0x40, 0x14, 0x02, 0x80, 0xCF, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x43, 0xF8, 0x00, 0x0F, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x03,
  0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x03, 0xE2, 0x18,
  0x24, 0x40, 0x29, 0x00, 0x62, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0xC4, 0x03, 0x08, 0x0A, 0x10,
  0x24, 0x1F, 0x88, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x10, 0x10, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x7C, 0x16, 0x08, 0x60, 0x12, 0x80,
  0x4C, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x01, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x0F, 0x00, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x01, 0x10, 0x10, 0x81, 0x08,
  0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0xB0, 0x0A, 0x40, 0x62, 0x02, 0x08,
  0x10, 0x40, 0x81, 0x08, 0x08, 0x40, 0x22, 0x01, 0x80, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x00, 0x13, 0xE0, 0xF8, 0x50, 0x44, 0x11, 0x80, 0xA0, 0x4C,
  0x03, 0x01, 0x30, 0x08, 0x04, 0x80, 0x20, 0x12, 0x00, 0x80, 0x48, 0x04,
  0x01, 0x40, 0x10, 0x05, 0x00, 0x40, 0x14, 0x01, 0x00, 0x90, 0x08, 0x02,
  0x40, 0x20, 0x0A, 0x00, 0x80, 0x28, 0x02, 0x01, 0x20, 0x08, 0x04, 0x11,
  0xF0, 0x58, 0x21, 0x80, 0x4A, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x88,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x07, 0xE0, 0xC0, 0x88, 0x02, 0x80, 0x14, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01,
  0x40, 0x11, 0x01, 0x07, 0xF0, 0x04, 0x7C, 0x05, 0x82, 0x06, 0x01, 0x0A,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x28, 0x04, 0x28, 0x08, 0x27,
  0xF0, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x07, 0xC4, 0x60, 0x92, 0x01, 0x50, 0x06, 0x40, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x0C,
  0x80, 0x62, 0x02, 0x88, 0x12, 0x1F, 0x88, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x11, 0xE2, 0xC0, 0x60,
  0x14, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0xE1, 0x01, 0x10, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x80, 0xC7, 0xF0, 0x10, 0x10, 0x20, 0x20, 0xFF, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xF8, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x06, 0x40,
  0x52, 0x04, 0x8F, 0xC8, 0x80, 0x0A, 0x00, 0x90, 0x08, 0x80, 0x44, 0x04,
  0x20, 0x21, 0x02, 0x04, 0x10, 0x21, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02,
  0x40, 0x14, 0x00, 0x40, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x18, 0x14,
  0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x12, 0x11, 0x08,
  0x88, 0x42, 0x22, 0x11, 0x09, 0x02, 0x42, 0x40, 0xA0, 0xA0, 0x28, 0x28,
  0x0C, 0x04, 0x03, 0x01, 0x00, 0x80, 0x08, 0x02, 0x10, 0x08, 0x10, 0x20,
  0x20, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x00, 0x05,
  0x00, 0x11, 0x00, 0x42, 0x01, 0x04, 0x04, 0x04, 0x10, 0x08, 0x40, 0x08,
  0x08, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x20, 0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x18, 0x18, 0x00, 0x3C, 0x07, 0x0E, 0x30, 0x07, 0x00,
};

const GFXglyph NotoSans_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 6, 1, -21 },
  { 17, 7, 7, 9, 3, -21 },
  { 24, 18, 21, 18, 1, -21 },
  { 72, 13, 25, 17, 2, -23 },
  { 113, 18, 22, 23, 3, -22 },
  { 163, 18, 22, 20, 1, -22 },
  { 213, 3, 7, 5, 3, -21 },
  { 216, 8, 26, 7, 1, -21 },
  { 242, 8, 26, 7, -2, -21 },
  { 268, 12, 13, 16, 4, -23 },
  { 288, 14, 13, 17, 2, -17 },
  { 311, 4, 7, 5, -1, -3 },
  { 315, 7, 1, 9, 1, -9 },
  { 316, 2, 2, 6, 1, -2 },
  { 317, 13, 21, 9, -1, -21 },
  { 352, 14, 22, 17, 2, -22 },
  { 391, 7, 21, 17, 5, -21 },
  { 410, 15, 22, 17, 0, -22 },
  { 452, 15, 22, 17, 1, -22 },
  { 494, 16, 22, 17, 0, -22 },
  { 538, 15, 21, 17, 1, -21 },
  { 578, 14, 22, 17, 2, -22 },
  { 617, 14, 21, 17, 3, -21 },
  { 654, 15, 22, 17, 1, -22 },
  { 696, 15, 22, 17, 1, -22 },
  { 738, 5, 16, 6, 1, -16 },
  { 748, 7, 20, 6, -1, -16 },
  { 766, 14, 14, 17, 2, -18 },
  { 791, 14, 7, 17, 2, -14 },
  { 804, 14, 14, 17, 2, -18 },
  { 829, 11, 22, 12, 2, -22 },
  { 860, 22, 24, 25, 2, -21 },
  { 926, 17, 21, 16, -2, -21 },
  { 971, 16, 21, 18, 1, -21 },
  { 1013, 16, 22, 18, 3, -22 },
  { 1057, 18, 21, 20, 1, -21 },
  { 1105, 16, 21, 16, 1, -21 },
  { 1147, 16, 21, 15, 1, -21 },
  { 1189, 17, 22, 21, 3, -22 },
  { 1236, 19, 21, 20, 1, -21 },
  { 1286, 10, 21, 8, 0, -21 },
  { 1313, 12, 26, 7, -5, -21 },
  { 1352, 18, 21, 16, 1, -21 },
  { 1400, 11, 21, 15, 1, -21 },
  { 1429, 23, 21, 24, 1, -21 },
  { 1490, 19, 21, 20, 1, -21 },
  { 1540, 17, 22, 21, 3, -22 },
  { 1587, 16, 21, 17, 1, -21 },
  { 1629, 17, 27, 21, 3, -22 },
  { 1687, 16, 21, 17, 1, -21 },
  { 1729, 14, 22, 15, 1, -22 },
  { 1768, 14, 21, 15, 3, -21 },
  { 1805, 18, 21, 21, 3, -21 },
  { 1853, 15, 21, 16, 3, -21 },
  { 1893, 23, 21, 25, 4, -21 },
  { 1954, 19, 21, 15, -2, -21 },
  { 2004, 14, 21, 15, 3, -21 },
  { 2041, 17, 21, 16, 0, -21 },
  { 2086, 11, 26, 9, 0, -21 },
  { 2122, 5, 21, 9, 3, -21 },
  { 2136, 11, 26, 9, -2, -21 },
  { 2172, 14, 14, 17, 1, -22 },
  { 2197, 12, 1, 11, -3, 3 },
  { 2199, 4, 5, 7, 4, -23 },
  { 2202, 13, 16, 16, 2, -16 },
  { 2228, 14, 23, 17, 1, -23 },
  { 2269, 12, 16, 14, 2, -16 },
  { 2293, 15, 23, 17, 2, -23 },
  { 2337, 12, 16, 15, 2, -16 },
  { 2361, 16, 30, 8, -4, -23 },
  { 2421, 15, 23, 17, 1, -16 },
  { 2465, 14, 23, 17, 1, -23 },
  { 2506, 6, 22, 6, 1, -22 },
  { 2523, 11, 29, 6, -4, -22 },
  { 2563, 13, 23, 13, 1, -23 },
  { 2601, 6, 23, 6, 1, -23 },
  { 2619, 22, 16, 25, 1, -16 },
  { 2663, 14, 16, 17, 1, -16 },
  { 2691, 13, 16, 17, 2, -16 },
  { 2717, 16, 23, 17, -1, -16 },
  { 2763, 14, 23, 17, 2, -16 },
  { 2804, 11, 16, 11, 1, -16 },
  { 2826, 12, 16, 13, 0, -16 },
  { 2850, 8, 20, 9, 2, -20 },
  { 2870, 13, 16, 17, 2, -16 },
  { 2896, 13, 16, 12, 1, -16 },
  { 2922, 18, 16, 20, 2, -16 },
  { 2958, 15, 16, 14, -1, -16 },
  { 2988, 17, 23, 12, -3, -16 },
  { 3037, 13, 16, 13, 0, -16 },
  { 3063, 10, 26, 10, 1, -21 },
  { 3096, 1, 30, 16, 8, -23 },
  { 3100, 11, 26, 10, -2, -21 },
  { 3136, 14, 3, 17, 2, -12 },
};

const GFXfont NotoSans_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_THINITALIC30PT7B_H_
