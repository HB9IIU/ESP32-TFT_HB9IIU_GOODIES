#ifndef _NOTOSANS_THINITALIC22PT7B_H_
#define _NOTOSANS_THINITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x44, 0x00, 0x08, 0x4A, 0x52, 0x99,
  0x48, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80, 0x84, 0x3F, 0xFC, 0x21,
  0x01, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xF8, 0x42, 0x02, 0x10, 0x10, 0x80,
  0x88, 0x08, 0x40, 0x01, 0x00, 0x40, 0xFC, 0x48, 0x22, 0x08, 0x82, 0x40,
  0x90, 0x1C, 0x01, 0x80, 0x58, 0x22, 0x08, 0x82, 0x20, 0x93, 0xF8, 0x10,
  0x04, 0x00, 0x38, 0x09, 0x10, 0x44, 0x42, 0x21, 0x08, 0x84, 0x42, 0x12,
  0x08, 0x53, 0x22, 0x52, 0x8A, 0x85, 0xD2, 0x10, 0x48, 0x42, 0x41, 0x11,
  0x08, 0x84, 0x22, 0x11, 0x10, 0x3C, 0x07, 0x80, 0x42, 0x02, 0x08, 0x20,
  0x41, 0x04, 0x04, 0x40, 0x2C, 0x01, 0x80, 0x32, 0x02, 0x10, 0x60, 0x45,
  0x01, 0x28, 0x06, 0x40, 0x22, 0x06, 0x8F, 0xC2, 0x55, 0xA0, 0x04, 0x21,
  0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C,
  0x00, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21,
  0x04, 0x21, 0x08, 0x00, 0x04, 0x04, 0x22, 0x09, 0x03, 0x78, 0xC0, 0xA0,
  0x88, 0x84, 0x02, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x25, 0x29, 0x00, 0xF8, 0x80, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09,
  0x01, 0x10, 0x41, 0xF0, 0x09, 0xD3, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x07, 0xC1, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x07, 0xFC,
  0x07, 0xC1, 0x82, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0xF8,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x40, 0x04, 0x80, 0x87, 0xF0,
  0x00, 0x20, 0x06, 0x00, 0xA0, 0x12, 0x02, 0x40, 0x24, 0x04, 0x40, 0x84,
  0x10, 0x42, 0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x0F, 0xE2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0B, 0x01, 0x98, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x47, 0xF0, 0x03, 0xE1,
  0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x13, 0xC3, 0x84, 0x40, 0x48, 0x0A,
  0x01, 0x40, 0x28, 0x04, 0x81, 0x10, 0x41, 0xF0, 0xFF, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x0F, 0x82, 0x08, 0x40, 0x90, 0x12, 0x02, 0x20, 0x84, 0x20,
  0x78, 0x19, 0x0C, 0x12, 0x02, 0x40, 0x28, 0x05, 0x01, 0x20, 0x63, 0xF0,
  0x0F, 0x82, 0x08, 0x81, 0x10, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x20,
  0xC3, 0xE8, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x87, 0xE0, 0x24, 0x00,
  0x00, 0x00, 0x40, 0x08, 0x40, 0x00, 0x00, 0x00, 0x01, 0x08, 0x84, 0x42,
  0x00, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x70, 0x60, 0x60, 0x20, 0x00, 0x7C, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x41, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xB0, 0x03, 0x86, 0x02, 0x00, 0x82, 0x00, 0x22, 0x00, 0x0A, 0x0F,
  0x85, 0x08, 0x43, 0x08, 0x21, 0x84, 0x10, 0xC4, 0x08, 0x62, 0x08, 0x51,
  0x04, 0x28, 0x46, 0x24, 0x1C, 0xE1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x10,
  0x07, 0xF0, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x14, 0x02, 0x40, 0x22,
  0x04, 0x20, 0x42, 0x08, 0x20, 0xFE, 0x10, 0x22, 0x02, 0x20, 0x14, 0x01,
  0x40, 0x18, 0x01, 0x1F, 0xC1, 0x02, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02,
  0x20, 0x63, 0xF8, 0x40, 0x44, 0x04, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04,
  0x80, 0x8F, 0xF0, 0x07, 0xE0, 0x81, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x03, 0xF8, 0x1F, 0x80, 0x83, 0x04, 0x04, 0x20, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02,
  0x40, 0x22, 0x06, 0x1F, 0xC0, 0x1F, 0xE2, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x07, 0xF8, 0x1F, 0xE2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x3F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x07, 0xF0, 0x40, 0x44, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x81, 0xF4, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x11,
  0x00, 0x87, 0xF8, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x20, 0x08,
  0x80, 0x22, 0x00, 0x8F, 0xFC, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04,
  0x40, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x1E, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x78, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x1E, 0x00, 0x10, 0x08, 0x81, 0x84,
  0x10, 0x21, 0x02, 0x10, 0x11, 0x00, 0x90, 0x05, 0x80, 0x74, 0x02, 0x10,
  0x10, 0x80, 0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0xFF, 0x10, 0x00, 0x88, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x62, 0x80,
  0x51, 0x40, 0x48, 0x90, 0x24, 0x48, 0x24, 0x44, 0x12, 0x22, 0x11, 0x11,
  0x10, 0x88, 0x88, 0x84, 0x28, 0x44, 0x14, 0x22, 0x0C, 0x11, 0x04, 0x08,
  0x10, 0x04, 0x40, 0x11, 0x80, 0x86, 0x02, 0x24, 0x08, 0x90, 0x22, 0x20,
  0x88, 0x84, 0x41, 0x11, 0x04, 0x44, 0x11, 0x10, 0x24, 0x40, 0xA2, 0x01,
  0x88, 0x06, 0x20, 0x08, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x80, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28,
  0x02, 0x40, 0x11, 0x01, 0x07, 0xF0, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x12,
  0x02, 0x40, 0x48, 0x09, 0x02, 0x43, 0x8F, 0x81, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x80, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28,
  0x02, 0x40, 0x11, 0x01, 0x07, 0x70, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02,
  0x3F, 0x88, 0x41, 0x04, 0x20, 0x84, 0x11, 0x01, 0x20, 0x24, 0x04, 0x07,
  0xE1, 0x00, 0x40, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x01, 0x00, 0x27, 0xF8, 0xFF, 0xE0, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x21, 0x02, 0x07, 0xE0, 0x80, 0x30, 0x06,
  0x01, 0x40, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x10,
  0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xA0,
  0x60, 0x50, 0x50, 0x48, 0x28, 0x24, 0x24, 0x22, 0x12, 0x11, 0x11, 0x08,
  0x88, 0x88, 0x48, 0x44, 0x24, 0x24, 0x14, 0x12, 0x0A, 0x0A, 0x06, 0x03,
  0x03, 0x01, 0x01, 0x00, 0x80, 0x10, 0x08, 0x40, 0x42, 0x04, 0x08, 0x40,
  0x44, 0x02, 0x40, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x28, 0x02, 0x40, 0x21,
  0x02, 0x08, 0x10, 0x21, 0x01, 0x10, 0x08, 0x80, 0x30, 0x09, 0x02, 0x20,
  0x44, 0x10, 0x84, 0x09, 0x01, 0x20, 0x28, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x1F, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0xF0, 0x88, 0x88, 0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x0F, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x3E, 0x00, 0x01, 0x00, 0xC0, 0x50,
  0x22, 0x08, 0x84, 0x22, 0x08, 0x81, 0x40, 0x60, 0x10, 0xFF, 0x89, 0x10,
  0x0F, 0x44, 0x32, 0x0D, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x48, 0x31, 0xF4, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x09, 0xE3, 0x85,
  0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x0B, 0x04, 0xBE,
  0x00, 0x0F, 0x88, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x07, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF2,
  0x10, 0xA2, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08,
  0x81, 0x88, 0x28, 0x7C, 0x80, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x1C, 0x73,
  0xC1, 0x00, 0x80, 0x40, 0x10, 0x07, 0xC0, 0x00, 0xF0, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x0E, 0x00, 0x0F, 0x22, 0x14, 0x81, 0x20, 0x24, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0x80, 0x90, 0x32, 0x0A, 0x3E, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x10, 0xFC, 0x00, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x09, 0xE3,
  0x85, 0x81, 0x20, 0x50, 0x14, 0x05, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x00, 0x11, 0x00, 0x22, 0x44, 0x44, 0x48, 0x88, 0x88, 0x01, 0x01,
  0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xE0, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x32, 0x11, 0x08, 0x44, 0x12, 0x05, 0x01, 0xA0, 0x48, 0x21,
  0x08, 0x42, 0x08, 0x82, 0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x44, 0x88,
  0x88, 0x80, 0x2F, 0x0E, 0x30, 0xB1, 0x60, 0xC1, 0x40, 0xC1, 0x40, 0x81,
  0x40, 0x81, 0x40, 0x81, 0x80, 0x81, 0x81, 0x02, 0x81, 0x02, 0x81, 0x02,
  0x81, 0x02, 0x27, 0x8E, 0x16, 0x04, 0x81, 0x40, 0x50, 0x14, 0x0A, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x04, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x10, 0xF8, 0x13, 0xC3, 0x84, 0xC0,
  0x88, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x82, 0x2F,
  0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x0F, 0x22, 0x14, 0x81,
  0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x32, 0x0A, 0x3E,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x27, 0x38, 0x60, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x10, 0x48, 0x04,
  0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x9F, 0x80, 0x10, 0x82,
  0x3F, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0F, 0x00, 0x20, 0x48,
  0x14, 0x05, 0x01, 0x40, 0x50, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x31,
  0xF4, 0x80, 0xC0, 0x60, 0x50, 0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28,
  0x18, 0x04, 0x00, 0x81, 0x06, 0x08, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12,
  0x24, 0x49, 0x12, 0x24, 0x48, 0xA1, 0x41, 0x85, 0x04, 0x08, 0x10, 0x20,
  0x10, 0x22, 0x08, 0x21, 0x04, 0x40, 0x50, 0x0C, 0x01, 0x00, 0x50, 0x11,
  0x04, 0x21, 0x02, 0x60, 0x40, 0x08, 0x08, 0x40, 0x42, 0x04, 0x10, 0x20,
  0x42, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x28, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x20,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x03, 0xFC,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x21, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x0C, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x70, 0x63, 0xE0,
};

const GFXglyph NotoSans_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 5, 6, 7, 2, -16 },
  { 13, 13, 16, 14, 1, -16 },
  { 39, 10, 18, 12, 1, -17 },
  { 62, 14, 16, 17, 2, -16 },
  { 90, 13, 16, 15, 1, -16 },
  { 116, 2, 6, 4, 2, -16 },
  { 118, 6, 19, 5, 1, -16 },
  { 133, 6, 19, 5, -1, -16 },
  { 148, 9, 10, 12, 3, -17 },
  { 160, 10, 10, 13, 2, -13 },
  { 173, 3, 6, 4, -1, -3 },
  { 176, 5, 1, 7, 1, -6 },
  { 177, 1, 1, 5, 1, -1 },
  { 178, 10, 16, 7, -1, -16 },
  { 198, 11, 16, 12, 1, -16 },
  { 220, 5, 16, 12, 4, -16 },
  { 230, 11, 16, 12, 0, -16 },
  { 252, 12, 16, 12, 0, -16 },
  { 276, 12, 16, 12, 0, -16 },
  { 300, 11, 16, 12, 1, -16 },
  { 322, 11, 16, 12, 1, -16 },
  { 344, 9, 16, 12, 3, -16 },
  { 362, 11, 16, 12, 1, -16 },
  { 384, 11, 16, 12, 1, -16 },
  { 406, 3, 12, 5, 1, -12 },
  { 411, 5, 15, 5, -1, -12 },
  { 421, 10, 10, 13, 2, -13 },
  { 434, 10, 5, 13, 2, -10 },
  { 441, 10, 10, 13, 2, -13 },
  { 454, 7, 16, 9, 2, -16 },
  { 468, 17, 18, 18, 1, -16 },
  { 507, 12, 16, 12, -1, -16 },
  { 531, 12, 16, 13, 1, -16 },
  { 555, 12, 16, 13, 2, -16 },
  { 579, 13, 16, 15, 1, -16 },
  { 605, 11, 16, 12, 1, -16 },
  { 627, 11, 16, 11, 1, -16 },
  { 649, 13, 16, 15, 2, -16 },
  { 675, 14, 16, 15, 1, -16 },
  { 703, 7, 16, 6, 0, -16 },
  { 717, 9, 20, 5, -4, -16 },
  { 740, 13, 16, 12, 1, -16 },
  { 766, 8, 16, 11, 1, -16 },
  { 782, 17, 16, 18, 1, -16 },
  { 816, 14, 16, 15, 1, -16 },
  { 844, 13, 16, 16, 2, -16 },
  { 870, 11, 16, 12, 1, -16 },
  { 892, 13, 20, 16, 2, -16 },
  { 925, 11, 16, 12, 1, -16 },
  { 947, 11, 16, 11, 0, -16 },
  { 969, 11, 16, 11, 2, -16 },
  { 991, 13, 16, 15, 2, -16 },
  { 1017, 11, 16, 12, 2, -16 },
  { 1039, 17, 16, 18, 3, -16 },
  { 1073, 13, 16, 11, -1, -16 },
  { 1099, 11, 16, 11, 2, -16 },
  { 1121, 13, 16, 12, 0, -16 },
  { 1147, 8, 19, 7, 0, -16 },
  { 1166, 4, 16, 7, 2, -16 },
  { 1174, 9, 19, 7, -2, -16 },
  { 1196, 10, 10, 12, 1, -16 },
  { 1209, 8, 1, 8, -2, 2 },
  { 1210, 3, 4, 5, 3, -17 },
  { 1212, 10, 12, 12, 1, -12 },
  { 1227, 10, 17, 13, 1, -17 },
  { 1249, 9, 12, 10, 1, -12 },
  { 1263, 12, 17, 13, 1, -17 },
  { 1289, 9, 12, 11, 1, -12 },
  { 1303, 12, 22, 6, -3, -17 },
  { 1336, 11, 17, 13, 1, -12 },
  { 1360, 10, 17, 12, 1, -17 },
  { 1382, 4, 16, 5, 1, -16 },
  { 1390, 8, 21, 5, -3, -16 },
  { 1411, 10, 17, 10, 1, -17 },
  { 1433, 4, 17, 5, 1, -17 },
  { 1442, 16, 12, 19, 1, -12 },
  { 1466, 10, 12, 12, 1, -12 },
  { 1481, 10, 12, 12, 1, -12 },
  { 1496, 11, 17, 13, 0, -12 },
  { 1520, 11, 17, 13, 1, -12 },
  { 1544, 8, 12, 8, 1, -12 },
  { 1556, 9, 12, 9, 0, -12 },
  { 1570, 6, 15, 7, 1, -15 },
  { 1582, 10, 12, 12, 1, -12 },
  { 1597, 9, 12, 9, 1, -12 },
  { 1611, 14, 12, 14, 1, -12 },
  { 1632, 11, 12, 10, -1, -12 },
  { 1649, 13, 17, 9, -3, -12 },
  { 1677, 10, 12, 10, 0, -12 },
  { 1692, 7, 19, 7, 1, -16 },
  { 1709, 1, 22, 12, 6, -17 },
  { 1712, 8, 20, 7, -1, -16 },
  { 1732, 10, 2, 13, 2, -9 },
};

const GFXfont NotoSans_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_THINITALIC22PT7B_H_
