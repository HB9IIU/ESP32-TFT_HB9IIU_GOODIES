#ifndef _NOTOSANS_THINITALIC67PT7B_H_
#define _NOTOSANS_THINITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x00, 0x0C, 0x06, 0x10,
  0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x84, 0x02, 0x18, 0x04,
  0x30, 0x18, 0x60, 0x30, 0x80, 0x61, 0x00, 0x86, 0x01, 0x0C, 0x06, 0x10,
  0x0C, 0x20, 0x10, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1E, 0x08, 0x0E, 0x00, 0xE0, 0x10, 0x04, 0x03, 0x80, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x38,
  0x20, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x38, 0x0C, 0x00, 0xC0, 0xE0, 0x1F,
  0xC1, 0x8F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x06, 0x00, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x02,
  0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x18, 0x00, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x18, 0x1F, 0xC6, 0x00, 0x08, 0x18, 0x1E, 0xF3, 0x00, 0x0C, 0x0C, 0x38,
  0x0D, 0x80, 0x06, 0x0C, 0x18, 0x03, 0xC0, 0x06, 0x0C, 0x18, 0x01, 0xE0,
  0x06, 0x0C, 0x18, 0x00, 0xF8, 0x03, 0x06, 0x0C, 0x00, 0x6C, 0x03, 0x06,
  0x0C, 0x00, 0x13, 0x87, 0x06, 0x06, 0x00, 0x08, 0xFF, 0x06, 0x06, 0x00,
  0x04, 0x08, 0x03, 0x03, 0x00, 0x02, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x10, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00, 0x20, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x30, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x60, 0x00, 0x01, 0x80, 0x30, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0xC0, 0x00, 0x00, 0x60,
  0xC0, 0xC0, 0x00, 0x00, 0x31, 0x80, 0xC0, 0x00, 0x00, 0x19, 0x80, 0xC0,
  0x00, 0x00, 0x1B, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x60, 0x00, 0x00, 0x73, 0x00,
  0x70, 0x00, 0x00, 0xC1, 0x80, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x60, 0x03, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C,
  0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x07,
  0x00, 0x80, 0x00, 0x38, 0x10, 0x00, 0x03, 0x82, 0x00, 0x00, 0x1C, 0xC0,
  0x02, 0x00, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x18, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x02, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80,
  0x04, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x27, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x33,
  0x00, 0xE2, 0x01, 0x86, 0x07, 0x06, 0x0C, 0x06, 0x38, 0x06, 0xE0, 0x0C,
  0x40, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x07, 0x00, 0x04, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xB0, 0x00, 0x00, 0x2F,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x18, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x01, 0xFF, 0xC0, 0x06, 0x0F, 0x83, 0xC0,
  0x08, 0x70, 0x00, 0xE0, 0x31, 0x80, 0x00, 0xE0, 0x66, 0x00, 0x00, 0xC0,
  0xD8, 0x00, 0x00, 0xC1, 0x60, 0x00, 0x01, 0x87, 0x80, 0x00, 0x01, 0x0E,
  0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x07, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x36, 0x06, 0x00, 0x00, 0x66,
  0x03, 0x00, 0x00, 0xCC, 0x01, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0x1E, 0x0C,
  0x00, 0x3F, 0xF8, 0x08, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x03, 0x80, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0x3E,
  0x07, 0x80, 0xE0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x20, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x0C, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x18, 0x00, 0x1C,
  0x00, 0x10, 0x00, 0xCC, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x0C, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x60, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0xD8, 0x00, 0x60, 0x00, 0x18, 0x00, 0x36, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x02, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x2C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x1B, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06,
  0xC0, 0x04, 0x00, 0x01, 0x80, 0x01, 0xB0, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xCC, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x33, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x18, 0xC0, 0x0C, 0x00, 0x07, 0x80, 0x06, 0x30, 0x01, 0x00, 0x01, 0x60,
  0x03, 0x0C, 0x00, 0x60, 0x00, 0xD8, 0x01, 0xC3, 0x00, 0x18, 0x00, 0x66,
  0x00, 0xE0, 0xC0, 0x03, 0x00, 0x31, 0x80, 0x70, 0x30, 0x00, 0xE0, 0x38,
  0x30, 0x78, 0x06, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x01, 0x00,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1E, 0x00,
  0x30, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x10,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x3E,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x04, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xFF, 0xFE,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x20, 0x3C, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00,
  0x61, 0xF0, 0x00, 0x00, 0x00, 0xC6, 0x60, 0x00, 0x00, 0x01, 0x18, 0x60,
  0x00, 0x00, 0x06, 0x60, 0xC0, 0x00, 0x00, 0x0D, 0x81, 0xC0, 0x00, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x02, 0xC0, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x1B, 0x00, 0x00, 0x00,
  0x03, 0x20, 0x03, 0x20, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x44, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x03, 0x18, 0x00,
  0x00, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x30, 0x01, 0x04, 0x00, 0x00, 0x01, 0x86, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x04, 0x04, 0x00, 0x00, 0x18, 0x18, 0x01, 0x80, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x02, 0x00, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x80,
  0x0C, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x86, 0x00, 0x02, 0x00, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x02, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x64,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x2C, 0x00, 0x00,
  0x01, 0x80, 0x1B, 0x00, 0x00, 0x00, 0x60, 0x06, 0x40, 0x00, 0x00, 0x10,
  0x01, 0x98, 0x00, 0x00, 0x04, 0x00, 0x46, 0x00, 0x00, 0x03, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x03, 0x06, 0x00,
  0x00, 0x08, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x03, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x60, 0x00, 0x04, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x04, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x30, 0x00, 0x06, 0x01, 0x80, 0x08,
  0x00, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x00, 0x30, 0x18, 0x01, 0x80, 0x00,
  0x04, 0x06, 0x00, 0x60, 0x00, 0x01, 0x81, 0x00, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x03, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00, 0x00, 0x18, 0x80, 0x0C, 0x00,
  0x00, 0x02, 0x60, 0x06, 0x00, 0x00, 0x00, 0xD8, 0x01, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x20, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x08, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x08, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x06, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x06, 0x00, 0x60, 0x00, 0x80, 0x10,
  0x00, 0x40, 0x06, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x20, 0x02,
  0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x20,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x20, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x20, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x08, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x2E, 0x00,
  0x00, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xC1,
  0x81, 0x83, 0x03, 0x06, 0x06, 0x06, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x04, 0x00, 0xF0, 0x0E, 0x18, 0x03, 0x80, 0x06, 0x30, 0x0C,
  0x00, 0x0C, 0x40, 0x30, 0x00, 0x0C, 0x80, 0xC0, 0x00, 0x0B, 0x03, 0x00,
  0x00, 0x1E, 0x06, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x81,
  0x00, 0x00, 0x07, 0x02, 0x00, 0x00, 0x16, 0x06, 0x00, 0x00, 0x68, 0x0C,
  0x00, 0x01, 0x90, 0x18, 0x00, 0x06, 0x60, 0x18, 0x00, 0x18, 0xC0, 0x38,
  0x00, 0x61, 0x00, 0x38, 0x01, 0x82, 0x00, 0x38, 0x1E, 0x04, 0x00, 0x3F,
  0xF0, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x3F, 0x80, 0x01,
  0x80, 0xFF, 0xE0, 0x01, 0x83, 0x80, 0x38, 0x01, 0x86, 0x00, 0x1C, 0x01,
  0x9C, 0x00, 0x0C, 0x01, 0x18, 0x00, 0x06, 0x03, 0x30, 0x00, 0x06, 0x03,
  0x60, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0x02, 0x80, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x28,
  0x00, 0x00, 0x30, 0x2C, 0x00, 0x00, 0x60, 0x6C, 0x00, 0x00, 0xE0, 0x66,
  0x00, 0x01, 0xC0, 0x46, 0x00, 0x03, 0x80, 0x43, 0x80, 0x0F, 0x00, 0xC1,
  0xE0, 0x3C, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xE0, 0x18, 0x00, 0x0F, 0xFF, 0x81, 0x00, 0x03, 0xC0, 0x1C,
  0x30, 0x00, 0x70, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x03, 0x30, 0x01, 0x80,
  0x00, 0x33, 0x00, 0x30, 0x00, 0x01, 0xA0, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x0E,
  0x00, 0x40, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x36, 0x00, 0x60, 0x00,
  0x06, 0x40, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x03,
  0x80, 0x03, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x3C, 0x08,
  0x00, 0x07, 0xFF, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x18, 0x00, 0x03,
  0xC3, 0x00, 0x01, 0xE0, 0x60, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x40, 0x01, 0xFF, 0xF0, 0x20, 0x01, 0xE0,
  0x0E, 0x08, 0x00, 0xE0, 0x00, 0xC6, 0x00, 0x60, 0x00, 0x19, 0x80, 0x30,
  0x00, 0x06, 0x60, 0x18, 0x00, 0x00, 0xD0, 0x0C, 0x00, 0x00, 0x34, 0x03,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x1C, 0x02, 0x00, 0x00, 0x05, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x30, 0x00, 0x01, 0xB0, 0x0C, 0x00, 0x00, 0xC8, 0x03, 0x00, 0x00, 0x62,
  0x00, 0x60, 0x00, 0x31, 0x80, 0x1C, 0x00, 0x18, 0x60, 0x03, 0x80, 0x1C,
  0x18, 0x00, 0x78, 0x1E, 0x04, 0x00, 0x0F, 0xFE, 0x03, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0x01, 0x80, 0xFF, 0xF0,
  0x03, 0x07, 0x00, 0x70, 0x06, 0x18, 0x00, 0x70, 0x0C, 0x60, 0x00, 0x60,
  0x11, 0x80, 0x00, 0x60, 0x66, 0x00, 0x00, 0xC0, 0xD8, 0x00, 0x01, 0x81,
  0xE0, 0x00, 0x03, 0x02, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x81, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x02, 0x00, 0x38, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x31, 0x98, 0x00, 0x00, 0x8C, 0x60,
  0x00, 0x06, 0x60, 0xC0, 0x00, 0x1B, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x18, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x38, 0x01, 0x81,
  0xC0, 0x06, 0x01, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC0, 0x4C, 0x00, 0x0C,
  0x70, 0x00, 0x30, 0x36, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x0D, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0xA0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0x01, 0xFF, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x0C, 0x30,
  0x00, 0xE0, 0x11, 0xC0, 0x00, 0xC0, 0x23, 0x00, 0x00, 0xC0, 0xCC, 0x00,
  0x01, 0x81, 0xB0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x06, 0x05, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x03, 0xFF, 0x80, 0x00, 0xC1,
  0xC0, 0x1C, 0x00, 0x18, 0x60, 0x01, 0xC0, 0x02, 0x38, 0x00, 0x18, 0x00,
  0x46, 0x00, 0x01, 0x80, 0x19, 0x80, 0x00, 0x30, 0x03, 0x60, 0x00, 0x03,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x0A, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x50, 0x00, 0x00, 0x60, 0x0B, 0x00, 0x00, 0x18,
  0x03, 0x60, 0x00, 0x07, 0x00, 0x66, 0x00, 0x01, 0xC0, 0x0C, 0xC0, 0x00,
  0x70, 0x01, 0x0E, 0x00, 0x3C, 0x00, 0x60, 0xF0, 0x1E, 0x00, 0x0C, 0x07,
  0xFF, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0x80, 0x0F, 0x00,
  0x70, 0x40, 0x0E, 0x00, 0x0C, 0x60, 0x0C, 0x00, 0x03, 0x30, 0x0C, 0x00,
  0x01, 0x98, 0x0C, 0x00, 0x00, 0x68, 0x0C, 0x00, 0x00, 0x34, 0x06, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70,
  0x10, 0x00, 0x00, 0x28, 0x08, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x36,
  0x03, 0x00, 0x00, 0x32, 0x01, 0x80, 0x00, 0x31, 0x00, 0x60, 0x00, 0x39,
  0x80, 0x38, 0x00, 0x30, 0xC0, 0x0E, 0x00, 0x70, 0x60, 0x03, 0xC0, 0xF0,
  0x20, 0x00, 0xFF, 0xE0, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0x81, 0xFF, 0x01, 0x83, 0x80, 0x01, 0x8E, 0x00,
  0x01, 0x1C, 0x00, 0x01, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x1E, 0x00, 0x3C, 0x0E, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x1C, 0x0F, 0xC0, 0x3C, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x0F, 0xFF,
  0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x1F, 0xF8, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03,
  0x81, 0x00, 0x00, 0x07, 0x02, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x00, 0x6C,
  0x0C, 0x00, 0x00, 0xD0, 0x18, 0x00, 0x03, 0x20, 0x30, 0x00, 0x0C, 0xC0,
  0x30, 0x00, 0x71, 0x80, 0x70, 0x01, 0xC3, 0x00, 0x78, 0x1E, 0x04, 0x00,
  0x7F, 0xF0, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x74,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x6C, 0x00, 0x03,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0x30, 0x00, 0x1B, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x43,
  0x00, 0x03, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00, 0x08, 0x30, 0x00,
  0x61, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x18,
  0x04, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x00, 0x30, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x04, 0x03, 0x00,
  0x20, 0x18, 0x01, 0x80, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x03,
  0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x82, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x04,
  0x40, 0x00, 0x66, 0x00, 0x01, 0x30, 0x00, 0x1B, 0x00, 0x00, 0x48, 0x00,
  0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x05, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x68, 0x00, 0x0F, 0x87,
  0x90, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph NotoSans_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 49, 14, 2, -48 },
  { 81, 15, 17, 21, 7, -48 },
  { 113, 40, 48, 41, 2, -48 },
  { 353, 31, 55, 37, 3, -51 },
  { 567, 41, 50, 51, 6, -49 },
  { 824, 40, 50, 46, 3, -49 },
  { 1074, 6, 17, 12, 7, -48 },
  { 1087, 19, 59, 16, 2, -48 },
  { 1228, 18, 59, 16, -4, -48 },
  { 1361, 27, 28, 36, 9, -51 },
  { 1456, 31, 31, 38, 5, -39 },
  { 1577, 9, 17, 12, -3, -8 },
  { 1597, 15, 2, 21, 3, -19 },
  { 1601, 4, 5, 14, 2, -4 },
  { 1604, 29, 48, 21, -3, -48 },
  { 1778, 31, 50, 37, 4, -49 },
  { 1972, 16, 48, 37, 11, -48 },
  { 2068, 33, 49, 37, 1, -49 },
  { 2271, 34, 50, 37, 1, -49 },
  { 2484, 34, 48, 37, 1, -48 },
  { 2688, 33, 49, 37, 3, -48 },
  { 2891, 31, 50, 37, 5, -49 },
  { 3085, 30, 48, 37, 8, -48 },
  { 3265, 33, 50, 37, 3, -49 },
  { 3472, 32, 50, 37, 3, -49 },
  { 3672, 10, 37, 14, 2, -36 },
  { 3719, 15, 45, 14, -3, -36 },
  { 3804, 31, 30, 38, 5, -39 },
  { 3921, 31, 15, 38, 5, -31 },
  { 3980, 31, 30, 38, 5, -39 },
  { 4097, 23, 50, 27, 5, -49 },
  { 4241, 50, 53, 56, 4, -47 },
  { 4573, 36, 48, 37, -3, -48 },
  { 4789, 36, 48, 40, 3, -48 },
  { 5005, 36, 50, 40, 6, -49 },
  { 5230, 40, 48, 45, 3, -48 },
  { 5470, 34, 48, 36, 3, -48 },
  { 5674, 35, 48, 33, 3, -48 },
  { 5884, 38, 50, 46, 6, -49 },
  { 6122, 42, 48, 46, 3, -48 },
  { 6374, 20, 48, 19, 1, -48 },
  { 6494, 26, 60, 15, -11, -48 },
  { 6689, 39, 48, 36, 3, -48 },
  { 6923, 25, 48, 33, 3, -48 },
  { 7073, 51, 48, 54, 3, -48 },
  { 7379, 42, 48, 45, 3, -48 },
  { 7631, 39, 50, 48, 6, -49 },
  { 7875, 34, 48, 37, 3, -48 },
  { 8079, 39, 60, 48, 6, -49 },
  { 8372, 34, 48, 38, 3, -48 },
  { 8576, 33, 50, 33, 1, -49 },
  { 8783, 33, 48, 33, 6, -48 },
  { 8981, 40, 49, 46, 6, -48 },
  { 9226, 34, 48, 36, 7, -48 },
  { 9430, 52, 48, 55, 8, -48 },
  { 9742, 42, 48, 33, -4, -48 },
  { 9994, 33, 48, 33, 6, -48 },
  { 10192, 39, 48, 36, -1, -48 },
  { 10426, 26, 59, 20, -1, -48 },
  { 10618, 10, 48, 21, 7, -48 },
  { 10678, 26, 59, 20, -5, -48 },
  { 10870, 31, 29, 37, 3, -48 },
  { 10983, 26, 2, 25, -6, 7 },
  { 10990, 7, 10, 15, 10, -51 },
  { 10999, 31, 37, 37, 3, -36 },
  { 11143, 32, 52, 38, 2, -51 },
  { 11351, 27, 37, 30, 4, -36 },
  { 11476, 36, 52, 38, 3, -51 },
  { 11710, 27, 37, 33, 4, -36 },
  { 11835, 37, 67, 18, -9, -51 },
  { 12145, 34, 52, 38, 2, -36 },
  { 12366, 31, 51, 37, 2, -51 },
  { 12564, 13, 48, 14, 2, -48 },
  { 12642, 25, 64, 14, -10, -48 },
  { 12842, 30, 51, 29, 2, -51 },
  { 13034, 13, 51, 14, 2, -51 },
  { 13117, 50, 36, 56, 2, -36 },
  { 13342, 31, 36, 37, 2, -36 },
  { 13482, 30, 37, 38, 4, -36 },
  { 13621, 35, 52, 38, -1, -36 },
  { 13849, 33, 52, 38, 3, -36 },
  { 14064, 24, 36, 25, 2, -36 },
  { 14172, 26, 37, 28, 1, -36 },
  { 14293, 19, 45, 21, 3, -44 },
  { 14400, 31, 36, 37, 4, -35 },
  { 14540, 28, 35, 27, 3, -35 },
  { 14663, 42, 35, 44, 4, -35 },
  { 14847, 33, 35, 30, -2, -35 },
  { 14992, 39, 51, 27, -8, -35 },
  { 15241, 30, 35, 29, -1, -35 },
  { 15373, 24, 59, 22, 2, -48 },
  { 15550, 2, 67, 36, 19, -51 },
  { 15567, 23, 59, 22, -3, -48 },
  { 15737, 31, 6, 38, 5, -27 },
};

const GFXfont NotoSans_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_THINITALIC67PT7B_H_
