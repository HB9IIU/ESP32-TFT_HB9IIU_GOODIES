#ifndef _NOTOSANS_THINITALIC61PT7B_H_
#define _NOTOSANS_THINITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x18, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x23, 0x03, 0x10, 0x18,
  0x80, 0xCC, 0x04, 0x60, 0x22, 0x03, 0x10, 0x18, 0x80, 0x8C, 0x04, 0x60,
  0x22, 0x03, 0x10, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xA7, 0xE0, 0x07,
  0x82, 0x07, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x08,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0x00, 0x00,
  0x0E, 0x10, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x0C, 0x08, 0x01, 0x01, 0x80, 0xE0, 0x10, 0x70, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x07, 0x3C,
  0x00, 0x00, 0xC0, 0x30, 0x30, 0x00, 0x06, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x02, 0x00, 0x06, 0x01, 0x80, 0x08,
  0x00, 0x30, 0x04, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x80, 0x02, 0x00, 0x30, 0x06, 0x00, 0x08, 0x01, 0x80, 0x18, 0x00, 0x20,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x20, 0x01, 0x00, 0x06, 0x01, 0x80, 0x04,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x01, 0x01,
  0x00, 0x03, 0x00, 0x0C, 0x0C, 0x06, 0x0C, 0x00, 0x30, 0x60, 0xFF, 0x30,
  0x00, 0x83, 0x06, 0x0E, 0xC0, 0x06, 0x0C, 0x30, 0x1B, 0x00, 0x10, 0x61,
  0x80, 0x34, 0x00, 0xC3, 0x0C, 0x00, 0xD8, 0x06, 0x18, 0x30, 0x03, 0x70,
  0x30, 0x61, 0x80, 0x04, 0xF7, 0x83, 0x06, 0x00, 0x11, 0xF8, 0x18, 0x10,
  0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x02, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x10, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x02, 0x00, 0x80,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06,
  0x01, 0x80, 0x00, 0x38, 0x30, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x04, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0xC0, 0x02, 0x00, 0x02,
  0x18, 0x00, 0x30, 0x00, 0x63, 0x00, 0x01, 0x80, 0x04, 0x60, 0x00, 0x0C,
  0x00, 0xC6, 0x00, 0x00, 0xC0, 0x18, 0x40, 0x00, 0x06, 0x01, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0xC0, 0x00, 0x01, 0x06, 0x0C, 0x00, 0x00, 0x18, 0xC0,
  0xC0, 0x00, 0x00, 0xD8, 0x0C, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x70, 0x00, 0x0E, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x60,
  0x1E, 0x00, 0xF0, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x10, 0x8C, 0x62, 0x10,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0xE0, 0x10, 0x00, 0x38, 0x08, 0x00, 0x07, 0x04, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x1A, 0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x01, 0xA0,
  0x00, 0x01, 0x90, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x20, 0x1C, 0xC0, 0x61, 0x83, 0x83, 0x0C, 0x04, 0x70, 0x19, 0x80, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x78, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0x81, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x00, 0x0C,
  0x1F, 0xFE, 0x00, 0x61, 0xC0, 0x1C, 0x02, 0x38, 0x00, 0x70, 0x13, 0x00,
  0x01, 0x81, 0xB0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x10, 0x70, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x40, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x78, 0x30,
  0x00, 0x06, 0xC0, 0xC0, 0x00, 0xE4, 0x03, 0x80, 0x1C, 0x60, 0x0F, 0x0F,
  0xC3, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x30,
  0x07, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xFE, 0x3C, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x30, 0x00,
  0x1F, 0xFF, 0x00, 0x30, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x0C,
  0x00, 0x30, 0x03, 0x10, 0x00, 0x60, 0x00, 0x80, 0x04, 0xC0, 0x03, 0x00,
  0x02, 0x00, 0x13, 0x00, 0x18, 0x00, 0x18, 0x00, 0x48, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x60, 0x03, 0x00, 0x01, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x04,
  0x00, 0x36, 0x00, 0x60, 0x00, 0x30, 0x00, 0xD0, 0x01, 0x00, 0x00, 0xC0,
  0x03, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x0B, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x6C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xB0, 0x03, 0x00, 0x01, 0x80, 0x04,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x30, 0x00, 0x30, 0x00, 0x8C,
  0x00, 0xC0, 0x01, 0xC0, 0x06, 0x10, 0x03, 0x00, 0x0D, 0x00, 0x30, 0x40,
  0x04, 0x00, 0x66, 0x01, 0xC1, 0x80, 0x18, 0x03, 0x18, 0x0E, 0x06, 0x00,
  0x38, 0x38, 0x30, 0xE0, 0x18, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01,
  0xC0, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x02, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x04, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x02, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x08, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x00, 0x63, 0x60, 0x00, 0x00, 0x08,
  0xC6, 0x00, 0x00, 0x01, 0x30, 0xC0, 0x00, 0x00, 0x6C, 0x0C, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x14,
  0x00, 0x00, 0x00, 0x1A, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x78, 0x03, 0x40,
  0x00, 0x00, 0x03, 0x60, 0x0D, 0x80, 0x00, 0x00, 0x09, 0x80, 0x26, 0x00,
  0x00, 0x00, 0x64, 0x00, 0x98, 0x00, 0x00, 0x03, 0x10, 0x06, 0x20, 0x00,
  0x00, 0x0C, 0xC0, 0x18, 0x80, 0x00, 0x00, 0x63, 0x00, 0x63, 0x00, 0x00,
  0x01, 0x0C, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x20, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x30, 0x40, 0x00, 0x01, 0x86, 0x00, 0xC1, 0x00, 0x00, 0x0C,
  0x18, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40, 0x08, 0x18, 0x00, 0x01, 0x81,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x06, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x00, 0x30, 0x08, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x30, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x30, 0x00, 0x80,
  0xC0, 0x06, 0x00, 0xC0, 0x02, 0x02, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x00, 0x20, 0x00, 0xC2, 0x00,
  0x04, 0x01, 0x80, 0x01, 0x18, 0x00, 0x30, 0x06, 0x00, 0x04, 0x40, 0x00,
  0xC0, 0x18, 0x00, 0x13, 0x00, 0x03, 0x00, 0x40, 0x00, 0x78, 0x00, 0x08,
  0x01, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x00,
  0x02, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x03, 0x60, 0x00, 0x00, 0x60, 0x0D,
  0x80, 0x00, 0x01, 0x80, 0x22, 0x00, 0x00, 0x04, 0x00, 0x8C, 0x00, 0x00,
  0x30, 0x06, 0x10, 0x00, 0x00, 0xC0, 0x18, 0x60, 0x00, 0x03, 0x00, 0x61,
  0x80, 0x00, 0x08, 0x01, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x0C, 0x00, 0x01,
  0x80, 0x30, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x80, 0x00, 0x40, 0x08, 0x03, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x40, 0x03, 0x00, 0x08, 0x03, 0x00, 0x04, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x80, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x20, 0x04, 0x00, 0x00,
  0xC0, 0x80, 0x30, 0x00, 0x03, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x03,
  0x00, 0x00, 0x18, 0x60, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x20, 0x00, 0x00,
  0xC4, 0x01, 0x80, 0x00, 0x01, 0x30, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x18,
  0x00, 0x00, 0x1B, 0x00, 0x40, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x07, 0x80, 0x02, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x1C, 0x01,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x07, 0x80, 0x02, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x38, 0x01, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x04, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x03,
  0x20, 0x00, 0x06, 0x40, 0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x04, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x10, 0x01, 0x80,
  0x20, 0x03, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x06, 0x00, 0x20,
  0x0C, 0x00, 0x40, 0x10, 0x00, 0x80, 0x20, 0x01, 0x00, 0xC0, 0x02, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x40, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x08, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x11, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x4C, 0x00, 0x01, 0x90, 0x00, 0x01, 0x20, 0x00, 0x06, 0xC0,
  0x00, 0x05, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x16, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x01,
  0x80, 0x04, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFE, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x06,
  0x04, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x81, 0x00, 0x70, 0x0C,
  0x30, 0x0C, 0x00, 0x63, 0x01, 0x80, 0x03, 0x20, 0x30, 0x00, 0x12, 0x06,
  0x00, 0x01, 0xA0, 0xC0, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xE0, 0x40, 0x00, 0x16,
  0x06, 0x00, 0x02, 0x60, 0x60, 0x00, 0x64, 0x03, 0x00, 0x0C, 0x40, 0x38,
  0x03, 0x8C, 0x01, 0xC0, 0xE0, 0xC0, 0x07, 0xFC, 0x08, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x3E, 0x00, 0x04, 0x0F, 0xFE, 0x00, 0x60, 0xC0, 0x38, 0x03,
  0x18, 0x00, 0x60, 0x19, 0x80, 0x01, 0x80, 0x98, 0x00, 0x0C, 0x05, 0x80,
  0x00, 0x20, 0x68, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0F, 0x00,
  0x00, 0x30, 0x68, 0x00, 0x03, 0x02, 0x60, 0x00, 0x38, 0x13, 0x00, 0x03,
  0x81, 0x8C, 0x00, 0x38, 0x0C, 0x38, 0x07, 0x00, 0x40, 0x7F, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1E,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x40, 0x0E, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x08, 0x00,
  0x1F, 0xFC, 0x08, 0x00, 0x70, 0x06, 0x18, 0x00, 0xC0, 0x03, 0x18, 0x01,
  0x80, 0x01, 0x98, 0x03, 0x00, 0x00, 0x90, 0x06, 0x00, 0x00, 0xD0, 0x0C,
  0x00, 0x00, 0x70, 0x08, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x10,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0D, 0x00, 0x40, 0x00, 0x0B, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x60,
  0x00, 0x33, 0x00, 0x30, 0x00, 0xE2, 0x00, 0x38, 0x01, 0xC2, 0x00, 0x1C,
  0x07, 0x06, 0x00, 0x07, 0xFC, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x02, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x38, 0x40, 0x00, 0xE0, 0xC0, 0x1F, 0x80, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x0F, 0x00, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x10, 0x03, 0x80, 0x30, 0x40, 0x18, 0x00, 0x63,
  0x00, 0xC0, 0x00, 0xCC, 0x06, 0x00, 0x01, 0x20, 0x30, 0x00, 0x06, 0x81,
  0x80, 0x00, 0x0A, 0x04, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1A, 0x02, 0x00,
  0x00, 0x58, 0x0C, 0x00, 0x03, 0x60, 0x30, 0x00, 0x19, 0x80, 0x60, 0x00,
  0xC4, 0x01, 0xC0, 0x0E, 0x10, 0x03, 0x80, 0xE0, 0xC0, 0x03, 0xFE, 0x03,
  0x00, 0x03, 0x80, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x07, 0xE0, 0x01, 0x03,
  0xFF, 0x80, 0x30, 0x70, 0x1C, 0x03, 0x1C, 0x00, 0x60, 0x33, 0x00, 0x02,
  0x02, 0x60, 0x00, 0x30, 0x2C, 0x00, 0x03, 0x06, 0x80, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x83, 0x80, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x08,
  0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x87, 0x80, 0x00,
  0x31, 0xB0, 0x00, 0x06, 0x63, 0x00, 0x00, 0x98, 0x60, 0x00, 0x16, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x04, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x30, 0xE0, 0x30, 0x1C, 0x07, 0x00, 0xC6, 0x00, 0x60, 0xC0,
  0x06, 0x02, 0x30, 0x00, 0x86, 0x00, 0x18, 0x09, 0x80, 0x03, 0x30, 0x00,
  0x20, 0x2C, 0x00, 0x0C, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x36, 0x00, 0x03,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x10, 0x3F, 0xF8, 0x03, 0x07, 0x01, 0xC0, 0x31,
  0xC0, 0x06, 0x02, 0x30, 0x00, 0x20, 0x26, 0x00, 0x03, 0x02, 0xC0, 0x00,
  0x30, 0x68, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x03, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x20, 0x7F, 0xF0, 0x00, 0x61, 0xE0, 0x38, 0x00, 0x63, 0x80, 0x0C, 0x00,
  0x46, 0x00, 0x06, 0x00, 0x4C, 0x00, 0x06, 0x00, 0x58, 0x00, 0x02, 0x00,
  0xD0, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x30, 0x0D, 0x00, 0x00, 0x60, 0x09,
  0x80, 0x00, 0xE0, 0x09, 0x80, 0x01, 0xC0, 0x18, 0xC0, 0x03, 0x80, 0x18,
  0x70, 0x0E, 0x00, 0x18, 0x1F, 0xF8, 0x00, 0x10, 0x03, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x40, 0x1C,
  0x01, 0x82, 0x01, 0x80, 0x06, 0x30, 0x18, 0x00, 0x19, 0x81, 0x80, 0x00,
  0x48, 0x18, 0x00, 0x03, 0x41, 0x80, 0x00, 0x0A, 0x08, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x84, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x68, 0x10, 0x00, 0x02, 0xC0, 0xC0, 0x00, 0x36, 0x06, 0x00, 0x03, 0x30,
  0x18, 0x00, 0x31, 0x00, 0xE0, 0x07, 0x08, 0x03, 0x80, 0xE0, 0xC0, 0x07,
  0xFC, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x04, 0x0F, 0xF0,
  0x30, 0xE0, 0x00, 0xC6, 0x00, 0x02, 0x30, 0x00, 0x09, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0x00, 0x38, 0x18, 0x00,
  0x10, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x7C, 0x03, 0xC0, 0x3F, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0x83, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0A, 0x0C, 0x00,
  0x01, 0xA0, 0xC0, 0x00, 0x36, 0x04, 0x00, 0x06, 0x60, 0x60, 0x00, 0xC4,
  0x03, 0x00, 0x38, 0x40, 0x38, 0x0F, 0x04, 0x00, 0xFF, 0xC0, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x04, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x10, 0x02, 0x00, 0x08, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07,
  0x80, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00, 0x22, 0x00, 0x02,
  0x80, 0x00, 0xC4, 0x00, 0x0D, 0x00, 0x01, 0x08, 0x00, 0x13, 0x00, 0x06,
  0x10, 0x00, 0x66, 0x00, 0x08, 0x20, 0x00, 0x8C, 0x00, 0x30, 0x40, 0x03,
  0x18, 0x00, 0x40, 0x80, 0x04, 0x10, 0x01, 0x81, 0x80, 0x18, 0x20, 0x02,
  0x03, 0x00, 0x20, 0x40, 0x0C, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x0C, 0x01,
  0x01, 0x00, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x40, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x30, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x41,
  0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x11,
  0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0x4C, 0x00, 0x0C,
  0x80, 0x00, 0x98, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x34, 0x00, 0x02,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x17, 0x87, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x68, 0x00,
  0x3E, 0x3C, 0x80, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 44, 13, 2, -44 },
  { 62, 13, 16, 19, 7, -44 },
  { 88, 36, 44, 37, 2, -44 },
  { 286, 28, 50, 34, 3, -46 },
  { 461, 38, 45, 47, 5, -44 },
  { 675, 36, 45, 42, 3, -44 },
  { 878, 5, 16, 10, 7, -44 },
  { 888, 17, 54, 15, 2, -44 },
  { 1003, 17, 54, 15, -4, -44 },
  { 1118, 25, 25, 32, 8, -46 },
  { 1197, 28, 29, 35, 5, -36 },
  { 1299, 8, 15, 11, -3, -7 },
  { 1314, 15, 1, 19, 2, -17 },
  { 1316, 3, 3, 13, 2, -3 },
  { 1318, 27, 44, 19, -3, -44 },
  { 1467, 28, 45, 34, 4, -44 },
  { 1625, 15, 44, 34, 10, -44 },
  { 1708, 30, 44, 34, 1, -44 },
  { 1873, 31, 45, 34, 1, -44 },
  { 2048, 31, 44, 34, 1, -44 },
  { 2219, 31, 45, 34, 2, -44 },
  { 2394, 29, 45, 34, 4, -44 },
  { 2558, 27, 44, 34, 7, -44 },
  { 2707, 29, 45, 34, 3, -44 },
  { 2871, 29, 45, 34, 3, -44 },
  { 3035, 9, 32, 13, 2, -32 },
  { 3071, 14, 40, 13, -3, -32 },
  { 3141, 28, 28, 35, 5, -36 },
  { 3239, 28, 13, 35, 5, -28 },
  { 3285, 28, 28, 35, 5, -36 },
  { 3383, 21, 44, 25, 5, -44 },
  { 3499, 46, 48, 51, 3, -43 },
  { 3775, 33, 44, 33, -3, -44 },
  { 3957, 32, 44, 36, 3, -44 },
  { 4133, 34, 45, 36, 5, -44 },
  { 4325, 36, 44, 41, 3, -44 },
  { 4523, 31, 44, 33, 3, -44 },
  { 4694, 31, 44, 30, 3, -44 },
  { 4865, 36, 45, 42, 5, -44 },
  { 5068, 38, 44, 42, 3, -44 },
  { 5277, 19, 44, 17, 0, -44 },
  { 5382, 24, 55, 14, -10, -44 },
  { 5547, 35, 44, 33, 3, -44 },
  { 5740, 22, 44, 30, 3, -44 },
  { 5861, 46, 44, 49, 3, -44 },
  { 6114, 38, 44, 41, 3, -44 },
  { 6323, 36, 45, 44, 5, -44 },
  { 6526, 31, 44, 34, 3, -44 },
  { 6697, 36, 54, 44, 5, -44 },
  { 6940, 31, 44, 34, 3, -44 },
  { 7111, 30, 45, 30, 1, -44 },
  { 7280, 29, 44, 30, 6, -44 },
  { 7440, 37, 45, 42, 5, -44 },
  { 7649, 31, 44, 33, 6, -44 },
  { 7820, 46, 44, 50, 8, -44 },
  { 8073, 38, 44, 30, -4, -44 },
  { 8282, 29, 44, 30, 6, -44 },
  { 8442, 35, 44, 33, 0, -44 },
  { 8635, 24, 54, 18, -1, -44 },
  { 8797, 9, 44, 19, 6, -44 },
  { 8847, 23, 54, 18, -4, -44 },
  { 9003, 28, 27, 34, 3, -44 },
  { 9098, 23, 1, 23, -5, 7 },
  { 9101, 7, 10, 14, 9, -47 },
  { 9110, 28, 34, 33, 3, -33 },
  { 9229, 29, 47, 35, 2, -46 },
  { 9400, 25, 34, 28, 3, -33 },
  { 9507, 32, 47, 35, 3, -46 },
  { 9695, 24, 34, 30, 4, -33 },
  { 9797, 33, 62, 16, -8, -47 },
  { 10053, 30, 48, 35, 2, -33 },
  { 10233, 28, 46, 34, 2, -46 },
  { 10394, 11, 44, 13, 2, -44 },
  { 10455, 22, 59, 13, -9, -44 },
  { 10618, 27, 46, 27, 2, -46 },
  { 10774, 11, 46, 13, 2, -46 },
  { 10838, 46, 33, 51, 2, -33 },
  { 11028, 28, 33, 34, 2, -33 },
  { 11144, 28, 34, 34, 3, -33 },
  { 11263, 32, 47, 35, -1, -33 },
  { 11451, 29, 47, 35, 3, -33 },
  { 11622, 22, 33, 23, 2, -33 },
  { 11713, 23, 34, 26, 1, -33 },
  { 11811, 17, 41, 19, 3, -40 },
  { 11899, 28, 33, 34, 3, -32 },
  { 12015, 25, 32, 25, 3, -32 },
  { 12115, 39, 32, 40, 3, -32 },
  { 12271, 31, 32, 28, -2, -32 },
  { 12395, 35, 47, 25, -7, -32 },
  { 12601, 28, 32, 27, -1, -32 },
  { 12713, 21, 54, 20, 2, -44 },
  { 12855, 2, 61, 33, 17, -46 },
  { 12871, 22, 54, 20, -3, -44 },
  { 13020, 28, 5, 35, 5, -24 },
};

const GFXfont NotoSans_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_THINITALIC61PT7B_H_
