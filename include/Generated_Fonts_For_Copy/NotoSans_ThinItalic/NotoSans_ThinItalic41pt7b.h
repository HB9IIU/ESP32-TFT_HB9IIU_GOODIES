#ifndef _NOTOSANS_THINITALIC41PT7B_H_
#define _NOTOSANS_THINITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x61, 0x41, 0x41, 0x41, 0x42, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x80, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x20, 0x0F, 0xFF, 0xFF, 0xC0,
  0x10, 0x10, 0x00, 0x18, 0x08, 0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0x80, 0x40, 0x1F, 0xFF, 0xFF, 0x80, 0x20, 0x10, 0x00, 0x10, 0x10,
  0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x04, 0x06, 0x00, 0x04, 0x02,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x1E, 0xBE, 0x06,
  0x10, 0x41, 0x02, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x08, 0x40, 0x00, 0xC8, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x09, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x01, 0x03, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x40, 0x04, 0x18, 0x70, 0x9C, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x01, 0x06, 0x60, 0x01,
  0x04, 0x18, 0x01, 0x04, 0x04, 0x01, 0x86, 0x02, 0x00, 0x82, 0x01, 0x00,
  0x81, 0x00, 0x80, 0xC1, 0x00, 0x40, 0x40, 0x80, 0x20, 0x40, 0x40, 0x10,
  0x40, 0x20, 0x18, 0x60, 0x10, 0x08, 0x20, 0x08, 0x04, 0x21, 0xE4, 0x06,
  0x23, 0x1A, 0x02, 0x33, 0x07, 0x03, 0x11, 0x01, 0x83, 0x11, 0x00, 0xB3,
  0x10, 0x80, 0x46, 0x18, 0xC0, 0x20, 0x08, 0x40, 0x10, 0x08, 0x20, 0x08,
  0x08, 0x10, 0x04, 0x0C, 0x08, 0x04, 0x04, 0x0C, 0x02, 0x04, 0x06, 0x01,
  0x04, 0x03, 0x01, 0x06, 0x01, 0x80, 0x82, 0x00, 0x40, 0x82, 0x00, 0x20,
  0xC3, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x71, 0x80, 0x00, 0xC0,
  0x40, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x01, 0x00, 0x20, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x00,
  0x80, 0x00, 0x83, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x08, 0x01, 0x20, 0x04,
  0x02, 0x40, 0x04, 0x02, 0x40, 0x02, 0x04, 0x80, 0x01, 0x08, 0x80, 0x01,
  0x98, 0x80, 0x00, 0x90, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0xC0, 0x01,
  0xB0, 0x40, 0x03, 0x10, 0x30, 0x0C, 0x08, 0x1F, 0xF0, 0x0C, 0x69, 0x25,
  0x24, 0x90, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x0C, 0x04, 0x03, 0x04,
  0x00, 0x62, 0x00, 0x0D, 0x01, 0x01, 0xFF, 0x80, 0xC0, 0x00, 0xA0, 0x01,
  0x88, 0x01, 0x84, 0x01, 0x81, 0x01, 0x80, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x20, 0x86, 0x10, 0xC2, 0x08, 0x43, 0x00, 0xFF, 0x80, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x38, 0xE0, 0x0C, 0x06, 0x03,
  0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x03, 0x20,
  0x00, 0x24, 0x00, 0x05, 0x80, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x04, 0x80,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x18, 0x80, 0x02, 0x10, 0x00, 0x81, 0x00, 0x30, 0x20, 0x0C, 0x03, 0x03,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0xC8, 0x62, 0x60, 0xB0, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x07, 0x00, 0x03, 0xCE, 0x00, 0x30,
  0x0C, 0x02, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x07, 0x8E, 0x00, 0xC0, 0x08, 0x08, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x07, 0xF0, 0x00, 0x41, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x61, 0x00,
  0x06, 0x0C, 0x00, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x03, 0x30, 0x00,
  0x31, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x10, 0x30,
  0x01, 0x01, 0x00, 0x10, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00,
  0x20, 0x18, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x40, 0x80, 0x02, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0xF0, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x84, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x80, 0x06, 0x0C, 0x01, 0x80, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x07, 0x04, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x1F, 0x80, 0x8C, 0x0C, 0x16, 0x00,
  0xC3, 0x80, 0x08, 0xA0, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x41, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x38,
  0x01, 0x00, 0x40, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0x20,
  0x08, 0x01, 0x03, 0x00, 0x08, 0xC0, 0x00, 0x70, 0x00, 0x19, 0x80, 0x0E,
  0x06, 0x01, 0x80, 0x30, 0x20, 0x01, 0x04, 0x00, 0x08, 0xC0, 0x00, 0x88,
  0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08,
  0x40, 0x01, 0x06, 0x00, 0x20, 0x30, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x1C, 0xE0, 0x0C, 0x02, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x10, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00,
  0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0xC4, 0x00, 0x38, 0x80, 0x0F,
  0x08, 0x03, 0x40, 0xE3, 0x88, 0x07, 0x83, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x04, 0x1C,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x80, 0x70, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0xF9, 0xC2, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x02, 0x10, 0x00, 0xF8, 0x02, 0x20, 0x06, 0x1C, 0x04,
  0x80, 0x30, 0x08, 0x09, 0x00, 0x80, 0x20, 0x14, 0x02, 0x00, 0x40, 0x28,
  0x04, 0x00, 0x80, 0x50, 0x10, 0x01, 0x00, 0xA0, 0x20, 0x04, 0x01, 0xC0,
  0xC0, 0x08, 0x07, 0x01, 0x00, 0x10, 0x0A, 0x02, 0x00, 0x60, 0x14, 0x04,
  0x00, 0x80, 0x48, 0x08, 0x03, 0x00, 0x98, 0x18, 0x0E, 0x02, 0x10, 0x10,
  0x32, 0x08, 0x20, 0x1B, 0xC6, 0x60, 0x40, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x48, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x42,
  0x00, 0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x18, 0x07, 0xFF, 0xE0, 0x20, 0x00, 0x81, 0x80, 0x02,
  0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x01, 0x10,
  0x00, 0x04, 0x80, 0x00, 0x16, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x03, 0xFF, 0xC0, 0x08, 0x00, 0xC0, 0x20, 0x01, 0x81, 0x80, 0x02,
  0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x03, 0x0C,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x08, 0x08, 0x01,
  0xC0, 0x7F, 0xF8, 0x01, 0x00, 0x38, 0x04, 0x00, 0x10, 0x10, 0x00, 0x20,
  0xC0, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80,
  0x00, 0xC6, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x03,
  0x04, 0x00, 0x18, 0x20, 0x03, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x78, 0x03, 0x80, 0x08, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x02, 0x00, 0x60, 0x02, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x30,
  0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x80, 0x1C, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0xE0, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x07, 0xFC, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x04, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x60, 0x00, 0x18, 0x20, 0x00, 0x10, 0x30, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x70, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x20, 0x20, 0x00, 0x08, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00,
  0x02, 0x07, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x10,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x07, 0x02, 0x00, 0x0C,
  0x02, 0x00, 0x18, 0x06, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x04, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x13, 0x40, 0x00,
  0x16, 0x20, 0x00, 0x1C, 0x20, 0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x20, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00,
  0x40, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xA0, 0x48, 0x00, 0x02, 0x40,
  0x90, 0x00, 0x04, 0x81, 0x20, 0x00, 0x12, 0x02, 0x40, 0x00, 0x64, 0x0C,
  0x80, 0x00, 0x88, 0x11, 0x80, 0x02, 0x10, 0x21, 0x00, 0x04, 0x60, 0x42,
  0x00, 0x10, 0x80, 0x84, 0x00, 0x61, 0x02, 0x08, 0x00, 0x82, 0x04, 0x10,
  0x02, 0x04, 0x08, 0x10, 0x04, 0x18, 0x10, 0x20, 0x10, 0x20, 0x60, 0x40,
  0x60, 0x40, 0x80, 0x80, 0x80, 0x81, 0x01, 0x02, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x02, 0x10, 0x08, 0x18, 0x04, 0x60, 0x10, 0x20, 0x08, 0x80,
  0x20, 0x40, 0x12, 0x00, 0x40, 0x80, 0x24, 0x01, 0x01, 0x00, 0x70, 0x02,
  0x04, 0x00, 0x60, 0x04, 0x08, 0x00, 0x80, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x90, 0x00, 0x10, 0x48, 0x00,
  0x10, 0x26, 0x00, 0x08, 0x11, 0x00, 0x04, 0x08, 0x80, 0x02, 0x08, 0x20,
  0x03, 0x04, 0x10, 0x01, 0x02, 0x0C, 0x00, 0x81, 0x02, 0x00, 0x40, 0x81,
  0x00, 0x20, 0x80, 0x40, 0x30, 0x40, 0x20, 0x10, 0x20, 0x08, 0x08, 0x10,
  0x04, 0x04, 0x18, 0x03, 0x02, 0x08, 0x00, 0x82, 0x04, 0x00, 0x41, 0x02,
  0x00, 0x10, 0x81, 0x00, 0x08, 0x41, 0x80, 0x02, 0x20, 0x80, 0x01, 0x20,
  0x40, 0x00, 0xD0, 0x20, 0x00, 0x28, 0x10, 0x00, 0x14, 0x10, 0x00, 0x06,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x38, 0x00, 0x60,
  0x02, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x20, 0x60, 0x00, 0x18, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x10, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x64, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x60, 0x00, 0x08, 0x10, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x10, 0x03, 0x00, 0x80, 0x0C, 0x0C, 0x00,
  0x20, 0x40, 0x01, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C,
  0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x40, 0x06, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x60, 0x02, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x20, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x10,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01,
  0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x08, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x10, 0x03, 0x00, 0x80, 0x0C, 0x0C,
  0x00, 0x20, 0x40, 0x01, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x0C, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80,
  0x06, 0x08, 0x00, 0x60, 0x40, 0x1C, 0x03, 0xFF, 0x00, 0x10, 0x08, 0x01,
  0x80, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x01,
  0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10,
  0x00, 0x61, 0x00, 0x01, 0x08, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0x1E, 0x03, 0x00, 0x10, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x80, 0x1C, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03,
  0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08,
  0xC0, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x40, 0xC0, 0x00, 0x80, 0x60, 0x01, 0x00, 0x30, 0x06, 0x00,
  0x0F, 0xF8, 0x00, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80,
  0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x10,
  0x40, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x80, 0x40, 0x0C, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x20, 0x10, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x40,
  0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10,
  0x80, 0x08, 0x80, 0x10, 0x40, 0x10, 0x80, 0x30, 0x40, 0x10, 0x80, 0x20,
  0x40, 0x20, 0x80, 0x60, 0x40, 0x20, 0x80, 0x40, 0x40, 0x40, 0x80, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x40, 0x80, 0x80, 0x80, 0x40, 0x80, 0x81, 0x00,
  0x41, 0x00, 0xC1, 0x00, 0x41, 0x00, 0x42, 0x00, 0x43, 0x00, 0x42, 0x00,
  0x42, 0x00, 0x46, 0x00, 0x46, 0x00, 0x44, 0x00, 0x44, 0x00, 0x4C, 0x00,
  0x4C, 0x00, 0x48, 0x00, 0x48, 0x00, 0x48, 0x00, 0x58, 0x00, 0x50, 0x00,
  0x50, 0x00, 0x50, 0x00, 0x50, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x20,
  0x00, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x02, 0x00, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x20, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x40, 0x00, 0x02, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x28, 0x00, 0x00, 0x26, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x30, 0x20, 0x00, 0x10, 0x10, 0x00, 0x10, 0x0C,
  0x00, 0x10, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x40, 0x18, 0x00,
  0x20, 0x08, 0x00, 0x18, 0x08, 0x00, 0x04, 0x08, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x3C, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x01, 0x02,
  0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x40, 0x10, 0x08, 0x01, 0x01, 0x80,
  0x10, 0x10, 0x00, 0x82, 0x00, 0x08, 0x40, 0x00, 0x8C, 0x00, 0x0C, 0x80,
  0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x20, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x41, 0x04, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x06, 0x20, 0x00, 0x84, 0x00, 0x20, 0x40, 0x08, 0x08, 0x03, 0x01, 0x00,
  0x40, 0x20, 0x10, 0x02, 0x06, 0x00, 0x40, 0x80, 0x08, 0x20, 0x00, 0x8C,
  0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x50, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC2, 0x18, 0x41, 0x08, 0x00, 0xFC, 0x20, 0x60, 0xC4, 0x10, 0x04,
  0x84, 0x00, 0xA1, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x33, 0x00, 0x04,
  0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x05, 0x18, 0x00, 0xC1,
  0x00, 0x28, 0x20, 0x09, 0x02, 0x06, 0x20, 0x3F, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x41, 0xF0, 0x04,
  0x60, 0xC0, 0x98, 0x06, 0x09, 0x00, 0x20, 0xA0, 0x03, 0x0C, 0x00, 0x10,
  0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x46, 0x00, 0x04, 0x60, 0x00, 0x85, 0x00, 0x18, 0x50, 0x03, 0x04, 0xC0,
  0x60, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xC0, 0xC1, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x40, 0x30, 0x33, 0x01, 0x00, 0x68,
  0x08, 0x00, 0xA0, 0x40, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x10, 0x60,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x82,
  0x00, 0x0C, 0x0C, 0x00, 0x50, 0x10, 0x03, 0x40, 0x40, 0x19, 0x00, 0x80,
  0xC4, 0x01, 0xFC, 0x20, 0x00, 0x01, 0xF8, 0x03, 0x06, 0x0C, 0x02, 0x18,
  0x03, 0x30, 0x01, 0x20, 0x01, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x0C, 0x80,
  0x38, 0xFF, 0xE0, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x08, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x26, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x08, 0x0C, 0x0C, 0x40,
  0x80, 0x34, 0x08, 0x00, 0xA0, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00,
  0x86, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x18,
  0x40, 0x01, 0x83, 0x00, 0x14, 0x08, 0x01, 0xA0, 0x40, 0x19, 0x01, 0x01,
  0x98, 0x07, 0xF0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x0C,
  0x03, 0x81, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x83, 0xF0, 0x11, 0x83, 0x04, 0x40, 0x30, 0x90,
  0x02, 0x14, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x06, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x40, 0x01, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x23, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x0C, 0x10, 0x02, 0x06, 0x00, 0x80, 0x80, 0x20,
  0x10, 0x08, 0x02, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00,
  0x46, 0x00, 0x09, 0xC0, 0x01, 0x68, 0x00, 0x58, 0x80, 0x0C, 0x10, 0x01,
  0x01, 0x00, 0x20, 0x20, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x04, 0x04,
  0x00, 0x80, 0x80, 0x08, 0x30, 0x01, 0x80, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x04, 0x3E, 0x01, 0xF8, 0x09, 0x83, 0x0C, 0x18, 0x26, 0x02,
  0x30, 0x18, 0x58, 0x06, 0xC0, 0x10, 0xA0, 0x05, 0x00, 0x21, 0x80, 0x0C,
  0x00, 0x42, 0x00, 0x10, 0x00, 0x8C, 0x00, 0x20, 0x01, 0x10, 0x00, 0xC0,
  0x02, 0x20, 0x01, 0x00, 0x08, 0x40, 0x02, 0x00, 0x10, 0x80, 0x04, 0x00,
  0x22, 0x00, 0x08, 0x00, 0x44, 0x00, 0x20, 0x00, 0x88, 0x00, 0x40, 0x02,
  0x10, 0x00, 0x80, 0x04, 0x60, 0x01, 0x00, 0x08, 0x80, 0x04, 0x00, 0x11,
  0x00, 0x08, 0x00, 0x62, 0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x04, 0x1F, 0x80, 0x8C, 0x18, 0x22, 0x01, 0x84,
  0x80, 0x10, 0xA0, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01, 0x10,
  0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x31, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00,
  0x60, 0x60, 0x10, 0x02, 0x04, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0xC8,
  0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x04, 0xC0,
  0x00, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x10, 0x03, 0x03, 0x00, 0xC0, 0x1F,
  0xE0, 0x00, 0x01, 0x07, 0xC0, 0x04, 0x60, 0xC0, 0x26, 0x01, 0x80, 0xB0,
  0x02, 0x02, 0x80, 0x0C, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x01,
  0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x04, 0x18, 0x00,
  0x10, 0x60, 0x00, 0x81, 0x40, 0x06, 0x05, 0x00, 0x30, 0x13, 0x01, 0x80,
  0x87, 0xF8, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x30, 0x31, 0x04,
  0x01, 0xA0, 0x80, 0x0A, 0x10, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x46,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x08,
  0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x18, 0x80, 0x03,
  0x0C, 0x00, 0x70, 0x40, 0x0D, 0x04, 0x01, 0x90, 0x20, 0x33, 0x01, 0xFC,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x04, 0x3E, 0x08, 0xC0, 0x26, 0x00, 0x58, 0x00, 0xA0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x06, 0x03,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0xC0, 0x18, 0x3F, 0xE0, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x07,
  0xFF, 0x98, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x22,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x04, 0x60, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x44, 0x00, 0x18, 0x80,
  0x03, 0x10, 0x00, 0xA2, 0x00, 0x28, 0x20, 0x09, 0x06, 0x06, 0x20, 0x7F,
  0x84, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xC8, 0x00, 0x44, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x20, 0x80, 0x30, 0x40, 0x10, 0x20, 0x18, 0x08,
  0x08, 0x04, 0x08, 0x02, 0x04, 0x01, 0x04, 0x00, 0x86, 0x00, 0x42, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x28, 0x00, 0xC0, 0x0A, 0x00,
  0x50, 0x04, 0xC0, 0x34, 0x01, 0x10, 0x09, 0x00, 0x84, 0x06, 0x40, 0x21,
  0x01, 0x10, 0x18, 0x40, 0xC4, 0x04, 0x10, 0x21, 0x03, 0x04, 0x18, 0x20,
  0x81, 0x04, 0x08, 0x60, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x10, 0x40, 0x02, 0x02, 0x00, 0x40, 0x20, 0x08, 0x03,
  0x01, 0x80, 0x10, 0x30, 0x01, 0x86, 0x00, 0x08, 0xC0, 0x00, 0x88, 0x00,
  0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xB0, 0x00, 0x11, 0x00,
  0x03, 0x18, 0x00, 0x60, 0x80, 0x0C, 0x08, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x10, 0x01, 0x00, 0x01, 0x01,
  0x00, 0x02, 0x01, 0x00, 0x06, 0x00, 0x80, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x00, 0x80, 0x10, 0x00, 0x80, 0x20, 0x00,
  0x40, 0x60, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x80, 0x00,
  0x41, 0x00, 0x00, 0x41, 0x00, 0x00, 0x22, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0xC0, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x38,
  0x1C, 0x0E, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 8, 10, 13, 5, -29 },
  { 40, 25, 29, 25, 1, -29 },
  { 131, 19, 33, 23, 2, -31 },
  { 210, 25, 30, 31, 4, -30 },
  { 304, 24, 30, 28, 2, -30 },
  { 394, 3, 10, 7, 5, -29 },
  { 398, 12, 35, 10, 1, -29 },
  { 451, 12, 35, 10, -3, -29 },
  { 504, 17, 17, 22, 5, -31 },
  { 541, 19, 19, 23, 3, -24 },
  { 587, 6, 10, 8, -2, -5 },
  { 595, 9, 1, 13, 2, -12 },
  { 597, 2, 2, 9, 1, -2 },
  { 598, 18, 29, 13, -2, -29 },
  { 664, 19, 30, 23, 3, -30 },
  { 736, 10, 29, 23, 7, -29 },
  { 773, 21, 30, 23, 0, -30 },
  { 852, 21, 30, 23, 1, -30 },
  { 931, 21, 29, 23, 1, -29 },
  { 1008, 20, 29, 23, 2, -29 },
  { 1081, 19, 30, 23, 3, -30 },
  { 1153, 18, 29, 23, 5, -29 },
  { 1219, 20, 30, 23, 2, -30 },
  { 1294, 19, 30, 23, 2, -30 },
  { 1366, 7, 22, 9, 1, -22 },
  { 1386, 10, 27, 9, -2, -22 },
  { 1420, 19, 18, 23, 3, -24 },
  { 1463, 19, 9, 23, 3, -19 },
  { 1485, 19, 18, 23, 3, -24 },
  { 1528, 14, 30, 17, 3, -30 },
  { 1581, 31, 33, 34, 2, -29 },
  { 1709, 22, 29, 22, -2, -29 },
  { 1789, 22, 29, 25, 2, -29 },
  { 1869, 23, 30, 24, 3, -30 },
  { 1956, 24, 29, 28, 2, -29 },
  { 2043, 21, 29, 22, 2, -29 },
  { 2120, 21, 29, 20, 2, -29 },
  { 2197, 24, 30, 28, 3, -30 },
  { 2287, 26, 29, 28, 2, -29 },
  { 2382, 13, 29, 11, 0, -29 },
  { 2430, 16, 36, 9, -7, -29 },
  { 2502, 24, 29, 22, 2, -29 },
  { 2589, 15, 29, 20, 2, -29 },
  { 2644, 31, 29, 33, 2, -29 },
  { 2757, 25, 29, 28, 2, -29 },
  { 2848, 25, 30, 29, 3, -30 },
  { 2942, 21, 29, 23, 2, -29 },
  { 3019, 25, 37, 29, 3, -30 },
  { 3135, 21, 29, 23, 2, -29 },
  { 3212, 20, 30, 20, 1, -30 },
  { 3287, 20, 29, 20, 4, -29 },
  { 3360, 24, 29, 28, 4, -29 },
  { 3447, 21, 29, 22, 4, -29 },
  { 3524, 32, 29, 34, 5, -29 },
  { 3640, 25, 29, 20, -2, -29 },
  { 3731, 20, 29, 20, 4, -29 },
  { 3804, 23, 29, 22, 0, -29 },
  { 3888, 15, 35, 12, 0, -29 },
  { 3954, 6, 29, 13, 4, -29 },
  { 3976, 16, 35, 12, -3, -29 },
  { 4046, 19, 18, 23, 2, -29 },
  { 4089, 15, 2, 15, -3, 4 },
  { 4093, 5, 6, 9, 6, -31 },
  { 4097, 19, 22, 22, 2, -22 },
  { 4150, 20, 31, 23, 1, -31 },
  { 4228, 17, 22, 19, 2, -22 },
  { 4275, 22, 31, 23, 2, -31 },
  { 4361, 16, 22, 20, 3, -22 },
  { 4405, 22, 41, 11, -5, -31 },
  { 4518, 21, 32, 23, 1, -22 },
  { 4602, 19, 31, 23, 1, -31 },
  { 4676, 8, 30, 8, 1, -30 },
  { 4706, 15, 40, 8, -6, -30 },
  { 4781, 19, 31, 18, 1, -31 },
  { 4855, 8, 31, 8, 1, -31 },
  { 4886, 31, 22, 35, 1, -22 },
  { 4972, 19, 22, 23, 1, -22 },
  { 5025, 19, 22, 23, 2, -22 },
  { 5078, 22, 32, 23, -1, -22 },
  { 5166, 20, 32, 23, 2, -22 },
  { 5246, 15, 22, 15, 1, -22 },
  { 5288, 16, 22, 17, 0, -22 },
  { 5332, 12, 27, 13, 2, -27 },
  { 5373, 19, 22, 23, 2, -22 },
  { 5426, 17, 22, 17, 2, -22 },
  { 5473, 26, 22, 27, 2, -22 },
  { 5545, 20, 22, 19, -1, -22 },
  { 5600, 24, 32, 17, -5, -22 },
  { 5696, 19, 22, 18, -1, -22 },
  { 5749, 15, 35, 13, 1, -29 },
  { 5815, 1, 41, 22, 12, -31 },
  { 5821, 15, 36, 13, -2, -29 },
  { 5889, 19, 3, 23, 3, -16 },
};

const GFXfont NotoSans_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_THINITALIC41PT7B_H_
