#ifndef _NOTOSANS_THINITALIC54PT7B_H_
#define _NOTOSANS_THINITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x38,
  0x0C, 0x00, 0x10, 0x33, 0x02, 0x30, 0x23, 0x02, 0x20, 0x62, 0x06, 0x60,
  0x46, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x8C, 0x08, 0x80, 0x88, 0x18, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x80, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC6, 0x1E, 0x03, 0x82, 0x02,
  0x03, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x60,
  0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00, 0x08, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x38,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x11, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x18, 0x00, 0x18, 0x18,
  0x10, 0x0C, 0x18, 0x0F, 0x04, 0x78, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x03, 0x8C, 0x00,
  0x03, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x80, 0x01, 0x01, 0x00, 0x60,
  0x01, 0x81, 0x80, 0x30, 0x01, 0x80, 0x80, 0x18, 0x01, 0x80, 0xC0, 0x0C,
  0x00, 0x80, 0x40, 0x06, 0x00, 0xC0, 0x20, 0x03, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x40, 0x18, 0x00, 0xC0, 0x40, 0x0C, 0x00, 0x40, 0x60, 0x04, 0x00,
  0x20, 0x60, 0x02, 0x00, 0x30, 0x20, 0x01, 0x00, 0x18, 0x20, 0x20, 0x80,
  0x08, 0x30, 0xFE, 0x40, 0x0C, 0x30, 0xC1, 0xA0, 0x04, 0x10, 0xC0, 0x70,
  0x06, 0x18, 0xC0, 0x3C, 0x02, 0x18, 0x40, 0x0A, 0x02, 0x18, 0x60, 0x05,
  0xC6, 0x08, 0x20, 0x02, 0x7E, 0x0C, 0x30, 0x01, 0x00, 0x0C, 0x18, 0x00,
  0x80, 0x0C, 0x08, 0x00, 0x40, 0x04, 0x04, 0x00, 0x60, 0x06, 0x06, 0x00,
  0x30, 0x06, 0x03, 0x00, 0x18, 0x06, 0x01, 0x80, 0x08, 0x02, 0x00, 0x80,
  0x04, 0x03, 0x00, 0x40, 0x06, 0x03, 0x00, 0x20, 0x02, 0x01, 0x00, 0x10,
  0x03, 0x01, 0x00, 0x0C, 0x01, 0x01, 0x80, 0x06, 0x01, 0x81, 0x80, 0x01,
  0x01, 0x80, 0x80, 0x00, 0xC1, 0x81, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x40,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20,
  0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x13, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x82,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x03, 0x18, 0x01, 0x80, 0x02, 0x30, 0x00,
  0xC0, 0x06, 0x60, 0x00, 0x40, 0x0C, 0x60, 0x00, 0x60, 0x08, 0xC0, 0x00,
  0x30, 0x18, 0xC0, 0x00, 0x10, 0x10, 0x80, 0x00, 0x18, 0x20, 0x80, 0x00,
  0x0C, 0x60, 0x80, 0x00, 0x06, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0C, 0x80, 0x60, 0x00,
  0x30, 0x40, 0x70, 0x00, 0x60, 0x60, 0x3C, 0x03, 0x80, 0x30, 0x0F, 0xFE,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x13, 0x33, 0x22, 0x66, 0x44, 0x4C,
  0x88, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x40, 0x0E, 0x01, 0x00, 0x1C, 0x04, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x80, 0x00, 0x1A, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x31, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x08, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x40, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x06, 0x08, 0x30, 0x61,
  0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00, 0xFF, 0xF8, 0xDF, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40,
  0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20,
  0x60, 0x00, 0x30, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x01, 0xC0, 0x1E, 0x03, 0x20, 0x71, 0x06, 0x18, 0xE0, 0xCC, 0x06, 0xC0,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC3, 0x80, 0x03, 0x00, 0x38,
  0x03, 0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xE1, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x10, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x10, 0x10, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x02, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x04, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x80,
  0x18, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0xFF, 0x80, 0x00, 0xFC, 0x1C, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x01, 0xE0, 0x07,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xC0, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x3E, 0x00, 0x20, 0xFF,
  0xC0, 0x31, 0xC0, 0x38, 0x19, 0x80, 0x06, 0x09, 0x00, 0x01, 0x05, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x23, 0x80, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x06, 0x40, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x20, 0x00, 0x18, 0x18, 0x00, 0x18, 0x04, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x04, 0x01,
  0x80, 0x01, 0x80, 0x40, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xEC, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x07, 0x00,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x22, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x88, 0x00, 0x01, 0xC4, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xA0, 0xC0,
  0x01, 0xB0, 0x30, 0x03, 0x98, 0x0E, 0x0F, 0x08, 0x01, 0xFE, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x04, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x00, 0x20, 0x07, 0x00, 0x70, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xE1, 0xE0, 0x40, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x03,
  0xFF, 0x00, 0x21, 0x80, 0x07, 0x01, 0xC0, 0x11, 0x80, 0x06, 0x00, 0x60,
  0x08, 0xC0, 0x06, 0x00, 0x20, 0x06, 0x40, 0x04, 0x00, 0x10, 0x03, 0x60,
  0x06, 0x00, 0x18, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0xD0, 0x02, 0x00,
  0x04, 0x00, 0x58, 0x03, 0x00, 0x02, 0x00, 0x2C, 0x01, 0x00, 0x03, 0x00,
  0x16, 0x00, 0x80, 0x01, 0x00, 0x1B, 0x00, 0xC0, 0x00, 0x80, 0x0D, 0x80,
  0x60, 0x00, 0xC0, 0x04, 0x80, 0x30, 0x00, 0x60, 0x06, 0x40, 0x18, 0x00,
  0x70, 0x02, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x18, 0x06, 0x00, 0x38, 0x03,
  0x0C, 0x01, 0x00, 0x36, 0x01, 0x86, 0x00, 0xC0, 0x33, 0x03, 0x81, 0x00,
  0x30, 0x70, 0xC3, 0x80, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x10, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x80, 0x1F, 0x80, 0x08, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x78, 0x08, 0x00, 0x7E, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x0F, 0x00, 0x10, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0x90, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x08,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x02, 0x07, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x23,
  0x20, 0x00, 0x00, 0x4C, 0x60, 0x00, 0x00, 0xB0, 0x40, 0x00, 0x03, 0xC0,
  0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0x80, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x01, 0x60, 0x00, 0x00, 0x0A, 0x01, 0x60, 0x00, 0x00, 0x1A,
  0x01, 0x20, 0x00, 0x00, 0x32, 0x03, 0x20, 0x00, 0x00, 0x26, 0x03, 0x20,
  0x00, 0x00, 0x66, 0x02, 0x30, 0x00, 0x00, 0x44, 0x02, 0x30, 0x00, 0x00,
  0xC4, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x06, 0x10, 0x00, 0x01, 0x0C, 0x06,
  0x10, 0x00, 0x03, 0x0C, 0x04, 0x10, 0x00, 0x02, 0x08, 0x04, 0x18, 0x00,
  0x06, 0x08, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x0C, 0x08, 0x00, 0x08, 0x18,
  0x0C, 0x08, 0x00, 0x18, 0x10, 0x08, 0x08, 0x00, 0x10, 0x10, 0x08, 0x08,
  0x00, 0x30, 0x10, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x40,
  0x30, 0x10, 0x04, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x02,
  0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x40, 0x20, 0x02, 0x04, 0x00, 0x40,
  0x60, 0x02, 0x0C, 0x00, 0xC0, 0x60, 0x02, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x10, 0x00, 0x80, 0x40, 0x03, 0x30, 0x00, 0x80, 0x40, 0x01, 0x20, 0x00,
  0x80, 0xC0, 0x01, 0x60, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x20, 0x16, 0x00, 0x00, 0x10, 0x09, 0x00, 0x00, 0x08, 0x04, 0x80,
  0x00, 0x0C, 0x06, 0x60, 0x00, 0x06, 0x03, 0x10, 0x00, 0x02, 0x01, 0x0C,
  0x00, 0x01, 0x00, 0x82, 0x00, 0x00, 0x80, 0x41, 0x80, 0x00, 0xC0, 0x60,
  0x40, 0x00, 0x60, 0x30, 0x20, 0x00, 0x20, 0x10, 0x18, 0x00, 0x10, 0x08,
  0x04, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x80, 0x06, 0x02,
  0x00, 0x60, 0x02, 0x01, 0x00, 0x10, 0x01, 0x00, 0x80, 0x08, 0x01, 0x80,
  0xC0, 0x06, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20,
  0x10, 0x00, 0x20, 0x10, 0x08, 0x00, 0x18, 0x18, 0x0C, 0x00, 0x04, 0x0C,
  0x06, 0x00, 0x02, 0x04, 0x02, 0x00, 0x01, 0x82, 0x01, 0x00, 0x00, 0x41,
  0x01, 0x80, 0x00, 0x31, 0x80, 0xC0, 0x00, 0x08, 0xC0, 0x60, 0x00, 0x06,
  0x40, 0x20, 0x00, 0x01, 0x20, 0x10, 0x00, 0x00, 0x90, 0x18, 0x00, 0x00,
  0x78, 0x0C, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x04, 0x00,
  0x07, 0x00, 0x80, 0x03, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x04, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x00, 0x18, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x40, 0x00, 0x40, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x08, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC3,
  0xF0, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x05, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x40,
  0x04, 0x00, 0x18, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00,
  0x10, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x08, 0x08,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x01,
  0x30, 0x00, 0x11, 0x00, 0x01, 0x98, 0x00, 0x18, 0x80, 0x00, 0x8C, 0x00,
  0x08, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x06, 0x18,
  0x00, 0x20, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x40, 0x03, 0x06, 0x00, 0x10,
  0x20, 0x01, 0x03, 0x00, 0x18, 0x10, 0x01, 0x81, 0x80, 0x08, 0x08, 0x00,
  0x80, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x20, 0x04, 0x02, 0x00, 0x40, 0x10,
  0x06, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00,
  0x40, 0x30, 0x02, 0x01, 0x00, 0x30, 0x18, 0x01, 0x01, 0x80, 0x18, 0x08,
  0x00, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x06, 0x04, 0x00, 0x20,
  0x40, 0x03, 0x06, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00,
  0x43, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80,
  0x01, 0x98, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0xC0, 0x00, 0x6C,
  0x00, 0x02, 0x40, 0x00, 0x34, 0x00, 0x01, 0x20, 0x00, 0x1A, 0x00, 0x00,
  0xB0, 0x00, 0x0F, 0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x08, 0x00, 0x01, 0x82,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x10, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x40, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20,
  0x10, 0x08, 0x06, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x10,
  0x00, 0x30, 0x10, 0x00, 0x60, 0x18, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x08, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x04, 0x08, 0x00, 0x06, 0x18, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0xC1, 0x06, 0x08, 0x30, 0x60, 0x81, 0x00, 0x1F, 0x81, 0x80, 0x78, 0x70,
  0x80, 0x60, 0x0C, 0x40, 0x60, 0x03, 0x20, 0x60, 0x00, 0xB0, 0x60, 0x00,
  0x58, 0x60, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x82, 0x00, 0x01, 0x41, 0x80, 0x01, 0x60, 0x40, 0x01, 0xB0,
  0x30, 0x01, 0x90, 0x08, 0x01, 0x88, 0x07, 0x03, 0x04, 0x00, 0xFF, 0x06,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x03, 0xF0, 0x00, 0x83,
  0x87, 0x00, 0x63, 0x00, 0x60, 0x19, 0x80, 0x0C, 0x04, 0xC0, 0x01, 0x81,
  0x60, 0x00, 0x60, 0xF0, 0x00, 0x08, 0x38, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C,
  0x20, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x41, 0x40, 0x00,
  0x30, 0x50, 0x00, 0x18, 0x36, 0x00, 0x0C, 0x0C, 0xC0, 0x06, 0x02, 0x1C,
  0x07, 0x00, 0x83, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xE1, 0xF0, 0x1C, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x60, 0x07, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xC0, 0xC0, 0x0F, 0x8F, 0x08, 0x01, 0x80, 0x18,
  0x80, 0x30, 0x00, 0xC8, 0x06, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x78, 0x18,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x80, 0x80, 0x00, 0x28, 0x0C, 0x00,
  0x04, 0x80, 0x40, 0x00, 0xD8, 0x06, 0x00, 0x19, 0x00, 0x20, 0x06, 0x10,
  0x03, 0x81, 0xC1, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xE3, 0xC0, 0x1C, 0x01, 0x80, 0xC0, 0x02, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x08,
  0xC0, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x01, 0xC1, 0x00,
  0xFC, 0x07, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x04, 0x03, 0x80, 0x70, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x30, 0x03, 0xE3, 0xC2, 0x00, 0x60, 0x06,
  0x20, 0x0C, 0x00, 0x32, 0x01, 0x80, 0x01, 0x20, 0x30, 0x00, 0x1E, 0x06,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x0A, 0x03, 0x00,
  0x01, 0x60, 0x10, 0x00, 0x36, 0x01, 0x80, 0x06, 0x40, 0x08, 0x01, 0x84,
  0x00, 0xE0, 0x70, 0x40, 0x03, 0xFC, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x3F, 0x80, 0x10, 0x78,
  0xE0, 0x18, 0xE0, 0x18, 0x08, 0xC0, 0x06, 0x04, 0xC0, 0x01, 0x02, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60,
  0x00, 0x08, 0x20, 0x00, 0x04, 0x30, 0x00, 0x02, 0x18, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0xCE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x03, 0x02, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x04, 0x00, 0x30, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x0C, 0x03,
  0x00, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x10, 0xE0, 0x00, 0x11, 0xA0, 0x00, 0x13, 0x30,
  0x00, 0x36, 0x10, 0x00, 0x2C, 0x18, 0x00, 0x30, 0x08, 0x00, 0x20, 0x0C,
  0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03,
  0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00,
  0xC0, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x02, 0x07, 0xE0, 0x03,
  0xF8, 0x02, 0x1C, 0x78, 0x0F, 0x1C, 0x06, 0x30, 0x0C, 0x18, 0x06, 0x04,
  0x40, 0x0C, 0x30, 0x03, 0x04, 0x80, 0x04, 0x60, 0x03, 0x05, 0x00, 0x06,
  0xC0, 0x01, 0x0F, 0x00, 0x07, 0x80, 0x01, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x18, 0x00, 0x04, 0x00, 0x03, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x18, 0x00, 0x04, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x40, 0x00, 0x30, 0x00, 0x08, 0x40, 0x00, 0x20, 0x00,
  0x18, 0xC0, 0x00, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x80, 0x00, 0x60, 0x00, 0x30, 0x02, 0x03, 0xF8,
  0x01, 0x07, 0x8E, 0x01, 0x8E, 0x01, 0x80, 0x8C, 0x00, 0x60, 0x4C, 0x00,
  0x10, 0x2C, 0x00, 0x0C, 0x3C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x02, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x10,
  0x40, 0x00, 0x08, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x10, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x60,
  0x07, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0x60, 0x00, 0x30, 0x10, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x7E, 0x00, 0x02, 0x0E, 0x1C, 0x00, 0x31, 0x80,
  0x30, 0x01, 0x18, 0x00, 0xC0, 0x09, 0x80, 0x03, 0x00, 0x58, 0x00, 0x18,
  0x07, 0x80, 0x00, 0x40, 0x38, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x02, 0x01, 0x40, 0x00, 0x30, 0x0A, 0x00, 0x03, 0x00, 0xD8, 0x00, 0x30,
  0x06, 0x60, 0x03, 0x00, 0x21, 0xC0, 0x70, 0x01, 0x07, 0xFE, 0x00, 0x08,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0xC0, 0x3E, 0x3C, 0x20, 0x18, 0x01, 0x88, 0x0C, 0x00, 0x32,
  0x06, 0x00, 0x04, 0x83, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0E, 0x08, 0x00,
  0x02, 0x83, 0x00, 0x01, 0x60, 0x40, 0x00, 0xD8, 0x18, 0x00, 0x64, 0x02,
  0x00, 0x71, 0x00, 0xE0, 0x70, 0x40, 0x0F, 0xF0, 0x30, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x07, 0xE0, 0x43, 0xCC, 0x18, 0xC0, 0x02,
  0x30, 0x00, 0x4C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0x1F, 0xC1, 0x80, 0x04, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x20, 0x00, 0xC1,
  0xC0, 0x1C, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x01, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x18, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x03, 0x84,
  0x00, 0x01, 0x82, 0x00, 0x01, 0x41, 0x00, 0x01, 0xA0, 0xC0, 0x01, 0x90,
  0x60, 0x01, 0x98, 0x18, 0x01, 0x88, 0x06, 0x03, 0x84, 0x01, 0xFF, 0x02,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10,
  0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x06, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x80, 0x20, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x08, 0x02, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x40, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x06, 0x40, 0x00, 0x1B, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x28, 0x00, 0x1C, 0x00,
  0x1A, 0x00, 0x07, 0x00, 0x04, 0xC0, 0x03, 0xC0, 0x03, 0x30, 0x00, 0x90,
  0x00, 0x8C, 0x00, 0x64, 0x00, 0x63, 0x00, 0x11, 0x00, 0x10, 0xC0, 0x0C,
  0x40, 0x0C, 0x30, 0x02, 0x10, 0x03, 0x04, 0x01, 0x84, 0x00, 0x81, 0x00,
  0x41, 0x80, 0x60, 0x40, 0x30, 0x60, 0x10, 0x10, 0x08, 0x18, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x01, 0x03, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x60, 0x08, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x86,
  0x00, 0x62, 0x00, 0x21, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03,
  0x20, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x14, 0x00, 0x1E, 0x00,
  0x05, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x20, 0x30, 0x00, 0x08, 0x02,
  0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x08, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x10,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x3E, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3F,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xB0, 0x1C, 0x00, 0xF0, 0x03,
  0xC1, 0xD0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 39, 11, 2, -39 },
  { 50, 12, 14, 17, 6, -39 },
  { 71, 32, 39, 33, 2, -39 },
  { 227, 25, 44, 30, 3, -41 },
  { 365, 33, 40, 41, 5, -39 },
  { 530, 32, 40, 37, 3, -39 },
  { 690, 4, 14, 9, 6, -39 },
  { 697, 15, 48, 13, 2, -39 },
  { 787, 15, 48, 13, -3, -39 },
  { 877, 22, 23, 29, 7, -41 },
  { 941, 25, 24, 31, 4, -31 },
  { 1016, 7, 13, 10, -2, -6 },
  { 1028, 13, 1, 17, 2, -15 },
  { 1030, 3, 3, 11, 2, -3 },
  { 1032, 23, 39, 17, -2, -39 },
  { 1145, 25, 40, 30, 4, -39 },
  { 1270, 13, 39, 30, 9, -39 },
  { 1334, 26, 39, 30, 1, -39 },
  { 1461, 27, 40, 30, 1, -39 },
  { 1596, 28, 39, 30, 1, -39 },
  { 1733, 27, 40, 30, 2, -39 },
  { 1868, 25, 40, 30, 4, -39 },
  { 1993, 24, 39, 30, 6, -39 },
  { 2110, 26, 40, 30, 3, -39 },
  { 2240, 25, 40, 30, 3, -39 },
  { 2365, 8, 29, 11, 2, -29 },
  { 2394, 12, 36, 11, -2, -29 },
  { 2448, 25, 25, 31, 4, -32 },
  { 2527, 25, 12, 31, 4, -25 },
  { 2565, 25, 25, 31, 4, -32 },
  { 2644, 19, 39, 22, 4, -39 },
  { 2737, 41, 43, 45, 3, -38 },
  { 2958, 30, 39, 30, -3, -39 },
  { 3105, 28, 39, 32, 3, -39 },
  { 3242, 29, 40, 32, 5, -39 },
  { 3387, 31, 39, 37, 3, -39 },
  { 3539, 27, 39, 29, 3, -39 },
  { 3671, 27, 39, 26, 3, -39 },
  { 3803, 31, 40, 37, 5, -39 },
  { 3958, 34, 39, 37, 3, -39 },
  { 4124, 17, 39, 15, 0, -39 },
  { 4207, 21, 48, 12, -9, -39 },
  { 4333, 31, 39, 29, 3, -39 },
  { 4485, 19, 39, 27, 3, -39 },
  { 4578, 40, 39, 44, 3, -39 },
  { 4773, 33, 39, 36, 3, -39 },
  { 4934, 32, 40, 39, 5, -39 },
  { 5094, 27, 39, 30, 3, -39 },
  { 5226, 32, 48, 39, 5, -39 },
  { 5418, 27, 39, 30, 3, -39 },
  { 5550, 26, 40, 27, 1, -39 },
  { 5680, 26, 39, 26, 5, -39 },
  { 5807, 32, 40, 37, 5, -39 },
  { 5967, 27, 39, 29, 6, -39 },
  { 6099, 41, 39, 45, 7, -39 },
  { 6299, 33, 39, 26, -3, -39 },
  { 6460, 26, 39, 26, 5, -39 },
  { 6587, 31, 39, 29, 0, -39 },
  { 6739, 20, 48, 16, 0, -39 },
  { 6859, 9, 39, 17, 5, -39 },
  { 6903, 21, 48, 16, -4, -39 },
  { 7029, 24, 24, 30, 3, -39 },
  { 7101, 21, 1, 20, -5, 6 },
  { 7104, 6, 8, 12, 8, -41 },
  { 7110, 25, 30, 30, 3, -29 },
  { 7204, 26, 42, 31, 2, -41 },
  { 7341, 22, 30, 24, 3, -29 },
  { 7424, 28, 42, 31, 3, -41 },
  { 7571, 22, 30, 27, 3, -29 },
  { 7654, 29, 54, 14, -7, -41 },
  { 7850, 28, 42, 31, 1, -29 },
  { 7997, 25, 41, 30, 2, -41 },
  { 8126, 10, 39, 11, 2, -39 },
  { 8175, 20, 52, 11, -8, -39 },
  { 8305, 24, 41, 24, 2, -41 },
  { 8428, 10, 41, 11, 2, -41 },
  { 8480, 40, 29, 45, 2, -29 },
  { 8625, 25, 29, 30, 2, -29 },
  { 8716, 25, 30, 31, 3, -29 },
  { 8810, 29, 42, 31, -1, -29 },
  { 8963, 26, 42, 31, 3, -29 },
  { 9100, 19, 29, 20, 2, -29 },
  { 9169, 21, 30, 23, 1, -29 },
  { 9248, 15, 37, 17, 3, -36 },
  { 9318, 25, 30, 30, 3, -29 },
  { 9412, 22, 29, 22, 3, -29 },
  { 9492, 34, 29, 35, 3, -29 },
  { 9616, 27, 29, 25, -2, -29 },
  { 9714, 31, 42, 22, -6, -29 },
  { 9877, 25, 29, 24, -1, -29 },
  { 9968, 20, 48, 18, 1, -39 },
  { 10088, 2, 54, 29, 15, -41 },
  { 10102, 19, 48, 18, -3, -39 },
  { 10216, 25, 4, 31, 4, -21 },
};

const GFXfont NotoSans_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_THINITALIC54PT7B_H_
