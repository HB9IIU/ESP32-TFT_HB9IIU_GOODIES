#ifndef _NOTOSANS_THINITALIC68PT7B_H_
#define _NOTOSANS_THINITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x0C,
  0x06, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x31, 0x80, 0x43, 0x01, 0x84, 0x03,
  0x08, 0x06, 0x30, 0x08, 0x60, 0x10, 0xC0, 0x61, 0x00, 0xC2, 0x01, 0x0C,
  0x02, 0x18, 0x04, 0x20, 0x18, 0x40, 0x31, 0x80, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0x0C, 0x1F, 0x00, 0x38, 0x0C, 0x02, 0x00, 0x70, 0x08, 0x00, 0x00, 0xE0,
  0x08, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x78, 0x40, 0x00, 0x00, 0x1E, 0x40, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x9E, 0x00, 0x00, 0x00, 0x83, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x04,
  0x03, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0xFE, 0x0C, 0x7C, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x04,
  0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x00, 0x06, 0x03, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x81, 0xFE,
  0x30, 0x00, 0x60, 0xE0, 0xE1, 0xCC, 0x00, 0x30, 0x30, 0x60, 0x1B, 0x00,
  0x0C, 0x18, 0x30, 0x06, 0xC0, 0x06, 0x0C, 0x18, 0x00, 0xF0, 0x03, 0x87,
  0x06, 0x00, 0x36, 0x00, 0xC1, 0x83, 0x00, 0x0D, 0xC0, 0xE0, 0xC0, 0x80,
  0x03, 0x3F, 0xF0, 0x60, 0x60, 0x00, 0xC7, 0xF0, 0x18, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x04, 0x00, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x00, 0x60, 0x08,
  0x00, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0x18, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x38, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x60, 0xF0, 0x00, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x20, 0x70, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x00, 0x18, 0x30, 0x00, 0x01, 0x80, 0x08, 0x30, 0x00,
  0x00, 0x60, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x08, 0x00, 0x00, 0x0C,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC6, 0x03,
  0x00, 0x00, 0x00, 0x66, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x18, 0x00, 0x00, 0x06,
  0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x0C, 0x01,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x00, 0x3C, 0x01, 0x80, 0x1F, 0x00,
  0xF8, 0x00, 0x60, 0x03, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x21,
  0x86, 0x10, 0x43, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x80, 0x07, 0x00, 0x30, 0x00, 0x78, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x1C, 0x10, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x06, 0x40, 0x3E, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x10,
  0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x20, 0x03, 0x80, 0x06, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x00, 0xFF, 0xFF, 0x67, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x40, 0x07, 0x60, 0x07, 0x30, 0x0E, 0x18, 0x0E, 0x08, 0x1C, 0x0C, 0x1C,
  0x06, 0x38, 0x03, 0x38, 0x01, 0x88, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0x80, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x08, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x20, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x07, 0xF0, 0x00, 0x30, 0x3F, 0xFE,
  0x00, 0x30, 0xF0, 0x07, 0x00, 0x21, 0xC0, 0x01, 0x80, 0x67, 0x00, 0x00,
  0xC0, 0x6E, 0x00, 0x00, 0x60, 0x68, 0x00, 0x00, 0x60, 0x58, 0x00, 0x00,
  0x30, 0xF0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x34, 0x06, 0x00, 0x00, 0x36, 0x01,
  0x80, 0x00, 0x33, 0x00, 0xE0, 0x00, 0x71, 0x80, 0x38, 0x00, 0xF0, 0x80,
  0x07, 0xCF, 0xE0, 0xC0, 0x00, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x0E, 0x03, 0xC0, 0x70, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xDF, 0x80, 0xF0, 0x03, 0x80, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x30, 0x60, 0x00, 0x1F, 0x0F,
  0xE0, 0x03, 0x18, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x63, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x0C, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x01, 0x98, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x32, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x01,
  0x80, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1B, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0x78,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x1B, 0x00, 0x18, 0x00, 0x01, 0x00, 0x03,
  0x60, 0x03, 0x00, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x0D, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x30, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x66, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x03,
  0x80, 0x03, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE3, 0x00, 0x18, 0x00,
  0x1E, 0x00, 0x18, 0x60, 0x03, 0x00, 0x06, 0x40, 0x06, 0x0C, 0x00, 0x70,
  0x01, 0x88, 0x01, 0x81, 0x80, 0x06, 0x00, 0x61, 0x80, 0x60, 0x30, 0x00,
  0x70, 0x38, 0x38, 0x38, 0x03, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x20, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x7F, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xE3, 0x00,
  0x00, 0x3F, 0xFF, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC4, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x80, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x00, 0x03, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x19,
  0xC0, 0x00, 0x00, 0x02, 0x30, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x60, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x58, 0x00, 0x00, 0x00, 0x06, 0x80, 0x19, 0x00, 0x00,
  0x00, 0x01, 0xB0, 0x03, 0x30, 0x00, 0x00, 0x00, 0x66, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x01, 0x18,
  0x00, 0x00, 0x00, 0x62, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x0C,
  0x20, 0x00, 0x00, 0x06, 0x18, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x18,
  0x01, 0x83, 0x00, 0x00, 0x01, 0x83, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60,
  0x60, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x80, 0xC0, 0x00, 0x03,
  0x01, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x18, 0x04, 0x00,
  0x00, 0xC0, 0x30, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x03, 0x00, 0x10, 0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x0C,
  0x00, 0x08, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00, 0x30, 0x00, 0x10,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x20, 0x06, 0x00,
  0x01, 0xB0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xC0, 0x0B, 0x00,
  0x00, 0x00, 0x20, 0x06, 0x60, 0x00, 0x00, 0x18, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x00, 0x62, 0x00, 0x00, 0x01, 0x80, 0x18, 0xC0, 0x00, 0x00, 0x60,
  0x04, 0x30, 0x00, 0x00, 0x10, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x01, 0x00, 0x00, 0x08, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x18, 0x03, 0x00, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0x30, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x18, 0x01, 0x00, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x18, 0x00, 0x00, 0x20, 0x60, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x01, 0x00, 0x00, 0x03, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x30, 0x03,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x80, 0x00, 0x00, 0x12, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x80, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xC0, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x40, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x02, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x20, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xA0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x0C,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x08, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x10, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x04,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x90, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xFE, 0x03, 0x00, 0x1E, 0x07, 0x82, 0x00,
  0x38, 0x01, 0xC2, 0x00, 0xE0, 0x00, 0xC6, 0x01, 0xC0, 0x00, 0x66, 0x03,
  0x80, 0x00, 0x26, 0x03, 0x00, 0x00, 0x34, 0x06, 0x00, 0x00, 0x14, 0x0C,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x01, 0xC0, 0x40,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x06, 0xC0, 0x60,
  0x00, 0x04, 0xC0, 0x30, 0x00, 0x0C, 0x80, 0x30, 0x00, 0x18, 0x80, 0x18,
  0x00, 0x71, 0x80, 0x1C, 0x00, 0xC1, 0x80, 0x0F, 0x07, 0x81, 0x00, 0x03,
  0xFF, 0x01, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0xF0, 0x3C, 0x00, 0x61, 0xC0,
  0x07, 0x00, 0x31, 0xC0, 0x01, 0x80, 0x19, 0x80, 0x00, 0x60, 0x09, 0x80,
  0x00, 0x18, 0x0D, 0x80, 0x00, 0x0C, 0x06, 0x80, 0x00, 0x06, 0x03, 0xC0,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x02, 0x80, 0x00, 0x03,
  0x01, 0x60, 0x00, 0x03, 0x81, 0xB0, 0x00, 0x01, 0x80, 0xCC, 0x00, 0x01,
  0x80, 0x67, 0x00, 0x03, 0x80, 0x21, 0xC0, 0x03, 0x80, 0x30, 0x78, 0x0F,
  0x00, 0x18, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x10,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x07, 0x80, 0x18, 0x00, 0x07, 0xFF, 0x01, 0x80,
  0x01, 0xF0, 0x3C, 0x18, 0x00, 0x38, 0x00, 0xE1, 0x80, 0x0E, 0x00, 0x03,
  0x10, 0x01, 0xC0, 0x00, 0x33, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x03, 0x00,
  0x00, 0x0B, 0x00, 0x60, 0x00, 0x00, 0xB0, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x04,
  0x00, 0x00, 0x07, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x1A,
  0x00, 0x60, 0x00, 0x03, 0x60, 0x06, 0x00, 0x00, 0x36, 0x00, 0x30, 0x00,
  0x06, 0x60, 0x03, 0x00, 0x01, 0xC4, 0x00, 0x38, 0x00, 0x38, 0x40, 0x01,
  0xC0, 0x0E, 0x0C, 0x00, 0x0F, 0x03, 0xC0, 0xC0, 0x00, 0x3F, 0xF0, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x88, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x78,
  0x60, 0x00, 0x7C, 0x0C, 0x01, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x10, 0x00, 0xF8, 0x1E, 0x0C, 0x00, 0x70, 0x01, 0xC3, 0x00,
  0x70, 0x00, 0x18, 0x80, 0x38, 0x00, 0x02, 0x20, 0x1C, 0x00, 0x00, 0xD8,
  0x06, 0x00, 0x00, 0x16, 0x03, 0x00, 0x00, 0x05, 0x81, 0x80, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x03,
  0x80, 0x80, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0xD0, 0x0C, 0x00, 0x00,
  0x2C, 0x03, 0x00, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x0C, 0xC0, 0x18, 0x00,
  0x0E, 0x20, 0x07, 0x00, 0x07, 0x18, 0x00, 0xE0, 0x03, 0x86, 0x00, 0x1E,
  0x07, 0x81, 0x80, 0x01, 0xFF, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x80, 0x7F, 0xF0,
  0x01, 0x81, 0xE0, 0x78, 0x01, 0x83, 0x00, 0x1C, 0x01, 0x8E, 0x00, 0x0E,
  0x01, 0x9C, 0x00, 0x06, 0x01, 0x30, 0x00, 0x06, 0x03, 0x20, 0x00, 0x02,
  0x03, 0x60, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x02,
  0x03, 0x80, 0x00, 0x02, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x04,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0xD8, 0x00, 0x00,
  0xC6, 0x60, 0x00, 0x02, 0x30, 0xC0, 0x00, 0x1B, 0x83, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x10, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x06, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0xC3, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x18, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x02, 0x30, 0x00, 0x21, 0xC0, 0x00, 0xC0, 0x4C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x03,
  0x40, 0x00, 0x1B, 0x00, 0x00, 0x60, 0x78, 0x00, 0x03, 0x40, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7F, 0xF0,
  0x01, 0x81, 0xE0, 0x78, 0x01, 0x83, 0x00, 0x1C, 0x01, 0x8E, 0x00, 0x0E,
  0x01, 0x1C, 0x00, 0x06, 0x01, 0x30, 0x00, 0x06, 0x03, 0x20, 0x00, 0x02,
  0x03, 0x60, 0x00, 0x02, 0x03, 0xC0, 0x00, 0x03, 0x02, 0x80, 0x00, 0x02,
  0x03, 0x80, 0x00, 0x02, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x3C,
  0x0F, 0x00, 0x03, 0x0E, 0x00, 0x38, 0x00, 0x31, 0xC0, 0x01, 0x80, 0x02,
  0x30, 0x00, 0x0C, 0x00, 0x26, 0x00, 0x00, 0x60, 0x06, 0x40, 0x00, 0x06,
  0x00, 0x6C, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0x03, 0x00, 0x50, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x08, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x00, 0x50,
  0x00, 0x00, 0x60, 0x05, 0x80, 0x00, 0x0E, 0x00, 0xD8, 0x00, 0x00, 0xC0,
  0x0C, 0xC0, 0x00, 0x18, 0x00, 0xCE, 0x00, 0x07, 0x00, 0x08, 0x70, 0x00,
  0xE0, 0x01, 0x83, 0xC0, 0x78, 0x00, 0x18, 0x0F, 0xFE, 0x00, 0x01, 0x80,
  0x1E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x40, 0x07, 0xC0, 0xF0, 0x60,
  0x07, 0x00, 0x1C, 0x30, 0x0E, 0x00, 0x03, 0x10, 0x0E, 0x00, 0x00, 0x88,
  0x0E, 0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0x16, 0x06, 0x00, 0x00, 0x0B,
  0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38, 0x10, 0x00,
  0x00, 0x1C, 0x08, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x1A, 0x03, 0x00,
  0x00, 0x1B, 0x01, 0x80, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x0C, 0xC0, 0x30,
  0x00, 0x0C, 0x40, 0x0C, 0x00, 0x1C, 0x20, 0x07, 0x00, 0x18, 0x30, 0x01,
  0xE0, 0x78, 0x18, 0x00, 0x3F, 0xF0, 0x0C, 0x00, 0x03, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0xFF, 0x80, 0xC0, 0xF0, 0xC0, 0x61, 0xC0, 0x00,
  0x31, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x09, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x03, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFD, 0xFF,
  0xFF, 0x81, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x08, 0x01, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x34, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x06,
  0x60, 0x60, 0x00, 0x18, 0x80, 0x60, 0x00, 0x61, 0x00, 0xE0, 0x03, 0x86,
  0x00, 0xF0, 0x3C, 0x0C, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x00, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x10, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x60,
  0x02, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x60,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0x43, 0x00, 0x06,
  0x10, 0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x62, 0x00,
  0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0xB0, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x05, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xE8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 13, 50, 14, 2, -49 },
  { 83, 15, 18, 21, 7, -49 },
  { 117, 40, 49, 42, 2, -49 },
  { 362, 32, 56, 37, 3, -52 },
  { 586, 42, 50, 52, 6, -49 },
  { 849, 41, 50, 46, 3, -49 },
  { 1106, 6, 18, 12, 7, -49 },
  { 1120, 19, 60, 16, 2, -49 },
  { 1263, 19, 60, 16, -4, -49 },
  { 1406, 27, 28, 36, 9, -51 },
  { 1501, 31, 32, 39, 5, -40 },
  { 1625, 9, 17, 12, -3, -8 },
  { 1645, 16, 1, 21, 3, -19 },
  { 1647, 4, 5, 14, 2, -4 },
  { 1650, 30, 49, 21, -3, -49 },
  { 1834, 32, 50, 37, 4, -49 },
  { 2034, 17, 49, 37, 11, -49 },
  { 2139, 33, 49, 37, 1, -49 },
  { 2342, 35, 50, 37, 1, -49 },
  { 2561, 35, 49, 37, 1, -49 },
  { 2776, 34, 50, 37, 3, -49 },
  { 2989, 32, 50, 37, 5, -49 },
  { 3189, 30, 49, 37, 8, -49 },
  { 3373, 33, 50, 37, 3, -49 },
  { 3580, 33, 50, 37, 3, -49 },
  { 3787, 11, 37, 14, 2, -36 },
  { 3838, 16, 45, 14, -3, -36 },
  { 3928, 31, 31, 39, 5, -40 },
  { 4049, 31, 16, 39, 5, -32 },
  { 4111, 31, 31, 39, 5, -40 },
  { 4232, 23, 50, 27, 6, -49 },
  { 4376, 51, 54, 57, 4, -48 },
  { 4721, 37, 49, 37, -3, -49 },
  { 4948, 36, 49, 41, 3, -49 },
  { 5169, 37, 50, 40, 6, -49 },
  { 5401, 40, 49, 46, 3, -49 },
  { 5646, 35, 49, 36, 3, -49 },
  { 5861, 35, 49, 33, 3, -49 },
  { 6076, 39, 50, 47, 6, -49 },
  { 6320, 43, 49, 46, 3, -49 },
  { 6584, 21, 49, 19, 1, -49 },
  { 6713, 28, 61, 16, -12, -49 },
  { 6927, 40, 49, 37, 3, -49 },
  { 7172, 25, 49, 33, 3, -49 },
  { 7326, 51, 49, 55, 3, -49 },
  { 7639, 42, 49, 46, 3, -49 },
  { 7897, 40, 50, 49, 6, -49 },
  { 8147, 35, 49, 38, 3, -49 },
  { 8362, 40, 61, 49, 6, -49 },
  { 8667, 35, 49, 38, 3, -49 },
  { 8882, 34, 50, 34, 1, -49 },
  { 9095, 33, 49, 33, 6, -49 },
  { 9298, 41, 50, 47, 6, -49 },
  { 9555, 34, 49, 36, 7, -49 },
  { 9764, 53, 49, 56, 8, -49 },
  { 10089, 42, 49, 33, -4, -49 },
  { 10347, 32, 49, 33, 7, -49 },
  { 10543, 40, 49, 37, -1, -49 },
  { 10788, 26, 60, 21, -1, -49 },
  { 10983, 10, 49, 21, 7, -49 },
  { 11045, 26, 60, 21, -5, -49 },
  { 11240, 31, 30, 37, 3, -49 },
  { 11357, 26, 2, 25, -6, 7 },
  { 11364, 8, 11, 15, 10, -52 },
  { 11375, 32, 38, 37, 3, -37 },
  { 11527, 33, 53, 39, 2, -52 },
  { 11746, 27, 38, 31, 4, -37 },
  { 11875, 36, 53, 39, 3, -52 },
  { 12114, 27, 38, 33, 4, -37 },
  { 12243, 37, 68, 18, -9, -52 },
  { 12558, 34, 53, 39, 2, -37 },
  { 12784, 32, 52, 38, 2, -52 },
  { 12992, 13, 49, 14, 2, -49 },
  { 13072, 25, 65, 14, -10, -49 },
  { 13276, 30, 52, 30, 2, -52 },
  { 13471, 13, 52, 14, 2, -52 },
  { 13556, 51, 37, 57, 2, -37 },
  { 13792, 32, 37, 38, 2, -37 },
  { 13940, 31, 38, 38, 4, -37 },
  { 14088, 36, 53, 39, -1, -37 },
  { 14327, 33, 53, 39, 3, -37 },
  { 14546, 25, 36, 25, 2, -36 },
  { 14659, 26, 38, 29, 1, -37 },
  { 14783, 19, 46, 21, 3, -45 },
  { 14893, 31, 37, 38, 4, -36 },
  { 15037, 28, 36, 28, 3, -36 },
  { 15163, 42, 36, 44, 4, -36 },
  { 15352, 34, 36, 31, -2, -36 },
  { 15505, 39, 53, 28, -8, -36 },
  { 15764, 31, 36, 30, -1, -36 },
  { 15904, 24, 60, 22, 2, -49 },
  { 16084, 2, 68, 36, 19, -52 },
  { 16101, 24, 59, 22, -3, -48 },
  { 16278, 31, 6, 39, 5, -27 },
};

const GFXfont NotoSans_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_THINITALIC68PT7B_H_
