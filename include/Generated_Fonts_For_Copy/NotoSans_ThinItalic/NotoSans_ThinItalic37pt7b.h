#ifndef _NOTOSANS_THINITALIC37PT7B_H_
#define _NOTOSANS_THINITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x00, 0x30, 0x20,
  0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01,
  0x01, 0x00, 0x04, 0x08, 0x00, 0x20, 0x20, 0x1F, 0xFF, 0xFC, 0x02, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x03, 0xFF, 0xFF, 0xC0, 0x40,
  0x40, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80,
  0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x31, 0x18, 0x61, 0x00, 0x20, 0x80,
  0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10, 0x03, 0x08, 0x00, 0xC4,
  0x00, 0x32, 0x00, 0x07, 0x00, 0x01, 0x60, 0x00, 0x88, 0x00, 0x42, 0x00,
  0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10, 0x04, 0x10,
  0x82, 0x30, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x07, 0x80, 0x04, 0x11, 0x80, 0x10, 0x41, 0x00, 0x21, 0x01, 0x00,
  0x82, 0x02, 0x02, 0x08, 0x04, 0x08, 0x10, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0x41, 0x01, 0x00, 0x84, 0x02, 0x01, 0x08, 0x04, 0x06, 0x23, 0xE8,
  0x08, 0x88, 0x70, 0x13, 0x20, 0x50, 0x44, 0x40, 0xB1, 0x11, 0x01, 0x3C,
  0x42, 0x02, 0x01, 0x88, 0x04, 0x02, 0x10, 0x08, 0x08, 0x20, 0x10, 0x20,
  0x40, 0x20, 0xC0, 0x80, 0x81, 0x01, 0x01, 0x04, 0x02, 0x06, 0x10, 0x04,
  0x08, 0x20, 0x08, 0x21, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x0C,
  0x00, 0x10, 0x18, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x02, 0x00,
  0x20, 0x08, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x10,
  0xC0, 0x00, 0x4C, 0x00, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0xC2, 0x00,
  0x04, 0x08, 0x03, 0x20, 0x10, 0x09, 0x00, 0x20, 0x48, 0x00, 0xC1, 0x20,
  0x01, 0x08, 0x80, 0x02, 0x42, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00,
  0xA0, 0xC0, 0x04, 0x41, 0x80, 0x61, 0x81, 0xFE, 0x03, 0x00, 0x25, 0x24,
  0xA4, 0x80, 0x00, 0xE0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x04, 0x08, 0x0C, 0x10, 0x04,
  0x20, 0x06, 0x40, 0x03, 0xFF, 0x02, 0x00, 0x0A, 0x00, 0x62, 0x01, 0x84,
  0x06, 0x08, 0x08, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x08, 0x44, 0x22,
  0x11, 0x08, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x61, 0x80, 0x20, 0x10, 0x10, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x21, 0x00, 0x08, 0x40, 0x03, 0x20, 0x00, 0xC8, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x02, 0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x20, 0x20, 0x18, 0x0C, 0x0C,
  0x01, 0xFC, 0x00, 0x01, 0x83, 0x42, 0x46, 0x24, 0x14, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x00, 0x00, 0x1E, 0x00,
  0x1C, 0x30, 0x0C, 0x01, 0x01, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x60, 0xC0, 0x60, 0x08, 0x20, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x20, 0x06,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x08, 0x00, 0x61,
  0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x20, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10,
  0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xE0, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x2F, 0xC0, 0x06, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0xC0, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x70, 0x40, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0xFE, 0x05,
  0x80, 0x85, 0x80, 0x23, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x10, 0x40, 0x10, 0x30, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x61, 0xC0, 0x20, 0x18, 0x10,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00,
  0x83, 0x00, 0x40, 0x40, 0x20, 0x0C, 0x30, 0x01, 0xB0, 0x00, 0x78, 0x00,
  0xE1, 0x00, 0x40, 0x30, 0x20, 0x06, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0x40, 0x04,
  0x08, 0x06, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00, 0xC1,
  0x00, 0x21, 0x80, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x00, 0x14, 0x40,
  0x14, 0x18, 0x32, 0x03, 0xC1, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x3F, 0xC0, 0x00, 0x04, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x01, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x03, 0x83, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x00, 0x3C, 0x03, 0x20, 0x0C, 0x38, 0x12, 0x03, 0x01,
  0x01, 0x40, 0x60, 0x10, 0x14, 0x04, 0x01, 0x01, 0x40, 0x80, 0x20, 0x18,
  0x08, 0x02, 0x01, 0x81, 0x00, 0x20, 0x28, 0x10, 0x02, 0x02, 0x81, 0x00,
  0x40, 0x28, 0x10, 0x04, 0x04, 0x81, 0x00, 0xC0, 0x48, 0x18, 0x14, 0x08,
  0x80, 0x82, 0x23, 0x04, 0x07, 0xC3, 0xE0, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00,
  0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0x40,
  0x04, 0x04, 0x00, 0x80, 0x40, 0x18, 0x02, 0x01, 0x00, 0x20, 0x3F, 0xFE,
  0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00,
  0x01, 0x07, 0xFF, 0x80, 0x80, 0x08, 0x10, 0x00, 0x82, 0x00, 0x10, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00,
  0x08, 0x40, 0x06, 0x08, 0x07, 0x01, 0xFF, 0xC0, 0x60, 0x06, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x44, 0x00, 0x10, 0x80, 0x1C,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x07, 0x01, 0x80, 0x10, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x10, 0x03, 0x00, 0x40, 0x06, 0x01, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0xC0,
  0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x02, 0x04,
  0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x38, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xE0, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFC, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x81, 0xF0, 0x18, 0x00, 0x80,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x01, 0xFF, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x21, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x10, 0x30, 0x00, 0x40,
  0x60, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40,
  0x00, 0x20, 0x80, 0x00, 0xC1, 0xFF, 0xFF, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x00, 0x00,
  0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x0F, 0xC0,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x7E, 0x00,
  0x04, 0x00, 0x18, 0x20, 0x01, 0x01, 0x00, 0x10, 0x08, 0x03, 0x00, 0x80,
  0x30, 0x04, 0x02, 0x00, 0x20, 0x20, 0x01, 0x02, 0x00, 0x08, 0x20, 0x00,
  0x86, 0x00, 0x04, 0x60, 0x00, 0x27, 0x00, 0x01, 0x48, 0x00, 0x14, 0x20,
  0x00, 0xC1, 0x00, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x08, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xA0, 0x50, 0x00, 0x0A, 0x09, 0x00, 0x01, 0x20, 0x90, 0x00,
  0x14, 0x09, 0x00, 0x02, 0x40, 0x90, 0x00, 0x44, 0x09, 0x00, 0x04, 0x41,
  0x08, 0x00, 0x84, 0x10, 0x80, 0x08, 0x81, 0x08, 0x01, 0x08, 0x10, 0x80,
  0x20, 0x83, 0x08, 0x02, 0x08, 0x20, 0x40, 0x40, 0x82, 0x04, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04,
  0x20, 0x20, 0x40, 0x22, 0x02, 0x04, 0x02, 0x40, 0x20, 0x40, 0x28, 0x02,
  0x08, 0x02, 0x80, 0x20, 0x80, 0x30, 0x04, 0x08, 0x03, 0x00, 0x40, 0x06,
  0x00, 0x02, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x28, 0x00, 0x20, 0x90,
  0x00, 0x41, 0x10, 0x00, 0x82, 0x20, 0x02, 0x04, 0x60, 0x04, 0x08, 0x40,
  0x08, 0x20, 0x80, 0x10, 0x40, 0x80, 0x40, 0x81, 0x00, 0x81, 0x01, 0x01,
  0x04, 0x02, 0x02, 0x08, 0x06, 0x04, 0x10, 0x04, 0x10, 0x20, 0x08, 0x20,
  0x40, 0x08, 0x41, 0x00, 0x10, 0x82, 0x00, 0x11, 0x04, 0x00, 0x24, 0x08,
  0x00, 0x68, 0x10, 0x00, 0x50, 0x40, 0x00, 0xA0, 0x80, 0x00, 0xC1, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x03, 0x00, 0x30, 0x02, 0x01, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0x20, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x02, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x40, 0x00, 0x11,
  0x00, 0x00, 0x84, 0x00, 0x06, 0x08, 0x00, 0x30, 0x30, 0x01, 0x80, 0x60,
  0x0C, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x80, 0x30, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x30,
  0x60, 0x18, 0x0F, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x03,
  0x00, 0x30, 0x02, 0x01, 0x00, 0x04, 0x08, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0,
  0x00, 0x04, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x84, 0x00, 0x06, 0x08, 0x00,
  0x30, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0x00, 0x80, 0x30, 0x10, 0x01, 0x02, 0x00, 0x20,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x60, 0x7F, 0xF0, 0x08,
  0x08, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x20, 0x20,
  0x04, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x10, 0x80,
  0x02, 0x10, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x60, 0x70, 0x60, 0x04, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x20, 0x04, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x41,
  0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00,
  0x02, 0x08, 0x00, 0x04, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1A,
  0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x10, 0x80, 0x04, 0x10, 0x00, 0x82,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x08, 0x04,
  0x03, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x24, 0x00, 0x05,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x38, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08,
  0x08, 0x20, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02,
  0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x11, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00,
  0x14, 0x00, 0x60, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x03, 0x00, 0x06, 0x02, 0x00, 0x10, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x02, 0x00, 0x08, 0x08, 0x00, 0x10, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x23, 0x00, 0x00, 0x44, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x84, 0x00, 0x02, 0x08, 0x00, 0x08, 0x08, 0x00, 0x20,
  0x10, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x60, 0x10, 0x00,
  0x40, 0x40, 0x00, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x00, 0xA0,
  0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x08, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x50,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x84, 0x21, 0x08, 0x21,
  0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08,
  0x40, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xC0, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x20, 0x04, 0x10,
  0x06, 0x08, 0x02, 0x04, 0x02, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x00,
  0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x80, 0x00, 0x80, 0xFF, 0xFC,
  0xC2, 0x08, 0x61, 0x04, 0x01, 0xF0, 0x83, 0x04, 0x42, 0x01, 0x22, 0x00,
  0x62, 0x00, 0x31, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31,
  0x00, 0x18, 0x80, 0x14, 0x20, 0x14, 0x18, 0x32, 0x07, 0xE1, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x3C, 0x02, 0x30, 0xC0, 0x90, 0x08,
  0x28, 0x02, 0x14, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x26, 0x00, 0x11, 0x80, 0x04, 0x60, 0x02, 0x14, 0x01, 0x09, 0x80, 0x82,
  0x3F, 0xC0, 0x00, 0xFC, 0x0E, 0x04, 0x30, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x40, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x01,
  0xF0, 0x40, 0xC1, 0x90, 0x20, 0x0A, 0x08, 0x01, 0x42, 0x00, 0x18, 0x40,
  0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00,
  0x50, 0x80, 0x14, 0x08, 0x06, 0x81, 0x81, 0x10, 0x1F, 0xC2, 0x00, 0x00,
  0xF0, 0x06, 0x18, 0x30, 0x18, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x48, 0x01,
  0xA0, 0x06, 0x40, 0x18, 0x87, 0xC3, 0xB0, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x40, 0x7F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x20, 0x60, 0xC4, 0x18, 0x05, 0x04, 0x00, 0xA1, 0x80, 0x0C, 0x20, 0x01,
  0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0xC2, 0x00, 0x28,
  0x40, 0x0A, 0x04, 0x03, 0x40, 0xC0, 0x88, 0x0F, 0xE1, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x70, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x3E, 0x04, 0x61, 0x82, 0x40, 0x21, 0x40, 0x11, 0x40, 0x08, 0xC0,
  0x04, 0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x80, 0x02, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x01, 0x84, 0x01, 0x82, 0x01, 0x81, 0x01, 0x01, 0x01, 0x00, 0x81, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x11, 0x00, 0x11, 0x80, 0x09, 0x40, 0x05, 0x10,
  0x03, 0x08, 0x01, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x08, 0x20, 0x04, 0x10, 0x01, 0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x08, 0x7C, 0x07, 0xC0, 0x98,
  0x61, 0x86, 0x0B, 0x02, 0x20, 0x30, 0xC0, 0x14, 0x01, 0x14, 0x01, 0x40,
  0x11, 0x80, 0x18, 0x01, 0x10, 0x01, 0x00, 0x11, 0x00, 0x10, 0x01, 0x10,
  0x01, 0x00, 0x22, 0x00, 0x20, 0x02, 0x20, 0x02, 0x00, 0x22, 0x00, 0x20,
  0x02, 0x20, 0x02, 0x00, 0x22, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00, 0x44,
  0x00, 0x40, 0x04, 0x40, 0x04, 0x00, 0x44, 0x00, 0x40, 0x04, 0x80, 0x08,
  0x00, 0x88, 0x00, 0x80, 0x08, 0x08, 0x3E, 0x04, 0x61, 0x82, 0x40, 0x21,
  0x40, 0x11, 0x40, 0x08, 0xC0, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x80,
  0x01, 0xF8, 0x03, 0x02, 0x02, 0x00, 0x82, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x40, 0x04,
  0x20, 0x04, 0x08, 0x04, 0x03, 0xFC, 0x00, 0x02, 0x0F, 0x00, 0x23, 0x0C,
  0x02, 0x40, 0x20, 0x28, 0x02, 0x05, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x41, 0x80, 0x04, 0x18,
  0x00, 0x81, 0x40, 0x10, 0x26, 0x02, 0x02, 0x3F, 0xC0, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x41, 0x83,
  0x10, 0xC0, 0x28, 0x40, 0x0A, 0x30, 0x01, 0x88, 0x00, 0x64, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x28, 0x80, 0x14, 0x10, 0x0D,
  0x06, 0x04, 0x40, 0xFE, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x7C, 0x23, 0x00, 0xB0, 0x02, 0x80, 0x14, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x01, 0xF8, 0x0C, 0x0C, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x23, 0x00,
  0x81, 0xFE, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40, 0xFF, 0xC4, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0xF0, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x80, 0x02, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00,
  0x64, 0x00, 0x22, 0x00, 0x31, 0x00, 0x18, 0x80, 0x14, 0x40, 0x12, 0x10,
  0x12, 0x07, 0xF1, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48,
  0x00, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02,
  0x01, 0x04, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x24, 0x00,
  0x50, 0x00, 0x60, 0x00, 0x80, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x14, 0x01, 0x80, 0x28, 0x05, 0x00, 0x90, 0x09, 0x01, 0x20,
  0x22, 0x04, 0x40, 0x44, 0x08, 0x81, 0x08, 0x20, 0x86, 0x10, 0x41, 0x08,
  0x21, 0x02, 0x20, 0x42, 0x04, 0x40, 0x88, 0x09, 0x01, 0x10, 0x12, 0x02,
  0x20, 0x28, 0x02, 0x80, 0x50, 0x05, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x02, 0x00, 0x20, 0x00, 0x08, 0x00, 0x41, 0x00, 0x20, 0x40, 0x18, 0x08,
  0x0C, 0x02, 0x02, 0x00, 0x41, 0x00, 0x10, 0x80, 0x06, 0x40, 0x00, 0xA0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x03, 0x20, 0x01, 0x8C, 0x00,
  0x41, 0x00, 0x20, 0x60, 0x10, 0x08, 0x08, 0x02, 0x04, 0x00, 0x42, 0x00,
  0x18, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x40,
  0x20, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x10, 0x01, 0x01,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00,
  0x42, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x03,
  0x00, 0x60, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60,
  0x1C, 0x00, 0x18, 0x00, 0x31, 0xC0, 0x60, 0x39, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 9, 11, 4, -26 },
  { 33, 22, 26, 23, 1, -26 },
  { 105, 17, 30, 20, 2, -28 },
  { 169, 23, 27, 28, 3, -27 },
  { 247, 22, 27, 25, 2, -27 },
  { 322, 3, 9, 6, 4, -26 },
  { 326, 11, 32, 9, 1, -26 },
  { 370, 10, 32, 9, -2, -26 },
  { 410, 15, 16, 20, 5, -28 },
  { 440, 17, 17, 21, 3, -22 },
  { 477, 5, 9, 7, -2, -4 },
  { 483, 9, 1, 12, 1, -11 },
  { 485, 2, 2, 8, 1, -2 },
  { 486, 17, 26, 11, -2, -26 },
  { 542, 18, 27, 20, 2, -27 },
  { 603, 9, 26, 20, 6, -26 },
  { 633, 19, 27, 20, 0, -27 },
  { 698, 18, 27, 20, 1, -27 },
  { 759, 19, 27, 20, 1, -27 },
  { 824, 19, 26, 20, 1, -26 },
  { 886, 17, 27, 20, 3, -27 },
  { 944, 17, 26, 20, 4, -26 },
  { 1000, 18, 27, 20, 2, -27 },
  { 1061, 17, 27, 20, 2, -27 },
  { 1119, 6, 20, 8, 1, -20 },
  { 1134, 9, 25, 8, -2, -20 },
  { 1163, 17, 17, 21, 3, -22 },
  { 1200, 17, 8, 21, 3, -17 },
  { 1217, 17, 17, 21, 3, -22 },
  { 1254, 13, 27, 15, 3, -27 },
  { 1298, 28, 29, 31, 2, -26 },
  { 1400, 20, 26, 20, -2, -26 },
  { 1465, 19, 26, 22, 2, -26 },
  { 1527, 20, 27, 22, 3, -27 },
  { 1595, 22, 26, 25, 2, -26 },
  { 1667, 19, 26, 20, 2, -26 },
  { 1729, 19, 26, 18, 2, -26 },
  { 1791, 22, 27, 26, 3, -27 },
  { 1866, 23, 26, 25, 2, -26 },
  { 1941, 12, 26, 10, 0, -26 },
  { 1980, 15, 32, 9, -6, -26 },
  { 2040, 21, 26, 20, 2, -26 },
  { 2109, 13, 26, 18, 2, -26 },
  { 2152, 28, 26, 30, 2, -26 },
  { 2243, 23, 26, 25, 2, -26 },
  { 2318, 22, 27, 26, 3, -27 },
  { 2393, 19, 26, 21, 2, -26 },
  { 2455, 22, 33, 26, 3, -27 },
  { 2546, 19, 26, 21, 2, -26 },
  { 2608, 18, 27, 18, 1, -27 },
  { 2669, 18, 26, 18, 3, -26 },
  { 2728, 23, 26, 26, 3, -26 },
  { 2803, 19, 26, 20, 4, -26 },
  { 2865, 28, 26, 31, 5, -26 },
  { 2956, 23, 26, 18, -2, -26 },
  { 3031, 17, 26, 18, 4, -26 },
  { 3087, 21, 26, 20, 0, -26 },
  { 3156, 14, 32, 11, 0, -26 },
  { 3212, 5, 26, 11, 4, -26 },
  { 3229, 14, 32, 11, -3, -26 },
  { 3285, 17, 17, 20, 2, -27 },
  { 3322, 14, 1, 14, -3, 4 },
  { 3324, 5, 6, 8, 5, -28 },
  { 3328, 17, 20, 20, 2, -20 },
  { 3371, 18, 28, 21, 1, -28 },
  { 3434, 15, 20, 17, 2, -20 },
  { 3472, 19, 28, 21, 2, -28 },
  { 3539, 15, 20, 18, 2, -20 },
  { 3577, 20, 37, 10, -5, -28 },
  { 3670, 19, 29, 21, 1, -20 },
  { 3739, 17, 28, 20, 1, -28 },
  { 3799, 7, 27, 8, 1, -27 },
  { 3823, 13, 36, 8, -5, -27 },
  { 3882, 17, 28, 16, 1, -28 },
  { 3942, 7, 28, 8, 1, -28 },
  { 3967, 28, 20, 31, 1, -20 },
  { 4037, 17, 20, 20, 1, -20 },
  { 4080, 17, 20, 21, 2, -20 },
  { 4123, 20, 29, 21, -1, -20 },
  { 4196, 18, 29, 21, 2, -20 },
  { 4262, 14, 20, 14, 1, -20 },
  { 4297, 15, 20, 16, 0, -20 },
  { 4335, 10, 24, 11, 2, -24 },
  { 4365, 17, 20, 20, 2, -20 },
  { 4408, 15, 20, 15, 2, -20 },
  { 4446, 23, 20, 24, 2, -20 },
  { 4504, 18, 20, 17, -1, -20 },
  { 4549, 21, 29, 15, -4, -20 },
  { 4626, 17, 20, 16, -1, -20 },
  { 4669, 13, 32, 12, 1, -26 },
  { 4721, 1, 37, 20, 10, -28 },
  { 4726, 13, 32, 12, -2, -26 },
  { 4778, 17, 4, 21, 3, -15 },
};

const GFXfont NotoSans_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_THINITALIC37PT7B_H_
