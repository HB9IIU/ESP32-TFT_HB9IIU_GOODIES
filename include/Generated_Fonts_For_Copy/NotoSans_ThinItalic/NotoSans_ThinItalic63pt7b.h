#ifndef _NOTOSANS_THINITALIC63PT7B_H_
#define _NOTOSANS_THINITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x18, 0x0C,
  0x60, 0x21, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x42, 0x01, 0x08, 0x0C,
  0x60, 0x31, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x63, 0x01, 0x8C, 0x04,
  0x20, 0x10, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x20, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC6, 0x3F,
  0x00, 0x70, 0x30, 0x18, 0x07, 0x01, 0x80, 0x00, 0x70, 0x08, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0xE0, 0x40, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x06, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x20, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x06, 0x04,
  0x00, 0xC0, 0xE0, 0x3C, 0x06, 0x1C, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1C, 0x01, 0x83, 0x80, 0x00, 0x18, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00,
  0x40, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x01, 0x03, 0x07, 0xF8, 0xC0, 0x03, 0x06, 0x0E,
  0x1C, 0xC0, 0x03, 0x06, 0x18, 0x06, 0x40, 0x06, 0x0C, 0x30, 0x06, 0x60,
  0x06, 0x18, 0x20, 0x02, 0x60, 0x0C, 0x30, 0x60, 0x02, 0x70, 0x18, 0x30,
  0x40, 0x03, 0x38, 0x70, 0x60, 0xC0, 0x03, 0x1F, 0xE0, 0xC0, 0x80, 0x03,
  0x07, 0x01, 0x81, 0x80, 0x03, 0x00, 0x01, 0x81, 0x80, 0x02, 0x00, 0x03,
  0x01, 0x80, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x04, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0x01, 0xC1,
  0xC0, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x2E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x41,
  0x80, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x21, 0x80, 0x01, 0x80,
  0x03, 0x18, 0x00, 0x06, 0x00, 0x31, 0x80, 0x00, 0x18, 0x01, 0x8C, 0x00,
  0x00, 0x60, 0x18, 0x40, 0x00, 0x03, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x0C,
  0x30, 0x00, 0x00, 0x30, 0xC1, 0x80, 0x00, 0x01, 0x8C, 0x0C, 0x00, 0x00,
  0x06, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0xCC, 0x03, 0x00, 0x00, 0x1C,
  0x30, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x30, 0x00, 0x38, 0x06, 0x00, 0xF0,
  0x0F, 0x00, 0x18, 0x03, 0xFF, 0xE0, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x63, 0x18, 0x84, 0x63, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x80, 0x10, 0x00, 0x70, 0x04, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x00, 0x68,
  0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x20, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x0E, 0x00, 0x40, 0x07, 0x00, 0x18, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xA0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3A, 0x00, 0x66, 0x01, 0xC6, 0x03,
  0x84, 0x0E, 0x04, 0x18, 0x0C, 0x70, 0x0C, 0xC0, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x1E, 0x00, 0x04, 0x0F, 0xFF, 0x00, 0x30, 0xF0, 0x0E,
  0x00, 0xC7, 0x00, 0x0C, 0x02, 0x30, 0x00, 0x18, 0x09, 0x80, 0x00, 0x30,
  0x68, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x01, 0x07, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x38, 0x20, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x81, 0x00, 0x00, 0x36, 0x06, 0x00, 0x03, 0x90,
  0x0C, 0x00, 0x1C, 0xC0, 0x1C, 0x03, 0xC3, 0x00, 0x1F, 0xFC, 0x08, 0x00,
  0x0F, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x70, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x38, 0x04, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFE, 0x01, 0xE0,
  0x1C, 0x04, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0xFF, 0xF0, 0x02, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x03, 0x18, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x10, 0x00, 0x60,
  0x00, 0x40, 0x03, 0x30, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x30, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x20, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x00,
  0x00, 0x80, 0x03, 0x60, 0x02, 0x00, 0x01, 0x80, 0x02, 0x60, 0x06, 0x00,
  0x01, 0x80, 0x02, 0x60, 0x06, 0x00, 0x01, 0x80, 0x06, 0x40, 0x06, 0x00,
  0x01, 0x00, 0x06, 0x40, 0x04, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x0C, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x0C, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x18, 0x40, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x40, 0x04, 0x00,
  0x0A, 0x00, 0x30, 0x60, 0x06, 0x00, 0x1A, 0x00, 0x60, 0x60, 0x06, 0x00,
  0x33, 0x00, 0xE0, 0x60, 0x03, 0x00, 0xE3, 0x01, 0xC0, 0x60, 0x01, 0xE3,
  0xC1, 0xC7, 0x80, 0x20, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x20, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x04, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x0E,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0x78, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x00, 0xFF, 0xFE, 0x30, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x04, 0x1C, 0x00, 0x00,
  0x00, 0x61, 0xB0, 0x00, 0x00, 0x03, 0x19, 0x80, 0x00, 0x00, 0x1B, 0x86,
  0x00, 0x00, 0x00, 0xB0, 0x30, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x05, 0x80, 0x00, 0x00, 0x03,
  0x60, 0x1B, 0x00, 0x00, 0x00, 0x04, 0x80, 0x32, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x64, 0x00, 0x00, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xCC,
  0x01, 0x18, 0x00, 0x00, 0x03, 0x10, 0x06, 0x30, 0x00, 0x00, 0x04, 0x20,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x18, 0x40, 0x00, 0x00, 0x61, 0x80,
  0x30, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x00, 0x03, 0x04, 0x01,
  0x83, 0x00, 0x00, 0x04, 0x08, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x06,
  0x04, 0x00, 0x00, 0x60, 0x60, 0x08, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x10,
  0x10, 0x00, 0x03, 0x01, 0x00, 0x60, 0x30, 0x00, 0x04, 0x06, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x02, 0x00,
  0x80, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x20, 0x01, 0x80,
  0xC0, 0x02, 0x00, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x01, 0x80, 0x02, 0x04,
  0x00, 0x18, 0x03, 0x00, 0x04, 0x18, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x60,
  0x00, 0x60, 0x08, 0x00, 0x18, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x24, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x58, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x02,
  0x80, 0x00, 0x00, 0x20, 0x05, 0x80, 0x00, 0x00, 0x40, 0x1B, 0x00, 0x00,
  0x01, 0x80, 0x33, 0x00, 0x00, 0x03, 0x00, 0x66, 0x00, 0x00, 0x06, 0x00,
  0xC6, 0x00, 0x00, 0x08, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x08, 0x00,
  0x00, 0x60, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x30, 0x00, 0x02, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x80, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x00, 0x80, 0x10, 0x03, 0x00, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x02, 0x00, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04,
  0x00, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0x00, 0x60, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x10, 0x00, 0x01, 0x81,
  0x00, 0x20, 0x00, 0x03, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x18, 0x03, 0x00, 0x00, 0x04, 0x20, 0x04, 0x00, 0x00, 0x0C,
  0x40, 0x08, 0x00, 0x00, 0x09, 0x80, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x60,
  0x00, 0x00, 0x36, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xB4, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x40, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x20,
  0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x08, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x40,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x40,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0x40,
  0x03, 0x00, 0x40, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06, 0x00, 0x40,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x40, 0x08, 0x00, 0x60, 0x08, 0x00, 0x40, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0x21,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x21, 0x80, 0x00, 0x21, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x23, 0x00, 0x00, 0x22, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x26, 0x00, 0x00, 0x26, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18,
  0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x02,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFE, 0xC0, 0xC1,
  0x81, 0x81, 0x03, 0x03, 0x02, 0x06, 0x04, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x40, 0x1E, 0x01, 0x86, 0x01, 0xC0, 0x06, 0x30, 0x18, 0x00,
  0x19, 0x01, 0x80, 0x00, 0x48, 0x18, 0x00, 0x03, 0x40, 0x80, 0x00, 0x1E,
  0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x38, 0x10, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x36,
  0x06, 0x00, 0x03, 0x20, 0x30, 0x00, 0x31, 0x00, 0xC0, 0x03, 0x18, 0x03,
  0x00, 0x30, 0xC0, 0x0E, 0x07, 0x04, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x60,
  0x7F, 0xF0, 0x01, 0x07, 0x00, 0xE0, 0x0C, 0x30, 0x01, 0xC0, 0x31, 0x80,
  0x03, 0x00, 0xC8, 0x00, 0x06, 0x02, 0x40, 0x00, 0x08, 0x0B, 0x00, 0x00,
  0x30, 0x78, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x41,
  0xE0, 0x00, 0x03, 0x06, 0x80, 0x00, 0x18, 0x13, 0x00, 0x00, 0xC0, 0x46,
  0x00, 0x06, 0x01, 0x1C, 0x00, 0x70, 0x0C, 0x3C, 0x07, 0x80, 0x30, 0x3F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0x80, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x20, 0x07, 0x80, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0x80, 0x60, 0x00, 0x7F, 0xF8, 0x10, 0x00, 0x78, 0x07, 0x0C,
  0x00, 0x38, 0x00, 0x63, 0x00, 0x18, 0x00, 0x0C, 0xC0, 0x0C, 0x00, 0x01,
  0x20, 0x06, 0x00, 0x00, 0x68, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x0A, 0x00, 0x40, 0x00, 0x07, 0x80, 0x10, 0x00, 0x03, 0x60, 0x06, 0x00,
  0x01, 0x98, 0x01, 0x80, 0x00, 0xC4, 0x00, 0x30, 0x00, 0x61, 0x00, 0x06,
  0x00, 0x70, 0xC0, 0x00, 0xE0, 0x78, 0x30, 0x00, 0x1F, 0xF8, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1E, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00,
  0xE1, 0x80, 0x01, 0xE0, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x20, 0x0F, 0x00, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7C, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x04, 0x00, 0xF0, 0x0E, 0x08, 0x03,
  0x80, 0x06, 0x30, 0x0C, 0x00, 0x06, 0x60, 0x30, 0x00, 0x04, 0x80, 0xC0,
  0x00, 0x0D, 0x03, 0x80, 0x00, 0x0A, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x02, 0x80, 0x80, 0x00, 0x0F, 0x01, 0x00, 0x00, 0x36, 0x03,
  0x00, 0x00, 0xCC, 0x06, 0x00, 0x03, 0x10, 0x06, 0x00, 0x0C, 0x20, 0x06,
  0x00, 0x70, 0xC0, 0x07, 0x03, 0xC1, 0x80, 0x07, 0xFE, 0x03, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x01, 0xFC, 0x00, 0x30, 0x3F, 0xF8, 0x01, 0x07, 0x00, 0xE0, 0x18,
  0x60, 0x01, 0x80, 0xC6, 0x00, 0x0C, 0x06, 0x60, 0x00, 0x30, 0x26, 0x00,
  0x01, 0x81, 0x60, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0xBC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x10, 0x18, 0x00, 0x06,
  0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x38, 0x00, 0x04,
  0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x08, 0x68, 0x00, 0x01, 0x8C, 0xC0, 0x00, 0x19, 0x84, 0x00, 0x01,
  0xB0, 0x60, 0x00, 0x16, 0x02, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x01,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x02, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x04, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x18, 0xC0,
  0x06, 0x0E, 0x00, 0x60, 0x33, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x4C, 0x00,
  0x08, 0xC0, 0x00, 0xC0, 0x90, 0x00, 0x19, 0x00, 0x01, 0x81, 0x40, 0x00,
  0x36, 0x00, 0x01, 0x07, 0x80, 0x00, 0x78, 0x00, 0x02, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x04, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0x41, 0xC0, 0x38, 0x06,
  0x18, 0x00, 0x60, 0x31, 0x80, 0x03, 0x01, 0x98, 0x00, 0x0C, 0x09, 0x80,
  0x00, 0x60, 0x58, 0x00, 0x03, 0x07, 0x80, 0x00, 0x18, 0x38, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x10, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x10, 0x1F, 0xFC, 0x00, 0x08, 0x38, 0x07, 0x00,
  0x0C, 0x30, 0x01, 0xC0, 0x06, 0x30, 0x00, 0x60, 0x03, 0x30, 0x00, 0x18,
  0x01, 0x30, 0x00, 0x04, 0x00, 0xB0, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x02, 0x01, 0xE0, 0x00, 0x03, 0x00, 0xD0, 0x00, 0x03, 0x00, 0x6C,
  0x00, 0x03, 0x00, 0x23, 0x00, 0x03, 0x00, 0x11, 0xC0, 0x07, 0x00, 0x18,
  0x78, 0x0F, 0x00, 0x0C, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x10, 0x07, 0x80, 0x70, 0x40, 0x38, 0x00,
  0x63, 0x01, 0x80, 0x00, 0xCC, 0x0C, 0x00, 0x01, 0x20, 0x60, 0x00, 0x06,
  0x83, 0x80, 0x00, 0x0A, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0A, 0x04,
  0x00, 0x00, 0x78, 0x10, 0x00, 0x03, 0x60, 0x60, 0x00, 0x19, 0x81, 0x80,
  0x00, 0xC4, 0x03, 0x00, 0x06, 0x10, 0x06, 0x00, 0x70, 0xC0, 0x0E, 0x07,
  0x83, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x07, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7C, 0x02, 0x07, 0xFC, 0x04, 0x1C, 0x00, 0x18,
  0xE0, 0x00, 0x33, 0x80, 0x00, 0x64, 0x00, 0x00, 0x90, 0x00, 0x01, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x01, 0xC0,
  0x07, 0x03, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xF8, 0x03, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF0,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x20, 0x0F, 0xF8, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x38, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x34, 0x0C, 0x00, 0x00, 0xB0, 0x10, 0x00, 0x06, 0xC0, 0x60,
  0x00, 0x32, 0x01, 0x80, 0x03, 0x88, 0x03, 0x00, 0x1C, 0x20, 0x07, 0x01,
  0xC1, 0x80, 0x0F, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20,
  0x20, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x10, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x20, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x40, 0x00, 0x18, 0x00, 0x06, 0x40, 0x00, 0x38, 0x00,
  0x06, 0x40, 0x00, 0x28, 0x00, 0x0C, 0x40, 0x00, 0x68, 0x00, 0x0C, 0x40,
  0x00, 0xC8, 0x00, 0x18, 0x40, 0x00, 0xC8, 0x00, 0x18, 0x60, 0x01, 0x8C,
  0x00, 0x30, 0x60, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x20,
  0x60, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x40, 0x60, 0x06,
  0x04, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0x80, 0x60, 0x0C, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x03, 0x00, 0x20,
  0x30, 0x06, 0x02, 0x00, 0x20, 0x20, 0x06, 0x06, 0x00, 0x20, 0x60, 0x06,
  0x06, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00,
  0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x21, 0x00,
  0x02, 0x30, 0x00, 0x33, 0x00, 0x02, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x10, 0x01, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x87, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x81, 0xC8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x02,
  0x00,
};

const GFXglyph NotoSans_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 46, 13, 2, -45 },
  { 70, 14, 16, 20, 7, -45 },
  { 98, 37, 45, 39, 2, -45 },
  { 307, 29, 52, 35, 3, -48 },
  { 496, 40, 47, 48, 5, -46 },
  { 731, 37, 47, 43, 3, -46 },
  { 949, 5, 16, 11, 7, -45 },
  { 959, 18, 55, 15, 2, -45 },
  { 1083, 18, 55, 15, -4, -45 },
  { 1207, 26, 27, 33, 8, -48 },
  { 1295, 29, 29, 36, 5, -37 },
  { 1401, 9, 15, 12, -3, -7 },
  { 1418, 15, 2, 20, 2, -18 },
  { 1422, 3, 4, 13, 2, -3 },
  { 1424, 28, 45, 19, -3, -45 },
  { 1582, 29, 47, 35, 4, -46 },
  { 1753, 16, 45, 35, 10, -45 },
  { 1843, 31, 46, 35, 1, -46 },
  { 2022, 32, 47, 35, 1, -46 },
  { 2210, 32, 45, 35, 1, -45 },
  { 2390, 32, 46, 35, 2, -45 },
  { 2574, 30, 47, 35, 4, -46 },
  { 2751, 28, 45, 35, 7, -45 },
  { 2909, 30, 47, 35, 3, -46 },
  { 3086, 30, 47, 35, 3, -46 },
  { 3263, 10, 35, 13, 2, -34 },
  { 3307, 15, 42, 13, -3, -34 },
  { 3386, 29, 28, 36, 5, -37 },
  { 3488, 29, 14, 36, 5, -29 },
  { 3539, 29, 28, 36, 5, -37 },
  { 3641, 22, 47, 25, 5, -46 },
  { 3771, 48, 50, 53, 3, -44 },
  { 4071, 34, 45, 34, -3, -45 },
  { 4263, 34, 45, 38, 3, -45 },
  { 4455, 35, 47, 37, 5, -46 },
  { 4661, 37, 45, 43, 3, -45 },
  { 4870, 32, 45, 34, 3, -45 },
  { 5050, 32, 45, 31, 3, -45 },
  { 5230, 37, 47, 43, 5, -46 },
  { 5448, 40, 45, 43, 3, -45 },
  { 5673, 20, 45, 18, 0, -45 },
  { 5786, 26, 56, 15, -11, -45 },
  { 5968, 37, 45, 34, 3, -45 },
  { 6177, 23, 45, 31, 3, -45 },
  { 6307, 47, 45, 51, 3, -45 },
  { 6572, 39, 45, 42, 3, -45 },
  { 6792, 38, 47, 45, 5, -46 },
  { 7016, 32, 45, 35, 3, -45 },
  { 7196, 38, 57, 45, 5, -46 },
  { 7467, 32, 45, 35, 3, -45 },
  { 7647, 31, 47, 31, 1, -46 },
  { 7830, 30, 45, 31, 6, -45 },
  { 7999, 38, 46, 44, 6, -45 },
  { 8218, 31, 45, 34, 7, -45 },
  { 8393, 48, 45, 52, 8, -45 },
  { 8663, 40, 45, 31, -4, -45 },
  { 8888, 30, 45, 31, 6, -45 },
  { 9057, 37, 45, 34, -1, -45 },
  { 9266, 24, 55, 19, -1, -45 },
  { 9431, 10, 45, 19, 6, -45 },
  { 9488, 24, 55, 19, -5, -45 },
  { 9653, 29, 27, 35, 3, -45 },
  { 9751, 23, 1, 23, -5, 7 },
  { 9754, 7, 10, 14, 9, -48 },
  { 9763, 29, 35, 34, 3, -34 },
  { 9890, 30, 49, 36, 2, -48 },
  { 10074, 26, 35, 28, 3, -34 },
  { 10188, 34, 49, 36, 3, -48 },
  { 10397, 25, 35, 31, 4, -34 },
  { 10507, 34, 63, 17, -8, -48 },
  { 10775, 31, 49, 36, 2, -34 },
  { 10965, 29, 48, 35, 2, -48 },
  { 11139, 12, 45, 13, 2, -45 },
  { 11207, 23, 60, 13, -9, -45 },
  { 11380, 28, 48, 28, 2, -48 },
  { 11548, 12, 48, 13, 2, -48 },
  { 11620, 47, 34, 53, 2, -34 },
  { 11820, 29, 34, 35, 2, -34 },
  { 11944, 29, 35, 36, 3, -34 },
  { 12071, 33, 49, 36, -1, -34 },
  { 12274, 30, 49, 36, 3, -34 },
  { 12458, 23, 34, 23, 2, -34 },
  { 12556, 24, 35, 27, 1, -34 },
  { 12661, 18, 43, 19, 3, -42 },
  { 12758, 30, 34, 35, 3, -33 },
  { 12886, 26, 33, 26, 3, -33 },
  { 12994, 40, 33, 41, 3, -33 },
  { 13159, 32, 33, 29, -2, -33 },
  { 13291, 36, 48, 26, -7, -33 },
  { 13507, 28, 33, 27, -1, -33 },
  { 13623, 22, 55, 21, 2, -45 },
  { 13775, 1, 63, 34, 18, -48 },
  { 13783, 22, 55, 21, -3, -45 },
  { 13935, 29, 6, 36, 5, -25 },
};

const GFXfont NotoSans_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_THINITALIC63PT7B_H_
