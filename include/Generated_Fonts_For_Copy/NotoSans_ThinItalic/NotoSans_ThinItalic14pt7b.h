#ifndef _NOTOSANS_THINITALIC14PT7B_H_
#define _NOTOSANS_THINITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x10, 0xB7, 0x60, 0x09, 0x04, 0x84, 0x8F, 0xF1,
  0x21, 0x23, 0xFC, 0x48, 0x24, 0x24, 0x00, 0x08, 0x37, 0x14, 0x50, 0x83,
  0x89, 0x26, 0xE6, 0x10, 0x71, 0x48, 0xA4, 0x92, 0x89, 0xBF, 0x64, 0x52,
  0x49, 0x44, 0xA3, 0x80, 0x3C, 0x22, 0x24, 0x2C, 0x30, 0x51, 0x89, 0x86,
  0x84, 0xFA, 0xF0, 0x12, 0x24, 0x48, 0x88, 0x88, 0x84, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x4C, 0x11, 0x38, 0x76, 0x48, 0x10, 0x41, 0x3F, 0x10, 0x40,
  0x56, 0xE0, 0x80, 0x04, 0x10, 0x82, 0x10, 0x42, 0x08, 0x42, 0x00, 0x3D,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0x35, 0xA2, 0x22, 0x24, 0x44,
  0x3E, 0x04, 0x08, 0x10, 0x40, 0x86, 0x10, 0x41, 0xF8, 0x3E, 0x04, 0x08,
  0x11, 0xC0, 0x80, 0x81, 0x03, 0xF8, 0x02, 0x0C, 0x28, 0x92, 0x48, 0xA1,
  0x3F, 0x04, 0x10, 0x3E, 0x81, 0x02, 0x07, 0x80, 0x81, 0x02, 0x09, 0xE0,
  0x1E, 0x41, 0x04, 0x0F, 0x90, 0xA1, 0x42, 0x84, 0xF0, 0xFC, 0x20, 0x84,
  0x10, 0x84, 0x10, 0x82, 0x00, 0x3D, 0x14, 0x51, 0x39, 0xA8, 0x61, 0x87,
  0xE0, 0x3D, 0x18, 0x61, 0x85, 0xF0, 0x42, 0x0B, 0xC0, 0x20, 0x00, 0x20,
  0x10, 0x00, 0x02, 0x44, 0x80, 0x0C, 0xCC, 0x10, 0x38, 0x10, 0xFC, 0x00,
  0x3F, 0xC0, 0xC0, 0xC3, 0x33, 0x00, 0xF8, 0x42, 0x11, 0x31, 0x10, 0x04,
  0x00, 0x1F, 0x88, 0x14, 0x06, 0x3D, 0x91, 0x68, 0x9A, 0x26, 0x9B, 0x99,
  0x20, 0x07, 0xE0, 0x02, 0x06, 0x0A, 0x0A, 0x12, 0x11, 0x2F, 0x41, 0x41,
  0x81, 0x7C, 0x85, 0x0A, 0x17, 0xD0, 0xA0, 0xC1, 0x85, 0xF0, 0x1F, 0x20,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x7E, 0x41, 0x41, 0x41,
  0x41, 0x81, 0x81, 0x82, 0x84, 0xF8, 0x7E, 0x81, 0x02, 0x07, 0xD0, 0x20,
  0x40, 0x81, 0xF0, 0x7E, 0x81, 0x02, 0x04, 0x17, 0xA0, 0x40, 0x81, 0x00,
  0x1F, 0x20, 0x40, 0x80, 0x80, 0x8F, 0x81, 0x82, 0x82, 0x7E, 0x41, 0x41,
  0x41, 0x41, 0x7F, 0x81, 0x82, 0x82, 0x82, 0x82, 0x31, 0x22, 0x22, 0x44,
  0x4C, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x89, 0xC0, 0x43, 0x44, 0x48,
  0x50, 0x60, 0x50, 0x90, 0x88, 0x88, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10,
  0x87, 0xC0, 0x40, 0x58, 0x36, 0x0D, 0x85, 0x61, 0x64, 0xA9, 0x4A, 0x52,
  0x98, 0xA2, 0x20, 0x41, 0x61, 0x61, 0x51, 0x51, 0x89, 0x8A, 0x86, 0x86,
  0x82, 0x3E, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x7C,
  0x85, 0x0A, 0x14, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x3E, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x74, 0x08, 0x0C, 0x7C, 0x85, 0x0A, 0x14,
  0x4F, 0x22, 0x44, 0x89, 0x08, 0x1E, 0x41, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x05, 0xF0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0x40,
  0xA0, 0x50, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x3E, 0x00, 0x81,
  0x82, 0x84, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x20, 0x84, 0x62, 0x19,
  0x46, 0x52, 0xA4, 0xA9, 0x4A, 0x53, 0x18, 0x82, 0x21, 0x00, 0x10, 0x88,
  0x84, 0x81, 0x80, 0x80, 0x40, 0x50, 0x48, 0x42, 0x41, 0x00, 0x83, 0x09,
  0x12, 0x45, 0x04, 0x08, 0x10, 0x40, 0x80, 0x3F, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x40, 0xFC, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0xC0, 0x92, 0x24, 0x92, 0x24, 0x38, 0x42, 0x10, 0x88, 0x42, 0x10, 0x89,
  0xC0, 0x08, 0x62, 0x91, 0x46, 0x10, 0xF8, 0xA4, 0x31, 0x38, 0x61, 0x86,
  0x28, 0xBE, 0x20, 0x40, 0x81, 0x67, 0x28, 0x50, 0xA1, 0x42, 0x87, 0xF0,
  0x3A, 0x21, 0x08, 0x42, 0x1F, 0x02, 0x04, 0x09, 0xD4, 0x50, 0xA1, 0x42,
  0x85, 0x13, 0xE0, 0x32, 0x63, 0x3E, 0x42, 0x1F, 0x07, 0x08, 0x08, 0x1C,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xE0, 0x1C, 0x45,
  0x0A, 0x18, 0x30, 0x51, 0x3E, 0x04, 0x0B, 0xE0, 0x20, 0x40, 0x81, 0x67,
  0x28, 0x50, 0xA1, 0x43, 0x0A, 0x10, 0x20, 0x24, 0x92, 0x90, 0x08, 0x00,
  0x21, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00, 0x20, 0x40, 0x81, 0x12, 0x49,
  0x14, 0x38, 0x51, 0x12, 0x20, 0x24, 0x94, 0x92, 0x52, 0x00, 0x1C, 0xCC,
  0x65, 0x08, 0xA1, 0x14, 0x42, 0x88, 0x61, 0x14, 0x22, 0x0C, 0xE5, 0x0A,
  0x14, 0x28, 0x61, 0x42, 0x39, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x0C, 0xE5,
  0x0A, 0x14, 0x28, 0x50, 0xFE, 0x81, 0x02, 0x00, 0x39, 0x18, 0x61, 0x86,
  0x18, 0xBE, 0x08, 0x20, 0x80, 0x0D, 0xC4, 0x10, 0x41, 0x08, 0x20, 0x3D,
  0x04, 0x18, 0x10, 0x20, 0xBC, 0x47, 0x88, 0x88, 0x88, 0xC0, 0x86, 0x18,
  0x61, 0x8A, 0x2F, 0x80, 0x8C, 0x65, 0x4A, 0x62, 0x00, 0x91, 0xC8, 0xAA,
  0x95, 0x4C, 0xA4, 0x22, 0x20, 0x46, 0x50, 0xC1, 0x05, 0x09, 0x22, 0x00,
  0x11, 0x11, 0x12, 0x12, 0x14, 0x18, 0x08, 0x10, 0x10, 0xE0, 0x3C, 0x21,
  0x08, 0x41, 0x0F, 0x80, 0x18, 0x88, 0x42, 0x23, 0x08, 0x42, 0x10, 0xC0,
  0xFF, 0xFC, 0x18, 0x42, 0x11, 0x08, 0x62, 0x11, 0x09, 0xC0, 0x62, 0x70,
};

const GFXglyph NotoSans_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 4, 2, -10 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 6, 12, 8, 1, -11 },
  { 28, 9, 10, 11, 1, -10 },
  { 40, 8, 10, 10, 1, -10 },
  { 50, 1, 4, 2, 2, -10 },
  { 51, 4, 12, 3, 0, -10 },
  { 57, 4, 12, 3, -1, -10 },
  { 63, 5, 6, 7, 2, -11 },
  { 67, 6, 6, 8, 1, -8 },
  { 72, 2, 4, 3, -1, -2 },
  { 73, 3, 1, 4, 1, -4 },
  { 74, 1, 1, 3, 0, -1 },
  { 75, 6, 10, 4, -1, -10 },
  { 83, 6, 10, 8, 1, -10 },
  { 91, 4, 10, 8, 2, -10 },
  { 96, 7, 10, 8, 0, -10 },
  { 105, 7, 10, 8, 0, -10 },
  { 114, 7, 10, 8, 0, -10 },
  { 123, 7, 10, 8, 1, -10 },
  { 132, 7, 10, 8, 1, -10 },
  { 141, 6, 10, 8, 2, -10 },
  { 149, 6, 10, 8, 1, -10 },
  { 157, 6, 10, 8, 1, -10 },
  { 165, 3, 7, 3, 0, -7 },
  { 168, 4, 9, 3, -1, -7 },
  { 173, 6, 6, 8, 1, -8 },
  { 178, 6, 4, 8, 1, -7 },
  { 181, 6, 6, 8, 1, -8 },
  { 186, 5, 10, 6, 1, -10 },
  { 193, 10, 11, 12, 1, -10 },
  { 207, 8, 10, 8, -1, -10 },
  { 217, 7, 10, 8, 1, -10 },
  { 226, 8, 10, 8, 1, -10 },
  { 236, 8, 10, 9, 1, -10 },
  { 246, 7, 10, 7, 1, -10 },
  { 255, 7, 10, 7, 1, -10 },
  { 264, 8, 10, 10, 1, -10 },
  { 274, 8, 10, 10, 1, -10 },
  { 284, 4, 10, 4, 0, -10 },
  { 289, 5, 12, 3, -2, -10 },
  { 297, 8, 10, 8, 1, -10 },
  { 307, 5, 10, 7, 1, -10 },
  { 314, 10, 10, 11, 1, -10 },
  { 327, 8, 10, 9, 1, -10 },
  { 337, 8, 10, 10, 1, -10 },
  { 347, 7, 10, 8, 1, -10 },
  { 356, 8, 12, 10, 1, -10 },
  { 368, 7, 10, 8, 1, -10 },
  { 377, 7, 10, 7, 0, -10 },
  { 386, 7, 10, 7, 1, -10 },
  { 395, 9, 10, 10, 1, -10 },
  { 407, 8, 10, 7, 1, -10 },
  { 417, 10, 10, 12, 2, -10 },
  { 430, 9, 10, 7, -1, -10 },
  { 442, 7, 10, 7, 1, -10 },
  { 451, 8, 10, 8, 0, -10 },
  { 461, 5, 12, 4, 0, -10 },
  { 469, 3, 10, 4, 1, -10 },
  { 473, 5, 12, 4, -1, -10 },
  { 481, 6, 6, 8, 1, -10 },
  { 486, 5, 1, 5, -1, 1 },
  { 487, 2, 3, 3, 2, -11 },
  { 488, 6, 8, 8, 1, -8 },
  { 494, 7, 11, 8, 0, -11 },
  { 504, 5, 8, 6, 1, -8 },
  { 509, 7, 11, 8, 1, -11 },
  { 519, 5, 8, 7, 1, -8 },
  { 524, 8, 14, 4, -2, -11 },
  { 538, 7, 11, 8, 0, -8 },
  { 548, 7, 11, 8, 0, -11 },
  { 558, 3, 10, 3, 0, -10 },
  { 562, 5, 13, 3, -2, -10 },
  { 571, 7, 11, 6, 0, -11 },
  { 581, 3, 11, 3, 0, -11 },
  { 586, 11, 8, 12, 0, -8 },
  { 597, 7, 8, 8, 0, -8 },
  { 604, 6, 8, 8, 1, -8 },
  { 610, 7, 11, 8, 0, -8 },
  { 620, 6, 11, 8, 1, -8 },
  { 629, 6, 8, 5, 0, -8 },
  { 635, 6, 8, 6, 0, -8 },
  { 641, 4, 9, 4, 1, -9 },
  { 646, 6, 7, 8, 1, -7 },
  { 652, 5, 7, 6, 1, -7 },
  { 657, 9, 7, 9, 1, -7 },
  { 665, 7, 7, 6, 0, -7 },
  { 672, 8, 10, 6, -2, -7 },
  { 682, 6, 7, 6, 0, -7 },
  { 688, 5, 12, 5, 0, -10 },
  { 696, 1, 14, 7, 4, -11 },
  { 698, 5, 12, 5, -1, -10 },
  { 706, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_THINITALIC14PT7B_H_
