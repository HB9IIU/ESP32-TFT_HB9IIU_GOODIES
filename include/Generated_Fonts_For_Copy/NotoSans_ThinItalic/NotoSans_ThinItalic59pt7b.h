#ifndef _NOTOSANS_THINITALIC59PT7B_H_
#define _NOTOSANS_THINITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x18,
  0x08, 0xC0, 0xC6, 0x06, 0x20, 0x21, 0x01, 0x18, 0x08, 0xC0, 0xC4, 0x06,
  0x20, 0x21, 0x01, 0x18, 0x08, 0xC0, 0xC4, 0x04, 0x20, 0x23, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x40, 0x06, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x06, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xC2, 0x07, 0x00, 0xE0, 0x40, 0x20, 0x30,
  0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x08, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x18, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x60, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x0E, 0x06, 0x01, 0x87, 0x00, 0xFF, 0xAF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x40, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x08, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x60, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x03, 0x02, 0x00, 0x06, 0x00, 0x10, 0x30, 0x38, 0x30, 0x01, 0x83,
  0x07, 0xF9, 0x80, 0x08, 0x30, 0x60, 0xEC, 0x00, 0xC1, 0x06, 0x03, 0x60,
  0x04, 0x18, 0x60, 0x0B, 0x00, 0x61, 0x86, 0x00, 0x6C, 0x06, 0x18, 0x30,
  0x03, 0x70, 0x60, 0xC3, 0x00, 0x19, 0xFE, 0x0C, 0x18, 0x00, 0xC1, 0xC0,
  0xC0, 0x80, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x60, 0x01,
  0x00, 0x06, 0x02, 0x00, 0x08, 0x00, 0x60, 0x10, 0x00, 0x40, 0x02, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x08, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x04, 0x01, 0x80, 0x06, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x80,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x30,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x01, 0x0E, 0x00, 0x40, 0x00, 0x43,
  0x80, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x02, 0x18, 0x00, 0x08, 0x00,
  0xC6, 0x00, 0x01, 0x80, 0x10, 0x80, 0x00, 0x18, 0x06, 0x30, 0x00, 0x01,
  0x81, 0x86, 0x00, 0x00, 0x10, 0x60, 0x80, 0x00, 0x03, 0x08, 0x10, 0x00,
  0x00, 0x33, 0x02, 0x00, 0x00, 0x02, 0xC0, 0x40, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x60, 0x18, 0x00, 0x01, 0x84,
  0x03, 0x00, 0x00, 0x60, 0xC0, 0x38, 0x00, 0x38, 0x0C, 0x03, 0xC0, 0x3C,
  0x00, 0x80, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0xC6, 0x21, 0x18, 0xC4, 0x21, 0x18, 0xC4, 0x23, 0x00, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x01, 0xE0, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x04, 0x00, 0x00,
  0xE2, 0x00, 0x00, 0x19, 0x01, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x84, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x03, 0x80, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x06, 0x80, 0x72,
  0x03, 0x18, 0x38, 0x61, 0x81, 0x9C, 0x04, 0xC0, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0x80, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x02, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x10, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x09, 0xFF,
  0x80, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x08, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x10, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x01, 0xFC, 0x00, 0x30, 0x7F, 0xF8, 0x02, 0x1C, 0x01, 0xC0, 0x27, 0x00,
  0x06, 0x06, 0xC0, 0x00, 0x30, 0x78, 0x00, 0x03, 0x05, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xE0, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x16, 0x0C, 0x00, 0x06, 0x40, 0x60, 0x00,
  0xC4, 0x03, 0x80, 0x38, 0xC0, 0x0F, 0xFE, 0x0C, 0x00, 0x3F, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x3C,
  0x03, 0x82, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0x06, 0x00, 0x07, 0xFF, 0xC0,
  0x08, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x43, 0x00, 0x0C, 0x00, 0x30, 0x02,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC8,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x36, 0x00,
  0x60, 0x00, 0x20, 0x01, 0x30, 0x02, 0x00, 0x03, 0x00, 0x09, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x48, 0x01, 0x80, 0x00, 0x80, 0x06, 0xC0, 0x08, 0x00,
  0x04, 0x00, 0x36, 0x00, 0x40, 0x00, 0x60, 0x01, 0x30, 0x02, 0x00, 0x03,
  0x00, 0x19, 0x80, 0x30, 0x00, 0x30, 0x00, 0xCC, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x60, 0x0C, 0x00, 0x1C, 0x00, 0x63, 0x00, 0x20, 0x00, 0xA0, 0x06,
  0x18, 0x01, 0x80, 0x09, 0x00, 0x60, 0x40, 0x0C, 0x01, 0xCC, 0x06, 0x03,
  0x00, 0x30, 0x18, 0x60, 0x60, 0x18, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xC0,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x80, 0x0F, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x00, 0x07, 0x80,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF3, 0x00, 0x00, 0xFF, 0xF8,
  0xC0, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0xC1, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xC0, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x63, 0xC0, 0x00, 0x00, 0x11, 0x98, 0x00, 0x00, 0x0C, 0xC6, 0x00,
  0x00, 0x03, 0x60, 0xC0, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x10, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x0B, 0x00, 0xB0, 0x00, 0x00,
  0x01, 0xA0, 0x09, 0x00, 0x00, 0x00, 0x36, 0x01, 0x90, 0x00, 0x00, 0x03,
  0x60, 0x19, 0x00, 0x00, 0x00, 0x66, 0x01, 0x98, 0x00, 0x00, 0x04, 0x40,
  0x11, 0x80, 0x00, 0x00, 0xC4, 0x01, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x30,
  0x80, 0x00, 0x01, 0x8C, 0x03, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x30, 0xC0,
  0x00, 0x02, 0x08, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x20, 0xC0, 0x00,
  0x0C, 0x18, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x00, 0x18,
  0x18, 0x06, 0x04, 0x00, 0x01, 0x01, 0x00, 0x40, 0x60, 0x00, 0x30, 0x10,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x0C,
  0x02, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x18, 0x06, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40,
  0x04, 0x01, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x83, 0x00, 0x08, 0x02,
  0x00, 0x08, 0x20, 0x00, 0x80, 0x20, 0x00, 0x86, 0x00, 0x18, 0x06, 0x00,
  0x08, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x06, 0x00, 0x0D,
  0x80, 0x01, 0x00, 0x40, 0x00, 0xD0, 0x00, 0x10, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x01, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x03, 0x00, 0xB0, 0x00, 0x00, 0x30,
  0x09, 0x00, 0x00, 0x02, 0x01, 0x98, 0x00, 0x00, 0x20, 0x18, 0x80, 0x00,
  0x06, 0x01, 0x8C, 0x00, 0x00, 0x60, 0x10, 0xC0, 0x00, 0x04, 0x01, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x60, 0x00, 0x0C, 0x03, 0x02, 0x00, 0x00, 0xC0,
  0x30, 0x30, 0x00, 0x0C, 0x02, 0x01, 0x00, 0x00, 0x80, 0x20, 0x18, 0x00,
  0x08, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x40, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0xC0, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x80, 0x03, 0x00,
  0x20, 0x08, 0x00, 0x18, 0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x18, 0x00,
  0x08, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x00, 0x04, 0x04, 0x01,
  0x00, 0x00, 0x60, 0x40, 0x30, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0xC0, 0x30, 0x00, 0x03, 0x0C, 0x02, 0x00, 0x00, 0x10, 0x80, 0x20, 0x00,
  0x01, 0x88, 0x06, 0x00, 0x00, 0x09, 0x80, 0x60, 0x00, 0x00, 0xD8, 0x06,
  0x00, 0x00, 0x0D, 0x80, 0x40, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x3F,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0x00, 0x3F,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x80,
  0x30, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x10, 0x00, 0x40, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x07,
  0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x50, 0x00, 0x01, 0x10, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x21, 0x00, 0x00, 0x24, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x10, 0x00, 0x04, 0x40, 0x00, 0x30, 0x40, 0x00,
  0x31, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x84, 0x00, 0x02, 0x04, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x10, 0x60, 0x00, 0x40, 0x40, 0x00, 0xC1,
  0x80, 0x03, 0x01, 0x00, 0x02, 0x06, 0x00, 0x08, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x40, 0x60, 0x01, 0x00, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10,
  0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x08, 0x02, 0x00,
  0x08, 0x06, 0x00, 0x20, 0x18, 0x00, 0x20, 0x30, 0x00, 0x80, 0x40, 0x00,
  0x80, 0xC0, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x60, 0x00, 0x20, 0x40, 0x00, 0xC1, 0x80, 0x00, 0x83,
  0x00, 0x03, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x60,
  0x00, 0x30, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x8C, 0x00,
  0x03, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x34, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x10, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x10, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08,
  0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x80, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x40, 0x18, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3,
  0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE,
  0x04, 0x01, 0xC0, 0x71, 0x80, 0xE0, 0x02, 0x30, 0x30, 0x00, 0x64, 0x0C,
  0x00, 0x04, 0x83, 0x00, 0x00, 0xD0, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0xC2, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x14, 0x18, 0x00, 0x06, 0x81, 0x00, 0x01,
  0xB0, 0x30, 0x00, 0x66, 0x02, 0x00, 0x18, 0x80, 0x60, 0x06, 0x10, 0x07,
  0x03, 0x82, 0x00, 0x7F, 0xC0, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x07, 0x80, 0x03,
  0x03, 0xFF, 0x00, 0x30, 0xE0, 0x38, 0x02, 0x18, 0x00, 0xC0, 0x22, 0x00,
  0x06, 0x06, 0x40, 0x00, 0x60, 0x68, 0x00, 0x03, 0x07, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x03, 0x05, 0x80, 0x00, 0x30, 0x48, 0x00, 0x06, 0x04, 0xC0, 0x00,
  0xC0, 0xC6, 0x00, 0x38, 0x0C, 0x38, 0x0F, 0x00, 0x81, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x70, 0x03,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x07, 0x00, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x78, 0x02,
  0x00, 0x0F, 0xFE, 0x04, 0x00, 0x38, 0x06, 0x18, 0x01, 0xC0, 0x06, 0x30,
  0x06, 0x00, 0x06, 0x60, 0x18, 0x00, 0x06, 0x80, 0x60, 0x00, 0x05, 0x00,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0x40, 0x30, 0x00, 0x06,
  0x80, 0x20, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x66, 0x00, 0xC0, 0x01, 0x88,
  0x00, 0xC0, 0x0E, 0x10, 0x00, 0xE0, 0x78, 0x20, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x03,
  0xC0, 0x60, 0x0E, 0x00, 0x60, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x03, 0x88, 0x00, 0x0E, 0x30, 0x01, 0xF0,
  0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x04, 0x03, 0x80, 0x78, 0x03, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE3,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x40, 0x0E, 0x01, 0x82, 0x01,
  0xC0, 0x06, 0x30, 0x18, 0x00, 0x19, 0x81, 0x80, 0x00, 0x68, 0x18, 0x00,
  0x01, 0x40, 0xC0, 0x00, 0x0A, 0x0C, 0x00, 0x00, 0x70, 0x40, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x05, 0x03, 0x00, 0x00, 0x68, 0x08, 0x00,
  0x06, 0xC0, 0x60, 0x00, 0x66, 0x03, 0x00, 0x06, 0x20, 0x0C, 0x00, 0x61,
  0x00, 0x38, 0x1E, 0x08, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x01,
  0x80, 0x07, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0xF8, 0x00, 0xC0,
  0xFF, 0xC0, 0x18, 0x70, 0x0C, 0x02, 0x18, 0x00, 0xC0, 0x46, 0x00, 0x0C,
  0x19, 0x80, 0x01, 0x83, 0x60, 0x00, 0x30, 0x78, 0x00, 0x02, 0x0A, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x40, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x11, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x00, 0x30,
  0x00, 0x40, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x50, 0x00, 0x06,
  0x26, 0x00, 0x01, 0x30, 0x80, 0x00, 0x58, 0x30, 0x00, 0x1C, 0x04, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00, 0x40,
  0x00, 0x40, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x30, 0x7F, 0xC0, 0x0F, 0xF8, 0x02, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x23,
  0x00, 0x30, 0x60, 0x06, 0x02, 0x60, 0x01, 0x0C, 0x00, 0x30, 0x6C, 0x00,
  0x19, 0x80, 0x03, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x30, 0x50, 0x00, 0x1A,
  0x00, 0x01, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x60, 0x00, 0x1C, 0x00,
  0x01, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x80, 0x00, 0x10, 0x00, 0x02, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x40, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x7F, 0xE0, 0x08, 0x38, 0x06,
  0x01, 0x0C, 0x00, 0x60, 0x23, 0x00, 0x06, 0x0C, 0xC0, 0x00, 0xC1, 0xB0,
  0x00, 0x18, 0x2C, 0x00, 0x01, 0x05, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0xFF, 0xC0, 0x01, 0x07, 0x01, 0xC0, 0x02, 0x18, 0x00, 0xC0, 0x04, 0x60,
  0x00, 0xC0, 0x09, 0x00, 0x01, 0x80, 0x36, 0x00, 0x01, 0x80, 0x58, 0x00,
  0x03, 0x00, 0xA0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x04, 0x07, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x3C,
  0x00, 0x01, 0x80, 0x48, 0x00, 0x06, 0x00, 0x98, 0x00, 0x18, 0x03, 0x18,
  0x00, 0xE0, 0x06, 0x1C, 0x07, 0x80, 0x0C, 0x1F, 0xFC, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x81,
  0x00, 0x70, 0x0C, 0x10, 0x1C, 0x00, 0x63, 0x03, 0x00, 0x03, 0x30, 0x60,
  0x00, 0x1A, 0x0C, 0x00, 0x00, 0xA0, 0xC0, 0x00, 0x0A, 0x18, 0x00, 0x00,
  0xE1, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0A, 0x0C, 0x00, 0x01, 0xA0,
  0x40, 0x00, 0x36, 0x06, 0x00, 0x06, 0x60, 0x20, 0x00, 0xC4, 0x03, 0x00,
  0x18, 0x40, 0x1C, 0x0F, 0x04, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x18, 0x3F, 0xC0, 0x83, 0x80, 0x04, 0x30, 0x00, 0x22, 0x00, 0x03,
  0x20, 0x00, 0x1B, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xF0, 0x0E, 0x00, 0x78, 0x30, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0x3C, 0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x7F, 0xFF, 0x84, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x40, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x34, 0x18, 0x00, 0x04, 0x81, 0x00, 0x01, 0x30,
  0x30, 0x00, 0xE6, 0x07, 0x00, 0x30, 0x80, 0x70, 0x1C, 0x10, 0x03, 0xFE,
  0x02, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40,
  0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x10, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x10,
  0x08, 0x00, 0x10, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x09,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xB0,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x4C, 0x00, 0x0B, 0x00,
  0x06, 0x20, 0x00, 0xD8, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x03, 0x08, 0x00,
  0x62, 0x00, 0x18, 0x40, 0x02, 0x10, 0x01, 0x82, 0x00, 0x30, 0x80, 0x0C,
  0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x18, 0x20, 0x06, 0x04, 0x01, 0x81,
  0x80, 0x20, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x60, 0x08, 0x08, 0x03, 0x03, 0x00, 0x40,
  0xC0, 0x18, 0x30, 0x02, 0x04, 0x00, 0xC1, 0x00, 0x10, 0x60, 0x06, 0x18,
  0x00, 0x82, 0x00, 0x10, 0x80, 0x06, 0x30, 0x00, 0x8C, 0x00, 0x31, 0x00,
  0x04, 0x40, 0x01, 0x98, 0x00, 0x26, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00,
  0x6C, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x02, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x13,
  0x81, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0xE8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0x00,
};

const GFXglyph NotoSans_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 42, 12, 2, -42 },
  { 59, 13, 15, 18, 6, -42 },
  { 84, 35, 42, 36, 2, -42 },
  { 268, 27, 48, 32, 3, -45 },
  { 430, 37, 44, 45, 5, -43 },
  { 634, 35, 44, 40, 3, -43 },
  { 827, 5, 15, 10, 6, -42 },
  { 837, 16, 51, 14, 2, -42 },
  { 939, 17, 51, 14, -4, -42 },
  { 1048, 25, 25, 31, 7, -45 },
  { 1127, 28, 27, 34, 4, -34 },
  { 1222, 8, 15, 11, -3, -7 },
  { 1237, 14, 2, 18, 2, -17 },
  { 1241, 3, 3, 12, 2, -3 },
  { 1243, 26, 42, 18, -3, -42 },
  { 1380, 27, 44, 32, 4, -43 },
  { 1529, 14, 42, 32, 10, -42 },
  { 1603, 29, 43, 32, 1, -43 },
  { 1759, 30, 44, 32, 1, -43 },
  { 1924, 30, 42, 32, 1, -42 },
  { 2082, 30, 43, 32, 2, -42 },
  { 2244, 28, 44, 32, 4, -43 },
  { 2398, 26, 42, 32, 7, -42 },
  { 2535, 28, 44, 32, 3, -43 },
  { 2689, 28, 44, 32, 3, -43 },
  { 2843, 9, 31, 12, 2, -31 },
  { 2878, 14, 39, 12, -3, -31 },
  { 2947, 28, 27, 34, 4, -35 },
  { 3042, 28, 14, 34, 4, -28 },
  { 3091, 28, 27, 34, 4, -35 },
  { 3186, 20, 43, 24, 5, -43 },
  { 3294, 45, 47, 49, 3, -42 },
  { 3559, 32, 42, 32, -3, -42 },
  { 3727, 31, 42, 35, 3, -42 },
  { 3890, 32, 44, 35, 5, -43 },
  { 4066, 35, 42, 40, 3, -42 },
  { 4250, 30, 42, 32, 3, -42 },
  { 4408, 30, 42, 29, 3, -42 },
  { 4566, 34, 44, 41, 5, -43 },
  { 4753, 37, 42, 40, 3, -42 },
  { 4948, 19, 42, 16, 0, -42 },
  { 5048, 24, 52, 14, -10, -42 },
  { 5204, 34, 42, 32, 3, -42 },
  { 5383, 21, 42, 29, 3, -42 },
  { 5494, 44, 42, 48, 3, -42 },
  { 5725, 36, 42, 40, 3, -42 },
  { 5914, 35, 44, 42, 5, -43 },
  { 6107, 30, 42, 33, 3, -42 },
  { 6265, 35, 53, 42, 5, -43 },
  { 6497, 30, 42, 33, 3, -42 },
  { 6655, 29, 44, 29, 1, -43 },
  { 6815, 29, 42, 29, 5, -42 },
  { 6968, 36, 43, 41, 5, -42 },
  { 7162, 30, 42, 32, 6, -42 },
  { 7320, 46, 42, 49, 7, -42 },
  { 7562, 36, 42, 29, -3, -42 },
  { 7751, 28, 42, 29, 6, -42 },
  { 7898, 34, 42, 32, 0, -42 },
  { 8077, 23, 51, 18, -1, -42 },
  { 8224, 9, 42, 18, 6, -42 },
  { 8272, 22, 51, 18, -4, -42 },
  { 8413, 27, 26, 32, 3, -42 },
  { 8501, 22, 2, 22, -5, 6 },
  { 8507, 6, 9, 13, 9, -45 },
  { 8514, 27, 33, 32, 3, -32 },
  { 8626, 28, 46, 34, 2, -45 },
  { 8787, 24, 33, 27, 3, -32 },
  { 8886, 31, 46, 34, 3, -45 },
  { 9065, 23, 33, 29, 4, -32 },
  { 9160, 32, 59, 16, -8, -45 },
  { 9396, 29, 46, 34, 2, -32 },
  { 9563, 27, 45, 33, 2, -45 },
  { 9715, 11, 43, 12, 2, -43 },
  { 9775, 21, 57, 12, -8, -43 },
  { 9925, 26, 45, 26, 2, -45 },
  { 10072, 11, 45, 12, 2, -45 },
  { 10134, 44, 32, 50, 2, -32 },
  { 10310, 27, 32, 33, 2, -32 },
  { 10418, 27, 33, 33, 3, -32 },
  { 10530, 31, 46, 34, -1, -32 },
  { 10709, 28, 46, 34, 3, -32 },
  { 10870, 21, 32, 22, 2, -32 },
  { 10954, 23, 33, 25, 1, -32 },
  { 11049, 16, 40, 18, 3, -39 },
  { 11129, 27, 32, 33, 3, -31 },
  { 11237, 24, 31, 24, 3, -31 },
  { 11330, 37, 31, 38, 3, -31 },
  { 11474, 30, 31, 27, -2, -31 },
  { 11591, 34, 45, 24, -7, -31 },
  { 11783, 27, 31, 26, -1, -31 },
  { 11888, 21, 51, 19, 2, -42 },
  { 12022, 1, 59, 32, 17, -45 },
  { 12030, 21, 51, 19, -3, -42 },
  { 12164, 28, 5, 34, 4, -23 },
};

const GFXfont NotoSans_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_THINITALIC59PT7B_H_
