#ifndef _NOTOSANS_THINITALIC36PT7B_H_
#define _NOTOSANS_THINITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x84, 0x84, 0x00, 0x20,
  0x20, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x1F, 0xFF, 0xF9, 0x04, 0x08,
  0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x02, 0x04, 0x07, 0xFF, 0xFF, 0x01, 0x01, 0x00,
  0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x81, 0x80, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x01, 0xFE, 0x06, 0x21, 0x08, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x08, 0x40, 0x04, 0x80, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x98, 0x00, 0x8C, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x02, 0x04, 0x02, 0x08, 0x82, 0x30, 0x7F, 0xC0, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x08, 0x63, 0x00, 0x43, 0x04,
  0x01, 0x08, 0x10, 0x08, 0x40, 0x40, 0x41, 0x01, 0x03, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x40, 0x80, 0x42, 0x02, 0x01, 0x18, 0x08, 0x08, 0x47, 0x20,
  0x22, 0x23, 0x81, 0x91, 0x06, 0x04, 0x48, 0x14, 0x22, 0x20, 0x4F, 0x11,
  0x01, 0x00, 0x84, 0x04, 0x02, 0x10, 0x10, 0x10, 0x40, 0x40, 0x82, 0x01,
  0x04, 0x08, 0x04, 0x10, 0x20, 0x20, 0x80, 0x80, 0x84, 0x02, 0x04, 0x30,
  0x04, 0x31, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0C, 0x18, 0x00, 0xC0,
  0x40, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x02, 0x02, 0x00, 0x10, 0x60, 0x00, 0x44, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x20, 0x00, 0x40, 0x80, 0x24, 0x06, 0x02, 0x40,
  0x10, 0x14, 0x00, 0x41, 0x20, 0x01, 0x09, 0x00, 0x08, 0x88, 0x00, 0x28,
  0x40, 0x00, 0x82, 0x00, 0x0A, 0x18, 0x01, 0x90, 0x60, 0x10, 0x41, 0xFF,
  0x01, 0x00, 0x25, 0x24, 0xA4, 0x90, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x03, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x00, 0x80, 0x04, 0x00, 0x10, 0x20, 0x40, 0xC1, 0x00, 0xC8,
  0x00, 0xE0, 0xC0, 0xFC, 0x05, 0x00, 0x24, 0x01, 0x10, 0x18, 0x20, 0xC0,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x08, 0x44, 0x22, 0x11, 0x08, 0x80, 0xFF, 0x80, 0xF0,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x80, 0x41, 0x80,
  0x20, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x20, 0xC0, 0x20, 0x20, 0x20, 0x0F, 0xE0, 0x00,
  0x01, 0x81, 0x83, 0x42, 0x26, 0x14, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x60, 0x60, 0x20,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xC0, 0x40, 0xC0, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x03, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x80,
  0x18, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x10, 0x20, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x30, 0x01, 0x0F, 0xFF, 0xFC, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0xC0, 0x18, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x1E, 0x00, 0x98, 0x30, 0x48, 0x06, 0x14, 0x00, 0x86, 0x00, 0x21,
  0x00, 0x04, 0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x20, 0x30, 0x30, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x02, 0x01, 0x01, 0x83, 0x00, 0x26, 0x00, 0x0C, 0x00, 0x39, 0x80, 0x60,
  0x60, 0x40, 0x08, 0x40, 0x04, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x10, 0x80, 0x18, 0x60, 0x10, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x01, 0x03, 0x03, 0x00, 0x81, 0x00, 0x21, 0x00, 0x11,
  0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x64, 0x00, 0x22, 0x00, 0x30, 0x80, 0x28, 0x60, 0x64, 0x0F, 0xC4, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x1F,
  0x86, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x09, 0x00, 0x7F, 0x81, 0x20, 0x10, 0x10, 0x28, 0x04, 0x02, 0x05,
  0x01, 0x00, 0x80, 0xA0, 0x40, 0x10, 0x18, 0x08, 0x02, 0x03, 0x02, 0x00,
  0x80, 0x60, 0x40, 0x10, 0x14, 0x08, 0x02, 0x02, 0x81, 0x00, 0xC0, 0x50,
  0x20, 0x18, 0x12, 0x04, 0x05, 0x06, 0x40, 0x41, 0x21, 0x84, 0x07, 0xC3,
  0xC0, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x3F, 0xFC, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x07, 0xFC, 0x00, 0x80, 0x70, 0x10,
  0x01, 0x02, 0x00, 0x30, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x02, 0x08, 0x03, 0x81, 0xFF,
  0x80, 0x40, 0x0C, 0x08, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x00, 0x84, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00,
  0xC4, 0x00, 0x30, 0x80, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0C,
  0x03, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x20, 0x38, 0x01, 0x00, 0x30, 0x08, 0x00, 0xC0,
  0x80, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01,
  0x90, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0xC1, 0x00,
  0x0C, 0x10, 0x00, 0xC0, 0x80, 0x38, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xFE, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0F, 0xFF, 0x82, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x06,
  0x01, 0xC0, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xF2, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x80, 0x02, 0x06, 0x00, 0x10, 0x18,
  0x01, 0x80, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40,
  0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x42, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x82, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x3F,
  0x00, 0x04, 0x00, 0x18, 0x20, 0x01, 0x01, 0x00, 0x10, 0x08, 0x01, 0x00,
  0x80, 0x30, 0x04, 0x03, 0x00, 0x20, 0x30, 0x01, 0x02, 0x00, 0x10, 0x20,
  0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x26, 0x00, 0x01, 0x68, 0x00, 0x14,
  0x40, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x10, 0x10, 0x00, 0x80, 0x80, 0x02, 0x04, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xA0, 0xA0, 0x00, 0x14, 0x12, 0x00,
  0x04, 0x82, 0x40, 0x00, 0x90, 0x48, 0x00, 0x24, 0x11, 0x00, 0x08, 0x82,
  0x20, 0x01, 0x10, 0x44, 0x00, 0x42, 0x08, 0x40, 0x08, 0x81, 0x08, 0x02,
  0x10, 0x41, 0x00, 0x82, 0x08, 0x20, 0x10, 0x41, 0x04, 0x04, 0x08, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08, 0x20, 0x21, 0x01,
  0x04, 0x04, 0x40, 0x20, 0x80, 0x88, 0x08, 0x10, 0x0A, 0x01, 0x04, 0x01,
  0x80, 0x20, 0x80, 0x30, 0x04, 0x10, 0x04, 0x01, 0x80, 0x04, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x60, 0x00, 0x42, 0x80, 0x02, 0x09, 0x00, 0x08, 0x24,
  0x00, 0x20, 0x88, 0x00, 0x82, 0x20, 0x02, 0x10, 0x80, 0x10, 0x41, 0x00,
  0x41, 0x04, 0x01, 0x04, 0x08, 0x04, 0x10, 0x20, 0x10, 0x80, 0x40, 0x82,
  0x01, 0x02, 0x08, 0x04, 0x08, 0x20, 0x08, 0x20, 0x80, 0x21, 0x04, 0x00,
  0x44, 0x10, 0x01, 0x10, 0x40, 0x02, 0x41, 0x00, 0x09, 0x04, 0x00, 0x28,
  0x20, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x00,
  0x0C, 0x06, 0x01, 0x80, 0x08, 0x18, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00,
  0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21, 0x80, 0x02, 0x06, 0x00, 0x20,
  0x18, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0x01, 0xC0, 0x40,
  0x18, 0x10, 0x02, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x18, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x03, 0x08,
  0x03, 0x83, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x06, 0x01, 0x80,
  0x08, 0x18, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x04, 0x80, 0x00, 0x24,
  0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x44, 0x00, 0x06,
  0x20, 0x00, 0x21, 0x80, 0x02, 0x06, 0x00, 0x20, 0x18, 0x06, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x01, 0x01, 0xC0, 0x40, 0x18,
  0x10, 0x03, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x40, 0x04, 0x10, 0x02, 0x08, 0x1F,
  0x03, 0xFA, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08, 0x04, 0x04, 0x01, 0x01,
  0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x02, 0x20, 0x00, 0x80, 0x00, 0xFE, 0x01, 0x80, 0xC1, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x80, 0x30, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20, 0x00, 0x10,
  0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x21, 0x00,
  0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x02, 0x04,
  0x00, 0x10, 0x18, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01, 0x01,
  0x00, 0x40, 0x40, 0x20, 0x10, 0x08, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x02, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x09, 0x00,
  0x01, 0x40, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x24, 0x00, 0xA0, 0x02,
  0x40, 0x0A, 0x00, 0x44, 0x01, 0x20, 0x04, 0x40, 0x12, 0x00, 0x84, 0x02,
  0x20, 0x08, 0x40, 0x22, 0x01, 0x04, 0x04, 0x20, 0x10, 0x40, 0x41, 0x02,
  0x04, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x41,
  0x01, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x11,
  0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x30, 0x01, 0x40, 0x03, 0x00, 0x14, 0x00, 0x20, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x02, 0x00, 0x04, 0x04, 0x00, 0x20, 0x10,
  0x01, 0x80, 0x40, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x00, 0x88, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40, 0x01, 0x00, 0x80,
  0x0C, 0x02, 0x00, 0x20, 0x04, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x40,
  0x00, 0x82, 0x00, 0x02, 0x00, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x11,
  0x00, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x02, 0x00, 0x80, 0x40, 0x60, 0x10,
  0x10, 0x04, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x40,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x1F, 0xC0, 0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x82, 0x10, 0x84, 0x20, 0x84, 0x21, 0x08, 0x41, 0x08, 0x40, 0x01, 0xFC,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x48,
  0x00, 0x48, 0x00, 0x88, 0x01, 0x08, 0x03, 0x04, 0x02, 0x04, 0x04, 0x04,
  0x0C, 0x04, 0x08, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01,
  0x80, 0x01, 0xFF, 0xFC, 0x84, 0x42, 0x11, 0x03, 0xF1, 0x0C, 0x09, 0x18,
  0x05, 0x10, 0x05, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80,
  0x18, 0x80, 0x38, 0x40, 0x28, 0x40, 0xC8, 0x3F, 0x08, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0xFE, 0x04, 0x80, 0x82, 0x80, 0x62, 0x80, 0x11, 0x80,
  0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x13, 0x00, 0x09, 0x80, 0x08, 0xC0, 0x04,
  0x50, 0x04, 0x4C, 0x0C, 0x23, 0xF8, 0x00, 0x03, 0xFC, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0xC0, 0x41, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x03, 0xF8, 0x81, 0x80, 0x90, 0x60, 0x0A, 0x08, 0x01, 0x82, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x04,
  0x00, 0xA0, 0x40, 0x24, 0x08, 0x09, 0x00, 0xFE, 0x20, 0x00, 0x03, 0xF8,
  0x10, 0x10, 0x80, 0x44, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0xD0, 0x06,
  0x40, 0xE3, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x41, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x33, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x08,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x41, 0x80, 0x90, 0xC0, 0x14,
  0x20, 0x06, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x61, 0x00, 0x28, 0x20, 0x12, 0x08, 0x09, 0x01, 0xFC, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x20, 0x08, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0xFE, 0x04, 0x80, 0x82, 0x80, 0x42, 0x80, 0x11, 0x80, 0x08,
  0xC0, 0x04, 0x40, 0x02, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x04, 0xC0,
  0x18, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x03, 0x08, 0x06, 0x08, 0x0C,
  0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x25, 0x00, 0x29, 0x80, 0x30, 0x80, 0x20, 0xC0, 0x40, 0x40, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x10, 0x80, 0x10, 0x80, 0x08, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x08, 0xFC, 0x1F, 0xC1,
  0x20, 0x46, 0x08, 0x28, 0x09, 0x00, 0x8A, 0x01, 0x40, 0x11, 0x80, 0x28,
  0x02, 0x20, 0x06, 0x00, 0x44, 0x00, 0xC0, 0x08, 0x80, 0x10, 0x01, 0x20,
  0x02, 0x00, 0x24, 0x00, 0x40, 0x08, 0x80, 0x10, 0x01, 0x10, 0x02, 0x00,
  0x24, 0x00, 0x40, 0x04, 0x80, 0x08, 0x01, 0x10, 0x01, 0x00, 0x22, 0x00,
  0x40, 0x04, 0x40, 0x08, 0x00, 0x90, 0x01, 0x00, 0x12, 0x00, 0x20, 0x04,
  0x00, 0x08, 0xFE, 0x04, 0x80, 0x82, 0x80, 0x42, 0x80, 0x11, 0x80, 0x08,
  0xC0, 0x04, 0x40, 0x02, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x00, 0x03, 0xF8, 0x0C, 0x06, 0x18, 0x02,
  0x30, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0x40, 0x04, 0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x02, 0x3F, 0x80, 0x48,
  0x08, 0x0A, 0x01, 0x82, 0x80, 0x10, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x20, 0xC0, 0x04, 0x14, 0x01,
  0x04, 0xC0, 0xC0, 0x8F, 0xE0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x86, 0x02, 0x46, 0x00, 0xA2, 0x00, 0x62, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x00, 0x28, 0x40,
  0x24, 0x20, 0x24, 0x0F, 0xE2, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x08,
  0xF8, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x20, 0x11, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x13,
  0x00, 0x87, 0xFC, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x3F, 0xF1,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0xF0, 0x10, 0x01,
  0x88, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x62, 0x00, 0x51, 0x00, 0x30, 0x80, 0x28, 0x20, 0x64,
  0x0F, 0xC2, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x24, 0x00, 0xC8, 0x01,
  0x08, 0x04, 0x10, 0x08, 0x20, 0x20, 0x40, 0x40, 0x81, 0x01, 0x04, 0x01,
  0x08, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12, 0x00, 0x28, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x10, 0x07, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x24,
  0x02, 0x80, 0x48, 0x09, 0x01, 0x10, 0x12, 0x02, 0x20, 0x44, 0x08, 0x40,
  0x88, 0x10, 0x82, 0x08, 0x41, 0x04, 0x10, 0x81, 0x10, 0x21, 0x02, 0x20,
  0x44, 0x04, 0x80, 0x88, 0x09, 0x01, 0x20, 0x14, 0x02, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x0A, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x00, 0x08, 0x00,
  0xC1, 0x00, 0x60, 0x40, 0x30, 0x08, 0x08, 0x02, 0x04, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0C,
  0x80, 0x06, 0x20, 0x01, 0x04, 0x00, 0x81, 0x00, 0x40, 0x20, 0x20, 0x08,
  0x10, 0x01, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80,
  0x08, 0x04, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00,
  0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x01, 0x08,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x26, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x06, 0x00,
  0x78, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0xE0, 0x1C,
  0x00, 0x7F, 0x01, 0x81, 0xC3, 0x80, 0x3C,
};

const GFXglyph NotoSans_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 10, 11, 4, -26 },
  { 34, 21, 26, 22, 1, -26 },
  { 103, 16, 29, 20, 2, -27 },
  { 161, 22, 26, 27, 3, -26 },
  { 233, 21, 26, 25, 2, -26 },
  { 302, 3, 10, 6, 4, -26 },
  { 306, 10, 32, 9, 1, -26 },
  { 346, 10, 32, 9, -2, -26 },
  { 386, 14, 15, 19, 5, -27 },
  { 413, 16, 17, 21, 3, -21 },
  { 447, 5, 9, 7, -2, -4 },
  { 453, 9, 1, 11, 1, -10 },
  { 455, 2, 2, 8, 1, -2 },
  { 456, 16, 26, 11, -2, -26 },
  { 508, 17, 26, 20, 2, -26 },
  { 564, 9, 26, 20, 6, -26 },
  { 594, 18, 26, 20, 0, -26 },
  { 653, 18, 26, 20, 1, -26 },
  { 712, 18, 26, 20, 1, -26 },
  { 771, 18, 26, 20, 1, -26 },
  { 830, 18, 26, 20, 2, -26 },
  { 889, 16, 26, 20, 4, -26 },
  { 941, 17, 26, 20, 2, -26 },
  { 997, 17, 26, 20, 2, -26 },
  { 1053, 6, 19, 8, 1, -19 },
  { 1068, 9, 24, 8, -2, -19 },
  { 1095, 16, 16, 21, 3, -21 },
  { 1127, 16, 8, 21, 3, -17 },
  { 1143, 16, 16, 21, 3, -21 },
  { 1175, 12, 26, 15, 3, -26 },
  { 1214, 27, 28, 30, 2, -25 },
  { 1309, 20, 26, 20, -2, -26 },
  { 1374, 19, 26, 22, 2, -26 },
  { 1436, 20, 26, 21, 3, -26 },
  { 1501, 21, 26, 24, 2, -26 },
  { 1570, 18, 26, 19, 2, -26 },
  { 1629, 18, 26, 18, 2, -26 },
  { 1688, 21, 26, 25, 3, -26 },
  { 1757, 22, 26, 25, 2, -26 },
  { 1829, 11, 26, 10, 0, -26 },
  { 1865, 14, 32, 8, -6, -26 },
  { 1921, 21, 26, 20, 2, -26 },
  { 1990, 13, 26, 18, 2, -26 },
  { 2033, 27, 26, 29, 2, -26 },
  { 2121, 22, 26, 24, 2, -26 },
  { 2193, 21, 26, 26, 3, -26 },
  { 2262, 18, 26, 20, 2, -26 },
  { 2321, 21, 32, 26, 3, -26 },
  { 2405, 18, 26, 20, 2, -26 },
  { 2464, 17, 26, 18, 1, -26 },
  { 2520, 18, 26, 17, 3, -26 },
  { 2579, 22, 26, 25, 3, -26 },
  { 2651, 18, 26, 19, 4, -26 },
  { 2710, 28, 26, 30, 4, -26 },
  { 2801, 22, 26, 18, -2, -26 },
  { 2873, 18, 26, 17, 3, -26 },
  { 2932, 21, 26, 19, 0, -26 },
  { 3001, 13, 32, 11, 0, -26 },
  { 3053, 5, 26, 11, 4, -26 },
  { 3070, 14, 32, 11, -3, -26 },
  { 3126, 16, 16, 20, 2, -26 },
  { 3158, 14, 1, 13, -3, 4 },
  { 3160, 4, 6, 8, 5, -28 },
  { 3163, 16, 19, 20, 2, -19 },
  { 3201, 17, 27, 20, 1, -27 },
  { 3259, 14, 19, 16, 2, -19 },
  { 3293, 19, 27, 20, 2, -27 },
  { 3358, 14, 19, 18, 2, -19 },
  { 3392, 20, 37, 10, -5, -28 },
  { 3485, 18, 28, 20, 1, -19 },
  { 3548, 17, 27, 20, 1, -27 },
  { 3606, 7, 26, 7, 1, -26 },
  { 3629, 13, 35, 7, -5, -26 },
  { 3686, 16, 27, 16, 1, -27 },
  { 3740, 7, 27, 7, 1, -27 },
  { 3764, 27, 19, 30, 1, -19 },
  { 3829, 17, 19, 20, 1, -19 },
  { 3870, 16, 19, 20, 2, -19 },
  { 3908, 19, 27, 20, -1, -19 },
  { 3973, 17, 27, 20, 2, -19 },
  { 4031, 13, 19, 13, 1, -19 },
  { 4062, 14, 19, 15, 0, -19 },
  { 4096, 10, 24, 11, 2, -24 },
  { 4126, 17, 19, 20, 2, -19 },
  { 4167, 15, 19, 15, 2, -19 },
  { 4203, 23, 19, 23, 2, -19 },
  { 4258, 18, 19, 16, -1, -19 },
  { 4301, 21, 28, 15, -4, -19 },
  { 4375, 17, 19, 16, -1, -19 },
  { 4416, 13, 32, 12, 1, -26 },
  { 4468, 1, 36, 19, 10, -27 },
  { 4473, 13, 32, 12, -2, -26 },
  { 4525, 16, 3, 21, 3, -14 },
};

const GFXfont NotoSans_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_THINITALIC36PT7B_H_
