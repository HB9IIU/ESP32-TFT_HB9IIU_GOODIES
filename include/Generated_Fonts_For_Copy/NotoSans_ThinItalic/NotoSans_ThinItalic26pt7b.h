#ifndef _NOTOSANS_THINITALIC26PT7B_H_
#define _NOTOSANS_THINITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x20, 0x00, 0x00,
  0x20, 0x45, 0x24, 0xA2, 0x8A, 0x29, 0x00, 0x01, 0x08, 0x02, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20,
  0x10, 0x40, 0x20, 0x80, 0x42, 0x0F, 0xFF, 0xC2, 0x08, 0x04, 0x20, 0x08,
  0x40, 0x20, 0x80, 0x41, 0x00, 0x84, 0x00, 0x00, 0x80, 0x08, 0x03, 0xC0,
  0xCB, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10, 0x11, 0x00, 0xA0, 0x03, 0x00,
  0x28, 0x02, 0x40, 0x22, 0x04, 0x20, 0x42, 0x04, 0x4C, 0x58, 0x1E, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x1C, 0x01, 0x22, 0x02, 0x21, 0x04, 0x41, 0x08,
  0x41, 0x08, 0x81, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x4F, 0x84, 0x91,
  0x4D, 0x21, 0x31, 0x21, 0x02, 0x41, 0x04, 0x41, 0x08, 0x41, 0x08, 0x41,
  0x10, 0x42, 0x20, 0x42, 0x40, 0x3C, 0x01, 0xC0, 0x04, 0x10, 0x04, 0x10,
  0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0xC0, 0x03, 0x00,
  0x0D, 0x00, 0x11, 0x01, 0x20, 0x82, 0x40, 0x42, 0x80, 0x44, 0x80, 0x28,
  0x80, 0x10, 0x80, 0x28, 0x40, 0x48, 0x3F, 0x84, 0x56, 0xA8, 0x02, 0x08,
  0x20, 0x41, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02, 0x00, 0x40, 0x08, 0x62, 0x03,
  0x40, 0x1F, 0xC3, 0x00, 0x90, 0x22, 0x08, 0x40, 0x04, 0x00, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x25, 0x25, 0x00, 0xFC, 0x80, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00,
  0x03, 0x80, 0x86, 0x10, 0x22, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x84, 0x10, 0x3E, 0x00, 0x02, 0x1C, 0x53, 0x28, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80, 0x01, 0xE0,
  0x30, 0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x60, 0x84, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x7C, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x44, 0x06, 0x3F, 0xC0,
  0x00, 0x08, 0x00, 0x60, 0x02, 0x80, 0x12, 0x00, 0x50, 0x02, 0x40, 0x11,
  0x00, 0x84, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x08, 0x40, 0x23, 0xFF,
  0xF0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x07, 0xF8,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x3F,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x44, 0x04, 0x1F, 0xC0, 0x01, 0xF0, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x60, 0x99, 0x8A, 0x04, 0xC0, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0xFF, 0xF0,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x20, 0x82, 0x02, 0x20, 0x11, 0x00, 0x88,
  0x04, 0x40, 0x41, 0x04, 0x04, 0xC0, 0x38, 0x06, 0x30, 0x40, 0x44, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x22, 0x02, 0x0F, 0xE0, 0x03, 0xC0,
  0x61, 0x04, 0x04, 0x40, 0x22, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x20,
  0x11, 0x01, 0x84, 0x14, 0x1F, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x3F, 0x80, 0x13, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x21, 0x04, 0x10,
  0x80, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0x20, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x02, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x04, 0x0C,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x12, 0x07, 0xE1, 0x40, 0x82, 0x14,
  0x10, 0x21, 0x42, 0x04, 0x18, 0x20, 0x41, 0x84, 0x04, 0x18, 0x40, 0x82,
  0x84, 0x08, 0x28, 0x21, 0x84, 0x43, 0xE7, 0x84, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x83, 0xFE, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x01,
  0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x0F, 0xA0, 0x20, 0x60, 0x80, 0x44,
  0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x20, 0x30, 0xFF, 0x82,
  0x01, 0x08, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x12,
  0x01, 0x8F, 0xF8, 0x00, 0x01, 0xF8, 0x18, 0x10, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0x40, 0x08, 0x38, 0x08, 0x04, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10,
  0x80, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0xFF, 0x82, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFE, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFC, 0x0C, 0x04, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xF4, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x02, 0x20, 0x04, 0x40, 0x08, 0x40, 0x10, 0x7F, 0xC0,
  0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02, 0x1F, 0xFF, 0x08, 0x00, 0x84,
  0x00, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x00, 0x0F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xF0,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x01, 0x83, 0x80, 0x08, 0x02, 0x10, 0x08, 0x20, 0x20,
  0x80, 0x81, 0x02, 0x02, 0x18, 0x04, 0x40, 0x09, 0x00, 0x24, 0x00, 0x54,
  0x00, 0xC4, 0x01, 0x08, 0x02, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x41, 0x00, 0x42, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x0F, 0xFC, 0x08, 0x00, 0x10, 0x80, 0x03, 0x0C,
  0x00, 0x51, 0x40, 0x06, 0x14, 0x00, 0xA1, 0x40, 0x0A, 0x14, 0x01, 0x21,
  0x20, 0x24, 0x22, 0x02, 0x42, 0x20, 0x44, 0x22, 0x04, 0x42, 0x20, 0x84,
  0x21, 0x10, 0x84, 0x11, 0x08, 0x41, 0x20, 0x84, 0x12, 0x08, 0x41, 0x40,
  0x88, 0x18, 0x10, 0x80, 0x81, 0x00, 0x08, 0x01, 0x08, 0x01, 0x0C, 0x01,
  0x14, 0x01, 0x12, 0x01, 0x12, 0x02, 0x12, 0x02, 0x11, 0x02, 0x21, 0x02,
  0x20, 0x82, 0x20, 0x84, 0x20, 0x44, 0x20, 0x44, 0x40, 0x44, 0x40, 0x24,
  0x40, 0x28, 0x40, 0x18, 0x80, 0x18, 0x80, 0x08, 0x03, 0xF0, 0x04, 0x08,
  0x18, 0x04, 0x10, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x40, 0x08, 0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x0F, 0xC0,
  0x20, 0xC0, 0x80, 0x84, 0x02, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02,
  0x20, 0x08, 0x80, 0xC3, 0xFC, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x08,
  0x18, 0x04, 0x10, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x04, 0x40, 0x08, 0x40, 0x08, 0x20, 0x30, 0x1E, 0xC0, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x0F, 0xC0, 0x20, 0xC0, 0x80, 0x84,
  0x02, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x20, 0x10, 0x81, 0x83,
  0xF8, 0x08, 0x20, 0x20, 0x81, 0x02, 0x04, 0x04, 0x10, 0x10, 0x40, 0x22,
  0x00, 0x88, 0x02, 0x00, 0x03, 0xF0, 0x20, 0x42, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x3F, 0xE0, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x40, 0x10, 0x40, 0x20, 0x3F, 0xC0, 0x80, 0x0C, 0x00, 0xA0,
  0x05, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x82,
  0x20, 0x88, 0x42, 0x10, 0x44, 0x21, 0x04, 0x82, 0x20, 0x48, 0x12, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x00, 0x04, 0x00, 0x82, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80,
  0x20, 0x80, 0x08, 0x40, 0x04, 0x40, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x22, 0x00, 0x21, 0x00, 0x20, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x04, 0x30, 0x02, 0x00, 0x80, 0x0A, 0x00, 0x90,
  0x04, 0x80, 0x42, 0x04, 0x10, 0x40, 0x82, 0x04, 0x20, 0x12, 0x00, 0x90,
  0x05, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x88, 0x88, 0x88, 0x84,
  0x44, 0x44, 0x22, 0x22, 0x22, 0x10, 0x07, 0xC0, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0x80, 0x00,
  0x80, 0x14, 0x01, 0x40, 0x24, 0x04, 0x40, 0x42, 0x08, 0x21, 0x02, 0x10,
  0x22, 0x01, 0x40, 0x18, 0x01, 0xFF, 0xC0, 0x91, 0x10, 0x07, 0x91, 0x85,
  0x20, 0x32, 0x03, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x0C, 0x41, 0x43, 0xE4, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x13, 0xC2, 0xC2, 0x30, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x2C, 0x04, 0xA0, 0xC9, 0xF0,
  0x07, 0xC3, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x7C, 0x86, 0x0A, 0x20, 0x30,
  0x80, 0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08,
  0x80, 0x62, 0x02, 0x84, 0x14, 0x0F, 0x90, 0x0F, 0x84, 0x12, 0x05, 0x01,
  0x80, 0x60, 0x29, 0xF3, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x0F,
  0xC0, 0x00, 0x3C, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0xFE, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x03, 0x80, 0x00, 0x07,
  0xC8, 0xC1, 0x48, 0x0A, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x19, 0x01, 0x44, 0x14, 0x1F, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x41, 0xFC, 0x00, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x13, 0xC2, 0xC2, 0x30, 0x13, 0x01, 0x20,
  0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x48, 0x04, 0x08, 0x80, 0x00, 0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10,
  0x84, 0x20, 0x00, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0xF0, 0x00, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x09, 0x02, 0x20, 0x84, 0x20,
  0x88, 0x22, 0x04, 0x80, 0xA8, 0x19, 0x02, 0x10, 0x82, 0x10, 0x22, 0x04,
  0x40, 0x40, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08,
  0x84, 0x21, 0x00, 0x27, 0xC3, 0xC5, 0x04, 0x84, 0xC0, 0xA0, 0x90, 0x18,
  0x12, 0x02, 0x02, 0x40, 0x40, 0x50, 0x08, 0x0A, 0x02, 0x01, 0x40, 0x40,
  0x28, 0x08, 0x0A, 0x01, 0x01, 0x40, 0x20, 0x28, 0x08, 0x05, 0x01, 0x00,
  0x80, 0x23, 0xC2, 0xC2, 0x30, 0x13, 0x01, 0x20, 0x12, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x07, 0xC1,
  0x82, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x24, 0x02, 0x40, 0xC3, 0xF0, 0x11, 0xE0, 0xB0, 0x86, 0x02,
  0x30, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x04, 0xC0, 0x45, 0x06, 0x27, 0xC1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x07, 0xC8, 0xC1, 0x48, 0x0A, 0x40, 0x24, 0x01,
  0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x19, 0x01, 0x44,
  0x14, 0x1F, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x23, 0x96, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x02, 0x01, 0x3F, 0x80, 0x10,
  0x10, 0x10, 0x7F, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x78, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x41, 0x47,
  0xE4, 0x80, 0x30, 0x0A, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x82, 0x10,
  0x44, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x40, 0x00, 0x80, 0x80, 0xC0,
  0x40, 0xA0, 0x60, 0x50, 0x50, 0x48, 0x28, 0x22, 0x22, 0x21, 0x11, 0x10,
  0x90, 0x90, 0x48, 0x48, 0x28, 0x28, 0x14, 0x14, 0x0C, 0x0A, 0x06, 0x06,
  0x02, 0x02, 0x00, 0x10, 0x08, 0x40, 0x82, 0x08, 0x08, 0x80, 0x48, 0x01,
  0x40, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x44, 0x04, 0x20, 0x40, 0x84, 0x04,
  0x40, 0x30, 0x08, 0x02, 0x10, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x82, 0x01, 0x04, 0x02, 0x10, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0xFF, 0x00,
  0x01, 0x81, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x18, 0x04, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x30, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x83, 0x80, 0xFC, 0x18, 0x3E,
};

const GFXglyph NotoSans_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 5, 1, -19 },
  { 13, 6, 7, 8, 3, -19 },
  { 19, 15, 19, 16, 1, -19 },
  { 55, 12, 22, 14, 1, -20 },
  { 88, 16, 19, 20, 2, -19 },
  { 126, 16, 19, 18, 1, -19 },
  { 164, 2, 7, 4, 3, -19 },
  { 166, 7, 23, 6, 1, -19 },
  { 187, 8, 23, 6, -2, -19 },
  { 210, 11, 11, 14, 3, -20 },
  { 226, 12, 12, 15, 2, -15 },
  { 244, 3, 6, 5, -1, -3 },
  { 247, 6, 1, 8, 1, -8 },
  { 248, 1, 1, 5, 1, -1 },
  { 249, 11, 19, 8, -1, -19 },
  { 276, 12, 19, 14, 2, -19 },
  { 305, 7, 19, 14, 4, -19 },
  { 322, 13, 19, 14, 0, -19 },
  { 353, 13, 19, 14, 1, -19 },
  { 384, 14, 19, 14, 0, -19 },
  { 418, 13, 19, 14, 1, -19 },
  { 449, 12, 19, 14, 2, -19 },
  { 478, 12, 19, 14, 3, -19 },
  { 507, 13, 19, 14, 1, -19 },
  { 538, 13, 19, 14, 1, -19 },
  { 569, 4, 14, 5, 1, -14 },
  { 576, 6, 17, 5, -1, -14 },
  { 589, 12, 11, 15, 2, -15 },
  { 606, 12, 6, 15, 2, -12 },
  { 615, 12, 11, 15, 2, -15 },
  { 632, 9, 19, 10, 2, -19 },
  { 654, 20, 20, 22, 1, -18 },
  { 704, 14, 19, 14, -1, -19 },
  { 738, 14, 19, 16, 1, -19 },
  { 772, 14, 19, 15, 2, -19 },
  { 806, 16, 19, 18, 1, -19 },
  { 844, 14, 19, 14, 1, -19 },
  { 878, 14, 19, 13, 1, -19 },
  { 912, 15, 19, 18, 2, -19 },
  { 948, 17, 19, 18, 1, -19 },
  { 989, 8, 19, 7, 0, -19 },
  { 1008, 10, 24, 6, -4, -19 },
  { 1038, 15, 19, 14, 1, -19 },
  { 1074, 10, 19, 13, 1, -19 },
  { 1098, 20, 19, 21, 1, -19 },
  { 1146, 16, 19, 18, 1, -19 },
  { 1184, 16, 19, 19, 2, -19 },
  { 1222, 14, 19, 15, 1, -19 },
  { 1256, 16, 23, 19, 2, -19 },
  { 1302, 14, 19, 15, 1, -19 },
  { 1336, 13, 19, 13, 0, -19 },
  { 1367, 13, 19, 13, 2, -19 },
  { 1398, 16, 19, 18, 2, -19 },
  { 1436, 13, 19, 14, 3, -19 },
  { 1467, 20, 19, 21, 3, -19 },
  { 1515, 17, 19, 13, -2, -19 },
  { 1556, 13, 19, 13, 2, -19 },
  { 1587, 15, 19, 14, 0, -19 },
  { 1623, 10, 23, 8, 0, -19 },
  { 1652, 4, 19, 8, 3, -19 },
  { 1662, 10, 23, 8, -2, -19 },
  { 1691, 12, 12, 14, 1, -19 },
  { 1709, 10, 1, 10, -2, 3 },
  { 1711, 3, 4, 6, 4, -20 },
  { 1713, 12, 14, 14, 1, -14 },
  { 1734, 12, 20, 15, 1, -20 },
  { 1764, 11, 14, 12, 1, -14 },
  { 1784, 14, 20, 15, 1, -20 },
  { 1819, 10, 14, 13, 2, -14 },
  { 1837, 14, 26, 7, -3, -20 },
  { 1883, 13, 20, 15, 1, -14 },
  { 1916, 12, 20, 14, 1, -20 },
  { 1946, 5, 19, 5, 1, -19 },
  { 1958, 10, 25, 5, -4, -19 },
  { 1990, 11, 20, 11, 1, -20 },
  { 2018, 5, 20, 5, 1, -20 },
  { 2031, 19, 14, 22, 1, -14 },
  { 2065, 12, 14, 14, 1, -14 },
  { 2086, 12, 14, 15, 1, -14 },
  { 2107, 13, 20, 15, 0, -14 },
  { 2140, 13, 20, 15, 1, -14 },
  { 2173, 9, 14, 10, 1, -14 },
  { 2189, 10, 14, 11, 0, -14 },
  { 2207, 8, 17, 8, 1, -17 },
  { 2224, 12, 14, 14, 1, -14 },
  { 2245, 11, 14, 11, 1, -14 },
  { 2265, 17, 14, 17, 1, -14 },
  { 2295, 13, 14, 12, -1, -14 },
  { 2318, 15, 20, 11, -3, -14 },
  { 2356, 11, 14, 11, 0, -14 },
  { 2376, 9, 23, 9, 1, -19 },
  { 2402, 1, 26, 14, 7, -20 },
  { 2406, 9, 23, 9, -1, -19 },
  { 2432, 12, 2, 15, 2, -10 },
};

const GFXfont NotoSans_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_THINITALIC26PT7B_H_
