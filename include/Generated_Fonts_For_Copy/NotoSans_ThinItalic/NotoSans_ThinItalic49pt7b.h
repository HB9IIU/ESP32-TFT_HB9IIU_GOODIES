#ifndef _NOTOSANS_THINITALIC49PT7B_H_
#define _NOTOSANS_THINITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x60, 0x30, 0x00, 0x10, 0x22, 0x0C, 0xC1, 0x10, 0x22, 0x04,
  0x40, 0x88, 0x33, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x88, 0x10, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x80, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x0C, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x18, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x01, 0x81, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x40, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x10, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x00, 0x0E, 0x27, 0xC0,
  0x70, 0x40, 0x81, 0x81, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x01, 0x01,
  0x00, 0x03, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x90, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xB8, 0x00, 0x02, 0x18, 0x00, 0x04, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x60, 0xE0, 0x43, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x18, 0x0C, 0x30, 0x00, 0x20, 0x20, 0x30, 0x00,
  0x80, 0xC0, 0x60, 0x03, 0x01, 0x00, 0x40, 0x0C, 0x04, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x40, 0x04, 0x06, 0x00,
  0x80, 0x18, 0x08, 0x01, 0x00, 0x30, 0x20, 0x06, 0x00, 0x40, 0xC0, 0x0C,
  0x00, 0x83, 0x00, 0x18, 0x01, 0x04, 0x00, 0x30, 0x06, 0x10, 0x7E, 0x60,
  0x08, 0x63, 0x06, 0xC0, 0x30, 0x8C, 0x05, 0x80, 0x42, 0x10, 0x09, 0x01,
  0x0C, 0x60, 0x1B, 0x06, 0x30, 0x80, 0x33, 0xF0, 0x43, 0x00, 0x60, 0x01,
  0x04, 0x00, 0xC0, 0x06, 0x08, 0x01, 0x80, 0x18, 0x30, 0x02, 0x00, 0x20,
  0x60, 0x04, 0x00, 0x80, 0x80, 0x08, 0x03, 0x01, 0x00, 0x30, 0x0C, 0x02,
  0x00, 0x60, 0x10, 0x04, 0x00, 0x80, 0x40, 0x08, 0x03, 0x01, 0x80, 0x10,
  0x04, 0x06, 0x00, 0x20, 0x18, 0x08, 0x00, 0x60, 0x20, 0x20, 0x00, 0x60,
  0x80, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x20, 0x01, 0x00, 0x03, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x8C, 0x00, 0x80, 0x0C, 0xC0, 0x02, 0x00, 0x44, 0x00, 0x18, 0x06,
  0x60, 0x00, 0x40, 0x22, 0x00, 0x01, 0x02, 0x30, 0x00, 0x0C, 0x31, 0x80,
  0x00, 0x33, 0x0C, 0x00, 0x00, 0xB0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x38, 0x08, 0x00, 0x03, 0x60, 0x60, 0x00, 0x31, 0x01, 0x80, 0x06, 0x0C,
  0x06, 0x00, 0xE0, 0x30, 0x1F, 0xFC, 0x00, 0xC0, 0x11, 0x32, 0x22, 0x26,
  0x44, 0x44, 0x80, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x00, 0x30, 0x20, 0x01, 0xC2,
  0x00, 0x06, 0x20, 0x00, 0x1C, 0x3F, 0x00, 0x7E, 0x00, 0x0A, 0x00, 0x01,
  0x20, 0x00, 0x21, 0x00, 0x0C, 0x10, 0x01, 0x81, 0x80, 0x30, 0x08, 0x06,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x30, 0xC2, 0x18, 0x41, 0x08, 0x21, 0x84, 0x20, 0xFF, 0xE0, 0xBC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x40, 0x00,
  0x81, 0x80, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x80, 0x00, 0x13, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x46, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30,
  0x30, 0x00, 0x40, 0x20, 0x01, 0x00, 0x60, 0x04, 0x00, 0x60, 0x30, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xA0, 0x72, 0x0C, 0x23, 0x86,
  0x60, 0x6C, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1C, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x38, 0x06, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x80, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01,
  0x01, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x10, 0x01, 0x80, 0x08, 0x01, 0x80, 0x04, 0x00,
  0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0xFE, 0x00, 0x0F,
  0x83, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x80, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x20, 0xFF, 0x80, 0x23,
  0x00, 0xE0, 0x26, 0x00, 0x20, 0x68, 0x00, 0x10, 0x50, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60, 0x60, 0x00, 0x40, 0x20,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x02,
  0x01, 0x00, 0x03, 0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x03, 0x00, 0x04,
  0x01, 0x00, 0x0C, 0x00, 0x80, 0x30, 0x00, 0x60, 0x60, 0x00, 0x33, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x03, 0x81, 0x80, 0x06, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x30, 0x00, 0x10, 0x20, 0x00, 0x18, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04, 0x02, 0x00, 0x06,
  0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x18, 0x00, 0x0A,
  0x08, 0x00, 0x16, 0x04, 0x00, 0x64, 0x07, 0x00, 0xC4, 0x01, 0xFF, 0x0C,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xC1, 0x80, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x1C, 0x06, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x07, 0xC0, 0x04, 0x20, 0x01, 0xE7, 0xC0, 0x23, 0x00, 0x38, 0x06,
  0x01, 0x10, 0x03, 0x00, 0x20, 0x09, 0x80, 0x30, 0x01, 0x00, 0x68, 0x03,
  0x00, 0x08, 0x03, 0x40, 0x10, 0x00, 0xC0, 0x16, 0x01, 0x80, 0x04, 0x00,
  0xA0, 0x08, 0x00, 0x20, 0x05, 0x00, 0x40, 0x03, 0x00, 0x28, 0x06, 0x00,
  0x10, 0x03, 0x40, 0x20, 0x00, 0x80, 0x12, 0x01, 0x00, 0x0C, 0x00, 0x90,
  0x08, 0x00, 0x60, 0x0C, 0x80, 0x40, 0x07, 0x00, 0x44, 0x03, 0x00, 0x28,
  0x06, 0x20, 0x18, 0x02, 0x40, 0x61, 0x80, 0x60, 0x62, 0x06, 0x0C, 0x01,
  0xFE, 0x1D, 0xE0, 0x20, 0x03, 0x80, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x64, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x20, 0x20, 0x00, 0x18, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x00,
  0x20, 0x07, 0xC0, 0x18, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06,
  0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x10, 0x00, 0xF0,
  0x0F, 0xFF, 0xC0, 0x02, 0x00, 0x3C, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x18, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0x40, 0x00, 0x70, 0x10, 0x00, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x04, 0x01, 0xE0, 0x00, 0x60, 0x01, 0xC0,
  0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0x40, 0x00, 0xE0,
  0x02, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xF1, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x0F, 0xFF, 0xFF,
  0xF0, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x38, 0x04, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x8E, 0x00, 0x00, 0x0C, 0xD8, 0x00, 0x00, 0x4C, 0x40, 0x00, 0x02,
  0x83, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00, 0x10, 0x01, 0x80,
  0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x02, 0x80,
  0x00, 0x00, 0xF0, 0x16, 0x00, 0x00, 0x0D, 0x00, 0xB0, 0x00, 0x00, 0x48,
  0x0C, 0x80, 0x00, 0x06, 0x40, 0x64, 0x00, 0x00, 0x26, 0x02, 0x20, 0x00,
  0x03, 0x20, 0x11, 0x00, 0x00, 0x11, 0x00, 0x8C, 0x00, 0x01, 0x08, 0x0C,
  0x20, 0x00, 0x18, 0x40, 0x61, 0x00, 0x00, 0x86, 0x02, 0x08, 0x00, 0x0C,
  0x20, 0x10, 0x40, 0x00, 0x41, 0x00, 0x82, 0x00, 0x04, 0x08, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x40, 0x40, 0x02, 0x06, 0x02, 0x02, 0x00, 0x30, 0x20,
  0x10, 0x10, 0x01, 0x01, 0x00, 0x80, 0x80, 0x10, 0x08, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x40, 0x30, 0x08, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x20, 0x10,
  0x04, 0x04, 0x01, 0x01, 0x80, 0x20, 0x40, 0x08, 0x0C, 0x01, 0x06, 0x00,
  0xC0, 0x40, 0x0C, 0x20, 0x04, 0x02, 0x00, 0x23, 0x00, 0x20, 0x10, 0x01,
  0x10, 0x01, 0x01, 0x80, 0x09, 0x00, 0x08, 0x0C, 0x00, 0x58, 0x00, 0xC0,
  0x40, 0x02, 0x80, 0x04, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x07, 0x00,
  0x00, 0x10, 0x0A, 0x00, 0x00, 0x20, 0x16, 0x00, 0x00, 0x40, 0x24, 0x00,
  0x01, 0x80, 0xCC, 0x00, 0x02, 0x01, 0x88, 0x00, 0x04, 0x02, 0x10, 0x00,
  0x08, 0x04, 0x30, 0x00, 0x30, 0x08, 0x20, 0x00, 0x60, 0x30, 0x60, 0x00,
  0x80, 0x60, 0x40, 0x01, 0x00, 0x80, 0xC0, 0x02, 0x01, 0x00, 0x80, 0x0C,
  0x02, 0x01, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x20, 0x10, 0x02, 0x00, 0x40,
  0x20, 0x06, 0x00, 0x80, 0x40, 0x04, 0x03, 0x00, 0x80, 0x0C, 0x04, 0x03,
  0x00, 0x08, 0x08, 0x04, 0x00, 0x10, 0x10, 0x08, 0x00, 0x30, 0x60, 0x10,
  0x00, 0x20, 0xC0, 0x60, 0x00, 0x61, 0x00, 0xC0, 0x00, 0x42, 0x01, 0x00,
  0x00, 0xC4, 0x02, 0x00, 0x00, 0x98, 0x04, 0x00, 0x01, 0x30, 0x18, 0x00,
  0x03, 0x40, 0x30, 0x00, 0x02, 0x80, 0x40, 0x00, 0x07, 0x00, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x3E, 0x00,
  0x60, 0x01, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0C,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x20, 0x00,
  0x08, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x04, 0x00,
  0x0C, 0x02, 0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x40, 0x3E, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0x60,
  0x10, 0x00, 0x18, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x08, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x38, 0x03, 0xFF, 0xF0, 0x01, 0x00,
  0x60, 0x00, 0x80, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x04,
  0x00, 0x0C, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x70, 0x07, 0x01, 0x80, 0x01, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x80, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x30, 0x00, 0x18, 0x08, 0x00,
  0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x01, 0x00, 0x06, 0x00, 0x80,
  0x02, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x01, 0x00, 0x04,
  0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00,
  0x40, 0x60, 0x00, 0x20, 0x20, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x88, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x04,
  0xC0, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x8C, 0x00, 0x19,
  0x00, 0x06, 0x30, 0x00, 0x44, 0x00, 0x10, 0x40, 0x03, 0x10, 0x00, 0xC1,
  0x00, 0x08, 0x40, 0x02, 0x04, 0x00, 0x61, 0x00, 0x18, 0x10, 0x01, 0x04,
  0x00, 0x40, 0x40, 0x0C, 0x10, 0x01, 0x01, 0x00, 0x20, 0x40, 0x0C, 0x04,
  0x01, 0x81, 0x80, 0x20, 0x10, 0x04, 0x06, 0x01, 0x80, 0x40, 0x30, 0x18,
  0x04, 0x01, 0x00, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10,
  0x10, 0x02, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x61,
  0x00, 0x08, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x06, 0x20, 0x00, 0x8C,
  0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0x24, 0x00, 0x09, 0x80, 0x00, 0xB0,
  0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0xB0, 0x00, 0x0E, 0x00, 0x02, 0x80,
  0x00, 0x30, 0x00, 0x0A, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x06, 0x00, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x02, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x10, 0x00, 0x60, 0x30, 0x00, 0x80, 0x20, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80,
  0x02, 0x06, 0x00, 0x06, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20,
  0x60, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x08,
  0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x18, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80, 0x60,
  0x03, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x60, 0x03, 0x01,
  0x80, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x08, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x11, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC3, 0x06, 0x08, 0x30, 0x40, 0x83, 0x00, 0x7F, 0x82, 0x01, 0x81,
  0x84, 0x0C, 0x00, 0x98, 0x30, 0x01, 0xA0, 0xC0, 0x01, 0x41, 0x00, 0x02,
  0x86, 0x00, 0x03, 0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x41, 0x00,
  0x01, 0x82, 0x00, 0x07, 0x04, 0x00, 0x0A, 0x08, 0x00, 0x2C, 0x18, 0x00,
  0x90, 0x18, 0x02, 0x20, 0x18, 0x18, 0x40, 0x1F, 0xE1, 0x80, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0xFF, 0x00, 0x43, 0x03, 0x00,
  0x98, 0x01, 0x03, 0x60, 0x03, 0x05, 0x80, 0x02, 0x0A, 0x00, 0x06, 0x18,
  0x00, 0x04, 0x70, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x98, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x01,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0x70, 0x00, 0x21, 0x20, 0x00, 0x82,
  0x60, 0x06, 0x04, 0x60, 0x18, 0x08, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x38, 0x04, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x02, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x01,
  0xFF, 0x04, 0x00, 0xC0, 0x63, 0x00, 0xC0, 0x0C, 0xC0, 0x60, 0x01, 0xA0,
  0x30, 0x00, 0x28, 0x08, 0x00, 0x0A, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x10, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x06, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C,
  0x04, 0x00, 0x05, 0x01, 0x00, 0x03, 0x40, 0x60, 0x00, 0xA0, 0x18, 0x00,
  0x48, 0x03, 0x00, 0x62, 0x00, 0x60, 0x70, 0x80, 0x0F, 0xF0, 0x60, 0x00,
  0x00, 0x7F, 0x80, 0x38, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x10, 0xC0, 0x02,
  0x30, 0x00, 0x44, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x6C, 0x00, 0x19,
  0x00, 0x0E, 0x20, 0x0F, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x30, 0x18,
  0x40, 0x60, 0x02, 0x60, 0x60, 0x01, 0xA0, 0x60, 0x00, 0x50, 0x20, 0x00,
  0x28, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x18, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x07, 0x02, 0x00, 0x06, 0x81,
  0x00, 0x02, 0x80, 0xC0, 0x02, 0x40, 0x30, 0x06, 0x20, 0x0C, 0x0E, 0x10,
  0x03, 0xFC, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x07, 0xF8, 0x04, 0x30, 0x38, 0x13, 0x00, 0x20, 0xD8, 0x00, 0xC2, 0xC0,
  0x01, 0x0A, 0x00, 0x04, 0x30, 0x00, 0x11, 0xC0, 0x00, 0x46, 0x00, 0x01,
  0x18, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20,
  0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00,
  0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x23,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0x40, 0x03,
  0x81, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x37, 0x00, 0x07, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x30, 0x40, 0x03, 0x02,
  0x00, 0x30, 0x30, 0x03, 0x01, 0x00, 0x30, 0x08, 0x03, 0x00, 0x40, 0x30,
  0x06, 0x03, 0x00, 0x30, 0x20, 0x01, 0x02, 0x00, 0x08, 0x20, 0x00, 0x42,
  0x00, 0x06, 0x28, 0x00, 0x26, 0x40, 0x01, 0x61, 0x00, 0x0E, 0x08, 0x00,
  0x60, 0x20, 0x06, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x30, 0x08, 0x00,
  0x80, 0x40, 0x06, 0x06, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x00, 0x02, 0x08,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x00, 0x04, 0x1F, 0xC0,
  0x3F, 0xC0, 0x46, 0x06, 0x06, 0x06, 0x04, 0xC0, 0x30, 0x80, 0x30, 0x98,
  0x01, 0x10, 0x01, 0x0B, 0x00, 0x12, 0x00, 0x10, 0xA0, 0x01, 0x60, 0x01,
  0x0C, 0x00, 0x14, 0x00, 0x11, 0xC0, 0x01, 0x80, 0x01, 0x18, 0x00, 0x18,
  0x00, 0x11, 0x80, 0x01, 0x00, 0x01, 0x10, 0x00, 0x10, 0x00, 0x31, 0x00,
  0x03, 0x00, 0x02, 0x30, 0x00, 0x20, 0x00, 0x22, 0x00, 0x02, 0x00, 0x02,
  0x20, 0x00, 0x20, 0x00, 0x22, 0x00, 0x02, 0x00, 0x06, 0x20, 0x00, 0x60,
  0x00, 0x46, 0x00, 0x04, 0x00, 0x04, 0x40, 0x00, 0x40, 0x00, 0x44, 0x00,
  0x04, 0x00, 0x0C, 0x40, 0x00, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x00, 0x08,
  0xC0, 0x00, 0x80, 0x00, 0x88, 0x00, 0x08, 0x00, 0x08, 0x80, 0x00, 0x80,
  0x01, 0x88, 0x00, 0x18, 0x00, 0x18, 0x04, 0x1F, 0xE0, 0x10, 0xC0, 0xE0,
  0x4C, 0x00, 0x82, 0x60, 0x03, 0x0B, 0x00, 0x04, 0x28, 0x00, 0x10, 0xC0,
  0x00, 0x47, 0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x31, 0x00, 0x00,
  0xC4, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00,
  0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x18,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x03, 0x80,
  0x60, 0x03, 0x03, 0x00, 0x06, 0x18, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00,
  0x0C, 0xC0, 0x00, 0x21, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x83, 0xFC, 0x00, 0x21, 0x81,
  0x80, 0x09, 0x80, 0x10, 0x04, 0xC0, 0x06, 0x01, 0x60, 0x00, 0x80, 0x50,
  0x00, 0x30, 0x18, 0x00, 0x04, 0x0E, 0x00, 0x01, 0x03, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x03, 0x80, 0x01, 0x01, 0xA0, 0x00, 0x80, 0x4C, 0x00, 0xC0,
  0x11, 0x80, 0x60, 0x04, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0xC0,
  0x61, 0x03, 0x00, 0x13, 0x06, 0x00, 0x1A, 0x0C, 0x00, 0x0A, 0x08, 0x00,
  0x0A, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x50, 0x40, 0x00, 0xD0, 0x40, 0x00,
  0xB0, 0x60, 0x01, 0x20, 0x30, 0x06, 0x20, 0x18, 0x1C, 0x20, 0x0F, 0xF0,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x04, 0x1F,
  0x82, 0x38, 0x01, 0x30, 0x01, 0x30, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xE0, 0x1C, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x84, 0x00, 0x30, 0xE0, 0x1C, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x07, 0xFF, 0xC1, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x0F, 0xE0, 0x08, 0x00, 0x04, 0x60, 0x00, 0x11, 0x00, 0x00,
  0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x88,
  0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00,
  0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x08,
  0x80, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80,
  0x01, 0x42, 0x00, 0x09, 0x08, 0x00, 0x6C, 0x30, 0x03, 0x20, 0x60, 0x30,
  0x80, 0xFF, 0x82, 0x00, 0xC0, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x24,
  0x00, 0x06, 0x40, 0x00, 0x46, 0x00, 0x08, 0x60, 0x01, 0x82, 0x00, 0x10,
  0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x08,
  0x01, 0x01, 0x80, 0x10, 0x10, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x04,
  0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x09, 0x80, 0x00, 0x90, 0x00, 0x0B,
  0x00, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x06,
  0x80, 0x0D, 0x00, 0x12, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x90, 0x02, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x0C, 0x04,
  0x18, 0x08, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x80, 0x81, 0x83, 0x02, 0x02,
  0x04, 0x04, 0x10, 0x08, 0x30, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x86,
  0x01, 0x18, 0x02, 0x10, 0x04, 0x40, 0x08, 0xC0, 0x13, 0x00, 0x22, 0x00,
  0x48, 0x00, 0xD8, 0x01, 0x60, 0x03, 0x40, 0x05, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80, 0x10, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x40, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60,
  0x10, 0x00, 0x60, 0x08, 0x00, 0x60, 0x02, 0x00, 0x60, 0x01, 0x00, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0x20, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x20, 0x00, 0x20, 0x06, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10,
  0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x38,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0x01, 0xC0, 0x38, 0x01, 0xE3, 0x80, 0x00,
  0xF8,
};

const GFXglyph NotoSans_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 35, 10, 2, -35 },
  { 41, 11, 13, 15, 5, -35 },
  { 59, 29, 35, 30, 2, -35 },
  { 186, 23, 40, 27, 2, -37 },
  { 301, 31, 36, 37, 4, -35 },
  { 441, 29, 36, 33, 2, -36 },
  { 572, 4, 13, 8, 5, -35 },
  { 579, 13, 43, 12, 2, -35 },
  { 649, 14, 43, 12, -3, -35 },
  { 725, 20, 20, 26, 6, -37 },
  { 775, 22, 23, 28, 4, -29 },
  { 839, 6, 12, 9, -2, -6 },
  { 848, 11, 1, 15, 2, -14 },
  { 850, 2, 3, 10, 2, -3 },
  { 851, 21, 35, 15, -2, -35 },
  { 943, 23, 36, 27, 3, -36 },
  { 1047, 12, 35, 27, 8, -35 },
  { 1100, 25, 35, 27, 0, -35 },
  { 1210, 25, 35, 27, 1, -35 },
  { 1320, 25, 35, 27, 1, -35 },
  { 1430, 24, 35, 27, 2, -35 },
  { 1535, 24, 36, 27, 3, -36 },
  { 1643, 22, 35, 27, 6, -35 },
  { 1740, 24, 35, 27, 2, -35 },
  { 1845, 24, 35, 27, 2, -35 },
  { 1950, 7, 26, 10, 2, -26 },
  { 1973, 11, 32, 10, -2, -26 },
  { 2017, 22, 22, 28, 4, -29 },
  { 2078, 22, 11, 28, 4, -23 },
  { 2109, 22, 22, 28, 4, -29 },
  { 2170, 17, 35, 20, 4, -35 },
  { 2245, 37, 39, 41, 3, -35 },
  { 2426, 26, 35, 27, -2, -35 },
  { 2540, 26, 35, 29, 2, -35 },
  { 2654, 27, 35, 29, 4, -35 },
  { 2773, 29, 35, 33, 2, -35 },
  { 2900, 25, 35, 26, 2, -35 },
  { 3010, 25, 35, 24, 2, -35 },
  { 3120, 29, 35, 34, 4, -35 },
  { 3247, 31, 35, 33, 2, -35 },
  { 3383, 16, 35, 14, 0, -35 },
  { 3453, 19, 44, 11, -8, -35 },
  { 3558, 29, 35, 27, 2, -35 },
  { 3685, 18, 35, 24, 2, -35 },
  { 3764, 37, 35, 40, 2, -35 },
  { 3926, 31, 35, 33, 2, -35 },
  { 4062, 29, 36, 35, 4, -36 },
  { 4193, 25, 35, 27, 2, -35 },
  { 4303, 29, 44, 35, 4, -36 },
  { 4463, 25, 35, 28, 2, -35 },
  { 4573, 24, 35, 24, 1, -35 },
  { 4678, 23, 35, 24, 5, -35 },
  { 4779, 30, 35, 34, 4, -35 },
  { 4911, 25, 35, 26, 5, -35 },
  { 5021, 38, 35, 40, 6, -35 },
  { 5188, 31, 35, 24, -3, -35 },
  { 5324, 23, 35, 24, 5, -35 },
  { 5425, 28, 35, 26, 0, -35 },
  { 5548, 18, 43, 15, 0, -35 },
  { 5645, 7, 35, 15, 5, -35 },
  { 5676, 19, 43, 15, -4, -35 },
  { 5779, 23, 21, 27, 2, -35 },
  { 5840, 18, 2, 18, -4, 5 },
  { 5845, 6, 8, 11, 7, -38 },
  { 5851, 23, 26, 27, 2, -26 },
  { 5926, 23, 37, 28, 2, -37 },
  { 6033, 19, 26, 22, 3, -26 },
  { 6095, 26, 37, 28, 2, -37 },
  { 6216, 19, 26, 24, 3, -26 },
  { 6278, 26, 49, 13, -6, -37 },
  { 6438, 25, 38, 28, 1, -26 },
  { 6557, 22, 37, 27, 2, -37 },
  { 6659, 9, 35, 10, 2, -35 },
  { 6699, 18, 47, 10, -7, -35 },
  { 6805, 21, 37, 22, 2, -37 },
  { 6903, 9, 37, 10, 2, -37 },
  { 6945, 36, 26, 41, 2, -26 },
  { 7062, 22, 26, 27, 2, -26 },
  { 7134, 22, 26, 28, 3, -26 },
  { 7206, 26, 37, 28, -1, -26 },
  { 7327, 24, 37, 28, 2, -26 },
  { 7438, 17, 26, 18, 2, -26 },
  { 7494, 19, 26, 21, 1, -26 },
  { 7556, 14, 32, 15, 2, -32 },
  { 7612, 22, 26, 27, 3, -26 },
  { 7684, 20, 26, 20, 2, -26 },
  { 7749, 30, 26, 32, 3, -26 },
  { 7847, 25, 26, 22, -2, -26 },
  { 7929, 28, 38, 20, -6, -26 },
  { 8062, 22, 26, 21, -1, -26 },
  { 8134, 18, 43, 16, 1, -35 },
  { 8231, 1, 49, 26, 14, -37 },
  { 8238, 17, 43, 16, -2, -35 },
  { 8330, 22, 4, 28, 4, -19 },
};

const GFXfont NotoSans_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_THINITALIC49PT7B_H_
