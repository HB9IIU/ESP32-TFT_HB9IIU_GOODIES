#ifndef _NOTOSANS_THINITALIC55PT7B_H_
#define _NOTOSANS_THINITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x38,
  0x0C, 0x00, 0x10, 0x33, 0x03, 0x30, 0x23, 0x02, 0x20, 0x62, 0x06, 0x60,
  0x46, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xC4, 0x08, 0x80, 0x88, 0x08, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0x80, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x20, 0x00, 0x02, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF2, 0x7E, 0x01, 0x81, 0x03,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00, 0x08, 0x04,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x0E, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x13, 0x80, 0x00, 0x08, 0x60, 0x00, 0x04, 0x1C, 0x00, 0x02, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x04,
  0x00, 0x04, 0x06, 0x08, 0x06, 0x0E, 0x07, 0xC3, 0x3C, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xC0, 0x60, 0xC0, 0x00, 0x60, 0x30, 0x18, 0x00,
  0x10, 0x18, 0x06, 0x00, 0x08, 0x04, 0x00, 0x80, 0x06, 0x03, 0x00, 0x20,
  0x03, 0x00, 0x80, 0x08, 0x00, 0x80, 0x60, 0x02, 0x00, 0x60, 0x10, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x20, 0x18, 0x03, 0x00, 0x18, 0x04, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x30, 0x01, 0x81, 0x80, 0x08, 0x00, 0x40, 0xC0, 0x02,
  0x00, 0x10, 0x20, 0x00, 0x80, 0x0C, 0x18, 0x3E, 0x20, 0x02, 0x0C, 0x3D,
  0xC8, 0x01, 0x86, 0x18, 0x1A, 0x00, 0x61, 0x0C, 0x02, 0xC0, 0x30, 0xC2,
  0x00, 0xF0, 0x18, 0x61, 0x80, 0x36, 0x0C, 0x10, 0x40, 0x0C, 0xFE, 0x08,
  0x30, 0x03, 0x0E, 0x06, 0x08, 0x00, 0xC0, 0x03, 0x02, 0x00, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x00, 0x40, 0x60, 0x03, 0x00, 0x30, 0x10, 0x00, 0x80,
  0x18, 0x04, 0x00, 0x20, 0x04, 0x01, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x20, 0x03, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x10, 0x04, 0x06, 0x00, 0x06,
  0x03, 0x01, 0x00, 0x00, 0xC1, 0x80, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x40, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01,
  0xC2, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x18,
  0x00, 0x80, 0x02, 0x30, 0x00, 0xC0, 0x06, 0x60, 0x00, 0x60, 0x04, 0x40,
  0x00, 0x30, 0x0C, 0xC0, 0x00, 0x10, 0x08, 0xC0, 0x00, 0x18, 0x18, 0x80,
  0x00, 0x0C, 0x30, 0x80, 0x00, 0x04, 0x60, 0x80, 0x00, 0x06, 0xC0, 0x80,
  0x00, 0x03, 0x80, 0x80, 0x00, 0x03, 0x80, 0x80, 0x00, 0x06, 0x80, 0xC0,
  0x00, 0x0C, 0xC0, 0x60, 0x00, 0x18, 0x60, 0x70, 0x00, 0x60, 0x20, 0x1C,
  0x03, 0xC0, 0x30, 0x0F, 0xFF, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x13,
  0x33, 0x22, 0x66, 0x44, 0x44, 0x88, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x1C, 0x04, 0x00, 0x18, 0x10, 0x00, 0x18, 0x40, 0x00, 0x1B, 0x00,
  0x40, 0x39, 0xFF, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x19, 0x00, 0x00,
  0xC2, 0x00, 0x06, 0x08, 0x00, 0x30, 0x30, 0x01, 0x80, 0x40, 0x1C, 0x01,
  0x80, 0x20, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x08, 0x30, 0x61, 0x83, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xDF, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x88,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x08, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x70, 0x38, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x03, 0x40, 0x36, 0x07, 0x30,
  0x61, 0x0E, 0x08, 0xC0, 0xDC, 0x06, 0x80, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x0E,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x80, 0x78, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x02, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0,
  0x10, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x05, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x7F, 0xC0, 0x08, 0x78, 0x38, 0x06,
  0x30, 0x03, 0x81, 0x30, 0x00, 0x20, 0x58, 0x00, 0x0C, 0x1C, 0x00, 0x01,
  0x0E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x60, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x10, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x40, 0x18, 0x00, 0x30, 0x02, 0x00, 0x38, 0x00, 0xE0, 0x18,
  0x00, 0x0C, 0x1C, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x73,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x60, 0x03, 0x00, 0x70, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x18, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x10, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x10,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x38, 0x60, 0x00, 0x1E,
  0x08, 0x00, 0x0D, 0x83, 0x00, 0x06, 0x40, 0x70, 0x07, 0x10, 0x07, 0xFF,
  0x0C, 0x00, 0x7E, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x08, 0x03,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0xE0, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x60, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0xFC, 0x00, 0x31, 0x80, 0x03, 0xFF, 0xE0,
  0x08, 0xC0, 0x03, 0x00, 0x20, 0x04, 0xC0, 0x07, 0x00, 0x10, 0x02, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x20, 0x02, 0x00, 0x0C, 0x00, 0xB0, 0x03, 0x00,
  0x04, 0x00, 0x58, 0x03, 0x00, 0x02, 0x00, 0x28, 0x01, 0x00, 0x03, 0x00,
  0x1C, 0x01, 0x80, 0x01, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x80, 0x0F, 0x00,
  0x40, 0x00, 0xC0, 0x07, 0x80, 0x20, 0x00, 0x60, 0x02, 0xC0, 0x10, 0x00,
  0x20, 0x03, 0x60, 0x18, 0x00, 0x30, 0x01, 0xB0, 0x0C, 0x00, 0x18, 0x01,
  0x98, 0x02, 0x00, 0x1C, 0x00, 0xCC, 0x01, 0x00, 0x1A, 0x00, 0xC6, 0x00,
  0xC0, 0x19, 0x00, 0xC3, 0x00, 0x20, 0x18, 0xC0, 0xC0, 0x80, 0x1E, 0x38,
  0x31, 0xC0, 0x60, 0x03, 0xF0, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x20, 0x00, 0x10, 0x00, 0x80,
  0x00, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x38, 0x04, 0x00, 0x03, 0x00, 0x60, 0x03, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x38, 0x00, 0x80, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x03, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x0F, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x01,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0xC0, 0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x08, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x60, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x04, 0x38, 0x00, 0x00, 0x0C, 0x68, 0x00, 0x00, 0x0C, 0xCC, 0x00,
  0x00, 0x09, 0x84, 0x00, 0x00, 0x0B, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x20, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x01, 0xA0, 0x1A, 0x00, 0x00, 0x00,
  0xD0, 0x09, 0x00, 0x00, 0x00, 0xD8, 0x04, 0x80, 0x00, 0x00, 0x4C, 0x06,
  0x60, 0x00, 0x00, 0x64, 0x03, 0x30, 0x00, 0x00, 0x62, 0x01, 0x18, 0x00,
  0x00, 0x31, 0x00, 0x84, 0x00, 0x00, 0x31, 0x80, 0x42, 0x00, 0x00, 0x10,
  0xC0, 0x61, 0x00, 0x00, 0x18, 0x40, 0x30, 0xC0, 0x00, 0x18, 0x20, 0x10,
  0x60, 0x00, 0x0C, 0x30, 0x08, 0x10, 0x00, 0x0C, 0x18, 0x04, 0x08, 0x00,
  0x04, 0x0C, 0x06, 0x04, 0x00, 0x06, 0x04, 0x03, 0x02, 0x00, 0x02, 0x02,
  0x01, 0x01, 0x80, 0x03, 0x03, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x01, 0x00, 0x80, 0x60, 0x10, 0x01, 0x80, 0x40, 0x30, 0x08, 0x00,
  0x80, 0x20, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x08, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x01, 0x80, 0x40, 0x08, 0x06, 0x00, 0x40, 0x60, 0x04, 0x02, 0x00,
  0x20, 0x20, 0x02, 0x01, 0x00, 0x10, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x10, 0x00, 0x80, 0x60, 0x01, 0x18, 0x00, 0x40,
  0x20, 0x00, 0x88, 0x00, 0x60, 0x10, 0x00, 0x4C, 0x00, 0x30, 0x18, 0x00,
  0x2C, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x00, 0x08, 0x06, 0x00, 0x0E, 0x00,
  0x04, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x08, 0x07, 0x80, 0x00, 0x02,
  0x01, 0x20, 0x00, 0x01, 0x80, 0x4C, 0x00, 0x00, 0x60, 0x13, 0x00, 0x00,
  0x10, 0x0C, 0x40, 0x00, 0x04, 0x03, 0x18, 0x00, 0x03, 0x00, 0x82, 0x00,
  0x00, 0xC0, 0x20, 0xC0, 0x00, 0x30, 0x08, 0x10, 0x00, 0x08, 0x06, 0x06,
  0x00, 0x02, 0x01, 0x81, 0x80, 0x01, 0x80, 0x40, 0x20, 0x00, 0x60, 0x10,
  0x0C, 0x00, 0x10, 0x04, 0x01, 0x00, 0x04, 0x03, 0x00, 0x60, 0x01, 0x00,
  0xC0, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x08,
  0x06, 0x00, 0x10, 0x02, 0x01, 0x80, 0x06, 0x00, 0x80, 0x60, 0x00, 0x80,
  0x60, 0x10, 0x00, 0x30, 0x18, 0x04, 0x00, 0x04, 0x04, 0x03, 0x00, 0x01,
  0x81, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x20, 0x00, 0x08, 0x30, 0x08, 0x00,
  0x03, 0x0C, 0x02, 0x00, 0x00, 0x42, 0x01, 0x80, 0x00, 0x18, 0x80, 0x60,
  0x00, 0x02, 0x60, 0x10, 0x00, 0x00, 0xD8, 0x04, 0x00, 0x00, 0x34, 0x03,
  0x00, 0x00, 0x05, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0xE0, 0x08,
  0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x08, 0x00, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x03, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x20, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x06, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x18, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0x10, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x3C,
  0x00, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x20, 0x02,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x10, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x04, 0x80, 0x00, 0x34,
  0x00, 0x03, 0x20, 0x00, 0x09, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00,
  0x63, 0x00, 0x01, 0x10, 0x00, 0x10, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x30,
  0x00, 0x21, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x83, 0x00, 0x04,
  0x10, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80,
  0x0C, 0x04, 0x00, 0x60, 0x60, 0x02, 0x01, 0x00, 0x10, 0x18, 0x01, 0x80,
  0x40, 0x0C, 0x06, 0x00, 0x40, 0x10, 0x02, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02,
  0x01, 0x80, 0x10, 0x08, 0x00, 0x80, 0x40, 0x04, 0x06, 0x00, 0x20, 0x30,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00, 0x10,
  0x20, 0x00, 0x81, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4,
  0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x64, 0x00, 0x03, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80,
  0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x18, 0x00, 0x40, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x32, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x18, 0x20, 0x00, 0x18, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x02, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x10, 0x06, 0x00, 0x08, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xF8, 0xC1, 0x06, 0x08, 0x30, 0x60, 0x83, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xF0, 0x40, 0x38, 0x0C, 0x20, 0x70, 0x03, 0x30, 0x60, 0x00, 0x90,
  0x20, 0x00, 0x68, 0x30, 0x00, 0x14, 0x30, 0x00, 0x0E, 0x10, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x0C, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x84, 0x00, 0x01, 0xC2, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xA0, 0xC0,
  0x00, 0xD0, 0x20, 0x00, 0xC8, 0x18, 0x00, 0xCC, 0x06, 0x00, 0xC4, 0x01,
  0x81, 0xC2, 0x00, 0x7F, 0x81, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x81, 0xFF, 0x00, 0x21, 0xC0, 0x60, 0x18, 0xC0,
  0x0C, 0x06, 0x40, 0x01, 0x81, 0x20, 0x00, 0x20, 0x50, 0x00, 0x0C, 0x1C,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x21, 0x40, 0x00, 0x18, 0x50, 0x00, 0x0C, 0x16, 0x00, 0x02,
  0x0C, 0x80, 0x03, 0x83, 0x30, 0x01, 0x80, 0x87, 0x01, 0xC0, 0x20, 0x7F,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x0E,
  0x00, 0xC0, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x1F, 0xF0, 0x20, 0x03, 0x80,
  0xE3, 0x00, 0x70, 0x01, 0x98, 0x06, 0x00, 0x04, 0x80, 0x20, 0x00, 0x34,
  0x03, 0x00, 0x00, 0xA0, 0x30, 0x00, 0x05, 0x01, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xE0, 0x20, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x50, 0x0C, 0x00, 0x06, 0x80, 0x20, 0x00, 0x64,
  0x01, 0x80, 0x06, 0x20, 0x06, 0x00, 0x63, 0x00, 0x38, 0x0C, 0x10, 0x00,
  0x7F, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0x03, 0x80, 0x70, 0x02, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0xC0, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0x88, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x0F, 0x04, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x08,
  0x0E, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x38, 0x0E, 0x10, 0x0E,
  0x00, 0x33, 0x01, 0x80, 0x01, 0x20, 0x10, 0x00, 0x1A, 0x03, 0x00, 0x00,
  0xA0, 0x60, 0x00, 0x0A, 0x04, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x70, 0x20, 0x00, 0x07, 0x03, 0x00, 0x00, 0xA0,
  0x30, 0x00, 0x1A, 0x01, 0x00, 0x03, 0x20, 0x18, 0x00, 0x66, 0x00, 0xC0,
  0x0C, 0x60, 0x0E, 0x03, 0x04, 0x00, 0x3F, 0xE0, 0x40, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x10, 0x3F, 0xE0, 0x08, 0x70, 0x18, 0x0C, 0x60, 0x06, 0x06, 0x60, 0x01,
  0x82, 0x40, 0x00, 0xC1, 0x60, 0x00, 0x20, 0xE0, 0x00, 0x10, 0xE0, 0x00,
  0x08, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x10, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x08, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x03, 0x02, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x10, 0x04, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x10, 0xE0, 0x00, 0x11, 0xB0, 0x00, 0x13, 0x10,
  0x00, 0x36, 0x18, 0x00, 0x28, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x04,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01,
  0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x40, 0x80, 0x00, 0x60, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x01, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x8E, 0x07, 0x03, 0x81,
  0x80, 0xCC, 0x01, 0x83, 0x00, 0x60, 0x4C, 0x00, 0x63, 0x00, 0x18, 0x24,
  0x00, 0x33, 0x00, 0x0C, 0x14, 0x00, 0x0B, 0x00, 0x06, 0x0E, 0x00, 0x05,
  0x00, 0x01, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00,
  0xC3, 0x00, 0x00, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x20, 0x00, 0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x84, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x03,
  0xFE, 0x00, 0x87, 0x01, 0x80, 0xC6, 0x00, 0x60, 0x46, 0x00, 0x18, 0x24,
  0x00, 0x0C, 0x16, 0x00, 0x02, 0x0E, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x84, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x02, 0x07,
  0xFC, 0x00, 0x10, 0xE0, 0x30, 0x01, 0x8C, 0x00, 0xC0, 0x08, 0xC0, 0x03,
  0x00, 0x48, 0x00, 0x08, 0x02, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x01, 0x01, 0x40, 0x00, 0x18, 0x0A, 0x00, 0x01,
  0x80, 0x58, 0x00, 0x08, 0x06, 0x40, 0x01, 0xC0, 0x33, 0x00, 0x18, 0x01,
  0x8E, 0x03, 0x80, 0x08, 0x1F, 0xF0, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF8,
  0x10, 0x0E, 0x03, 0x84, 0x0E, 0x00, 0x33, 0x06, 0x00, 0x04, 0x81, 0x00,
  0x01, 0xA0, 0xC0, 0x00, 0x28, 0x60, 0x00, 0x0A, 0x10, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03,
  0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x07, 0x08, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xA0,
  0xC0, 0x00, 0x68, 0x10, 0x00, 0x32, 0x06, 0x00, 0x19, 0x80, 0xC0, 0x0C,
  0x60, 0x18, 0x0C, 0x10, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x02, 0x0F, 0xF0, 0x21, 0xC0, 0x06, 0x30, 0x00, 0x44, 0x00,
  0x04, 0x80, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x0E, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x61, 0x00, 0x06, 0x0F, 0x00, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x7F, 0xFF, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x81, 0x03, 0xFC, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x06,
  0x10, 0x00, 0x03, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x02, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x01, 0xC2, 0x00, 0x01, 0xE1, 0x80,
  0x00, 0xA0, 0xC0, 0x00, 0x90, 0x20, 0x01, 0x88, 0x18, 0x01, 0x8C, 0x06,
  0x03, 0x86, 0x01, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x31, 0x00,
  0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x01, 0x03,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x88, 0x00,
  0x06, 0x60, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x06, 0xC0, 0x03,
  0x40, 0x01, 0x30, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x23, 0x00,
  0x11, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x04, 0x10, 0x02, 0x18, 0x03, 0x04,
  0x01, 0x86, 0x00, 0x81, 0x00, 0x40, 0x80, 0x60, 0x40, 0x30, 0x20, 0x18,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x20, 0x0C, 0x10, 0x04, 0x18, 0x03,
  0x0C, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x62, 0x00, 0x11, 0x80, 0x19, 0x80,
  0x04, 0x40, 0x06, 0x40, 0x01, 0x30, 0x01, 0xB0, 0x00, 0x48, 0x00, 0x68,
  0x00, 0x16, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10,
  0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x02, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x00, 0x40, 0x02, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x01, 0x00, 0x10, 0x00, 0x02, 0x00, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x58, 0x07, 0x00, 0x70, 0x00, 0xF0,
  0xE8, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 39, 12, 2, -39 },
  { 50, 12, 14, 17, 6, -39 },
  { 71, 32, 39, 34, 2, -39 },
  { 227, 25, 45, 30, 3, -42 },
  { 368, 34, 41, 42, 5, -40 },
  { 543, 32, 41, 38, 3, -40 },
  { 707, 4, 14, 9, 6, -39 },
  { 714, 15, 48, 13, 2, -39 },
  { 804, 15, 48, 13, -3, -39 },
  { 894, 22, 23, 29, 7, -42 },
  { 958, 25, 25, 31, 4, -32 },
  { 1037, 7, 13, 10, -2, -6 },
  { 1049, 13, 2, 17, 2, -16 },
  { 1053, 3, 3, 12, 2, -3 },
  { 1055, 24, 39, 17, -2, -39 },
  { 1172, 25, 41, 30, 4, -40 },
  { 1301, 13, 39, 30, 9, -39 },
  { 1365, 27, 40, 30, 1, -40 },
  { 1500, 28, 41, 30, 1, -40 },
  { 1644, 28, 39, 30, 1, -39 },
  { 1781, 28, 40, 30, 2, -39 },
  { 1921, 26, 41, 30, 4, -40 },
  { 2055, 25, 39, 30, 6, -39 },
  { 2177, 26, 41, 30, 3, -40 },
  { 2311, 26, 41, 30, 3, -40 },
  { 2445, 8, 29, 12, 2, -29 },
  { 2474, 12, 36, 12, -2, -29 },
  { 2528, 25, 24, 31, 4, -32 },
  { 2603, 25, 13, 31, 4, -26 },
  { 2644, 25, 24, 31, 4, -32 },
  { 2719, 19, 40, 22, 4, -40 },
  { 2814, 41, 44, 46, 3, -39 },
  { 3040, 30, 39, 30, -3, -39 },
  { 3187, 29, 39, 33, 3, -39 },
  { 3329, 30, 41, 33, 5, -40 },
  { 3483, 32, 39, 37, 3, -39 },
  { 3639, 28, 39, 29, 3, -39 },
  { 3776, 28, 39, 27, 3, -39 },
  { 3913, 32, 41, 38, 5, -40 },
  { 4077, 34, 39, 37, 3, -39 },
  { 4243, 17, 39, 15, 0, -39 },
  { 4326, 22, 49, 13, -9, -39 },
  { 4461, 32, 39, 30, 3, -39 },
  { 4617, 20, 39, 27, 3, -39 },
  { 4715, 41, 39, 44, 3, -39 },
  { 4915, 34, 39, 37, 3, -39 },
  { 5081, 32, 41, 39, 5, -40 },
  { 5245, 28, 39, 31, 3, -39 },
  { 5382, 32, 49, 39, 5, -40 },
  { 5578, 28, 39, 31, 3, -39 },
  { 5715, 27, 41, 27, 1, -40 },
  { 5854, 27, 39, 27, 5, -39 },
  { 5986, 33, 40, 38, 5, -39 },
  { 6151, 28, 39, 29, 6, -39 },
  { 6288, 42, 39, 45, 7, -39 },
  { 6493, 34, 39, 27, -3, -39 },
  { 6659, 27, 39, 27, 5, -39 },
  { 6791, 31, 39, 30, 0, -39 },
  { 6943, 21, 48, 17, -1, -39 },
  { 7069, 9, 39, 17, 5, -39 },
  { 7113, 21, 48, 17, -4, -39 },
  { 7239, 25, 25, 30, 3, -40 },
  { 7318, 21, 1, 20, -5, 6 },
  { 7321, 6, 9, 12, 8, -42 },
  { 7328, 25, 31, 30, 3, -30 },
  { 7425, 26, 43, 31, 2, -42 },
  { 7565, 22, 31, 25, 3, -30 },
  { 7651, 29, 43, 31, 3, -42 },
  { 7807, 22, 31, 27, 3, -30 },
  { 7893, 30, 55, 15, -7, -42 },
  { 8100, 28, 43, 31, 1, -30 },
  { 8251, 25, 42, 30, 2, -42 },
  { 8383, 10, 40, 11, 2, -40 },
  { 8433, 20, 53, 11, -8, -40 },
  { 8566, 24, 42, 24, 2, -42 },
  { 8692, 10, 42, 11, 2, -42 },
  { 8745, 41, 30, 46, 2, -30 },
  { 8899, 25, 30, 30, 2, -30 },
  { 8993, 25, 31, 31, 3, -30 },
  { 9090, 29, 43, 31, -1, -30 },
  { 9246, 26, 43, 31, 3, -30 },
  { 9386, 20, 29, 20, 2, -29 },
  { 9459, 21, 31, 23, 1, -30 },
  { 9541, 15, 37, 17, 3, -36 },
  { 9611, 25, 30, 30, 3, -29 },
  { 9705, 22, 29, 23, 3, -29 },
  { 9785, 34, 29, 36, 3, -29 },
  { 9909, 28, 29, 25, -2, -29 },
  { 10011, 31, 42, 23, -6, -29 },
  { 10174, 25, 29, 24, -1, -29 },
  { 10265, 20, 48, 18, 1, -39 },
  { 10385, 1, 55, 29, 16, -42 },
  { 10392, 20, 48, 18, -3, -39 },
  { 10512, 25, 5, 31, 4, -22 },
};

const GFXfont NotoSans_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ThinItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_THINITALIC55PT7B_H_
