#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0xF3, 0xF9, 0xF9, 0xFC,
  0xEE, 0x77, 0x3B, 0x18, 0x01, 0xCE, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x9C,
  0x03, 0x1C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x30, 0x0E, 0x70,
  0x0E, 0x70, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x1C, 0xE0, 0x18, 0xC0,
  0x39, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x01,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xE8, 0x87, 0x60, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x37, 0xA0, 0x9C, 0x62, 0xF1,
  0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x01, 0xF0, 0x1C, 0x3F, 0x83, 0x83, 0xB8, 0x70, 0x73, 0x86, 0x07,
  0x38, 0xE0, 0x73, 0x9C, 0x07, 0x3B, 0x80, 0xE7, 0xB9, 0xC7, 0x77, 0x7E,
  0x7E, 0xEF, 0xF7, 0xEE, 0xE7, 0x19, 0xCE, 0x70, 0x39, 0xC7, 0x03, 0x9C,
  0xE0, 0x71, 0xCE, 0x0E, 0x1C, 0xE0, 0xE1, 0xDC, 0x1C, 0x1F, 0xC3, 0x80,
  0xF8, 0x00, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x8F, 0x7F,
  0x8E, 0xFB, 0xDE, 0xF3, 0xFC, 0xE1, 0xFC, 0xE0, 0xF8, 0xF1, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0x3E, 0x7F, 0xEE, 0xEE, 0xC0, 0x07, 0x83, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78,
  0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x02, 0x00, 0x78, 0x07, 0x06, 0x70, 0x7F,
  0x0F, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0x07, 0xB8, 0x33, 0x81, 0x1C, 0x01,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0xE7, 0x9C, 0xF3, 0x8E, 0x00, 0x7F, 0x7F, 0xFE, 0x77, 0xFF, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0x07, 0xFC, 0x3F, 0xE3, 0xC7, 0x1E, 0x3D, 0xE1, 0xEF, 0x0F, 0xF0, 0x77,
  0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xF3, 0x87, 0x9E, 0x3C, 0xF3,
  0xC7, 0xFE, 0x1F, 0xE0, 0x7C, 0x00, 0x03, 0xC1, 0xF1, 0xFC, 0xFF, 0xFF,
  0x9C, 0xE2, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0xE3, 0xE0, 0x83, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xC0, 0x3F, 0xC1,
  0xFF, 0x83, 0xFF, 0x08, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x01, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x81, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x03, 0xF8, 0x1D, 0xC0, 0x77, 0x03, 0xBC, 0x1C, 0xF0, 0xE3,
  0xC7, 0x8E, 0x1C, 0x78, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x30, 0x78, 0xFF, 0xE3, 0xFF,
  0x07, 0xF0, 0x00, 0x00, 0x30, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x30, 0x7F, 0xE3, 0xFF, 0x3F, 0xFD, 0xF1, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xDE, 0x3C, 0xF1, 0xE3, 0xFE, 0x1F, 0xF0, 0x7E, 0x00,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x90, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xC0,
  0x1F, 0xC0, 0xFF, 0x87, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9E,
  0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xF8, 0x78, 0xF1, 0xE1, 0xC7, 0x07,
  0x3C, 0x1C, 0x78, 0xF1, 0xFF, 0xC7, 0xFE, 0x07, 0xE0, 0x03, 0x80, 0xFE,
  0x1F, 0xF3, 0xFF, 0x78, 0xF7, 0x87, 0x78, 0x77, 0x0F, 0x70, 0xF7, 0x9F,
  0x7F, 0xF7, 0xFF, 0x3E, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x8F, 0xF8,
  0xFF, 0x0F, 0xC0, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0x9F, 0x3C, 0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x7E, 0x1F, 0xC1, 0xF8, 0x0F, 0x00, 0x60,
  0x00, 0x04, 0x1F, 0xEF, 0xFD, 0xFF, 0x43, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0x83, 0xC1, 0xE0, 0x0E,
  0x1C, 0x00, 0x63, 0x8F, 0xE7, 0x71, 0xFE, 0x77, 0x3C, 0xE7, 0x63, 0x8C,
  0x7E, 0x71, 0xC7, 0xE7, 0x1C, 0x6E, 0x71, 0xCE, 0xE7, 0x38, 0xEE, 0x73,
  0x9C, 0xE7, 0xFF, 0x8E, 0x3C, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x0C, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xEE, 0x01, 0xCE, 0x03, 0xCE, 0x03, 0xCE, 0x07,
  0x8E, 0x07, 0x8E, 0x0F, 0x0E, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1C,
  0x0E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E,
  0x1F, 0x3C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x60, 0x07,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x47, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x20, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x38, 0x3E, 0x78, 0x7C, 0x79, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0xFE, 0x78, 0xFE, 0xF8, 0xFE, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF8, 0x3C, 0x78, 0x3C, 0x7C, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0x0F, 0xF0, 0xFF, 0x07,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x7F,
  0x83, 0xF8, 0x1F, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xC0, 0xF1,
  0xE0, 0x38, 0xF8, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7F, 0x80,
  0x1D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0E,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07,
  0xC0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x7F,
  0xEF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x3F, 0x87,
  0x71, 0xDE, 0x1D, 0xC7, 0x70, 0xF7, 0x3D, 0xC3, 0xDC, 0xEF, 0x0E, 0x77,
  0xBC, 0x39, 0xDC, 0xF0, 0xE7, 0xF3, 0x87, 0x9F, 0x8E, 0x1E, 0x7E, 0x78,
  0x71, 0xF1, 0xE1, 0xC7, 0xC7, 0x8F, 0x1E, 0x1C, 0x00, 0x0F, 0x81, 0xE1,
  0xF0, 0x3C, 0x3F, 0x07, 0x07, 0xE0, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87,
  0x78, 0xE0, 0xEF, 0x1C, 0x1C, 0xE3, 0x87, 0x9E, 0xF0, 0xF3, 0xDE, 0x1E,
  0x7B, 0x83, 0x87, 0x70, 0x70, 0xFE, 0x1E, 0x1F, 0xC3, 0xC1, 0xF8, 0x70,
  0x3E, 0x0E, 0x07, 0xC3, 0xC0, 0xF8, 0x00, 0x00, 0x40, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x3E, 0x78, 0x3C, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x78, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x7E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x40, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0x78, 0x3C, 0x7C, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x79, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0x1E, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0x03,
  0xCE, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF3, 0xC1,
  0xF0, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1E, 0x08, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x20, 0x78, 0xE3, 0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3D,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x1E, 0x3C, 0x3C, 0x78,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC0,
  0xF3, 0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x71, 0xE0,
  0xE3, 0x81, 0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xE0, 0x1D, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x38, 0x1F, 0xE0, 0xF0,
  0x7B, 0xC1, 0xE0, 0xF7, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3F, 0x0E,
  0x3C, 0x7E, 0x3C, 0x38, 0xFC, 0x70, 0x73, 0xB9, 0xE0, 0xE7, 0x73, 0xC1,
  0xDC, 0xEF, 0x03, 0xB9, 0xDE, 0x07, 0xF3, 0xB8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0xF8, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x3D, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x83, 0xC3, 0xE0, 0x78, 0x00,
  0xF0, 0x3D, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0x79, 0xE0, 0xE7, 0x83, 0xBC,
  0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x07, 0xE0, 0xFC, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xFC, 0x3F, 0x80, 0xE3, 0x8E, 0x3C, 0x71,
  0xC7, 0x1C, 0x71, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF1, 0xC0, 0x07,
  0xE0, 0xFC, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0xFC, 0x3F, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x3C, 0x71, 0xC1, 0xDC,
  0x0F, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xF7, 0x9E, 0x71, 0x80, 0x0F, 0x3C,
  0x7E, 0xE3, 0xFF, 0x8F, 0x3E, 0x78, 0x79, 0xE1, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xFF, 0xE1, 0xFF, 0x87, 0xDE,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xEF, 0x07, 0xFE, 0x1F, 0xF8, 0x79, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xE0, 0xF3, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xC7, 0xFF, 0x1F, 0xF8,
  0xE7, 0xC0, 0x07, 0xC3, 0xFC, 0xFF, 0x9E, 0x27, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x4F, 0xF8, 0xFF, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xCE,
  0x0F, 0xDC, 0x3F, 0xF8, 0x79, 0xF1, 0xE1, 0xE3, 0xC3, 0x8F, 0x07, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x83, 0xF7,
  0x07, 0xDC, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xC7, 0x78, 0xF7, 0x0F,
  0xFF, 0xEF, 0xFC, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x04, 0xFF, 0xC7, 0xFC,
  0x3F, 0x80, 0x00, 0x1C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xA0, 0x1E, 0x00,
  0x3C, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0x9E, 0x1F, 0xB8, 0x7F, 0xF0, 0xF3,
  0xE3, 0xC3, 0xC7, 0x87, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1,
  0xE3, 0xC3, 0xCF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x00, 0x70, 0x01,
  0xE1, 0x03, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xEF, 0x07, 0xFE, 0x1F,
  0xFC, 0x7C, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0x87, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF0, 0x02, 0x0F,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x40, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x87, 0x8F, 0x1E,
  0x1E, 0x78, 0x39, 0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0xC3, 0x87, 0x8F, 0x0F,
  0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x1C, 0xF0,
  0xF0, 0xEF, 0xDF, 0xC7, 0xFE, 0xFE, 0x3E, 0x7C, 0xF3, 0xE3, 0xC7, 0x9E,
  0x1E, 0x3C, 0xF0, 0xE1, 0xE7, 0x8F, 0x0E, 0x38, 0x78, 0x73, 0xC3, 0xC7,
  0x9E, 0x1C, 0x3C, 0xF1, 0xE1, 0xE7, 0x0F, 0x0E, 0x38, 0x78, 0xF3, 0xC3,
  0xC7, 0x80, 0x1C, 0xF0, 0x77, 0xE1, 0xFF, 0xC7, 0xCF, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC3, 0x8F, 0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x78,
  0xF1, 0xC3, 0xCF, 0x0F, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0xCF, 0x78,
  0x77, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xFF,
  0xE7, 0xFC, 0x3F, 0x00, 0x0E, 0x78, 0x1D, 0xF8, 0x3F, 0xF0, 0x79, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x1C, 0x3C, 0x78, 0x78, 0xF0,
  0xF1, 0xE3, 0xC3, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x3C, 0x7E, 0xE3,
  0xFF, 0x8F, 0x3E, 0x78, 0x79, 0xE1, 0xCF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xFF, 0xE1, 0xFF, 0x87, 0xDC, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0xF1, 0xDE,
  0x1F, 0xE1, 0xFE, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0xC3, 0xFC, 0xFF,
  0x9E, 0x23, 0xC0, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x41,
  0xEF, 0xFD, 0xFF, 0x3F, 0xC0, 0x0E, 0x03, 0x81, 0xE0, 0xFF, 0x7F, 0xBF,
  0xE3, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0xF8, 0x7E, 0x1F, 0x80, 0x3C, 0x3C, 0xF0, 0xE3, 0x87, 0x8E, 0x1E, 0x78,
  0x79, 0xE1, 0xC7, 0x87, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C,
  0x78, 0xFF, 0xE1, 0xFB, 0x87, 0xCE, 0x00, 0xF0, 0x7B, 0x83, 0xDC, 0x3C,
  0xE1, 0xE7, 0x1E, 0x38, 0xF1, 0xCF, 0x0E, 0x78, 0x77, 0x83, 0xBC, 0x1D,
  0xC0, 0xFE, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xE1, 0xE1, 0xFC, 0x3C,
  0x3B, 0x8F, 0x8F, 0x71, 0xF1, 0xCE, 0x7E, 0x79, 0xCF, 0xCF, 0x39, 0xB9,
  0xC7, 0x77, 0x78, 0xEE, 0xEE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x3C, 0x7C,
  0x3C, 0xF0, 0x7B, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xC0, 0x7F, 0x81, 0xEF, 0x03, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C,
  0x00, 0x1E, 0x0F, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1E, 0x0E, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xFE, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xE0, 0x7C, 0x1F,
  0x83, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x07, 0xC1, 0xF0, 0x78,
  0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x03, 0xC1, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x0F, 0x01, 0xC0, 0x7C, 0x07, 0x0F, 0xC7, 0xC1, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x38, 0x0F, 0xF8, 0xFF,
  0xFF, 0x8F, 0xE8, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 12, 3, -19 },
  { 28, 16, 19, 16, 0, -19 },
  { 66, 14, 23, 14, 0, -21 },
  { 107, 20, 20, 22, 1, -20 },
  { 157, 16, 20, 17, 1, -20 },
  { 197, 4, 7, 7, 3, -19 },
  { 201, 9, 23, 8, 1, -19 },
  { 227, 10, 24, 9, -2, -20 },
  { 257, 12, 13, 13, 2, -21 },
  { 277, 13, 13, 14, 1, -16 },
  { 299, 6, 7, 7, -1, -3 },
  { 305, 8, 3, 8, 0, -9 },
  { 308, 5, 4, 7, 0, -4 },
  { 311, 14, 19, 11, -1, -19 },
  { 345, 13, 20, 14, 1, -20 },
  { 378, 10, 19, 14, 2, -19 },
  { 402, 15, 20, 14, -1, -20 },
  { 440, 14, 20, 14, 0, -20 },
  { 475, 14, 19, 14, 0, -19 },
  { 509, 14, 19, 14, 0, -19 },
  { 543, 13, 20, 14, 1, -20 },
  { 576, 14, 19, 14, 1, -19 },
  { 610, 14, 20, 14, 0, -20 },
  { 645, 12, 20, 14, 1, -20 },
  { 675, 7, 15, 7, 0, -15 },
  { 689, 8, 19, 7, -1, -15 },
  { 708, 13, 14, 14, 1, -17 },
  { 731, 13, 9, 14, 1, -14 },
  { 746, 13, 14, 14, 1, -17 },
  { 769, 10, 20, 11, 2, -20 },
  { 794, 20, 21, 21, 1, -19 },
  { 847, 16, 19, 15, -2, -19 },
  { 885, 15, 19, 15, 0, -19 },
  { 921, 15, 20, 15, 1, -20 },
  { 959, 16, 19, 17, 0, -19 },
  { 997, 14, 19, 13, 0, -19 },
  { 1031, 14, 19, 13, 0, -19 },
  { 1065, 16, 20, 17, 1, -20 },
  { 1105, 18, 19, 17, 0, -19 },
  { 1148, 12, 19, 10, -1, -19 },
  { 1177, 13, 25, 8, -4, -19 },
  { 1218, 18, 19, 15, 0, -19 },
  { 1261, 11, 19, 13, 0, -19 },
  { 1288, 22, 19, 22, 0, -19 },
  { 1341, 19, 19, 19, 0, -19 },
  { 1387, 16, 20, 18, 1, -20 },
  { 1427, 15, 19, 15, 0, -19 },
  { 1463, 16, 25, 18, 1, -20 },
  { 1513, 15, 19, 15, 0, -19 },
  { 1549, 14, 20, 13, 0, -20 },
  { 1584, 13, 19, 13, 2, -19 },
  { 1615, 15, 19, 17, 2, -19 },
  { 1651, 15, 19, 15, 2, -19 },
  { 1687, 23, 19, 22, 2, -19 },
  { 1742, 19, 19, 15, -2, -19 },
  { 1788, 14, 19, 14, 2, -19 },
  { 1822, 16, 19, 13, -1, -19 },
  { 1860, 11, 23, 8, -1, -19 },
  { 1892, 6, 19, 11, 3, -19 },
  { 1907, 11, 23, 8, -2, -19 },
  { 1939, 13, 12, 14, 0, -19 },
  { 1959, 10, 2, 10, -2, 2 },
  { 1962, 5, 5, 8, 4, -21 },
  { 1966, 14, 15, 15, 1, -15 },
  { 1993, 14, 21, 15, 0, -21 },
  { 2030, 11, 15, 12, 1, -15 },
  { 2051, 15, 21, 15, 1, -21 },
  { 2091, 12, 15, 14, 1, -15 },
  { 2114, 15, 27, 9, -3, -21 },
  { 2165, 15, 21, 15, 0, -15 },
  { 2205, 14, 21, 15, 0, -21 },
  { 2242, 8, 21, 7, 0, -21 },
  { 2263, 11, 27, 7, -3, -21 },
  { 2301, 15, 21, 14, 0, -21 },
  { 2341, 8, 21, 7, 0, -21 },
  { 2362, 21, 15, 22, 0, -15 },
  { 2402, 14, 15, 15, 0, -15 },
  { 2429, 12, 15, 14, 1, -15 },
  { 2452, 15, 21, 15, -1, -15 },
  { 2492, 14, 21, 15, 1, -15 },
  { 2529, 12, 15, 10, 0, -15 },
  { 2552, 11, 15, 12, 0, -15 },
  { 2573, 10, 18, 10, 1, -18 },
  { 2596, 14, 15, 15, 1, -15 },
  { 2623, 13, 15, 13, 1, -15 },
  { 2648, 19, 15, 20, 2, -15 },
  { 2684, 15, 15, 13, -1, -15 },
  { 2713, 16, 21, 13, -2, -15 },
  { 2755, 13, 15, 11, -1, -15 },
  { 2780, 11, 23, 9, 0, -19 },
  { 2812, 3, 27, 13, 5, -21 },
  { 2823, 10, 23, 9, -1, -19 },
  { 2852, 13, 5, 14, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC27PT7B_H_
