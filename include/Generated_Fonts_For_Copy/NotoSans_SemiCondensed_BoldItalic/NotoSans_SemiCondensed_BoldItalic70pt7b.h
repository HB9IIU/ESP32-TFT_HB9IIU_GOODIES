#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F,
  0xC7, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xE7, 0x83, 0xC0, 0x1F,
  0xF8, 0xF0, 0x10, 0x03, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x00,
  0x0F, 0xF8, 0xF0, 0x00, 0x01, 0xFF, 0x9E, 0x00, 0x00, 0x3F, 0xF3, 0xC0,
  0x00, 0x07, 0xFF, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3D, 0xFF, 0xC0, 0x00, 0x07,
  0x9F, 0xF8, 0x00, 0x00, 0xF3, 0xFF, 0x00, 0x00, 0x1E, 0x3F, 0xE0, 0x00,
  0x07, 0x87, 0xFC, 0x10, 0x00, 0xF0, 0xFF, 0x83, 0x00, 0x1E, 0x3F, 0xF0,
  0x7C, 0x03, 0xCF, 0xFE, 0x0F, 0xE0, 0xF3, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xCF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x83, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x7F,
  0x01, 0xE0, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F,
  0xE3, 0xFF, 0xE3, 0xFC, 0x7F, 0xC7, 0xF1, 0xFF, 0xFC, 0xFF, 0x1F, 0xE3,
  0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0x1F, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0x8F, 0xF9, 0xFF, 0x3F, 0xFF,
  0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xFF, 0x87, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF,
  0xC3, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF3,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x0C, 0x01, 0xFC, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xFC, 0x7F, 0x00, 0x1F, 0xFD, 0xF8, 0x00, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0x00, 0x3F, 0xF1, 0xFE, 0x01, 0xFF, 0xC7,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xC0, 0xFF,
  0x80, 0x0E, 0x03, 0xFE, 0x00, 0x10, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0x81, 0xFE,
  0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE,
  0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFD, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFE, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0x87,
  0xFE, 0x03, 0x81, 0xFF, 0x80, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x01, 0xC0, 0x01,
  0xFF, 0x80, 0x04, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xE0, 0x3F, 0xFC, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x08, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x80, 0x00, 0x0F, 0xFE, 0x18, 0x00, 0x03, 0xFF,
  0x83, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x40, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x04, 0x00, 0x01, 0xFF,
  0xC0, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0xF8, 0x07,
  0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x20, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xE0,
  0xF8, 0x07, 0xFE, 0x0E, 0x00, 0x3F, 0xF0, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x81,
  0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x7F,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFC, 0x7F, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0xE0, 0xFE,
  0x07, 0xF3, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0xFF,
  0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFD, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x0F, 0xE7,
  0xF0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x9F, 0xFE,
  0x7F, 0xC1, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xFD,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x00,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFE,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x0F,
  0xFF, 0x00, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x04,
  0x00, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x78, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x04, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x81, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00,
  0x1F, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F,
  0xDF, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF7, 0xFC, 0x00,
  0x7F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x3F,
  0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xE0,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF,
  0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xCF, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0,
  0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0x00, 0x1F, 0xFC, 0x00, 0x10, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x04, 0x00, 0x01, 0xFF, 0xC0,
  0x60, 0x00, 0x1F, 0xF8, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x0F, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0xC7,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xEF,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x3F, 0x80, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xCF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE3,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFE, 0x3F, 0x83, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x80, 0x07, 0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x3F, 0x87, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x0F, 0xE3, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0xC0, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0,
  0x3F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xFC, 0x00, 0x07,
  0xFB, 0xFC, 0x03, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x07,
  0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFB, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xCF,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xF8, 0x03, 0xFF,
  0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xFE, 0x00,
  0x3F, 0xE7, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x1F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFC, 0x03,
  0xFC, 0x7F, 0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xC3, 0xE0, 0x1F, 0xFC, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x04, 0x07, 0xFF,
  0x00, 0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x3F, 0xE0, 0x00,
  0xFF, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x1F,
  0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xE1, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x08, 0x3F, 0xF8, 0x00, 0x60,
  0x7F, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x38, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0x80, 0x07, 0xFF, 0xF1,
  0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xE7,
  0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0x04, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x7E, 0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xFF, 0x00, 0x3F,
  0xE7, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xBF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x80, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFE,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x7F, 0x8F, 0xFF, 0xC1, 0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0xC0,
  0x07, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF,
  0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xFF,
  0x80, 0x00, 0xFF, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x03,
  0xFD, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xEF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xFF, 0xC0, 0x01, 0xFF,
  0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xF9,
  0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFD, 0xFF,
  0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x0F, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x1F, 0xE7,
  0xFF, 0x00, 0xFF, 0x7F, 0xF8, 0x0F, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC2, 0x00, 0x07, 0xFF, 0x0F, 0x00, 0x1F,
  0xFC, 0x3F, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF1, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xF9, 0xFE,
  0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0xE1,
  0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xDF,
  0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF,
  0x03, 0xFF, 0x07, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFD, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0xFE,
  0x7F, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0x9F, 0xC3, 0xFF, 0x01, 0xFE, 0x1F,
  0xE7, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x7F, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x1F, 0xC7, 0xFC, 0x01, 0xFE,
  0x3F, 0x87, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE1, 0xFC, 0xFF, 0x80, 0x1F,
  0xE7, 0xF0, 0x7F, 0x3F, 0xE0, 0x07, 0xFB, 0xFC, 0x1F, 0xDF, 0xF0, 0x01,
  0xFE, 0xFF, 0x07, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0x81, 0xFD, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0C, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0F, 0xFC, 0x00, 0x01,
  0x3F, 0xFF, 0x80, 0x03, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0x7F, 0xFC,
  0x80, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 21, 51, 19, 0, -50 },
  { 135, 25, 18, 30, 7, -50 },
  { 192, 41, 50, 41, 1, -50 },
  { 449, 35, 57, 35, 1, -53 },
  { 699, 50, 52, 56, 4, -51 },
  { 1024, 43, 52, 45, 1, -51 },
  { 1304, 12, 18, 18, 7, -50 },
  { 1331, 25, 61, 22, 2, -50 },
  { 1522, 25, 62, 22, -5, -51 },
  { 1716, 30, 33, 35, 6, -54 },
  { 1840, 32, 34, 37, 3, -42 },
  { 1976, 17, 18, 19, -4, -9 },
  { 2015, 19, 9, 22, 1, -23 },
  { 2037, 12, 12, 19, 0, -11 },
  { 2055, 37, 50, 28, -3, -50 },
  { 2287, 33, 52, 35, 2, -51 },
  { 2502, 26, 50, 36, 6, -50 },
  { 2665, 37, 51, 35, -2, -51 },
  { 2901, 35, 52, 35, 0, -51 },
  { 3129, 36, 50, 36, -1, -50 },
  { 3354, 35, 51, 35, 1, -50 },
  { 3578, 34, 52, 35, 3, -51 },
  { 3799, 37, 50, 35, 2, -50 },
  { 4031, 35, 52, 35, 1, -51 },
  { 4259, 33, 52, 35, 2, -51 },
  { 4474, 18, 40, 19, 0, -39 },
  { 4564, 22, 48, 19, -4, -39 },
  { 4696, 32, 36, 37, 3, -43 },
  { 4840, 32, 21, 37, 3, -35 },
  { 4924, 32, 36, 37, 3, -43 },
  { 5068, 28, 52, 29, 4, -51 },
  { 5250, 51, 56, 55, 3, -50 },
  { 5607, 40, 50, 40, -4, -50 },
  { 5857, 39, 50, 40, 1, -50 },
  { 6101, 39, 52, 38, 3, -51 },
  { 6355, 41, 50, 43, 1, -50 },
  { 6612, 36, 50, 34, 1, -50 },
  { 6837, 36, 50, 33, 1, -50 },
  { 7062, 40, 52, 44, 4, -51 },
  { 7322, 45, 50, 45, 1, -50 },
  { 7604, 31, 50, 25, -2, -50 },
  { 7798, 33, 65, 21, -11, -50 },
  { 8067, 44, 50, 39, 1, -50 },
  { 8342, 27, 50, 33, 1, -50 },
  { 8511, 57, 50, 57, 1, -50 },
  { 8868, 48, 50, 48, 1, -50 },
  { 9168, 42, 52, 46, 3, -51 },
  { 9441, 39, 50, 39, 1, -50 },
  { 9685, 42, 63, 46, 3, -51 },
  { 10016, 37, 50, 39, 1, -50 },
  { 10248, 36, 52, 34, 0, -51 },
  { 10482, 33, 50, 34, 6, -50 },
  { 10689, 41, 51, 44, 4, -50 },
  { 10951, 38, 50, 38, 6, -50 },
  { 11189, 58, 50, 58, 6, -50 },
  { 11552, 48, 50, 38, -4, -50 },
  { 11852, 36, 50, 36, 6, -50 },
  { 12077, 40, 50, 34, -2, -50 },
  { 12327, 29, 61, 22, -2, -50 },
  { 12549, 16, 50, 28, 7, -50 },
  { 12649, 29, 61, 22, -5, -50 },
  { 12871, 34, 31, 36, 1, -50 },
  { 13003, 27, 5, 26, -6, 6 },
  { 13020, 14, 12, 22, 10, -54 },
  { 13041, 36, 40, 38, 2, -39 },
  { 13221, 35, 54, 38, 1, -53 },
  { 13458, 30, 40, 31, 2, -39 },
  { 13608, 39, 54, 38, 2, -53 },
  { 13872, 31, 40, 36, 3, -39 },
  { 14027, 40, 71, 24, -8, -54 },
  { 14382, 38, 56, 38, 0, -39 },
  { 14648, 35, 53, 39, 1, -53 },
  { 14880, 20, 53, 19, 1, -53 },
  { 15013, 30, 70, 19, -9, -53 },
  { 15276, 39, 53, 36, 1, -53 },
  { 15535, 21, 53, 19, 1, -53 },
  { 15675, 54, 39, 57, 1, -39 },
  { 15939, 35, 39, 39, 1, -39 },
  { 16110, 32, 40, 37, 3, -39 },
  { 16270, 39, 56, 38, -3, -39 },
  { 16543, 36, 56, 38, 2, -39 },
  { 16795, 29, 39, 27, 1, -39 },
  { 16937, 30, 40, 30, 0, -39 },
  { 17087, 24, 47, 26, 3, -46 },
  { 17228, 35, 39, 38, 3, -38 },
  { 17399, 33, 38, 33, 4, -38 },
  { 17556, 50, 38, 51, 4, -38 },
  { 17794, 41, 38, 34, -4, -38 },
  { 17989, 42, 55, 33, -5, -38 },
  { 18278, 33, 38, 30, -2, -38 },
  { 18435, 29, 61, 24, 0, -50 },
  { 18657, 8, 69, 34, 13, -53 },
  { 18726, 28, 61, 24, -4, -50 },
  { 18940, 32, 12, 37, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC70PT7B_H_
