#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0x8F, 0xF7, 0xF8, 0xFF, 0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xDE, 0x3C, 0x07, 0xF9,
  0xC0, 0x80, 0x7F, 0x1C, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0x7F, 0x1C, 0x00,
  0x07, 0xFB, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xEF, 0xF8, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0xE7,
  0xF8, 0x00, 0x1E, 0x7F, 0x8C, 0x01, 0xE7, 0xF8, 0xF0, 0x1C, 0x7F, 0x8F,
  0xC1, 0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x07, 0xE0,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x1F, 0xCF, 0xE3, 0xFE, 0x3F, 0x0F, 0xC7, 0xE7, 0xFF, 0x9F, 0xCF,
  0xE7, 0xE7, 0xFF, 0xE7, 0xFF, 0xE7, 0xF3, 0xFF, 0xF3, 0xFF, 0xF3, 0xF3,
  0xFF, 0xFD, 0xFF, 0xF3, 0xF1, 0xF8, 0xFE, 0x7F, 0xE3, 0xF9, 0xFC, 0x7F,
  0x0F, 0xE1, 0xF8, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xE7, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFF, 0x0F, 0xFB, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFE,
  0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0xFE, 0x7F,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0x00, 0xFC, 0x00, 0xC0,
  0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFB, 0xE0, 0x07, 0xF9, 0xF8, 0x07, 0xFC, 0xFE, 0x01, 0xFC, 0x3F,
  0x00, 0x7C, 0x1F, 0xC0, 0x1E, 0x0F, 0xE0, 0x02, 0x07, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0x07, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F,
  0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC,
  0x03, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xF1, 0xFC, 0x03, 0xFE,
  0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFB, 0xF8, 0xFF, 0xBF,
  0xC3, 0xF9, 0xFE, 0x1F, 0x0F, 0xF0, 0x70, 0xFF, 0x02, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7C, 0x03, 0xFC, 0x00, 0x60, 0x07, 0xFC, 0x00, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1E, 0x03,
  0xFF, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0xFF, 0x87, 0x00, 0x0F, 0xFC, 0x3F,
  0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xF9,
  0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x78,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x04,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x80,
  0x01, 0xFF, 0x87, 0x00, 0x1F, 0xF8, 0x3F, 0x83, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xF9,
  0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xDF, 0xFC, 0x03,
  0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF,
  0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x7F, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD,
  0xFE, 0x07, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xF0, 0x01, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0x80,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F,
  0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF1, 0xFF,
  0x8F, 0x01, 0xFF, 0x08, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x3E, 0x0F, 0xE0, 0x3F, 0xFF,
  0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC,
  0x7E, 0x0F, 0xFF, 0xF8, 0x3F, 0x3F, 0x03, 0xF8, 0x7E, 0x0F, 0xCF, 0xC1,
  0xFC, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0x07, 0xE0, 0xFD, 0xF8, 0x3F, 0x01,
  0xF0, 0x3F, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xDF, 0x87, 0xE0, 0x3F, 0x03,
  0xE7, 0xC1, 0xF8, 0x0F, 0xC1, 0xFB, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0xFC,
  0x1F, 0x01, 0xF8, 0x1F, 0xBF, 0x0F, 0xC0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0,
  0x3F, 0x83, 0xF3, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x3F, 0x07, 0xF0,
  0x7E, 0x3F, 0x0F, 0xE3, 0xFE, 0x3F, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0x7F, 0xFB, 0xFF, 0xE0, 0xFC, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F, 0x81,
  0xFE, 0x1F, 0xF0, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x00, 0x10, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0x00, 0xFF, 0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0xFE, 0x01, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x7F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x07, 0xFF,
  0x00, 0x0C, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xCF,
  0xF8, 0x0F, 0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xF1,
  0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x7F, 0xBF, 0x00, 0xFE,
  0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xDF,
  0xE0, 0x1F, 0xCF, 0xC0, 0x7E, 0x7F, 0x80, 0x7F, 0x3F, 0x03, 0xF9, 0xFC,
  0x03, 0xFC, 0xFC, 0x0F, 0xC7, 0xF0, 0x0F, 0xF3, 0xF0, 0x7F, 0x3F, 0xC0,
  0x3F, 0x8F, 0xC1, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFC, 0x3F, 0x0F, 0xE0, 0x1F, 0xE3, 0xF1, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC7, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x3F, 0x87, 0xF8, 0x07, 0xF0,
  0xFC, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF7, 0xF0, 0x7F, 0x00, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF,
  0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xFF,
  0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0xE0,
  0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0x03, 0xF9, 0xFE, 0x07,
  0xF8, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC7, 0xF0, 0x07,
  0xF0, 0x7F, 0x8F, 0xE0, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0xC0,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x87, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x8F,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFF,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x8F, 0xF0,
  0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xE0, 0x7C, 0x03, 0xFE, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x10, 0x00, 0x1F, 0xE0, 0x60, 0x01, 0xFF, 0x03, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFF,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0xFD, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFB, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xF7, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xCF, 0xC1,
  0xFE, 0x03, 0xFC, 0x3F, 0x9F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x3F, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFC, 0x7E, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0xFC, 0x7F,
  0x80, 0x3F, 0xCF, 0xE1, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x07, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF0, 0x3F, 0x7F, 0x80,
  0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFC,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03,
  0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFE, 0x1F, 0xC0, 0x3F, 0xF9, 0xFC, 0x07, 0xFF, 0xEF, 0xE0, 0x3F,
  0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0x87, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xFE, 0x7F, 0x00, 0x7F, 0xE3, 0xF0,
  0x01, 0xFE, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x1C, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0xF0, 0x07,
  0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0,
  0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFC,
  0x03, 0xF1, 0xFF, 0xC0, 0x3F, 0x87, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1C,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x60, 0x7F, 0xC1, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70,
  0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x3F, 0xC3,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x9F, 0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x08, 0x1F, 0xF0, 0x0E, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0xFF, 0xE7, 0xF0, 0x03, 0xFF,
  0xEF, 0xE0, 0x0F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0x9F, 0xC0, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x7F,
  0xC0, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC1, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0x9F, 0xFC, 0x03, 0xFB,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x87, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xF7, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x7E, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xC7, 0xFF, 0x0F, 0xFF, 0x01, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE0, 0x7F, 0x7F, 0xFE, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xE1, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0x0F, 0xF8, 0x03, 0xF1, 0xFF, 0xC0, 0x3F, 0x3F, 0xFE, 0x07, 0xF7, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1,
  0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xFB, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF1, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xFC, 0x3F, 0xC0, 0x01, 0xF8, 0xFF, 0xE0, 0x03,
  0xF3, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0x80, 0x0F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0xEF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0x87,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0x00, 0x7F,
  0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x04, 0x0F,
  0x01, 0xF8, 0x7F, 0x01, 0xF8, 0xFF, 0x03, 0xF9, 0xFF, 0x03, 0xFB, 0xFE,
  0x03, 0xFB, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xC4,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0xFC, 0x0F, 0xF0, 0x1C, 0x0F, 0xF0, 0x04,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0xC0, 0x0F, 0xF8,
  0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x20, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0x80, 0xFF,
  0xFD, 0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x1F, 0xFC, 0x7F, 0x00, 0x7F, 0xC3,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB,
  0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F,
  0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0x9F, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFE,
  0xFE, 0x03, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0xFE, 0x07,
  0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xFF, 0x07,
  0xF8, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0xFE,
  0x1F, 0xBF, 0x0F, 0xF0, 0xFE, 0x1F, 0xBF, 0x0F, 0xE0, 0xFE, 0x3F, 0xBF,
  0x1F, 0xE0, 0xFE, 0x3F, 0x3F, 0x1F, 0xE0, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0,
  0xFE, 0x7E, 0x3F, 0x3F, 0xC0, 0xFE, 0x7E, 0x3F, 0x3F, 0x80, 0xFE, 0x7E,
  0x3F, 0x7F, 0x80, 0xFE, 0xFC, 0x3F, 0x7F, 0x00, 0xFE, 0xFC, 0x3F, 0x7F,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x3E, 0xFE, 0x00, 0xFD,
  0xF8, 0x3E, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x40, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x4F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x80, 0x07, 0xFE, 0x20, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 42, 16, 0, -41 },
  { 96, 20, 15, 25, 6, -41 },
  { 134, 33, 41, 33, 1, -41 },
  { 304, 28, 46, 29, 1, -43 },
  { 465, 41, 42, 46, 3, -41 },
  { 681, 35, 42, 36, 1, -41 },
  { 865, 9, 15, 14, 6, -41 },
  { 882, 20, 50, 18, 2, -41 },
  { 1007, 20, 50, 18, -4, -41 },
  { 1132, 25, 27, 28, 5, -44 },
  { 1217, 26, 28, 30, 3, -34 },
  { 1308, 13, 15, 15, -3, -7 },
  { 1333, 16, 7, 18, 1, -19 },
  { 1347, 10, 10, 15, 0, -9 },
  { 1360, 31, 41, 23, -3, -41 },
  { 1519, 27, 42, 29, 2, -41 },
  { 1661, 21, 41, 29, 5, -41 },
  { 1769, 31, 41, 29, -2, -41 },
  { 1928, 29, 42, 29, 0, -41 },
  { 2081, 30, 41, 29, -1, -41 },
  { 2235, 29, 42, 29, 0, -41 },
  { 2388, 28, 42, 29, 2, -41 },
  { 2535, 30, 41, 29, 2, -41 },
  { 2689, 28, 42, 29, 1, -41 },
  { 2836, 27, 42, 29, 1, -41 },
  { 2978, 15, 33, 15, 0, -32 },
  { 3040, 18, 40, 15, -3, -32 },
  { 3130, 26, 29, 30, 3, -35 },
  { 3225, 26, 17, 30, 3, -29 },
  { 3281, 26, 29, 30, 3, -35 },
  { 3376, 23, 42, 24, 3, -41 },
  { 3497, 42, 46, 44, 2, -41 },
  { 3739, 32, 41, 32, -3, -41 },
  { 3903, 31, 41, 32, 1, -41 },
  { 4062, 31, 42, 31, 3, -41 },
  { 4225, 33, 41, 35, 1, -41 },
  { 4395, 29, 41, 28, 1, -41 },
  { 4544, 29, 41, 27, 1, -41 },
  { 4693, 33, 42, 36, 3, -41 },
  { 4867, 36, 41, 36, 1, -41 },
  { 5052, 26, 41, 20, -2, -41 },
  { 5186, 27, 53, 17, -9, -41 },
  { 5365, 36, 41, 32, 1, -41 },
  { 5550, 22, 41, 27, 1, -41 },
  { 5663, 46, 41, 46, 1, -41 },
  { 5899, 39, 41, 39, 1, -41 },
  { 6099, 33, 42, 38, 3, -41 },
  { 6273, 32, 41, 32, 1, -41 },
  { 6437, 33, 51, 38, 3, -41 },
  { 6648, 30, 41, 32, 1, -41 },
  { 6802, 29, 42, 28, 0, -41 },
  { 6955, 27, 41, 27, 5, -41 },
  { 7094, 34, 42, 36, 3, -41 },
  { 7273, 31, 41, 31, 5, -41 },
  { 7432, 47, 41, 47, 5, -41 },
  { 7673, 39, 41, 31, -3, -41 },
  { 7873, 29, 41, 29, 5, -41 },
  { 8022, 33, 41, 27, -2, -41 },
  { 8192, 23, 50, 18, -1, -41 },
  { 8336, 13, 41, 23, 6, -41 },
  { 8403, 23, 50, 18, -4, -41 },
  { 8547, 27, 26, 29, 1, -41 },
  { 8635, 22, 4, 21, -5, 5 },
  { 8646, 12, 9, 18, 8, -44 },
  { 8660, 29, 33, 31, 2, -32 },
  { 8780, 29, 44, 31, 0, -43 },
  { 8940, 24, 33, 25, 2, -32 },
  { 9039, 31, 44, 31, 2, -43 },
  { 9210, 26, 33, 29, 2, -32 },
  { 9318, 32, 58, 19, -6, -44 },
  { 9550, 31, 46, 31, 0, -32 },
  { 9729, 28, 43, 31, 1, -43 },
  { 9880, 17, 43, 16, 0, -43 },
  { 9972, 24, 57, 16, -7, -43 },
  { 10143, 31, 43, 29, 1, -43 },
  { 10310, 18, 43, 16, 0, -43 },
  { 10407, 43, 32, 47, 1, -32 },
  { 10579, 28, 32, 31, 1, -32 },
  { 10691, 26, 33, 30, 2, -32 },
  { 10799, 31, 46, 31, -2, -32 },
  { 10978, 29, 46, 31, 2, -32 },
  { 11145, 24, 32, 22, 0, -32 },
  { 11241, 24, 33, 25, 0, -32 },
  { 11340, 19, 39, 21, 3, -38 },
  { 11433, 29, 32, 31, 2, -31 },
  { 11549, 27, 31, 27, 3, -31 },
  { 11654, 40, 31, 41, 4, -31 },
  { 11809, 33, 31, 28, -3, -31 },
  { 11937, 34, 45, 27, -4, -31 },
  { 12129, 26, 31, 24, -1, -31 },
  { 12230, 24, 50, 20, 0, -41 },
  { 12380, 6, 56, 28, 11, -43 },
  { 12422, 23, 50, 20, -3, -41 },
  { 12566, 26, 10, 30, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC57PT7B_H_
