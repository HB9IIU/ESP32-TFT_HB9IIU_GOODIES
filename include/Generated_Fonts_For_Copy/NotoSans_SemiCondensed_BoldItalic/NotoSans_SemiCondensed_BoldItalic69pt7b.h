#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xE1, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE7, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xE7, 0x8F, 0x80, 0x3F, 0xF1, 0xE0, 0xE0, 0x0F, 0xF8, 0x78, 0x08, 0x03,
  0xFE, 0x3C, 0x00, 0x00, 0xFF, 0x8F, 0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x00,
  0x0F, 0xFC, 0xF0, 0x00, 0x03, 0xFF, 0xB8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7B, 0xFF, 0x80, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x0F, 0x1F, 0xF8,
  0x00, 0x03, 0xC7, 0xFE, 0x10, 0x00, 0xF1, 0xFF, 0x86, 0x00, 0x3C, 0x7F,
  0xE1, 0xE0, 0x1E, 0x3F, 0xF0, 0x7F, 0x07, 0x9F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x8F, 0xF1, 0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xF1, 0xFF, 0xF9, 0xFE, 0x3F,
  0xC7, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xF8, 0xFF, 0xBF, 0xEF, 0xFF,
  0xE3, 0xFC, 0xFF, 0x8F, 0xF3, 0xFF, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF,
  0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF,
  0xBF, 0xF0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF7, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x02, 0x00, 0x7F, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x3E, 0x07, 0xF0, 0x01,
  0xFE, 0x1F, 0x80, 0x07, 0xFE, 0x7E, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xBF, 0x80, 0x0F, 0xFC, 0x7F, 0x00, 0x7F, 0xF1, 0xFC, 0x00,
  0xFF, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x03,
  0x80, 0xFF, 0x80, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0x01,
  0xFE, 0x3F, 0xE7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFE, 0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x9F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x07,
  0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFB, 0xFE, 0x1F, 0xFC, 0xFF, 0x83, 0xFC, 0x7F, 0xE0, 0x7E, 0x1F, 0xF0,
  0x1F, 0x07, 0xFC, 0x03, 0x01, 0xFF, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xC0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x03, 0xFF,
  0x00, 0x04, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFC,
  0x00, 0xE0, 0x03, 0xFF, 0x80, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x84, 0x00, 0x00, 0x7F, 0xE0, 0xC0,
  0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x08, 0x00,
  0x03, 0xFF, 0x83, 0x00, 0x01, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x01, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x7F,
  0xC7, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFC, 0x03,
  0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x3F, 0xF0, 0x07,
  0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x80, 0x07, 0xFF, 0x00, 0xFE, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xE1, 0xE0, 0x0F,
  0xFC, 0x30, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0x0F, 0xFF, 0xFF, 0x07,
  0xF1, 0xFC, 0x07, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x03,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0xC0,
  0x3F, 0x80, 0xFE, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xBF, 0x83, 0xF8,
  0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x8F, 0xC0, 0xFE, 0x07, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0xC7, 0xFF, 0x1F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x81, 0xFF, 0xFB, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x0E,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0xFF,
  0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x30, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xDF,
  0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0x00,
  0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFE,
  0x7F, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x9F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8,
  0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF0,
  0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x10, 0x00, 0x07, 0xFE,
  0x03, 0x00, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF3, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF9,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFC, 0x7F, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0x83, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x7F,
  0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF,
  0xF0, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xEF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xF8, 0xFF,
  0x80, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xCF, 0xF8,
  0x00, 0xFF, 0xF1, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0x3F, 0xFE, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0xE0, 0x0F, 0xF1,
  0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xE0, 0x3F, 0xF8,
  0x00, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0x01, 0xFF, 0xC0, 0x3C, 0x07, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xE0,
  0x03, 0xFF, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0xC0,
  0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x1F,
  0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xE0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xC0, 0x7F, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x18, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xF3, 0xFE, 0x00,
  0x7F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x60, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x08, 0x00, 0x07, 0xFE,
  0x00, 0x78, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0x3F, 0xFF,
  0x00, 0x7F, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xF0, 0x07,
  0xF9, 0xFF, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xF0,
  0x3F, 0xDF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE,
  0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x87,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0xFC, 0x00,
  0x1F, 0xEF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xF0, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x7F,
  0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3C, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x3F, 0xF0, 0x1F, 0xE7, 0xFF,
  0x01, 0xFE, 0xFF, 0xE0, 0x3F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x84, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFC, 0x07, 0xFE, 0x00, 0xE0, 0x7F, 0xE0, 0x02, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x88, 0x00, 0x1F, 0xF8, 0x70, 0x00, 0xFF, 0xC3,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x02, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xF9, 0xFE, 0x00, 0xFF,
  0xFC, 0x7F, 0x80, 0x1F, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xF3, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xBF, 0x83,
  0xFE, 0x07, 0xF8, 0x3F, 0xDF, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xCF, 0xE1,
  0xFF, 0x81, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xE7, 0xF8,
  0x7F, 0xC0, 0x7F, 0x87, 0xF3, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF9, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE3, 0xF8, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x7F,
  0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0xFE, 0x1F,
  0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x0F, 0xE7, 0xFC, 0x00, 0xFF, 0x7F, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0x83, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0x81,
  0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF1,
  0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x06, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0x1F, 0xFF, 0x00, 0x03, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xC0, 0x00, 0xFF,
  0xFC, 0x80, 0x00, 0x3F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 21, 50, 19, 0, -49 },
  { 133, 25, 18, 30, 7, -49 },
  { 190, 40, 49, 40, 1, -49 },
  { 435, 34, 56, 35, 1, -52 },
  { 673, 49, 51, 55, 4, -50 },
  { 986, 42, 51, 44, 1, -50 },
  { 1254, 11, 18, 17, 7, -49 },
  { 1279, 25, 60, 22, 2, -49 },
  { 1467, 25, 61, 22, -5, -50 },
  { 1658, 30, 32, 34, 6, -53 },
  { 1778, 32, 33, 37, 3, -41 },
  { 1910, 16, 17, 18, -3, -8 },
  { 1944, 19, 9, 21, 1, -23 },
  { 1966, 12, 12, 18, 0, -11 },
  { 1984, 36, 50, 28, -3, -50 },
  { 2209, 33, 51, 35, 2, -50 },
  { 2420, 26, 49, 35, 6, -49 },
  { 2580, 37, 50, 35, -2, -50 },
  { 2812, 35, 51, 35, 0, -50 },
  { 3036, 36, 49, 35, -1, -49 },
  { 3257, 34, 50, 35, 1, -49 },
  { 3470, 34, 51, 35, 2, -50 },
  { 3687, 36, 49, 35, 2, -49 },
  { 3908, 34, 51, 35, 1, -50 },
  { 4125, 32, 51, 35, 2, -50 },
  { 4329, 18, 39, 19, 0, -38 },
  { 4417, 22, 47, 19, -4, -38 },
  { 4547, 32, 35, 37, 3, -42 },
  { 4687, 32, 21, 37, 3, -35 },
  { 4771, 32, 35, 37, 3, -42 },
  { 4911, 27, 51, 29, 4, -50 },
  { 5084, 50, 55, 54, 3, -49 },
  { 5428, 39, 49, 39, -4, -49 },
  { 5667, 38, 49, 39, 1, -49 },
  { 5900, 38, 51, 38, 3, -50 },
  { 6143, 40, 49, 43, 1, -49 },
  { 6388, 36, 49, 34, 1, -49 },
  { 6609, 35, 49, 33, 1, -49 },
  { 6824, 40, 51, 43, 4, -50 },
  { 7079, 44, 49, 44, 1, -49 },
  { 7349, 31, 49, 25, -2, -49 },
  { 7539, 33, 64, 21, -11, -49 },
  { 7803, 44, 49, 38, 1, -49 },
  { 8073, 27, 49, 32, 1, -49 },
  { 8239, 56, 49, 56, 1, -49 },
  { 8582, 47, 49, 47, 1, -49 },
  { 8870, 41, 51, 46, 3, -50 },
  { 9132, 38, 49, 38, 1, -49 },
  { 9365, 41, 62, 46, 3, -50 },
  { 9683, 37, 49, 39, 1, -49 },
  { 9910, 35, 51, 34, 0, -50 },
  { 10134, 32, 49, 33, 6, -49 },
  { 10330, 41, 50, 43, 4, -49 },
  { 10587, 38, 49, 38, 6, -49 },
  { 10820, 57, 49, 57, 6, -49 },
  { 11170, 47, 49, 38, -4, -49 },
  { 11458, 36, 49, 35, 6, -49 },
  { 11679, 39, 49, 33, -2, -49 },
  { 11918, 29, 60, 22, -2, -49 },
  { 12136, 16, 50, 28, 7, -50 },
  { 12236, 28, 60, 22, -5, -49 },
  { 12446, 33, 31, 35, 1, -49 },
  { 12574, 26, 5, 26, -6, 6 },
  { 12591, 14, 11, 22, 10, -53 },
  { 12611, 35, 39, 38, 2, -38 },
  { 12782, 34, 53, 38, 1, -52 },
  { 13008, 30, 39, 30, 2, -38 },
  { 13155, 38, 53, 38, 2, -52 },
  { 13407, 32, 39, 35, 2, -38 },
  { 13563, 39, 70, 23, -8, -53 },
  { 13905, 37, 55, 38, 0, -38 },
  { 14160, 34, 52, 38, 1, -52 },
  { 14381, 20, 53, 19, 1, -53 },
  { 14514, 30, 70, 19, -9, -53 },
  { 14777, 38, 52, 36, 1, -52 },
  { 15024, 20, 52, 19, 1, -52 },
  { 15154, 53, 38, 57, 1, -38 },
  { 15406, 34, 38, 38, 1, -38 },
  { 15568, 32, 39, 37, 2, -38 },
  { 15724, 38, 54, 38, -3, -38 },
  { 15981, 35, 55, 38, 2, -38 },
  { 16222, 28, 38, 27, 1, -38 },
  { 16355, 29, 39, 30, 0, -38 },
  { 16497, 24, 47, 25, 3, -46 },
  { 16638, 34, 39, 38, 3, -38 },
  { 16804, 32, 38, 33, 4, -38 },
  { 16956, 49, 38, 50, 4, -38 },
  { 17189, 40, 38, 34, -3, -38 },
  { 17379, 42, 55, 33, -5, -38 },
  { 17668, 32, 38, 29, -2, -38 },
  { 17820, 29, 60, 24, 0, -49 },
  { 18038, 7, 69, 34, 13, -53 },
  { 18099, 28, 60, 24, -4, -49 },
  { 18309, 32, 11, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC69PT7B_H_
