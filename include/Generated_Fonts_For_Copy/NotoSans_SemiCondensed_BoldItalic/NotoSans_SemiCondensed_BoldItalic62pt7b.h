#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F,
  0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE7, 0x1F, 0x00, 0xFF, 0x8E, 0x06, 0x01, 0xFF, 0x3C, 0x00,
  0x03, 0xFC, 0x78, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0xF9, 0xC0, 0x00,
  0x1F, 0xFB, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xEF, 0xFC, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x07, 0x1F, 0xF0, 0x00, 0x1E,
  0x3F, 0xE1, 0x00, 0x3C, 0x7F, 0x87, 0x80, 0x79, 0xFF, 0x0F, 0xC0, 0xE7,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF,
  0x8F, 0xE1, 0xFC, 0x7E, 0x3F, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFF, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xFE,
  0x1F, 0x8F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x81,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xBF, 0xE1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xC7, 0xF8, 0x3F, 0xE1, 0xFF, 0xBF, 0xE1, 0xFF, 0x03, 0xFE,
  0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x1F, 0xC0, 0x0E, 0x03, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xFD, 0xF0, 0x05, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x7F,
  0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7C, 0x1F, 0xE0, 0x07, 0x81, 0xFC,
  0x00, 0x60, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFC, 0x1F, 0xC7, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF3, 0xFE, 0x7F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07,
  0xFD, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF3,
  0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xE3, 0xFE, 0x0F, 0x87, 0xF8, 0x0C, 0x0F, 0xF0, 0x10, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0x0F,
  0x00, 0x3F, 0xE0, 0x02, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x78, 0x07, 0xFE, 0x00, 0xC0,
  0x07, 0xFC, 0x01, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC4, 0x00, 0x01, 0xFF, 0x0C, 0x00, 0x07, 0xFE, 0x1F, 0x00,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFC,
  0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x00,
  0x7F, 0xE0, 0xE0, 0x00, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x1C, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xF8, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0xBF, 0xFE, 0x01, 0xFE, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0x87, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F,
  0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x7F,
  0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0xFF, 0x03, 0xFF,
  0xF7, 0xF8, 0x0F, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x40, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0x1E, 0x01, 0xFF, 0x18, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3C, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xFF, 0xC1, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x87, 0xF0, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x1F, 0xC0, 0xFF, 0xBF,
  0xC0, 0xFC, 0x7E, 0x07, 0xF8, 0x3F, 0x03, 0xF3, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x3F, 0x07, 0xF0, 0x1F, 0x81,
  0xFD, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x03, 0xF8, 0x1F,
  0x9F, 0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF9,
  0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xEF, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x3F,
  0x87, 0xF0, 0x1F, 0x80, 0xFC, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xE3, 0xF8,
  0x7F, 0x03, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F, 0x83,
  0xF8, 0xFF, 0x87, 0xF0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x3F,
  0xFE, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xFB, 0xFF, 0xE0, 0x1F, 0x81, 0xFF,
  0xC7, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xE3, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0xFF, 0xE0,
  0x01, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xC0, 0x1F, 0xFF, 0x03, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFE,
  0x03, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0x18, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF8,
  0x7F, 0xC0, 0x3F, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F,
  0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0,
  0x07, 0xF7, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x0F, 0xE3, 0xFC, 0x01, 0xFE,
  0x7F, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF0, 0x7F, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF8, 0x03,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xC7, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xDF, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xF7, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF7, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x0F,
  0xF1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xF8, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x05, 0xA0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x18, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x00,
  0x7F, 0xC0, 0x78, 0x00, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF9, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x7F, 0x03, 0xFC, 0x03,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF,
  0x00, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x1F, 0xC7,
  0xFC, 0x00, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x7F,
  0x3F, 0xE0, 0x03, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC1,
  0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0xE0, 0x01, 0xFC, 0xFE,
  0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0xFE, 0xFF, 0x00, 0x07, 0xF7,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xC7, 0xF8,
  0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xE1, 0xFC, 0x03, 0xFF,
  0xE7, 0xF8, 0x0F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F,
  0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xDF, 0xE0, 0x1F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFC, 0x7F, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x7F, 0xF8, 0x01, 0xFE,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFE,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0x7E, 0x0F,
  0xF8, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1C, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x02, 0x07, 0xFE, 0x03, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x07,
  0xFF, 0x8F, 0xC0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x06, 0x07, 0xFF,
  0x03, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3B,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xFE, 0x1F, 0xC0, 0x0F, 0xFF, 0x9F, 0xE0,
  0x0F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0x7F, 0xC0, 0x07,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x08, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x01, 0x00, 0x03, 0xFF, 0x00, 0xE0, 0x03, 0xFF, 0x00,
  0x7E, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x9F, 0xFC, 0x01, 0xFE, 0x7F, 0xFC,
  0x03, 0xFD, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xC1,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE,
  0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3B, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80,
  0x7F, 0xE3, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x00,
  0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xDF, 0xFF, 0xC0, 0x03, 0xFB, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFD, 0xFF, 0xFC, 0x00, 0x7F, 0x9F, 0xFF, 0x00, 0x0F, 0xF1,
  0xFF, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xF3,
  0xF8, 0x0F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xDF,
  0xE0, 0x1F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFC, 0xFF, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x07, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC7, 0xFC, 0x07, 0xF3, 0xFF,
  0x01, 0xFD, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xE1, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1,
  0xF0, 0x3F, 0xE0, 0x0C, 0x0F, 0xF8, 0x01, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x20,
  0x00, 0xFF, 0x8E, 0x00, 0x7F, 0xE3, 0xF8, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC,
  0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x3F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0x83, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0, 0x3F,
  0xF8, 0x7F, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x00,
  0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE1, 0xFF, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xEF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFC, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFC,
  0x0F, 0xF0, 0xFF, 0x07, 0xEF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xCF, 0xC3, 0xFE, 0x0F, 0xF1, 0xFC, 0xFC, 0x3F, 0xC0,
  0xFF, 0x1F, 0xCF, 0xC7, 0xFC, 0x0F, 0xF1, 0xF8, 0xFC, 0x7F, 0x80, 0xFF,
  0x3F, 0x8F, 0xC7, 0xF8, 0x0F, 0xF3, 0xF8, 0xFC, 0xFF, 0x00, 0xFF, 0x7F,
  0x0F, 0xCF, 0xF0, 0x0F, 0xF7, 0xF0, 0xFC, 0xFE, 0x00, 0xFF, 0x7E, 0x0F,
  0xDF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFD, 0xFE, 0x00, 0xFE, 0xFE, 0x0F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFB, 0xFE, 0x00,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x04, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x13, 0xFF, 0xC0, 0x01, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE8, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 19, 45, 17, 0, -44 },
  { 108, 22, 16, 27, 6, -44 },
  { 152, 36, 44, 36, 1, -44 },
  { 350, 31, 51, 31, 1, -47 },
  { 548, 45, 46, 50, 3, -45 },
  { 807, 38, 46, 40, 1, -45 },
  { 1026, 11, 16, 16, 6, -44 },
  { 1048, 22, 54, 19, 2, -44 },
  { 1197, 23, 55, 20, -5, -45 },
  { 1356, 27, 28, 31, 5, -47 },
  { 1451, 28, 30, 33, 3, -37 },
  { 1556, 14, 16, 17, -3, -8 },
  { 1584, 17, 7, 19, 1, -20 },
  { 1599, 11, 10, 17, 0, -9 },
  { 1613, 33, 45, 25, -3, -45 },
  { 1799, 29, 46, 31, 2, -45 },
  { 1966, 23, 44, 32, 6, -44 },
  { 2093, 33, 45, 31, -2, -45 },
  { 2279, 31, 46, 31, 0, -45 },
  { 2458, 32, 44, 32, -1, -44 },
  { 2634, 32, 45, 31, 0, -44 },
  { 2814, 31, 46, 31, 2, -45 },
  { 2993, 32, 44, 31, 2, -44 },
  { 3169, 31, 46, 31, 1, -45 },
  { 3348, 29, 46, 31, 2, -45 },
  { 3515, 16, 35, 17, 0, -34 },
  { 3585, 19, 42, 17, -3, -34 },
  { 3685, 28, 31, 33, 3, -38 },
  { 3794, 28, 18, 33, 3, -31 },
  { 3857, 28, 31, 33, 3, -38 },
  { 3966, 24, 46, 26, 4, -45 },
  { 4104, 46, 49, 48, 2, -44 },
  { 4386, 36, 44, 35, -4, -44 },
  { 4584, 34, 44, 35, 1, -44 },
  { 4771, 34, 46, 34, 3, -45 },
  { 4967, 36, 44, 38, 1, -44 },
  { 5165, 32, 44, 30, 1, -44 },
  { 5341, 32, 44, 30, 1, -44 },
  { 5517, 36, 46, 39, 3, -45 },
  { 5724, 40, 44, 40, 1, -44 },
  { 5944, 28, 44, 22, -2, -44 },
  { 6098, 30, 57, 19, -10, -44 },
  { 6312, 39, 44, 35, 1, -44 },
  { 6527, 24, 44, 29, 1, -44 },
  { 6659, 50, 44, 50, 1, -44 },
  { 6934, 42, 44, 43, 1, -44 },
  { 7165, 37, 46, 41, 3, -45 },
  { 7378, 34, 44, 34, 1, -44 },
  { 7565, 37, 56, 41, 3, -45 },
  { 7824, 33, 44, 35, 1, -44 },
  { 8006, 32, 46, 30, 0, -45 },
  { 8190, 29, 44, 30, 5, -44 },
  { 8350, 37, 45, 39, 3, -44 },
  { 8559, 33, 44, 34, 6, -44 },
  { 8741, 51, 44, 51, 6, -44 },
  { 9022, 43, 44, 34, -4, -44 },
  { 9259, 31, 44, 32, 6, -44 },
  { 9430, 35, 44, 30, -2, -44 },
  { 9623, 26, 54, 19, -2, -44 },
  { 9799, 14, 45, 25, 7, -45 },
  { 9878, 25, 54, 19, -4, -44 },
  { 10047, 30, 28, 32, 1, -44 },
  { 10152, 24, 4, 23, -6, 6 },
  { 10164, 12, 9, 19, 9, -47 },
  { 10178, 31, 35, 34, 2, -34 },
  { 10314, 32, 48, 34, 0, -47 },
  { 10506, 26, 35, 27, 2, -34 },
  { 10620, 34, 48, 34, 2, -47 },
  { 10824, 28, 35, 32, 2, -34 },
  { 10947, 35, 62, 21, -7, -47 },
  { 11219, 33, 49, 34, 0, -34 },
  { 11422, 31, 47, 34, 1, -47 },
  { 11605, 19, 47, 17, 0, -47 },
  { 11717, 27, 62, 17, -8, -47 },
  { 11927, 34, 47, 32, 1, -47 },
  { 12127, 19, 47, 17, 0, -47 },
  { 12239, 47, 34, 51, 1, -34 },
  { 12439, 31, 34, 34, 1, -34 },
  { 12571, 29, 35, 33, 2, -34 },
  { 12698, 35, 49, 34, -3, -34 },
  { 12913, 31, 49, 34, 2, -34 },
  { 13103, 26, 34, 24, 0, -34 },
  { 13214, 26, 35, 27, 0, -34 },
  { 13328, 21, 42, 23, 3, -41 },
  { 13439, 30, 35, 34, 3, -34 },
  { 13571, 30, 34, 29, 3, -34 },
  { 13699, 44, 34, 45, 4, -34 },
  { 13886, 36, 34, 30, -3, -34 },
  { 14039, 37, 49, 30, -4, -34 },
  { 14266, 29, 34, 26, -2, -34 },
  { 14390, 26, 54, 22, 0, -44 },
  { 14566, 7, 61, 30, 11, -47 },
  { 14620, 24, 54, 22, -3, -44 },
  { 14782, 28, 10, 33, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC62PT7B_H_
