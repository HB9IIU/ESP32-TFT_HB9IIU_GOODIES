#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F,
  0x00, 0x7C, 0xFB, 0xC7, 0x9E, 0x3D, 0xF3, 0xEF, 0x1F, 0x78, 0xF3, 0xC7,
  0x9E, 0x3C, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0xC7, 0x80, 0x0E,
  0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0xCC, 0x1F, 0x70,
  0x07, 0xD8, 0x01, 0xF6, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x19, 0xF0, 0x06,
  0x7C, 0x81, 0x9F, 0x38, 0x6F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x80, 0x01, 0x03, 0xF8, 0x07, 0x81, 0xFE, 0x01, 0xE0, 0xFF, 0xC0,
  0xF0, 0x7C, 0xF0, 0x78, 0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x0F, 0x03, 0xE3,
  0xC7, 0x80, 0xF0, 0xF1, 0xE0, 0x3C, 0x7C, 0xF0, 0x0F, 0x1E, 0x78, 0x03,
  0xC7, 0x9E, 0x7C, 0xF3, 0xCF, 0x3F, 0xBF, 0xF7, 0x9F, 0xF7, 0xF9, 0xEF,
  0xBD, 0xFC, 0xF3, 0xCF, 0x1E, 0x79, 0xF3, 0xC0, 0x1E, 0x78, 0xF0, 0x0F,
  0x1E, 0x3C, 0x07, 0x87, 0x8F, 0x01, 0xE1, 0xE3, 0xC0, 0xF0, 0xF9, 0xF0,
  0x78, 0x3E, 0x78, 0x1E, 0x07, 0xBE, 0x0F, 0x01, 0xFF, 0x07, 0x80, 0x7F,
  0x83, 0xE0, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01,
  0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xF1, 0xFF, 0x87, 0xCF, 0xFE, 0x3E,
  0x7E, 0xFC, 0xFB, 0xF1, 0xFF, 0xCF, 0x87, 0xFF, 0x3E, 0x0F, 0xF8, 0xF8,
  0x1F, 0xC3, 0xE0, 0x7E, 0x0F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0x00, 0x7D, 0xE7, 0xBE, 0xFB, 0xCF,
  0x3C, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x61, 0xE0,
  0x79, 0xE0, 0x7D, 0xC0, 0xFF, 0xFF, 0x7F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xE0, 0x3E, 0xF0, 0x7E, 0xF0, 0x3C, 0xF8, 0x18, 0x78, 0x08, 0x70,
  0x00, 0x40, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x78, 0x78, 0x00, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x19, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xE3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF7, 0xE0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x7E, 0xF8,
  0x1F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F,
  0x8F, 0xCF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0xEF,
  0x9F, 0x7C, 0x31, 0xF0, 0x87, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x78,
  0x3E, 0x03, 0x03, 0xF0, 0x20, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0C, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0x00, 0x7E, 0x38, 0x1F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x79, 0xF0, 0x1E,
  0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xE1,
  0xF0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xEE,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x88, 0x03, 0xF1, 0xC1, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE7, 0xC1, 0xF7, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF1,
  0xF1, 0xF8, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xCF, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xE3, 0xE0, 0xFB, 0xF0, 0x3F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0x7E, 0x3E, 0x3F,
  0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF9, 0xF8, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xF7,
  0xE1, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xDF, 0x03, 0x8F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE2, 0x07, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0x03, 0xE0, 0xFC,
  0x7F, 0x1F, 0x83, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00, 0x00,
  0x40, 0x3E, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0xF1, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xE6, 0x0F, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x10, 0x1E, 0x1E, 0x0F, 0xF8, 0xE1, 0xE1,
  0xFF, 0x8E, 0x3C, 0x3F, 0xF8, 0xF3, 0x87, 0x87, 0x0F, 0x78, 0xF0, 0xF0,
  0xE7, 0x8F, 0x0F, 0x0E, 0x78, 0xE0, 0xF1, 0xE7, 0x1E, 0x0E, 0x1E, 0xF1,
  0xE1, 0xE1, 0xEF, 0x1E, 0x1E, 0x3C, 0xF1, 0xE3, 0xE3, 0xCF, 0x1E, 0x3E,
  0x78, 0xF1, 0xFF, 0xFF, 0x07, 0x0F, 0xEF, 0xE0, 0x78, 0x7C, 0x7C, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x1F, 0x80,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x1F, 0x07, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0x7D, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x1F, 0x83, 0xE0,
  0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C,
  0x1F, 0x87, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFE, 0x0C, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x20, 0x7F, 0x0E, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x7F, 0x07,
  0xC1, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xF8, 0x1F, 0x87, 0xC1, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xF0, 0x18, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x7E, 0x1F, 0xFB,
  0xF0, 0xFF, 0x9F, 0x87, 0xFC, 0xF8, 0x3F, 0xE7, 0xC0, 0x3F, 0x3E, 0x01,
  0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7F, 0x03, 0xE1, 0xFC, 0x3F, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0xFC,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x80, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x7E,
  0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3D,
  0xF0, 0x7F, 0xE0, 0xF7, 0xC1, 0xF7, 0x87, 0xBE, 0x07, 0x9E, 0x1E, 0xF8,
  0x3E, 0x78, 0xF3, 0xE0, 0xF9, 0xE3, 0xCF, 0x83, 0xE7, 0x9F, 0x3C, 0x0F,
  0x9E, 0x79, 0xF0, 0x3C, 0x7B, 0xE7, 0xC1, 0xF1, 0xEF, 0x1F, 0x07, 0xC7,
  0xFC, 0x7C, 0x1F, 0x1F, 0xE1, 0xE0, 0x78, 0x7F, 0x8F, 0x81, 0xE1, 0xFC,
  0x3E, 0x0F, 0x87, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x03, 0xC1, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xF8, 0x07, 0xC1,
  0xFC, 0x07, 0xC1, 0xFE, 0x03, 0xE0, 0xFF, 0x01, 0xF0, 0x7F, 0xC0, 0xF8,
  0x3F, 0xE0, 0x78, 0x3F, 0xF0, 0x7C, 0x1F, 0x7C, 0x3E, 0x0F, 0xBE, 0x1F,
  0x07, 0xDF, 0x0F, 0x83, 0xC7, 0x87, 0x83, 0xE3, 0xE7, 0xC1, 0xF1, 0xF3,
  0xE0, 0xF8, 0xF9, 0xF0, 0x7C, 0x3C, 0xF8, 0x3C, 0x1F, 0x78, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x83, 0xC0,
  0x7F, 0x83, 0xE0, 0x3F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF8, 0x07, 0xF0, 0x78,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0,
  0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xFC, 0x07,
  0xE3, 0xF0, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1,
  0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xE0,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x87,
  0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC,
  0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x3F, 0x0F, 0x9F, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x7C, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x3F, 0x07,
  0xE7, 0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x83, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0x80, 0x7C,
  0x3C, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07,
  0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x1F, 0x80,
  0xFB, 0xE0, 0x3F, 0x03, 0xF7, 0xC0, 0x7E, 0x07, 0xCF, 0x81, 0xFC, 0x0F,
  0x9F, 0x03, 0xF8, 0x3E, 0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x1F, 0xE1, 0xF0,
  0xF8, 0x7F, 0xC3, 0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xE1, 0xEF, 0x1F, 0x07,
  0xC7, 0xDE, 0x3E, 0x0F, 0x8F, 0x3C, 0xF8, 0x1F, 0x3E, 0x79, 0xF0, 0x3E,
  0x78, 0xF3, 0xE0, 0x7D, 0xF1, 0xEF, 0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xF7,
  0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xEF, 0x81,
  0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F,
  0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x43, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8,
  0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x7D,
  0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x00, 0x40, 0x00, 0x7E, 0x7C, 0x3F, 0xEF,
  0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0xC1, 0xF1,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x0F, 0xFF, 0xC1,
  0xFF, 0x78, 0x1F, 0xCF, 0x01, 0xF3, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x20, 0x0F, 0x9F, 0x81, 0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFC, 0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3,
  0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x9F,
  0x87, 0xE3, 0xF8, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xEF, 0xF0, 0x7C,
  0xFC, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x84, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x18,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x10, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0xDF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0x3F, 0x3C, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8,
  0x3E, 0xFC, 0x1F, 0x7C, 0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0x0F,
  0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x04, 0x3F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0x9F, 0x03, 0xFD, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFD, 0xF0, 0x1F,
  0x9F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x80, 0x7E, 0x0F,
  0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x10, 0x0F, 0x9F, 0x81, 0xF7, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFC, 0x7E, 0x3F, 0x07, 0xC7, 0xE0, 0xF8,
  0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x1F, 0x83,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F,
  0x80, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xE1, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x80,
  0x7C, 0xFC, 0x3F, 0x03, 0xCF, 0xF3, 0xFC, 0x1E, 0xFF, 0xBF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x83, 0xE3, 0xF0, 0xFC,
  0x1F, 0x1F, 0x07, 0xC1, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C,
  0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0xF8,
  0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0xC1, 0xF0, 0x7C,
  0x00, 0x00, 0x82, 0x01, 0xE3, 0xF0, 0x3C, 0xFF, 0x07, 0xBF, 0xF0, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x07, 0xE3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x8F, 0xC1, 0xF0, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF8,
  0x7E, 0x7C, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0x00, 0x1F, 0x3F, 0x00, 0xF7, 0xFC, 0x07, 0xBF, 0xE0, 0x3F,
  0xFF, 0x81, 0xF8, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7E, 0x3C,
  0x1F, 0xEF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF,
  0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xDF, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x02, 0x0F, 0x9F, 0x0F,
  0xBE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x00, 0x40, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x9E, 0x3F,
  0x04, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xC0, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0x3F, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC1,
  0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xFC,
  0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xE3, 0xE3, 0xF8, 0xFF, 0xFC, 0x3F,
  0xEF, 0x0F, 0xFB, 0xC1, 0xF8, 0xF0, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x1E, 0x1F, 0x87, 0x87, 0xC1, 0xE3, 0xF0,
  0x78, 0xF8, 0x1E, 0x3E, 0x07, 0x9F, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFB, 0xE1, 0xFC,
  0x3E, 0x7C, 0x3F, 0x87, 0xCF, 0x87, 0xF0, 0xF9, 0xF1, 0xFE, 0x3E, 0x3E,
  0x3F, 0xC7, 0xC7, 0xCF, 0x79, 0xF0, 0xF9, 0xEF, 0x3E, 0x0F, 0x7D, 0xE7,
  0x81, 0xEF, 0x3D, 0xF0, 0x3D, 0xE7, 0xBC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x1F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07,
  0xC1, 0xFC, 0x1F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7E,
  0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3C, 0x1F, 0x00, 0x78, 0x7E, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x5F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0x00, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 13, 9, 16, 4, -26 },
  { 52, 22, 26, 22, 0, -26 },
  { 124, 18, 30, 19, 1, -28 },
  { 192, 26, 27, 30, 2, -27 },
  { 280, 22, 27, 24, 1, -27 },
  { 355, 6, 9, 9, 4, -26 },
  { 362, 13, 32, 12, 1, -26 },
  { 414, 14, 33, 12, -3, -27 },
  { 472, 16, 17, 18, 3, -28 },
  { 506, 17, 18, 20, 2, -22 },
  { 545, 9, 10, 10, -2, -5 },
  { 557, 10, 4, 11, 1, -12 },
  { 562, 6, 6, 10, 0, -6 },
  { 567, 20, 27, 15, -2, -27 },
  { 635, 18, 27, 19, 1, -27 },
  { 696, 14, 26, 19, 3, -26 },
  { 742, 20, 27, 19, -1, -27 },
  { 810, 19, 27, 19, 0, -27 },
  { 875, 19, 26, 19, 0, -26 },
  { 937, 19, 26, 19, 0, -26 },
  { 999, 18, 27, 19, 1, -27 },
  { 1060, 20, 26, 19, 1, -26 },
  { 1125, 18, 27, 19, 1, -27 },
  { 1186, 17, 27, 19, 1, -27 },
  { 1244, 10, 21, 10, 0, -21 },
  { 1271, 12, 26, 10, -2, -21 },
  { 1310, 17, 19, 20, 2, -23 },
  { 1351, 17, 11, 20, 2, -19 },
  { 1375, 17, 19, 20, 2, -23 },
  { 1416, 15, 27, 15, 2, -27 },
  { 1467, 28, 30, 29, 1, -27 },
  { 1572, 21, 26, 21, -2, -26 },
  { 1641, 20, 26, 21, 1, -26 },
  { 1706, 20, 27, 20, 2, -27 },
  { 1774, 21, 26, 23, 1, -26 },
  { 1843, 19, 26, 18, 1, -26 },
  { 1905, 19, 26, 18, 1, -26 },
  { 1967, 21, 27, 23, 2, -27 },
  { 2038, 23, 26, 24, 1, -26 },
  { 2113, 17, 26, 13, -1, -26 },
  { 2169, 18, 34, 11, -6, -26 },
  { 2246, 23, 26, 21, 1, -26 },
  { 2321, 14, 26, 17, 1, -26 },
  { 2367, 30, 26, 30, 1, -26 },
  { 2465, 25, 26, 25, 1, -26 },
  { 2547, 22, 27, 25, 2, -27 },
  { 2622, 20, 26, 21, 1, -26 },
  { 2687, 22, 33, 25, 2, -27 },
  { 2778, 19, 26, 21, 1, -26 },
  { 2840, 19, 27, 18, 0, -27 },
  { 2905, 18, 26, 18, 3, -26 },
  { 2964, 22, 26, 23, 2, -26 },
  { 3036, 20, 26, 20, 3, -26 },
  { 3101, 31, 26, 30, 3, -26 },
  { 3202, 25, 26, 20, -2, -26 },
  { 3284, 19, 26, 19, 3, -26 },
  { 3346, 21, 26, 18, -1, -26 },
  { 3415, 15, 32, 12, -1, -26 },
  { 3475, 8, 27, 15, 4, -27 },
  { 3502, 16, 32, 12, -3, -26 },
  { 3566, 18, 17, 19, 0, -27 },
  { 3605, 14, 3, 14, -3, 3 },
  { 3611, 8, 6, 12, 5, -28 },
  { 3617, 19, 21, 20, 1, -21 },
  { 3667, 19, 28, 20, 0, -28 },
  { 3734, 16, 21, 16, 1, -21 },
  { 3776, 21, 28, 20, 1, -28 },
  { 3850, 17, 21, 19, 1, -21 },
  { 3895, 21, 37, 13, -4, -28 },
  { 3993, 20, 30, 20, 0, -21 },
  { 4068, 19, 28, 20, 0, -28 },
  { 4135, 11, 28, 10, 0, -28 },
  { 4174, 16, 37, 10, -5, -28 },
  { 4248, 21, 28, 19, 0, -28 },
  { 4322, 12, 28, 10, 0, -28 },
  { 4364, 29, 21, 30, 0, -21 },
  { 4441, 19, 21, 20, 0, -21 },
  { 4491, 17, 21, 20, 1, -21 },
  { 4536, 21, 30, 20, -2, -21 },
  { 4615, 19, 30, 20, 1, -21 },
  { 4687, 16, 21, 14, 0, -21 },
  { 4729, 16, 21, 16, 0, -21 },
  { 4771, 12, 25, 14, 2, -25 },
  { 4809, 18, 20, 20, 2, -20 },
  { 4854, 18, 20, 17, 2, -20 },
  { 4899, 27, 20, 27, 2, -20 },
  { 4967, 22, 20, 18, -2, -20 },
  { 5022, 23, 29, 18, -3, -20 },
  { 5106, 17, 20, 16, -1, -20 },
  { 5149, 15, 32, 13, 0, -26 },
  { 5209, 4, 36, 18, 7, -28 },
  { 5227, 15, 32, 13, -2, -26 },
  { 5287, 17, 6, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC37PT7B_H_
