#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0x7C, 0xFB, 0xE7, 0x9E, 0x3C,
  0xF3, 0xE7, 0x9E, 0x38, 0xF1, 0xC7, 0x9E, 0x38, 0xF1, 0xC0, 0x00, 0x71,
  0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x1E,
  0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03,
  0x8F, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x71, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1E, 0x66, 0x3E, 0x40, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xBE, 0x03, 0x3E,
  0x83, 0x3E, 0xF3, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x3C,
  0x3F, 0xC0, 0x78, 0x3F, 0xE0, 0xF0, 0x79, 0xE0, 0xE0, 0x79, 0xE1, 0xE0,
  0xF1, 0xE3, 0xC0, 0xF1, 0xE3, 0x80, 0xF1, 0xE7, 0x80, 0xF3, 0xCF, 0x00,
  0xF3, 0xCE, 0x3C, 0xF3, 0xDE, 0xFE, 0xFF, 0xBD, 0xFF, 0xFF, 0x39, 0xEF,
  0x7E, 0x7B, 0xCF, 0x18, 0xF3, 0xCF, 0x00, 0xE3, 0x8F, 0x01, 0xE7, 0x8F,
  0x03, 0xC7, 0x8F, 0x03, 0x87, 0x8E, 0x07, 0x87, 0x9E, 0x0F, 0x07, 0x9E,
  0x0E, 0x07, 0xFC, 0x1E, 0x03, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x30, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0,
  0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xF1, 0xFF, 0x1F, 0x3F, 0xF1, 0xE7, 0xCF,
  0xBE, 0xF8, 0xFB, 0xCF, 0x87, 0xFC, 0xF8, 0x7F, 0x8F, 0x83, 0xF0, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xC7, 0xE0,
  0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xF0, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x02, 0x1E, 0x07, 0x3C, 0x1F, 0xF0, 0x7F,
  0xFF, 0x9F, 0xFF, 0x0F, 0xFE, 0x3F, 0x80, 0xFF, 0x03, 0xEF, 0x07, 0x9E,
  0x07, 0x1E, 0x04, 0x38, 0x00, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xDF,
  0xE0, 0x79, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x3F, 0x80, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0xE3, 0xFF,
  0x7F, 0xF1, 0xF7, 0x8E, 0x7C, 0x23, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xC1, 0xF0, 0x20, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x20, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC8, 0x07,
  0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xDF, 0x03, 0xCF, 0x83, 0xC7, 0xC3,
  0xE3, 0xC1, 0xE1, 0xE1, 0xE1, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x98, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0x10, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x38, 0x1F, 0x7F, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xF1, 0xF3, 0xF0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x8F, 0x87,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1F, 0x1F, 0x1F, 0x3E,
  0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C,
  0xF8, 0x3C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF8, 0x7C, 0xFC, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0xE0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xBE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0x07, 0xC7, 0xE3,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xFF, 0x9F, 0xFC, 0xFF, 0xF3, 0xDF, 0x90, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x78, 0x3F, 0x1E, 0x78, 0x7F, 0xC7, 0x3C, 0x7F, 0xE3, 0x9C, 0x78,
  0xF1, 0xDE, 0x38, 0x70, 0xEE, 0x3C, 0x38, 0x77, 0x1C, 0x3C, 0x7F, 0x8E,
  0x1E, 0x3F, 0xCF, 0x0E, 0x1D, 0xE7, 0x8F, 0x1E, 0xF3, 0xC7, 0x8E, 0x78,
  0xFF, 0xFF, 0x3C, 0x7F, 0xFF, 0x0E, 0x1F, 0x3F, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0,
  0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFF, 0xC0, 0x0F, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F,
  0x87, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x8F, 0xC3,
  0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xE0,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xE0, 0x63,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x0C, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0xFE, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF,
  0x83, 0xF1, 0xF0, 0xFE, 0x7C, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC,
  0x04, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x83, 0xFC, 0xF8, 0x7F, 0xCF, 0x87, 0xFC, 0xF8, 0x7F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0xF0,
  0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F,
  0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xE7, 0xC0,
  0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xFC, 0x1E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xB8, 0x1F, 0xF0, 0xF7, 0x03, 0xFC,
  0x1E, 0xE0, 0xF7, 0x83, 0xDC, 0x1E, 0xF0, 0xFB, 0xC7, 0xBE, 0x1F, 0x78,
  0xF7, 0xC3, 0xCF, 0x3C, 0xF0, 0x79, 0xE7, 0x9E, 0x0F, 0x3D, 0xE3, 0xC3,
  0xE7, 0xBC, 0xF8, 0x78, 0xFF, 0x1F, 0x0F, 0x1F, 0xE3, 0xC1, 0xE3, 0xF8,
  0x78, 0x7C, 0x7F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE1, 0xE1, 0xF8, 0x7C, 0x3C,
  0x3E, 0x0F, 0x07, 0x87, 0xC1, 0xE0, 0x0F, 0xC0, 0x3E, 0x1F, 0xC0, 0x78,
  0x3F, 0x80, 0xF0, 0x7F, 0x01, 0xE0, 0xFE, 0x07, 0xC3, 0xFE, 0x0F, 0x87,
  0xBC, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0xF8, 0xF8, 0x3D, 0xF1, 0xF0, 0xF9,
  0xE3, 0xE1, 0xF3, 0xC7, 0x83, 0xC7, 0xCF, 0x07, 0x8F, 0xBE, 0x0F, 0x0F,
  0x7C, 0x3E, 0x1E, 0xF0, 0x7C, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0, 0x7F,
  0x87, 0xC0, 0xFF, 0x0F, 0x81, 0xFC, 0x1E, 0x01, 0xF8, 0x3C, 0x03, 0xF0,
  0x78, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7E,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF,
  0x81, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE3, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xC0, 0x7C,
  0x00, 0x30, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7C,
  0x08, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x10, 0x0F, 0x8E, 0x0F, 0xC7, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x78, 0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x01, 0xFF, 0x81, 0xF0, 0x1E, 0xF8, 0x1F,
  0x03, 0xEF, 0x83, 0xF0, 0x3C, 0xF8, 0x3F, 0x07, 0xCF, 0x87, 0xF0, 0x7C,
  0xF8, 0x7F, 0x07, 0x8F, 0x87, 0xF0, 0xF8, 0xF8, 0xFF, 0x0F, 0x0F, 0x8F,
  0xF1, 0xF0, 0xF9, 0xEF, 0x1F, 0x0F, 0x9E, 0xF3, 0xE0, 0xFB, 0xCF, 0x3E,
  0x0F, 0x3C, 0xF3, 0xC0, 0xF3, 0xCF, 0x7C, 0x0F, 0x78, 0xF7, 0x80, 0xF7,
  0x8F, 0x78, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3D, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0xF8, 0x0F, 0xFE, 0x07, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F,
  0x1F, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xE3, 0xC7, 0x8F, 0x1E, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x0F, 0x3C,
  0x0F, 0x1E, 0x07, 0x87, 0x07, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF3, 0xC0,
  0x3B, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF1, 0xF1, 0xE1, 0xE0,
  0x03, 0xC7, 0x83, 0xFB, 0xC3, 0xFD, 0xE3, 0xFF, 0xF3, 0xF3, 0xF1, 0xF0,
  0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x3E, 0x07, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xDE, 0x0F, 0xDE, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x3C, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x78,
  0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x83, 0xE7,
  0xC1, 0xF3, 0xF1, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x79, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xF0, 0x87, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x04, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x3C, 0x07, 0xEF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0x9F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xBC,
  0x07, 0xE7, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x1F, 0x3E, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x08, 0x7E, 0x38, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0xFE, 0xF0, 0x7F, 0xBC, 0x3F, 0xFF, 0x1F,
  0x9F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xF3, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x08, 0x0F, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x3C, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE3, 0xF9, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x00, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x00, 0x18, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x3C, 0x7C, 0x0F, 0x9F,
  0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0x0F, 0x1E,
  0x0F, 0x03, 0xDF, 0xC7, 0xF0, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F,
  0xCF, 0xE7, 0xC7, 0xE3, 0xF0, 0xF1, 0xF0, 0xF8, 0x3C, 0x7C, 0x3E, 0x0F,
  0x1E, 0x0F, 0x87, 0xCF, 0x83, 0xC1, 0xF3, 0xE0, 0xF0, 0x7C, 0xF8, 0x7C,
  0x1E, 0x3C, 0x1F, 0x0F, 0x9F, 0x07, 0xC3, 0xE7, 0xC1, 0xE0, 0xF9, 0xF0,
  0xF8, 0x3E, 0x7C, 0x3E, 0x0F, 0x1E, 0x0F, 0x87, 0xCF, 0x83, 0xC1, 0xF0,
  0x0F, 0x1E, 0x07, 0xBF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0xF8, 0xFC,
  0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7,
  0xC1, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x3E,
  0x3C, 0x1F, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x3F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0x8F, 0x01, 0xEF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x3C,
  0x0F, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x0F,
  0x8F, 0x83, 0xE3, 0xF1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x7F, 0x07,
  0xCF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x83, 0xFB,
  0xC3, 0xFD, 0xE3, 0xFF, 0xF3, 0xF3, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7,
  0xC1, 0xE3, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x9E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x1E, 0x1E, 0xF8, 0x3D, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3E, 0x08, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE8, 0x1F, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0,
  0x1F, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x78, 0xF0, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F,
  0x07, 0xC7, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xDE, 0x0F, 0xCF, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x79, 0xF0, 0x79,
  0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1E, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x3E, 0xF1, 0xFE,
  0x3C, 0xF1, 0xFE, 0x7C, 0xF1, 0xDE, 0x78, 0xF3, 0xDE, 0xF8, 0xF3, 0x9E,
  0xF0, 0xF7, 0x9F, 0xF0, 0xF7, 0x9D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0,
  0x3C, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFB, 0xC0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0, 0x3E, 0x1F, 0x07, 0xE1,
  0xF0, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0,
  0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xBC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x7F,
  0x01, 0xF8, 0x07, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x07,
  0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x00, 0x3C, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 13, 9, 15, 3, -24 },
  { 46, 20, 24, 20, 0, -24 },
  { 106, 16, 28, 17, 1, -26 },
  { 162, 24, 25, 27, 2, -25 },
  { 237, 20, 25, 22, 1, -25 },
  { 300, 6, 9, 9, 3, -24 },
  { 307, 12, 29, 11, 1, -24 },
  { 351, 12, 30, 11, -2, -25 },
  { 396, 15, 16, 17, 3, -26 },
  { 426, 15, 16, 18, 2, -20 },
  { 456, 8, 8, 9, -2, -4 },
  { 464, 9, 4, 11, 1, -11 },
  { 469, 6, 5, 9, 0, -5 },
  { 473, 18, 25, 14, -2, -25 },
  { 530, 16, 25, 17, 1, -25 },
  { 580, 13, 24, 17, 3, -24 },
  { 619, 18, 25, 17, -1, -25 },
  { 676, 17, 25, 17, 0, -25 },
  { 730, 17, 24, 17, 0, -24 },
  { 781, 17, 24, 17, 0, -24 },
  { 832, 17, 25, 17, 1, -25 },
  { 886, 18, 24, 17, 1, -24 },
  { 940, 16, 25, 17, 1, -25 },
  { 990, 16, 25, 17, 1, -25 },
  { 1040, 9, 19, 9, 0, -19 },
  { 1062, 11, 23, 9, -2, -19 },
  { 1094, 15, 17, 18, 2, -21 },
  { 1126, 15, 10, 18, 2, -17 },
  { 1145, 15, 17, 18, 2, -21 },
  { 1177, 13, 25, 14, 2, -25 },
  { 1218, 25, 27, 27, 1, -24 },
  { 1303, 19, 24, 19, -2, -24 },
  { 1360, 18, 24, 19, 1, -24 },
  { 1414, 18, 25, 19, 2, -25 },
  { 1471, 19, 24, 21, 1, -24 },
  { 1528, 17, 24, 17, 1, -24 },
  { 1579, 17, 24, 16, 1, -24 },
  { 1630, 20, 25, 21, 2, -25 },
  { 1693, 21, 24, 22, 1, -24 },
  { 1756, 15, 24, 12, -1, -24 },
  { 1801, 16, 31, 10, -5, -24 },
  { 1863, 21, 24, 19, 1, -24 },
  { 1926, 13, 24, 16, 1, -24 },
  { 1965, 27, 24, 28, 1, -24 },
  { 2046, 23, 24, 23, 1, -24 },
  { 2115, 20, 25, 23, 2, -25 },
  { 2178, 18, 24, 19, 1, -24 },
  { 2232, 20, 31, 23, 2, -25 },
  { 2310, 18, 24, 19, 1, -24 },
  { 2364, 17, 25, 17, 0, -25 },
  { 2418, 16, 24, 16, 3, -24 },
  { 2466, 20, 24, 21, 2, -24 },
  { 2526, 19, 24, 19, 3, -24 },
  { 2583, 28, 24, 28, 3, -24 },
  { 2667, 23, 24, 19, -2, -24 },
  { 2736, 18, 24, 17, 3, -24 },
  { 2790, 19, 24, 16, -1, -24 },
  { 2847, 14, 29, 11, -1, -24 },
  { 2898, 7, 25, 14, 4, -25 },
  { 2920, 14, 29, 11, -2, -24 },
  { 2971, 17, 15, 17, 0, -24 },
  { 3003, 13, 2, 13, -3, 3 },
  { 3007, 7, 5, 11, 5, -26 },
  { 3012, 17, 19, 19, 1, -19 },
  { 3053, 17, 26, 19, 0, -26 },
  { 3109, 15, 19, 15, 1, -19 },
  { 3145, 19, 26, 19, 1, -26 },
  { 3207, 16, 19, 17, 1, -19 },
  { 3245, 19, 34, 12, -4, -26 },
  { 3326, 18, 27, 19, 0, -19 },
  { 3387, 17, 26, 19, 0, -26 },
  { 3443, 10, 26, 9, 0, -26 },
  { 3476, 14, 34, 9, -4, -26 },
  { 3536, 19, 26, 18, 0, -26 },
  { 3598, 11, 26, 9, 0, -26 },
  { 3634, 26, 19, 28, 0, -19 },
  { 3696, 17, 19, 19, 0, -19 },
  { 3737, 16, 19, 18, 1, -19 },
  { 3775, 18, 27, 19, -1, -19 },
  { 3836, 17, 27, 19, 1, -19 },
  { 3894, 15, 19, 13, 0, -19 },
  { 3930, 14, 19, 15, 0, -19 },
  { 3964, 11, 23, 12, 2, -23 },
  { 3996, 17, 19, 19, 1, -19 },
  { 4037, 16, 19, 16, 2, -19 },
  { 4075, 24, 19, 25, 2, -19 },
  { 4132, 20, 19, 17, -2, -19 },
  { 4180, 20, 27, 16, -2, -19 },
  { 4248, 16, 19, 14, -1, -19 },
  { 4286, 14, 29, 12, 0, -24 },
  { 4337, 4, 34, 17, 6, -26 },
  { 4354, 14, 29, 12, -2, -24 },
  { 4405, 15, 6, 18, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC34PT7B_H_
