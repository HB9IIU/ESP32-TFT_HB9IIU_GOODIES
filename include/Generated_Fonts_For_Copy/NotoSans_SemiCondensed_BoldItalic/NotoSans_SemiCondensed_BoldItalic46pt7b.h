#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0x40,
  0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3,
  0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x7C, 0x03, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x80, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x0F, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xDC, 0xF0,
  0x3F, 0x38, 0x40, 0xFE, 0x60, 0x01, 0xFC, 0xC0, 0x03, 0xFB, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0D,
  0xFC, 0x00, 0x39, 0xF8, 0x00, 0x73, 0xF1, 0x00, 0xE7, 0xE3, 0x81, 0x9F,
  0xC7, 0xC7, 0x7F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x1F, 0xFC, 0x01, 0xF0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x0F,
  0x80, 0xFC, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0xF8,
  0x00, 0xF8, 0xF9, 0xF1, 0xFC, 0xF9, 0xF9, 0xF3, 0xFE, 0xF9, 0xF3, 0xE7,
  0xFF, 0xFF, 0xF7, 0xCF, 0xFF, 0xFF, 0xE7, 0xCF, 0x9F, 0x7F, 0xCF, 0x9F,
  0x1F, 0x3F, 0x9F, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x1F, 0x00, 0x3E, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x3E,
  0x1F, 0x01, 0xF0, 0x7E, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x03, 0xE0, 0x7E,
  0x7E, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x3F, 0xFC, 0x0F, 0x80, 0x3F,
  0xF8, 0x1F, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0xFF, 0xF0, 0x7E,
  0x1F, 0xFF, 0x8F, 0xE3, 0xFB, 0xF8, 0xFC, 0x7F, 0x1F, 0xDF, 0xC7, 0xE1,
  0xFD, 0xF8, 0xFE, 0x0F, 0xFF, 0x8F, 0xE0, 0xFF, 0xF0, 0xFE, 0x07, 0xFE,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xF7,
  0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xDF, 0xBF, 0x7C,
  0xF9, 0xF3, 0xC7, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x7A, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x60,
  0x78, 0x07, 0x8F, 0x80, 0x7E, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x10, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xF3, 0xE0, 0x7E, 0x3E, 0x03, 0xE3, 0xF0, 0x0C, 0x1F,
  0x00, 0x41, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7E,
  0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xBF, 0x0F, 0x1F, 0x87, 0x0F, 0xC1,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x03, 0xF9, 0xFF, 0x03, 0xE0, 0x7F, 0x01, 0xC0, 0x7F, 0x01, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7C, 0x3F, 0xC0, 0x60, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE2, 0x00, 0x1F, 0xC7, 0x80, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xFD, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF8, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0xC0, 0x0F, 0xF0, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x20, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x3F, 0x81, 0xFB, 0xFF, 0x07, 0xEF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x7F, 0x7F,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F,
  0xF3, 0xF0, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFE, 0xFC, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x20, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x3E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x30,
  0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0x07, 0xF3, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x7F, 0xD3, 0xE1, 0xF0, 0x7F, 0xF8,
  0x78, 0xF8, 0x3F, 0xFE, 0x1E, 0x3E, 0x1F, 0xFF, 0x87, 0xDF, 0x07, 0xC3,
  0xE1, 0xF7, 0xC3, 0xE0, 0xF0, 0x79, 0xE1, 0xF0, 0x7C, 0x1E, 0xF8, 0x7C,
  0x1F, 0x07, 0xBE, 0x1E, 0x07, 0xC3, 0xEF, 0x8F, 0x81, 0xE0, 0xFB, 0xC3,
  0xE0, 0xF8, 0x3C, 0xF0, 0xF8, 0x3E, 0x1F, 0x3C, 0x3E, 0x0F, 0x87, 0xCF,
  0x0F, 0x87, 0xC3, 0xE3, 0xC3, 0xE3, 0xF9, 0xF8, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3E, 0x1F, 0xF7, 0xFE, 0x0F, 0x87, 0xF9, 0xFF, 0x03, 0xE0, 0x7C, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xC0, 0x7F, 0x80, 0x60, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x02, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8,
  0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0xFF,
  0x87, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0x01, 0xFF, 0x00, 0x60, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0x07, 0xFF, 0x8F, 0xE0, 0xFF, 0xF3, 0xF8,
  0x1F, 0xFC, 0x7F, 0x03, 0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x83, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0xC0, 0xFD, 0xF0, 0x3E, 0xFC, 0x07, 0xEF, 0x81, 0xF7, 0xE0,
  0x3E, 0x7C, 0x1F, 0xBF, 0x03, 0xF3, 0xE0, 0xF9, 0xF8, 0x1F, 0x9F, 0x0F,
  0xCF, 0xC0, 0xFC, 0xF8, 0x7C, 0xFC, 0x07, 0xE7, 0xC7, 0xE7, 0xE0, 0x3E,
  0x3E, 0x3E, 0x3F, 0x03, 0xF1, 0xF3, 0xF1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F,
  0xC0, 0xFC, 0x7D, 0xF8, 0xFC, 0x07, 0xE3, 0xEF, 0x87, 0xE0, 0x3E, 0x1F,
  0xFC, 0x3F, 0x03, 0xF0, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xFE, 0x1F, 0x80,
  0xFC, 0x3F, 0xE0, 0xFC, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0xFC,
  0x0F, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0,
  0xFF, 0xE0, 0x1F, 0x81, 0xFF, 0xC0, 0x3F, 0x03, 0xFF, 0x80, 0x7E, 0x07,
  0xFF, 0x01, 0xF8, 0x0F, 0xBF, 0x03, 0xF0, 0x3F, 0x7E, 0x07, 0xE0, 0x7E,
  0xFC, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0x81, 0xF9, 0xF8, 0x7E, 0x03, 0xE3,
  0xF0, 0xFC, 0x0F, 0xC7, 0xE1, 0xF8, 0x1F, 0x8F, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x9F, 0x80, 0xFC, 0x3F, 0x3F, 0x03, 0xF0, 0x3F,
  0x7E, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x1F, 0x81, 0xFB,
  0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x07, 0xFF,
  0x03, 0xF0, 0x0F, 0xFC, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xF0,
  0x3F, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x81, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x8F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xE3, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xFC,
  0x3F, 0x03, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x81, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xE3, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF3,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFE, 0xFC, 0x07, 0xF0, 0x08, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x80, 0x07, 0xE0, 0x60, 0x0F, 0xE0, 0x7C, 0x3F, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0x00, 0xFE, 0xFC, 0x03, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xF0, 0x1F,
  0xCF, 0xC0, 0x7F, 0xC0, 0x7E, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0xFC, 0x07,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC1, 0xFC,
  0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83, 0xF0, 0xFD,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x3F, 0x0F, 0x9F, 0x1F, 0xC0,
  0xFC, 0x7E, 0x7C, 0x7E, 0x03, 0xF1, 0xF1, 0xF1, 0xF8, 0x0F, 0xCF, 0xC7,
  0xCF, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x7D, 0xF8, 0x03,
  0xF7, 0xE1, 0xF7, 0xE0, 0x0F, 0xDF, 0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0x78, 0x3E, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF8, 0xFE, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x3E,
  0x00, 0x20, 0x00, 0x03, 0xF8, 0xFC, 0x1F, 0xF9, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F,
  0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE3, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xEF, 0xC0,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x40, 0x03, 0xF3, 0xF8,
  0x07, 0xF7, 0xFC, 0x07, 0xEF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7D, 0xFF, 0xE0, 0x7C, 0xFF, 0x80, 0xFC, 0x7F, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xF0, 0x21, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0x0F,
  0xF0, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0xFF, 0xDF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xC0, 0x1F, 0xF3, 0xE0,
  0x07, 0xF3, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x3F,
  0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0x8F, 0xF9, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFC, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x9F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x7F, 0xE7,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE,
  0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xE0, 0x1F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x02, 0x00, 0x7F, 0x01, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x80, 0x0F, 0xCF, 0xE0, 0x3F, 0xBF, 0xE0, 0x7E, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x0F, 0xF0, 0x7E,
  0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE3, 0xF8, 0x1F, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x9F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x7E,
  0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x00,
  0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x3E, 0x3F, 0x83, 0xFC, 0x07, 0xCF, 0xFC, 0x7F, 0xE0, 0x7D,
  0xFF, 0xCF, 0xFE, 0x07, 0xDF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x87, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x07, 0xE1, 0xFC,
  0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x0F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0xC3, 0xF0,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xC7, 0xF0,
  0x1F, 0x1F, 0xF0, 0x3E, 0x7F, 0xF0, 0x7D, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFE, 0x3F, 0x87, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xE0, 0x00, 0x08, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x03, 0xF9, 0xF8,
  0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3E, 0x3F,
  0x80, 0x1F, 0xBF, 0xF0, 0x07, 0xDF, 0xFC, 0x01, 0xF7, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F,
  0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xE0,
  0x1F, 0xBF, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xF8,
  0xFC, 0x0F, 0xF9, 0xF0, 0x7F, 0xFB, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x8F, 0xF1, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1,
  0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xF7, 0xE0, 0x7F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x3E, 0x07,
  0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFE, 0x3C, 0x1F, 0xC0, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x88, 0x03,
  0xF8, 0xE0, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x7F, 0x87, 0xF1,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xF3,
  0xE0, 0x3F, 0x87, 0xC0, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F,
  0xC0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xBF, 0x07, 0xFC,
  0x1F, 0xDF, 0x83, 0xFC, 0x0F, 0xCF, 0xC1, 0xFE, 0x0F, 0xE7, 0xE1, 0xFF,
  0x07, 0xE3, 0xF0, 0xFF, 0x87, 0xF1, 0xF8, 0xFB, 0xC3, 0xF0, 0xFC, 0x7D,
  0xE1, 0xF8, 0x7E, 0x3E, 0xF1, 0xF8, 0x3F, 0x3E, 0x78, 0xFC, 0x1F, 0x9F,
  0x3C, 0xFC, 0x0F, 0xDF, 0x1E, 0x7E, 0x07, 0xEF, 0x8F, 0x3F, 0x03, 0xF7,
  0xC7, 0xBF, 0x01, 0xFF, 0xC3, 0xDF, 0x80, 0xFF, 0xE3, 0xEF, 0x80, 0x7D,
  0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x23, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xD0, 0x00,
  0x30,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 34, 13, 0, -33 },
  { 61, 17, 12, 20, 4, -33 },
  { 87, 27, 33, 27, 1, -33 },
  { 199, 23, 38, 23, 1, -35 },
  { 309, 32, 33, 37, 3, -33 },
  { 441, 28, 33, 29, 1, -33 },
  { 557, 7, 12, 12, 5, -33 },
  { 568, 17, 40, 14, 1, -33 },
  { 653, 16, 40, 15, -3, -33 },
  { 733, 20, 21, 23, 4, -35 },
  { 786, 21, 22, 24, 2, -27 },
  { 844, 10, 12, 12, -2, -6 },
  { 859, 12, 6, 14, 1, -15 },
  { 868, 8, 8, 12, 0, -7 },
  { 876, 24, 33, 19, -2, -33 },
  { 975, 22, 33, 23, 1, -33 },
  { 1066, 17, 33, 23, 4, -33 },
  { 1137, 24, 33, 23, -1, -33 },
  { 1236, 23, 33, 23, 0, -33 },
  { 1331, 24, 33, 23, -1, -33 },
  { 1430, 24, 33, 23, 0, -33 },
  { 1529, 22, 33, 23, 2, -33 },
  { 1620, 23, 33, 23, 2, -33 },
  { 1715, 23, 33, 23, 1, -33 },
  { 1810, 22, 33, 23, 1, -33 },
  { 1901, 12, 27, 12, 0, -26 },
  { 1942, 14, 32, 12, -2, -26 },
  { 1998, 21, 23, 24, 2, -28 },
  { 2059, 21, 14, 24, 2, -23 },
  { 2096, 21, 23, 24, 2, -28 },
  { 2157, 18, 34, 19, 3, -33 },
  { 2234, 34, 37, 36, 2, -33 },
  { 2392, 26, 33, 26, -3, -33 },
  { 2500, 25, 33, 26, 1, -33 },
  { 2604, 26, 33, 25, 2, -33 },
  { 2712, 26, 33, 28, 1, -33 },
  { 2820, 23, 33, 23, 1, -33 },
  { 2915, 23, 33, 22, 1, -33 },
  { 3010, 27, 33, 29, 2, -33 },
  { 3122, 29, 33, 29, 1, -33 },
  { 3242, 21, 33, 17, -2, -33 },
  { 3329, 22, 43, 14, -7, -33 },
  { 3448, 29, 33, 26, 1, -33 },
  { 3568, 18, 33, 22, 1, -33 },
  { 3643, 37, 33, 37, 1, -33 },
  { 3796, 31, 33, 32, 1, -33 },
  { 3924, 27, 33, 30, 2, -33 },
  { 4036, 25, 33, 26, 1, -33 },
  { 4140, 27, 41, 30, 2, -33 },
  { 4279, 24, 33, 26, 1, -33 },
  { 4378, 24, 33, 22, 0, -33 },
  { 4477, 22, 33, 22, 4, -33 },
  { 4568, 27, 33, 29, 3, -33 },
  { 4680, 25, 33, 25, 4, -33 },
  { 4784, 38, 33, 38, 4, -33 },
  { 4941, 32, 33, 25, -3, -33 },
  { 5073, 24, 33, 24, 4, -33 },
  { 5172, 27, 33, 22, -2, -33 },
  { 5284, 19, 40, 14, -1, -33 },
  { 5379, 10, 33, 19, 5, -33 },
  { 5421, 19, 40, 14, -3, -33 },
  { 5516, 23, 21, 23, 0, -33 },
  { 5577, 18, 3, 17, -4, 4 },
  { 5584, 9, 7, 14, 7, -35 },
  { 5592, 23, 26, 25, 2, -26 },
  { 5667, 24, 35, 25, 0, -35 },
  { 5772, 19, 26, 20, 2, -26 },
  { 5834, 25, 35, 25, 2, -35 },
  { 5944, 20, 26, 23, 2, -26 },
  { 6009, 26, 46, 16, -5, -35 },
  { 6159, 25, 37, 25, 0, -26 },
  { 6275, 23, 35, 25, 0, -35 },
  { 6376, 14, 35, 13, 0, -35 },
  { 6438, 20, 46, 13, -6, -35 },
  { 6553, 26, 35, 24, 0, -35 },
  { 6667, 14, 35, 13, 0, -35 },
  { 6729, 36, 26, 38, 0, -26 },
  { 6846, 23, 26, 25, 0, -26 },
  { 6921, 21, 26, 25, 2, -26 },
  { 6990, 26, 37, 25, -2, -26 },
  { 7111, 23, 37, 25, 2, -26 },
  { 7218, 20, 26, 18, 0, -26 },
  { 7283, 20, 26, 20, 0, -26 },
  { 7348, 16, 30, 17, 2, -30 },
  { 7408, 23, 25, 25, 2, -25 },
  { 7480, 22, 25, 22, 2, -25 },
  { 7549, 33, 25, 33, 3, -25 },
  { 7653, 27, 25, 22, -2, -25 },
  { 7738, 27, 36, 22, -3, -25 },
  { 7860, 21, 25, 19, -1, -25 },
  { 7926, 19, 40, 16, 0, -33 },
  { 8021, 5, 45, 22, 9, -35 },
  { 8050, 18, 40, 16, -2, -33 },
  { 8140, 21, 8, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC46PT7B_H_
