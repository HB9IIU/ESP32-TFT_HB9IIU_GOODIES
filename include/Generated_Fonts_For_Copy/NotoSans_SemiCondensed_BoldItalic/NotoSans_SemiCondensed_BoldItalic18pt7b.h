#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x60, 0x06, 0x38, 0xE0, 0xEF,
  0x3C, 0xF6, 0xD8, 0x06, 0xC1, 0x98, 0x36, 0x06, 0xC7, 0xFE, 0x32, 0x06,
  0xC0, 0x98, 0xFF, 0xC6, 0xC0, 0xD8, 0x33, 0x06, 0xC0, 0x02, 0x01, 0x07,
  0xE7, 0xF3, 0x49, 0xA0, 0xF0, 0x3E, 0x0F, 0x05, 0xA2, 0xDF, 0xEF, 0xE0,
  0x80, 0x40, 0x38, 0x73, 0xE3, 0x1B, 0x31, 0x9B, 0x0C, 0xD8, 0x6D, 0xBB,
  0xFB, 0xEE, 0xDB, 0x0D, 0x98, 0xCC, 0xC6, 0x6C, 0x63, 0xE6, 0x0E, 0x00,
  0x0F, 0x03, 0xF0, 0x66, 0x0C, 0xC1, 0xB8, 0x3E, 0x0F, 0x1B, 0xF7, 0x67,
  0xDC, 0xFB, 0x8E, 0x3F, 0xC7, 0xDC, 0xFB, 0x6C, 0x0E, 0x18, 0x61, 0xC3,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x18, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x8E, 0x31, 0xC6, 0x30, 0x0C, 0x0C,
  0x6C, 0xFF, 0x1F, 0x3C, 0x7C, 0x26, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x37, 0x6E, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xE0, 0x00, 0x0F, 0x0F, 0xCE, 0xE6, 0x37, 0x1B, 0x9D, 0x8E, 0xC7, 0x63,
  0x73, 0x99, 0xCF, 0xC3, 0xC0, 0x0C, 0xF7, 0xFF, 0xD8, 0x63, 0x8E, 0x38,
  0xC3, 0x1C, 0x70, 0x0F, 0x87, 0xF1, 0x9C, 0x47, 0x01, 0xC0, 0x60, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0x1F, 0xC4, 0xE0,
  0x70, 0x38, 0xF8, 0x70, 0x0E, 0x03, 0x01, 0xA1, 0xDF, 0xCF, 0xC0, 0x03,
  0x83, 0xC1, 0xE1, 0xE1, 0xB1, 0xD8, 0xDC, 0xCE, 0xFF, 0xFF, 0x83, 0x81,
  0xC0, 0xC0, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0x01, 0xF1, 0xFC, 0x0E, 0x03,
  0x03, 0xA1, 0xDF, 0xCF, 0xC0, 0x0F, 0x1F, 0x38, 0x70, 0x60, 0xFE, 0xFE,
  0xE7, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0xE0,
  0x70, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x00, 0x0F, 0x0F, 0xCE,
  0x66, 0x33, 0xB8, 0xF8, 0x78, 0xEE, 0x63, 0x71, 0xB8, 0xCF, 0xE7, 0xE0,
  0x1F, 0x1F, 0x8C, 0xEE, 0x77, 0x3B, 0x9D, 0xFE, 0x7E, 0x03, 0x03, 0x83,
  0x9F, 0x8F, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x71, 0xC6, 0x38, 0x01, 0x07, 0x1E, 0x78, 0xE0,
  0xF8, 0x3E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x1F, 0x78, 0xE0, 0x80, 0x3C, 0xFD, 0x18, 0x30, 0xE3, 0x8E,
  0x38, 0x60, 0x01, 0x87, 0x0E, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x0C, 0xC0,
  0x36, 0x7D, 0xE6, 0x4F, 0x66, 0x7B, 0x33, 0x99, 0xB4, 0xDF, 0xB7, 0xF9,
  0x80, 0x06, 0x08, 0x1F, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x1F,
  0x0D, 0xC3, 0x71, 0xDC, 0x67, 0x3F, 0xCF, 0xF7, 0x0D, 0x83, 0xE0, 0xC0,
  0x1F, 0x87, 0xF3, 0x9C, 0xE3, 0x39, 0xCF, 0xE3, 0xF1, 0xCE, 0x71, 0x9C,
  0x66, 0x39, 0xFC, 0xFE, 0x00, 0x0F, 0x87, 0xF3, 0x89, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x11, 0xF8, 0x3E, 0x00, 0x1F, 0x03,
  0xF8, 0xE7, 0x1C, 0x73, 0x8E, 0x61, 0xCC, 0x3B, 0x86, 0x71, 0xCE, 0x39,
  0x9E, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE3, 0x80, 0xE0, 0x38, 0x0F, 0xC3,
  0xF1, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE3,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0xF1, 0xFC, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x00, 0x0F, 0xC7, 0xF3, 0x8D, 0xC0, 0x70, 0x38, 0x0E, 0x7F, 0x9E,
  0xE1, 0xB8, 0xEE, 0x39, 0xFC, 0x3F, 0x00, 0x1C, 0x71, 0x86, 0x38, 0x63,
  0x8E, 0x38, 0xE3, 0xFE, 0x3F, 0xC7, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0xC6,
  0x18, 0xE3, 0x80, 0x1F, 0x8F, 0x83, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x0C, 0x0E, 0x0F, 0x8F, 0xC0, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE2, 0xF1, 0xF0,
  0xF0, 0x00, 0x1C, 0x71, 0x8E, 0x19, 0xC3, 0xB8, 0x3F, 0x03, 0x60, 0x3E,
  0x07, 0xE0, 0x77, 0x07, 0x70, 0x63, 0x06, 0x38, 0xE3, 0x80, 0x1C, 0x30,
  0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0xFF, 0xE0, 0x1C, 0x1E,
  0x38, 0x3C, 0x70, 0xF1, 0xF1, 0xE3, 0x66, 0xC6, 0xCF, 0x8D, 0xB7, 0x3B,
  0x6C, 0x77, 0x98, 0xCF, 0x31, 0x9C, 0xE3, 0x39, 0x8E, 0x63, 0x00, 0x1C,
  0x38, 0xE1, 0x8F, 0x8C, 0x7C, 0x63, 0x67, 0x1B, 0x30, 0xDD, 0x8E, 0x6C,
  0x73, 0x63, 0x1F, 0x18, 0xF0, 0xC3, 0x8E, 0x1C, 0x00, 0x0F, 0x83, 0xF8,
  0xE7, 0x38, 0x66, 0x0F, 0xC1, 0xB8, 0x37, 0x0E, 0xE1, 0xDC, 0x33, 0x8E,
  0x3F, 0x83, 0xE0, 0x1F, 0x07, 0xF3, 0x9C, 0xE3, 0x38, 0xCC, 0x73, 0xF9,
  0xFC, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xE7,
  0x38, 0x66, 0x0F, 0xC1, 0xB8, 0x37, 0x0E, 0xE1, 0xDC, 0x33, 0x8E, 0x3F,
  0x83, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x1F, 0x07, 0xE1, 0x9C, 0xE7, 0x39,
  0xCC, 0x63, 0xF9, 0xF8, 0x77, 0x1D, 0xC6, 0x31, 0x8E, 0xE3, 0x80, 0x0F,
  0x9F, 0xCE, 0x46, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xA1, 0x9F,
  0xCF, 0xC0, 0x7F, 0xBF, 0xE7, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x1C, 0x0E, 0x07, 0x00, 0x38, 0xE6, 0x19, 0xC3, 0x38, 0xE7, 0x1C,
  0xC3, 0x18, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0x9C, 0x7F, 0x87, 0xE0, 0xC1,
  0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x73, 0x31, 0xB8, 0xD8, 0x6C, 0x3C, 0x1E,
  0x0E, 0x00, 0xC3, 0x0F, 0x1C, 0x7C, 0x71, 0xB3, 0xC6, 0xCF, 0x3B, 0x3C,
  0xCD, 0xB7, 0x36, 0xD8, 0xF3, 0x63, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3,
  0x80, 0x1C, 0x71, 0xCE, 0x0C, 0xE0, 0xDC, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x03, 0xB8, 0x33, 0x87, 0x18, 0xE1, 0xC0, 0xC3, 0xE3, 0xB9,
  0x9D, 0xC6, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x00,
  0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x3F, 0xCF, 0xF0, 0x1E, 0x3C, 0xE1, 0x83, 0x06, 0x0C,
  0x38, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x3C, 0x78, 0xCC, 0xCE, 0x66, 0x66,
  0x66, 0x73, 0x30, 0x1E, 0x3C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30,
  0x61, 0xC3, 0x06, 0x3C, 0x78, 0x06, 0x07, 0x03, 0x83, 0x61, 0xB1, 0x99,
  0x8D, 0xC3, 0xFE, 0xDD, 0x80, 0x3B, 0xBF, 0x9D, 0xDC, 0xEE, 0x76, 0x3B,
  0x19, 0x9C, 0xFE, 0x7B, 0x00, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xFC,
  0xEE, 0x63, 0x71, 0xB9, 0xD8, 0xEE, 0xEF, 0xF6, 0xF0, 0x1E, 0xFD, 0xCF,
  0x0C, 0x18, 0x30, 0x62, 0xFC, 0xF8, 0x01, 0x80, 0xC0, 0x60, 0x73, 0xBB,
  0xF9, 0x9D, 0xCE, 0xC7, 0x63, 0xB1, 0x99, 0xCF, 0xE7, 0xB0, 0x1E, 0x7F,
  0x67, 0xE7, 0xFE, 0xFC, 0xC0, 0xC0, 0xFC, 0x7C, 0x01, 0xC1, 0xF0, 0x74,
  0x18, 0x0F, 0x87, 0xE0, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x00, 0x1D, 0xCF, 0xE3, 0xB9, 0xCE,
  0x73, 0x98, 0xE6, 0x31, 0x9C, 0x7F, 0x1F, 0xC0, 0x60, 0x18, 0xFE, 0x3F,
  0x00, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0xE6, 0x63, 0x73, 0xB9,
  0xD8, 0xCC, 0x6E, 0x37, 0x38, 0x18, 0xC6, 0x03, 0x9C, 0xC6, 0x73, 0x98,
  0xCE, 0x70, 0x06, 0x07, 0x06, 0x00, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x39, 0xCC, 0xE3, 0x70, 0xF8, 0x7C, 0x1F, 0x87, 0xE1, 0x98, 0xE7,
  0x39, 0xC0, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0xE3,
  0x80, 0x37, 0x38, 0xFF, 0xF3, 0xBD, 0xCC, 0x67, 0x73, 0x9D, 0xCE, 0x76,
  0x31, 0x98, 0xC6, 0xE7, 0x3B, 0x9C, 0xE0, 0x37, 0x1F, 0xCE, 0x66, 0x37,
  0x3B, 0x9D, 0x8C, 0xC6, 0xE3, 0x73, 0x80, 0x1E, 0x7E, 0x67, 0xE7, 0xC7,
  0xC7, 0xC7, 0xCE, 0xFE, 0x78, 0x1B, 0x87, 0xF1, 0xDC, 0x63, 0x38, 0xCE,
  0x73, 0x1C, 0xEE, 0x7F, 0x9F, 0xC7, 0x01, 0x80, 0x60, 0x38, 0x00, 0x39,
  0xBF, 0x99, 0xDC, 0xEC, 0x76, 0x3B, 0x19, 0x9C, 0xFE, 0x7F, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x37, 0x3E, 0x3E, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0x3F, 0x3E, 0x72, 0x70, 0x38, 0x1C, 0x0E, 0x8E, 0xFC, 0xF8, 0x30,
  0xC7, 0xFF, 0x61, 0x86, 0x38, 0xE3, 0x0F, 0x3C, 0x73, 0xB1, 0x98, 0xDC,
  0x6E, 0x77, 0x3B, 0x19, 0x9C, 0xFE, 0x7B, 0x00, 0xC3, 0xC7, 0xE6, 0xEE,
  0xEC, 0xFC, 0x78, 0x78, 0x70, 0x70, 0xC7, 0x3E, 0x39, 0xB3, 0xDD, 0x9E,
  0xCD, 0xB6, 0x6D, 0xF3, 0x4F, 0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x00, 0x38,
  0xE3, 0x38, 0x7E, 0x0F, 0x80, 0xE0, 0x1C, 0x07, 0x81, 0xF8, 0x73, 0x1C,
  0x70, 0x30, 0xE7, 0x38, 0xE6, 0x1D, 0xC3, 0xB0, 0x3E, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0x3F, 0x7F, 0x0E,
  0x0C, 0x1C, 0x38, 0x70, 0x60, 0xFC, 0xFC, 0x06, 0x1C, 0x70, 0xC1, 0x83,
  0x0E, 0x78, 0xE0, 0xE0, 0xC3, 0x86, 0x0E, 0x1C, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x18, 0x38, 0x30, 0x60, 0xC3, 0x87, 0x07, 0x1E, 0x30, 0xE1,
  0x83, 0x0E, 0x3C, 0x60, 0x71, 0xFF, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 6, 5, 8, 2, -13 },
  { 15, 11, 13, 11, 0, -13 },
  { 33, 9, 15, 9, 0, -14 },
  { 50, 13, 13, 14, 1, -13 },
  { 72, 11, 13, 11, 0, -13 },
  { 90, 3, 5, 5, 2, -13 },
  { 92, 7, 16, 6, 0, -13 },
  { 106, 6, 16, 6, -1, -13 },
  { 118, 8, 8, 9, 1, -14 },
  { 126, 8, 9, 10, 1, -11 },
  { 135, 4, 4, 5, -1, -2 },
  { 137, 5, 2, 6, 0, -6 },
  { 139, 3, 3, 5, 0, -3 },
  { 141, 10, 13, 7, -1, -13 },
  { 158, 9, 13, 9, 0, -13 },
  { 173, 6, 13, 9, 2, -13 },
  { 183, 10, 13, 9, -1, -13 },
  { 200, 9, 13, 9, 0, -13 },
  { 215, 9, 13, 9, 0, -13 },
  { 230, 9, 13, 9, 0, -13 },
  { 245, 8, 13, 9, 1, -13 },
  { 258, 9, 13, 9, 1, -13 },
  { 273, 9, 13, 9, 0, -13 },
  { 288, 9, 13, 9, 0, -13 },
  { 303, 5, 10, 5, 0, -10 },
  { 310, 6, 12, 5, -1, -10 },
  { 319, 8, 9, 10, 1, -11 },
  { 328, 8, 5, 10, 1, -9 },
  { 333, 8, 9, 10, 1, -11 },
  { 342, 7, 13, 7, 1, -13 },
  { 354, 13, 15, 14, 1, -13 },
  { 379, 10, 13, 10, -1, -13 },
  { 396, 10, 13, 10, 0, -13 },
  { 413, 10, 13, 10, 1, -13 },
  { 430, 11, 13, 11, 0, -13 },
  { 448, 10, 13, 9, 0, -13 },
  { 465, 10, 13, 9, 0, -13 },
  { 482, 10, 13, 11, 1, -13 },
  { 499, 12, 13, 12, 0, -13 },
  { 519, 9, 13, 6, -1, -13 },
  { 534, 9, 17, 5, -3, -13 },
  { 554, 12, 13, 10, 0, -13 },
  { 574, 7, 13, 8, 0, -13 },
  { 586, 15, 13, 15, 0, -13 },
  { 611, 13, 13, 12, 0, -13 },
  { 633, 11, 13, 12, 1, -13 },
  { 651, 10, 13, 10, 0, -13 },
  { 668, 11, 16, 12, 1, -13 },
  { 690, 10, 13, 10, 0, -13 },
  { 707, 9, 13, 9, 0, -13 },
  { 722, 9, 13, 9, 1, -13 },
  { 737, 11, 13, 11, 1, -13 },
  { 755, 9, 13, 10, 2, -13 },
  { 770, 14, 13, 15, 2, -13 },
  { 793, 12, 13, 10, -1, -13 },
  { 813, 9, 13, 9, 2, -13 },
  { 828, 11, 13, 9, -1, -13 },
  { 846, 7, 16, 6, 0, -13 },
  { 860, 4, 13, 7, 2, -13 },
  { 867, 7, 16, 6, -1, -13 },
  { 881, 9, 8, 9, 0, -13 },
  { 890, 7, 1, 7, -2, 2 },
  { 891, 3, 3, 6, 3, -14 },
  { 893, 9, 10, 10, 1, -10 },
  { 905, 9, 14, 10, 0, -14 },
  { 921, 7, 10, 8, 1, -10 },
  { 930, 9, 14, 10, 1, -14 },
  { 946, 8, 10, 9, 1, -10 },
  { 956, 10, 18, 6, -2, -14 },
  { 979, 10, 14, 10, 0, -10 },
  { 997, 9, 14, 10, 0, -14 },
  { 1013, 5, 14, 5, 0, -14 },
  { 1022, 8, 18, 5, -2, -14 },
  { 1040, 10, 14, 9, 0, -14 },
  { 1058, 6, 14, 5, 0, -14 },
  { 1069, 14, 10, 15, 0, -10 },
  { 1087, 9, 10, 10, 0, -10 },
  { 1099, 8, 10, 10, 1, -10 },
  { 1109, 10, 14, 10, -1, -10 },
  { 1127, 9, 14, 10, 1, -10 },
  { 1143, 8, 10, 7, 0, -10 },
  { 1153, 8, 10, 8, 0, -10 },
  { 1163, 6, 12, 7, 1, -12 },
  { 1172, 9, 10, 10, 1, -10 },
  { 1184, 8, 10, 8, 1, -10 },
  { 1194, 13, 10, 13, 1, -10 },
  { 1211, 11, 10, 9, -1, -10 },
  { 1225, 11, 14, 9, -1, -10 },
  { 1245, 8, 10, 8, 0, -10 },
  { 1255, 7, 16, 6, 0, -13 },
  { 1269, 2, 18, 9, 3, -14 },
  { 1274, 7, 16, 6, -1, -13 },
  { 1288, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC18PT7B_H_
