#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8,
  0x01, 0x80, 0x00, 0x7F, 0x3F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7,
  0xC3, 0xE3, 0xE1, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0x80, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xED, 0xF0, 0x3F, 0x38, 0x60, 0x7E, 0x70,
  0x00, 0xFC, 0xE0, 0x01, 0xF9, 0xC0, 0x03, 0xFB, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x19, 0xFC, 0x00,
  0x33, 0xF8, 0x00, 0xE7, 0xF2, 0x01, 0xCF, 0xE7, 0x03, 0x9F, 0x8F, 0xC6,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x07,
  0xFC, 0x00, 0x7C, 0x07, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x80, 0x3E, 0x03,
  0xFF, 0xE0, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x00,
  0xF8, 0x7C, 0x1F, 0x00, 0xFC, 0x7E, 0x0F, 0x80, 0x7C, 0x3F, 0x0F, 0x80,
  0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC7, 0xC0,
  0x07, 0xC7, 0xE7, 0xC1, 0x83, 0xE3, 0xE3, 0xE7, 0xF9, 0xF3, 0xF3, 0xE7,
  0xFE, 0xFF, 0xF3, 0xE7, 0xFF, 0x7F, 0xFB, 0xF7, 0xFF, 0xDF, 0xF9, 0xF3,
  0xF3, 0xEF, 0xF9, 0xF3, 0xF1, 0xF1, 0xF1, 0xF9, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x7C,
  0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x0F, 0x80, 0x7E, 0x0F, 0x87, 0xC0, 0x3E,
  0x07, 0xC7, 0xE0, 0x3E, 0x03, 0xE3, 0xE0, 0x3F, 0x01, 0xF3, 0xF0, 0x1F,
  0x00, 0xFF, 0xF0, 0x1F, 0x00, 0x3F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFC,
  0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x03, 0xF8, 0x3F, 0xF8, 0x1F, 0x87, 0xFF, 0xE1,
  0xFC, 0x7F, 0xFF, 0x0F, 0xC3, 0xF9, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xE1,
  0xF8, 0x3F, 0xFF, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x07, 0xF0,
  0x3F, 0xF8, 0x3F, 0x80, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x3F, 0x80, 0x7F, 0xE1, 0xFE, 0x00, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x20, 0x7C, 0x07,
  0x07, 0xC0, 0x7C, 0x78, 0x07, 0xF7, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xBC,
  0x03, 0xFB, 0xE0, 0x7F, 0x3E, 0x03, 0xE3, 0xF0, 0x1E, 0x1F, 0x00, 0xC1,
  0xF8, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE1,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7C, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF8, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9,
  0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x3F, 0x83, 0xF0, 0xFF, 0x07, 0xF3, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xDF, 0xC7, 0xE7, 0xF0, 0xF1,
  0xF8, 0x10, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1,
  0xFC, 0x03, 0x80, 0xFF, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xC0, 0xFF, 0x01,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x80,
  0x07, 0xF0, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xDF, 0x80, 0x07, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xE1,
  0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0xC0, 0x0F, 0xF0, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xF7, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF1, 0xF0, 0x0F, 0xEF, 0xF8, 0x1F, 0xBF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFE, 0x1F, 0xC7, 0xF8, 0x1F, 0x8F, 0xE0,
  0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xF3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE,
  0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFC,
  0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC,
  0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC7, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0x7E, 0x0F, 0xFB, 0xF8, 0x1F, 0xCF, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0xC0, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0,
  0x30, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xCF, 0xF3, 0x81, 0xFC, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0x83, 0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0xFC, 0x7C, 0x7C,
  0x1F, 0xFF, 0x1F, 0x3E, 0x0F, 0xFF, 0xC3, 0xCF, 0x87, 0xE1, 0xE0, 0xF7,
  0xC3, 0xF0, 0xF8, 0x3D, 0xF0, 0xF8, 0x3E, 0x1F, 0x78, 0x7C, 0x0F, 0x87,
  0xFE, 0x1F, 0x03, 0xC1, 0xFF, 0x87, 0xC1, 0xF0, 0x7F, 0xE3, 0xE0, 0x7C,
  0x1E, 0xF8, 0xF8, 0x1F, 0x0F, 0xBE, 0x3E, 0x0F, 0x83, 0xEF, 0x0F, 0x83,
  0xE1, 0xF3, 0xC3, 0xE1, 0xF8, 0x7C, 0xF0, 0xFC, 0xFE, 0x3E, 0x3E, 0x1F,
  0xFF, 0xFF, 0x0F, 0x87, 0xFD, 0xFF, 0xC3, 0xE0, 0xFF, 0x3F, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x07, 0xF8, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF,
  0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0x70, 0x3F, 0xE0, 0x04, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x7F,
  0xF3, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC,
  0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFE, 0x03, 0xC0, 0x7F, 0x80, 0x08, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0x7F, 0x03,
  0xFF, 0xC7, 0xF0, 0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xF8,
  0xFE, 0x07, 0xFF, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x3F,
  0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xBF, 0x03, 0xF7, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0x01, 0xF7, 0xE0, 0x3F,
  0x7C, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xC1, 0xFB,
  0xF8, 0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x3F, 0x3F, 0x01, 0xF9,
  0xF0, 0xF8, 0xFC, 0x07, 0xE7, 0xC3, 0xE3, 0xF0, 0x1F, 0x9F, 0x9F, 0x1F,
  0xC0, 0xFC, 0x7E, 0x7C, 0x7E, 0x03, 0xF1, 0xFB, 0xF1, 0xF8, 0x0F, 0xC7,
  0xEF, 0x87, 0xE0, 0x3F, 0x0F, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0xF0, 0xFE,
  0x07, 0xE0, 0xFF, 0xC3, 0xF0, 0x1F, 0x83, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x03,
  0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03,
  0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07,
  0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFC, 0x07, 0xDF, 0x80, 0xFC, 0x0F,
  0xDF, 0x81, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F,
  0xCF, 0xC1, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0x87, 0xE3, 0xF8, 0x1F,
  0x87, 0xE3, 0xF0, 0x1F, 0x87, 0xE3, 0xF0, 0x1F, 0x87, 0xF3, 0xF0, 0x1F,
  0x83, 0xF3, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0x3F,
  0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xE0, 0x7E,
  0x01, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xC0, 0x7E,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x87, 0xF0,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE7, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0x07, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x03, 0xFE, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0x8F, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x1C, 0x07, 0xF0, 0x04, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x07, 0xF0, 0x60, 0x0F, 0xF0, 0x7E,
  0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xE7, 0xE0,
  0x00, 0xFB, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0,
  0x1F, 0x9F, 0x80, 0x7F, 0x80, 0x7F, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x7E,
  0x01, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3F, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0xE0, 0x7E, 0x0F,
  0xC1, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x3F, 0x07, 0xDF,
  0x07, 0xE0, 0x7E, 0x1F, 0xBE, 0x1F, 0xC0, 0xFC, 0x3E, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0xFC, 0xFE, 0x03, 0xF1, 0xF1, 0xF9, 0xF8, 0x07, 0xE7, 0xE3,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC7, 0xCF, 0xC0, 0x1F, 0x9F, 0x0F, 0x9F, 0x80,
  0x3F, 0x7E, 0x1F, 0x7F, 0x00, 0x7E, 0xF8, 0x3E, 0xFC, 0x00, 0xFD, 0xF0,
  0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFE,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF8,
  0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0xC0,
  0x1F, 0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x02, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x3E, 0x0F, 0x00, 0xFC, 0x3E, 0x07, 0xFC, 0xFC, 0x1F, 0xFD, 0xF8,
  0x7F, 0xFB, 0xF1, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F,
  0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x01,
  0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFB, 0xE0,
  0x3F, 0xE7, 0xC0, 0x3F, 0x8F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF1, 0xF0, 0x03, 0xF7, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7C, 0xFF, 0xC0, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x3C, 0x3F, 0xC0, 0x43,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x10, 0xFF, 0x0E, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x7F, 0xCF,
  0xC0, 0x7F, 0xF7, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xCF,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xE0, 0x0F, 0xF9, 0xF0,
  0x03, 0xF8, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xE1, 0xFC, 0xFE, 0x07, 0xE7, 0xE0,
  0x3F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0x9F, 0x83, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x18, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x60, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x23, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0x80, 0x7F, 0xCF, 0xC0, 0x7F, 0xF7, 0xE0, 0x7F, 0xFB, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0xFF,
  0x03, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFB, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x7F, 0x81, 0xE0,
  0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x09, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x1F, 0xE0,
  0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F,
  0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x07,
  0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x1F, 0x3F,
  0xE1, 0xFF, 0x01, 0xFB, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xE0,
  0x7D, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xF3, 0xFC, 0x1F, 0xE1, 0xFF,
  0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0x87, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x03, 0xE7, 0xFC,
  0x07, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xDF, 0xFF, 0x07, 0xFE, 0xFF,
  0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xF3, 0xFC, 0xFF, 0x0F, 0xE7, 0xF0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF,
  0x01, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x7F, 0xC0, 0x1F, 0xBF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7E, 0xFF, 0xE0, 0x1F, 0xBF, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x3E, 0x07, 0xFC, 0x7C, 0x1F, 0xFD, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8,
  0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xEF, 0xC0, 0x3F, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE1, 0xF0,
  0x3E, 0x7F, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFE, 0x60, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFC, 0x1C, 0x1F, 0xC0, 0x41, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x88, 0x03, 0xF8, 0xE0, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x10, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x7E,
  0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFB, 0xE0, 0x7F, 0xE7, 0xC0, 0x7F, 0x8F, 0x80,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC,
  0x07, 0xF3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x07, 0xF0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x7F, 0x01,
  0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x03, 0xFC, 0x0F,
  0xDF, 0x81, 0xFE, 0x07, 0xEF, 0xC1, 0xFF, 0x07, 0xF7, 0xE0, 0xFF, 0x83,
  0xF3, 0xF0, 0xFF, 0xC3, 0xF9, 0xF8, 0x7F, 0xE1, 0xF8, 0xFC, 0x3D, 0xF1,
  0xFC, 0x7E, 0x3E, 0xF8, 0xFC, 0x3F, 0x1F, 0x7C, 0x7E, 0x1F, 0x9F, 0x3E,
  0x7E, 0x0F, 0xCF, 0x9F, 0x3F, 0x07, 0xE7, 0xCF, 0xBF, 0x83, 0xF7, 0xC7,
  0xDF, 0x81, 0xFB, 0xE3, 0xEF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x87, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x08, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x05, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE8, 0x00, 0xFF,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 35, 13, 0, -34 },
  { 63, 17, 13, 20, 5, -34 },
  { 91, 27, 34, 27, 1, -34 },
  { 206, 23, 39, 24, 1, -36 },
  { 319, 33, 34, 38, 3, -34 },
  { 460, 29, 34, 30, 1, -34 },
  { 584, 8, 13, 12, 5, -34 },
  { 597, 17, 41, 15, 1, -34 },
  { 685, 16, 41, 15, -3, -34 },
  { 767, 20, 22, 23, 4, -36 },
  { 822, 22, 23, 25, 2, -28 },
  { 886, 11, 12, 13, -2, -6 },
  { 903, 13, 6, 15, 1, -16 },
  { 913, 8, 8, 13, 0, -7 },
  { 921, 25, 34, 19, -2, -34 },
  { 1028, 23, 34, 24, 1, -34 },
  { 1126, 18, 34, 24, 4, -34 },
  { 1203, 25, 34, 24, -1, -34 },
  { 1310, 24, 34, 24, 0, -34 },
  { 1412, 25, 34, 24, -1, -34 },
  { 1519, 24, 34, 24, 0, -34 },
  { 1621, 23, 34, 24, 2, -34 },
  { 1719, 24, 34, 24, 2, -34 },
  { 1821, 23, 34, 24, 1, -34 },
  { 1919, 22, 34, 24, 1, -34 },
  { 2013, 12, 27, 13, 0, -26 },
  { 2054, 15, 32, 13, -3, -26 },
  { 2114, 22, 24, 25, 2, -29 },
  { 2180, 22, 14, 25, 2, -24 },
  { 2219, 22, 24, 25, 2, -29 },
  { 2285, 18, 35, 19, 3, -34 },
  { 2364, 34, 38, 37, 2, -34 },
  { 2526, 27, 34, 27, -3, -34 },
  { 2641, 26, 34, 27, 1, -34 },
  { 2752, 26, 34, 26, 2, -34 },
  { 2863, 27, 34, 29, 1, -34 },
  { 2978, 24, 34, 23, 1, -34 },
  { 3080, 24, 34, 22, 1, -34 },
  { 3182, 28, 34, 30, 2, -34 },
  { 3301, 30, 34, 30, 1, -34 },
  { 3429, 22, 34, 17, -2, -34 },
  { 3523, 22, 44, 14, -7, -34 },
  { 3644, 30, 34, 26, 1, -34 },
  { 3772, 18, 34, 22, 1, -34 },
  { 3849, 38, 34, 38, 1, -34 },
  { 4011, 32, 34, 32, 1, -34 },
  { 4147, 28, 34, 31, 2, -34 },
  { 4266, 26, 34, 26, 1, -34 },
  { 4377, 28, 42, 31, 2, -34 },
  { 4524, 25, 34, 26, 1, -34 },
  { 4631, 24, 34, 23, 0, -34 },
  { 4733, 22, 34, 23, 4, -34 },
  { 4827, 27, 34, 29, 3, -34 },
  { 4942, 26, 34, 26, 4, -34 },
  { 5053, 39, 34, 39, 4, -34 },
  { 5219, 32, 34, 26, -3, -34 },
  { 5355, 24, 34, 24, 4, -34 },
  { 5457, 27, 34, 23, -2, -34 },
  { 5572, 19, 41, 15, -1, -34 },
  { 5670, 11, 34, 19, 5, -34 },
  { 5717, 19, 41, 15, -3, -34 },
  { 5815, 23, 22, 24, 0, -34 },
  { 5879, 18, 3, 17, -4, 4 },
  { 5886, 9, 8, 15, 7, -36 },
  { 5895, 23, 26, 26, 2, -26 },
  { 5970, 24, 36, 26, 0, -36 },
  { 6078, 20, 26, 21, 2, -26 },
  { 6143, 25, 36, 26, 2, -36 },
  { 6256, 21, 26, 24, 2, -26 },
  { 6325, 26, 47, 16, -5, -36 },
  { 6478, 25, 37, 26, 0, -26 },
  { 6594, 24, 36, 26, 0, -36 },
  { 6702, 14, 36, 13, 0, -36 },
  { 6765, 20, 47, 13, -6, -36 },
  { 6883, 27, 36, 24, 0, -36 },
  { 7005, 15, 36, 13, 0, -36 },
  { 7073, 37, 26, 39, 0, -26 },
  { 7194, 24, 26, 26, 0, -26 },
  { 7272, 21, 26, 25, 2, -26 },
  { 7341, 26, 37, 26, -2, -26 },
  { 7462, 23, 37, 26, 2, -26 },
  { 7569, 20, 26, 18, 0, -26 },
  { 7634, 20, 26, 20, 0, -26 },
  { 7699, 16, 31, 17, 2, -31 },
  { 7761, 23, 26, 26, 2, -26 },
  { 7836, 22, 26, 22, 3, -26 },
  { 7908, 33, 26, 34, 3, -26 },
  { 8016, 27, 26, 23, -2, -26 },
  { 8104, 28, 37, 22, -3, -26 },
  { 8234, 22, 26, 20, -1, -26 },
  { 8306, 20, 41, 16, 0, -34 },
  { 8409, 5, 47, 23, 9, -36 },
  { 8439, 19, 41, 16, -3, -34 },
  { 8537, 22, 7, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC47PT7B_H_
