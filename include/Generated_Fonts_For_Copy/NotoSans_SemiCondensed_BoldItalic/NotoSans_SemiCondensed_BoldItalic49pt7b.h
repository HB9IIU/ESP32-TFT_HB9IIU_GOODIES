#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x7F, 0x1F, 0xBF,
  0x8F, 0xDF, 0x87, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF0, 0xFD,
  0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0x7C, 0x0F, 0xE7,
  0x0C, 0x0F, 0xC7, 0x00, 0x0F, 0xC6, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xEE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3B, 0xFC, 0x00, 0x39, 0xFC, 0x00, 0x39, 0xFC, 0x80, 0x31,
  0xFC, 0xC0, 0x71, 0xF8, 0xF0, 0x73, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x0F,
  0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0xF8, 0x03, 0xE1,
  0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE3, 0xE0,
  0x01, 0xF0, 0xF8, 0xF8, 0x10, 0x3E, 0x1F, 0x3F, 0x1F, 0xC7, 0xC7, 0xE7,
  0xCF, 0xFC, 0xFD, 0xF9, 0xF3, 0xFF, 0xDF, 0xFF, 0x7E, 0x7F, 0xF9, 0xFF,
  0xCF, 0x9F, 0x9F, 0x3F, 0xF3, 0xE3, 0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x7E,
  0x00, 0x1F, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE1, 0xF8, 0x01, 0xF8, 0xFC,
  0x3E, 0x00, 0x3E, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x3F, 0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x00, 0xFF, 0xF8,
  0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x01,
  0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x07, 0xE0, 0xFF, 0xF8,
  0x3F, 0x87, 0xFF, 0xF0, 0xFE, 0x3F, 0xDF, 0xC7, 0xF1, 0xFE, 0x7F, 0x9F,
  0xC7, 0xF0, 0xFF, 0xFE, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xC3,
  0xF8, 0x0F, 0xFE, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0, 0xFF,
  0x03, 0xFE, 0x03, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xE1,
  0xFE, 0x00, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8,
  0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x10, 0x3F, 0x01, 0xE1,
  0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xBF, 0x03, 0xFC, 0xF8, 0x0F, 0xC7, 0xE0, 0x3C, 0x3F, 0x00,
  0xE0, 0xFC, 0x02, 0x07, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x00, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x04, 0x3F, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFD, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x01, 0xFE, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xDF, 0xC7, 0xE7, 0xE1,
  0xE3, 0xF8, 0x30, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0x03, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0x80, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xCF, 0xFC, 0x07, 0x01, 0xFE, 0x02, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x10, 0x00, 0x7F, 0x8C, 0x00, 0x7F, 0x87, 0xE1, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0x7C, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x10, 0x00, 0xFF, 0x0E,
  0x00, 0xFF, 0x87, 0xF3, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x06, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x87, 0x00, 0x3F, 0x3F, 0xC0, 0x7F, 0x7F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xC7, 0xF8, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81,
  0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xBF, 0x81, 0xFE, 0x7E, 0x00, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x38, 0x3F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x81,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0x80, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7C, 0x3F, 0xC6, 0x03,
  0xF9, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x1F, 0x81, 0xFF, 0xE1, 0xF1,
  0xF0, 0x3F, 0xFE, 0x1F, 0x3F, 0x07, 0xFF, 0xE1, 0xF3, 0xE0, 0xFC, 0x3E,
  0x1F, 0x7E, 0x1F, 0x87, 0xC1, 0xF7, 0xC1, 0xF0, 0x7C, 0x1F, 0x7C, 0x3E,
  0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C, 0x1E, 0xF8, 0x7C, 0x0F, 0x83, 0xEF,
  0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x0F, 0x83, 0xEF, 0x87, 0xC1, 0xF8,
  0x7C, 0xF8, 0x7C, 0x1F, 0x07, 0xCF, 0x87, 0xC3, 0xF0, 0xFC, 0xF8, 0x7C,
  0x3F, 0x0F, 0x8F, 0x87, 0xEF, 0xFB, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0x83, 0xFE, 0xFF, 0xE0, 0xF8, 0x3F, 0xC7, 0xF8, 0x0F, 0xC0, 0xF0, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1C, 0x07,
  0xF8, 0x00, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x70, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00,
  0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x3F, 0x80,
  0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x87, 0xF0, 0x1F, 0xF0,
  0x7F, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x1C, 0x07, 0xFC,
  0x00, 0x20, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0x1F, 0xC0,
  0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x3F, 0x81, 0xFF,
  0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8,
  0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0xFD,
  0xF8, 0x0F, 0xCF, 0x81, 0xFB, 0xF8, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x0F,
  0xCF, 0x83, 0xF3, 0xF0, 0x0F, 0xCF, 0x83, 0xF3, 0xF0, 0x1F, 0xCF, 0x83,
  0xE7, 0xF0, 0x1F, 0xCF, 0x87, 0xE7, 0xF0, 0x1F, 0x8F, 0x87, 0xC7, 0xE0,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE0, 0x1F, 0x8F, 0x8F, 0x87, 0xE0, 0x3F, 0x8F,
  0x9F, 0x8F, 0xE0, 0x3F, 0x0F, 0x9F, 0x0F, 0xE0, 0x3F, 0x0F, 0xBF, 0x0F,
  0xC0, 0x3F, 0x0F, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xF8,
  0x1F, 0x80, 0x7E, 0x0F, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x03, 0xF0,
  0x1F, 0xFC, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F,
  0x80, 0xFD, 0xF8, 0x1F, 0xC0, 0xFE, 0xFC, 0x0F, 0xE0, 0x7E, 0x7F, 0x07,
  0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x0F, 0xC7, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0xFE, 0x07, 0xF0, 0xFC, 0x7E, 0x03, 0xF0, 0x7E,
  0x3F, 0x01, 0xF8, 0x3F, 0x9F, 0x80, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0x07,
  0xEF, 0xE0, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80,
  0x7F, 0xF8, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xE0, 0x1F, 0xFC, 0x07, 0xE0,
  0x0F, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFC,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xE3, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x87, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF0, 0x38, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x08, 0x00, 0xFF, 0x07, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xBF,
  0x80, 0x3F, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xFC, 0x07,
  0xF1, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x7F,
  0x03, 0xFF, 0x81, 0xFC, 0x3F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF,
  0xE0, 0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x7F, 0x03, 0xF0, 0x7D, 0xF8, 0x7F,
  0x01, 0xF8, 0x7E, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x9F, 0x8F, 0xC0, 0x1F, 0x8F, 0x8F,
  0xCF, 0xE0, 0x0F, 0xCF, 0xC7, 0xE7, 0xF0, 0x07, 0xE7, 0xE3, 0xF3, 0xF0,
  0x03, 0xF7, 0xE1, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0xFD, 0xF8, 0x00, 0xFD,
  0xF0, 0x7D, 0xFC, 0x00, 0x7F, 0xF8, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x1F,
  0x7E, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x1F,
  0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE3, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x1F, 0x00, 0xFE, 0x1F, 0x03, 0xFF, 0x3F,
  0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0,
  0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7F, 0xC0, 0x3F, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xBF, 0xFC, 0x0F, 0x9F, 0xFC, 0x0F, 0xC7, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xBE, 0x3F, 0xE0, 0x43, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x01, 0x0F, 0xF8, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xBF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xBF,
  0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xEF, 0x80, 0x1F, 0xF9, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x01,
  0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x43, 0xFC, 0x07,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF1, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xC0, 0x3F, 0xF3, 0xF0, 0x1F, 0xFE, 0xFC, 0x0F,
  0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xF3, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x03, 0xFE,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x3F, 0x80, 0xE0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0xC0, 0x3F, 0x7F,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x23, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF8,
  0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03,
  0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x07, 0xE0,
  0x0F, 0x8F, 0xF8, 0x7F, 0xE0, 0x3E, 0x7F, 0xF3, 0xFF, 0x81, 0xFB, 0xFF,
  0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0xEF, 0xF0,
  0x7F, 0x83, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0xFE, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x7F, 0x01, 0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x80, 0xFC, 0x00, 0x03, 0xE1, 0xFC, 0x01, 0xF1, 0xFF, 0x00, 0xF9,
  0xFF, 0xC0, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F,
  0xCF, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE,
  0xFE, 0x0F, 0xF3, 0xFC, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x1F, 0xF0, 0x03, 0xE7, 0xFF, 0x00, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xF3, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFC, 0x03, 0xF3, 0xFF, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x01,
  0xFF, 0x3F, 0x07, 0xFF, 0xBF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF7, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F,
  0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xF9,
  0xFC, 0x0F, 0xDF, 0xE0, 0x7E, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0, 0x70, 0x7F, 0x00, 0x83, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x88, 0x01, 0xFC, 0x78,
  0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC4,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xF0, 0x7F,
  0xF3, 0xE0, 0x3F, 0xE3, 0xE0, 0x1F, 0xC3, 0xE0, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0x81, 0xF8, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xCF, 0xE0,
  0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x01, 0xFB, 0xF0,
  0x1F, 0xE0, 0x7F, 0x7E, 0x07, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0x83, 0xF9,
  0xF8, 0x3F, 0xF0, 0x7F, 0x3F, 0x07, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0xC3,
  0xF8, 0xFC, 0x3E, 0xF8, 0x7E, 0x1F, 0x87, 0xDF, 0x1F, 0xC3, 0xF1, 0xFB,
  0xE3, 0xF0, 0x7E, 0x3E, 0x7C, 0xFE, 0x0F, 0xC7, 0xCF, 0x9F, 0xC1, 0xF9,
  0xF1, 0xF3, 0xF0, 0x3F, 0x3E, 0x3E, 0xFE, 0x07, 0xEF, 0xC7, 0xDF, 0x80,
  0xFD, 0xF0, 0xFB, 0xF0, 0x1F, 0xBE, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x00,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xB0, 0x07, 0xFE, 0x40,
  0x00, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 36, 13, 0, -35 },
  { 69, 17, 13, 21, 5, -35 },
  { 97, 28, 35, 29, 1, -35 },
  { 220, 24, 40, 25, 1, -37 },
  { 340, 35, 35, 39, 3, -35 },
  { 494, 30, 35, 31, 1, -35 },
  { 626, 8, 13, 12, 5, -35 },
  { 639, 18, 43, 15, 1, -35 },
  { 736, 18, 44, 15, -4, -36 },
  { 835, 21, 23, 24, 4, -38 },
  { 896, 23, 24, 26, 2, -29 },
  { 965, 11, 12, 13, -2, -6 },
  { 982, 13, 6, 15, 1, -16 },
  { 992, 8, 9, 13, 0, -8 },
  { 1001, 26, 35, 20, -2, -35 },
  { 1115, 24, 36, 25, 1, -36 },
  { 1223, 18, 35, 25, 5, -35 },
  { 1302, 26, 35, 25, -1, -35 },
  { 1416, 25, 35, 25, 0, -35 },
  { 1526, 26, 35, 25, -1, -35 },
  { 1640, 25, 35, 25, 0, -35 },
  { 1750, 24, 36, 25, 2, -36 },
  { 1858, 25, 35, 25, 2, -35 },
  { 1968, 24, 36, 25, 1, -36 },
  { 2076, 23, 36, 25, 1, -36 },
  { 2180, 13, 28, 13, 0, -27 },
  { 2226, 16, 33, 13, -3, -27 },
  { 2292, 23, 25, 26, 2, -30 },
  { 2364, 23, 15, 26, 2, -25 },
  { 2408, 23, 25, 26, 2, -30 },
  { 2480, 19, 36, 20, 3, -35 },
  { 2566, 36, 39, 38, 2, -35 },
  { 2742, 28, 35, 28, -3, -35 },
  { 2865, 27, 35, 28, 1, -35 },
  { 2984, 27, 36, 27, 2, -36 },
  { 3106, 28, 35, 30, 1, -35 },
  { 3229, 25, 35, 24, 1, -35 },
  { 3339, 25, 35, 23, 1, -35 },
  { 3449, 29, 36, 31, 2, -36 },
  { 3580, 31, 35, 31, 1, -35 },
  { 3716, 23, 35, 18, -2, -35 },
  { 3817, 24, 45, 15, -8, -35 },
  { 3952, 31, 35, 27, 1, -35 },
  { 4088, 19, 35, 23, 1, -35 },
  { 4172, 40, 35, 40, 1, -35 },
  { 4347, 33, 35, 34, 1, -35 },
  { 4492, 29, 36, 32, 2, -36 },
  { 4623, 27, 35, 27, 1, -35 },
  { 4742, 29, 44, 32, 2, -36 },
  { 4902, 26, 35, 28, 1, -35 },
  { 5016, 25, 35, 24, 0, -35 },
  { 5126, 23, 35, 24, 4, -35 },
  { 5227, 29, 35, 31, 3, -35 },
  { 5354, 27, 35, 27, 4, -35 },
  { 5473, 41, 35, 40, 4, -35 },
  { 5653, 34, 35, 27, -3, -35 },
  { 5802, 26, 35, 25, 4, -35 },
  { 5916, 28, 35, 24, -2, -35 },
  { 6039, 20, 43, 15, -1, -35 },
  { 6147, 11, 35, 20, 5, -35 },
  { 6196, 20, 43, 15, -3, -35 },
  { 6304, 24, 22, 25, 0, -35 },
  { 6370, 19, 4, 18, -5, 4 },
  { 6380, 10, 8, 15, 7, -38 },
  { 6390, 24, 27, 27, 2, -27 },
  { 6471, 25, 37, 27, 0, -37 },
  { 6587, 20, 27, 22, 2, -27 },
  { 6655, 27, 37, 27, 2, -37 },
  { 6780, 22, 27, 25, 2, -27 },
  { 6855, 27, 49, 17, -5, -37 },
  { 7021, 26, 39, 27, 0, -27 },
  { 7148, 25, 37, 27, 0, -37 },
  { 7264, 15, 37, 13, 0, -37 },
  { 7334, 21, 49, 13, -6, -37 },
  { 7463, 28, 37, 25, 0, -37 },
  { 7593, 15, 37, 13, 0, -37 },
  { 7663, 38, 27, 40, 0, -27 },
  { 7792, 25, 27, 27, 0, -27 },
  { 7877, 22, 27, 26, 2, -27 },
  { 7952, 27, 39, 27, -2, -27 },
  { 8084, 24, 39, 27, 2, -27 },
  { 8201, 21, 27, 19, 0, -27 },
  { 8272, 21, 27, 21, 0, -27 },
  { 8343, 17, 32, 18, 2, -32 },
  { 8411, 24, 27, 27, 2, -27 },
  { 8492, 23, 27, 23, 3, -27 },
  { 8570, 35, 27, 35, 3, -27 },
  { 8689, 28, 27, 24, -2, -27 },
  { 8784, 30, 39, 23, -4, -27 },
  { 8931, 23, 27, 21, -1, -27 },
  { 9009, 20, 43, 17, 0, -35 },
  { 9117, 5, 48, 24, 9, -37 },
  { 9147, 20, 43, 17, -3, -35 },
  { 9255, 23, 8, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC49PT7B_H_
