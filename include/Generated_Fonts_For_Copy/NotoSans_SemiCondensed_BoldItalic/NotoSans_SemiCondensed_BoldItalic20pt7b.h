#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x70, 0x00, 0x18, 0xF3, 0x80,
  0x6F, 0xDF, 0xB6, 0x6C, 0xC0, 0x06, 0x60, 0x66, 0x0C, 0xC0, 0xCC, 0x3F,
  0xF7, 0xFF, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFE, 0x33, 0x03, 0x30, 0x36,
  0x06, 0x60, 0x03, 0x01, 0xE1, 0xFC, 0xFF, 0x3A, 0x0F, 0x83, 0xC0, 0x7C,
  0x0F, 0x81, 0xE0, 0xFB, 0x2E, 0xFF, 0x9F, 0x80, 0x80, 0x40, 0x3C, 0x39,
  0xF0, 0xC6, 0xE6, 0x3B, 0x38, 0xCC, 0xC3, 0x36, 0x6F, 0xFF, 0xDE, 0xDB,
  0x06, 0xEC, 0x3B, 0x30, 0xCC, 0xC6, 0x37, 0x38, 0xF9, 0xC1, 0xC0, 0x0F,
  0xC0, 0x7E, 0x07, 0x30, 0x3B, 0x81, 0xDC, 0x0F, 0xC0, 0x78, 0xE7, 0xEE,
  0x77, 0x73, 0x1F, 0x38, 0xF1, 0xE7, 0x87, 0xFE, 0x1F, 0x78, 0x7F, 0xEC,
  0x0E, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xE0, 0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18,
  0x30, 0xE1, 0xC3, 0x0E, 0x38, 0x61, 0xC0, 0x0C, 0x9C, 0xD8, 0xFF, 0x1F,
  0x7C, 0xEC, 0x6E, 0x04, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0x3B, 0x99, 0xCC, 0x00, 0x7D, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x00, 0x04, 0x0F, 0x8F,
  0xEE, 0x77, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xB1, 0xD8, 0xEE, 0xE7,
  0xF1, 0xE0, 0x0E, 0x7D, 0xFF, 0x65, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x8E, 0x00, 0x0F, 0xC3, 0xFC, 0x63, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x27, 0xF9, 0xFF, 0x00, 0x1F,
  0x8F, 0xF1, 0x1C, 0x07, 0x01, 0xC1, 0xE1, 0xE0, 0x7C, 0x03, 0x80, 0xE0,
  0x3A, 0x1E, 0xFF, 0x3F, 0x80, 0x01, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x86,
  0xE3, 0x39, 0xCC, 0xE3, 0x3F, 0xFF, 0xF8, 0x1C, 0x06, 0x03, 0x80, 0x1F,
  0xC7, 0xF1, 0x80, 0xE0, 0x38, 0x0F, 0xC7, 0xF8, 0x9E, 0x03, 0x80, 0xE0,
  0x3B, 0x1C, 0xFF, 0x3F, 0x80, 0x01, 0x43, 0xE1, 0xF8, 0xE0, 0x70, 0x18,
  0x0E, 0xF3, 0xFC, 0xE7, 0x38, 0xCC, 0x33, 0x1C, 0xE7, 0x3F, 0x87, 0xC0,
  0x7F, 0xDF, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x02, 0x07, 0xE1, 0xFC, 0xE7, 0x39,
  0xCE, 0x71, 0xF8, 0x78, 0x3F, 0x1C, 0xEE, 0x3B, 0x8E, 0xE3, 0x9F, 0xC3,
  0xE0, 0x04, 0x1F, 0x9F, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0x7F, 0x3F,
  0x81, 0xC1, 0xC9, 0xE7, 0xE3, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x67,
  0x38, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x09, 0xC7, 0x18, 0xE3, 0x00,
  0x00, 0x81, 0xC7, 0xCF, 0x8F, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0x80, 0x40,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x78, 0x3C, 0xF9, 0xF0, 0xE0, 0x40, 0x00, 0x7E, 0x7F, 0x47, 0x07, 0x06,
  0x1E, 0x3C, 0x30, 0x70, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x07, 0xF0, 0x78,
  0xE3, 0x80, 0xCC, 0x63, 0x67, 0xEF, 0xB9, 0xBC, 0xCC, 0xF3, 0x33, 0xD8,
  0xCF, 0x67, 0x6C, 0xFF, 0xB3, 0x9C, 0xE0, 0x01, 0xC1, 0x03, 0xFC, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0xEE, 0x1D, 0xC7, 0x38, 0xE7,
  0x3F, 0xE7, 0xFD, 0xFF, 0xB8, 0x76, 0x0F, 0xC1, 0xC0, 0x1F, 0xC3, 0xFC,
  0x73, 0x8C, 0x73, 0x8E, 0x7F, 0x8F, 0xE1, 0xFE, 0x71, 0xCE, 0x39, 0xC7,
  0x39, 0xE7, 0xF9, 0xFE, 0x00, 0x01, 0x01, 0xFC, 0x7F, 0x1E, 0x27, 0x80,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x10, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC1, 0xFE, 0x1C, 0xF1, 0x87, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x87, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0x7C, 0x7F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x70, 0x0C, 0x03, 0x80, 0x7F, 0x0F, 0xE1, 0xFC, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xE3, 0xC2, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x3E, 0xE3, 0xEE, 0x5C, 0xE1, 0xCE, 0x1C, 0xF1, 0xC7, 0xF8,
  0x3F, 0x80, 0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x30, 0xE3, 0x87, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x1C, 0x70,
  0xE0, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x06, 0x07, 0x07, 0xE7, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x78, 0xF8,
  0x78, 0x00, 0x1C, 0x78, 0xE7, 0x87, 0x38, 0x33, 0x83, 0xB8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x1C, 0x70,
  0xE0, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x7F, 0xFF, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE3,
  0xE3, 0xF1, 0xF1, 0xB0, 0xD9, 0xF8, 0x6C, 0xDC, 0x76, 0xEE, 0x3B, 0xE6,
  0x1D, 0xF3, 0x0C, 0xF3, 0x86, 0x79, 0xC7, 0x38, 0xE0, 0x1E, 0x1C, 0x78,
  0x71, 0xE1, 0x87, 0xC6, 0x3F, 0x38, 0xEC, 0xE3, 0x33, 0x8C, 0xEC, 0x73,
  0xB1, 0xC7, 0xC7, 0x1F, 0x18, 0x7C, 0x61, 0xE3, 0x83, 0x80, 0x01, 0x00,
  0xFC, 0x1F, 0xE3, 0x8F, 0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xFC,
  0x73, 0x8C, 0x33, 0x8E, 0x71, 0xCF, 0xF9, 0xFE, 0x7F, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0x8F, 0x78,
  0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3,
  0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x1F, 0xC3, 0xFC, 0x73,
  0x8C, 0x73, 0x8E, 0x73, 0xCF, 0xF1, 0xFC, 0x77, 0x0E, 0x71, 0xCE, 0x39,
  0xC6, 0x1D, 0xC3, 0x80, 0x1F, 0xC7, 0xF3, 0x88, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x33, 0x1C, 0xFF, 0x3F, 0x00, 0xFF, 0xFF,
  0xC6, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x00, 0x38, 0x73, 0x87, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x38, 0x7F, 0x03, 0xE0, 0xE1,
  0xFC, 0x3B, 0x8E, 0x71, 0xCE, 0x31, 0xCE, 0x39, 0x87, 0x70, 0xEC, 0x1F,
  0x83, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xC3, 0x87, 0xC3, 0x87, 0xC3,
  0x8E, 0xC7, 0x8E, 0xC7, 0x8C, 0xCF, 0x9C, 0xCD, 0x98, 0xDD, 0xB8, 0xD9,
  0xB8, 0xD9, 0xB0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0x1C,
  0x38, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0xEC, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x70, 0x70, 0xE1, 0xF8,
  0xEE, 0x71, 0x9C, 0x6E, 0x1F, 0x07, 0xC1, 0xE0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x8F,
  0xF8, 0x0F, 0x87, 0x83, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xF0, 0xF8, 0x00, 0xE7, 0x18, 0xC6,
  0x31, 0xCE, 0x71, 0x8C, 0x63, 0x1C, 0x1F, 0x1E, 0x06, 0x06, 0x0E, 0x0E,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0xF0, 0xF0, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x19, 0x8E, 0x63, 0x19, 0x87, 0xE0, 0xC0, 0xFF,
  0xE6, 0x30, 0x1D, 0xCF, 0xE7, 0x3B, 0xCE, 0xE3, 0xB8, 0xEE, 0x33, 0x9C,
  0xEF, 0x3F, 0xC7, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x3B, 0x8F, 0xF3,
  0x9C, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xC6, 0x73, 0xBF, 0xCF, 0xE0, 0x1F,
  0x3F, 0x72, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE1, 0xDC, 0x7F, 0x1C, 0xE7, 0x1C, 0xE3, 0x9C, 0x73,
  0x8C, 0x73, 0x8E, 0x71, 0xFE, 0x1D, 0xC0, 0x1F, 0x1F, 0xDC, 0xFC, 0x7E,
  0x77, 0xF3, 0xC1, 0x80, 0xE2, 0x7F, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x1C,
  0x03, 0x80, 0xFC, 0x3F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x1F, 0x03, 0xC0, 0x70, 0x00,
  0x0E, 0xE3, 0xF8, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x9C, 0x77,
  0x8F, 0xF0, 0xEE, 0x01, 0x80, 0x71, 0x9E, 0x3F, 0x83, 0xC0, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x3B, 0x8F, 0xF3, 0xDC, 0xE7, 0x31, 0xDC, 0x77, 0x1D,
  0xC6, 0x63, 0x98, 0xEE, 0x38, 0x1C, 0x71, 0x80, 0x38, 0xE3, 0x8E, 0x31,
  0xC7, 0x1C, 0x73, 0x8E, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x70, 0x38,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C,
  0x7C, 0x3E, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x8E, 0x73,
  0x8E, 0xE1, 0xB8, 0x3E, 0x0F, 0xC1, 0xFC, 0x3B, 0x86, 0x70, 0xC7, 0x38,
  0xE0, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x73, 0x8E,
  0x00, 0x3B, 0x9E, 0x37, 0xFE, 0x3D, 0xE7, 0x39, 0xC7, 0x31, 0xC6, 0x71,
  0xCE, 0x71, 0x8E, 0x73, 0x8E, 0x63, 0x8E, 0x63, 0x8C, 0xE3, 0x9C, 0x3B,
  0x8D, 0xF3, 0xDC, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xC6, 0x63, 0x98, 0xEE,
  0x38, 0x1E, 0x1F, 0x9C, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCE, 0xE7, 0x7F,
  0x1F, 0x00, 0x1D, 0xC3, 0xFC, 0x73, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x39,
  0xC6, 0x39, 0xCF, 0xF1, 0xDC, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x1D, 0xCF, 0xE7, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x33, 0x9C, 0xE7, 0x3F,
  0xC7, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x3B, 0x9F, 0x8F, 0xC7,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x00, 0x1F, 0x9F, 0x9C,
  0x4E, 0x03, 0xC1, 0xF0, 0x38, 0x1C, 0x8E, 0x7F, 0x3F, 0x00, 0x18, 0x71,
  0xFF, 0xF7, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0xCF, 0x80, 0x71, 0xDC,
  0x67, 0x19, 0x8E, 0xE3, 0xB8, 0xEE, 0x33, 0x9C, 0xEF, 0x3F, 0xC7, 0x70,
  0xE3, 0xF8, 0xEE, 0x73, 0x9C, 0xE6, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x00, 0xE3, 0x8F, 0xCF, 0x3B, 0x9E, 0x67, 0x6D, 0xCE, 0xDB, 0x9D,
  0xBE, 0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xC7, 0x00, 0x3C,
  0xF1, 0xCE, 0x1D, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB0, 0x3B,
  0x87, 0x38, 0xF3, 0x80, 0x38, 0xF3, 0x8E, 0x38, 0xC3, 0x9C, 0x19, 0x81,
  0xB8, 0x1B, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x0F,
  0x80, 0xF0, 0x0E, 0x00, 0x1F, 0xC7, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x1F, 0xCF, 0xF0, 0x07, 0x0F, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0xF8, 0xE0, 0xF0, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x1E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0F,
  0x07, 0x1E, 0x18, 0x38, 0x38, 0x30, 0x70, 0xF0, 0xE0, 0x70, 0xFF, 0xF7,
  0xF0, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 9, 2, -14 },
  { 17, 12, 14, 12, 0, -14 },
  { 38, 10, 16, 10, 0, -15 },
  { 58, 14, 14, 16, 1, -14 },
  { 83, 13, 14, 13, 0, -14 },
  { 106, 3, 5, 5, 2, -14 },
  { 108, 7, 17, 6, 1, -14 },
  { 123, 7, 18, 6, -1, -15 },
  { 139, 8, 9, 10, 2, -15 },
  { 148, 9, 10, 11, 1, -12 },
  { 160, 5, 5, 5, -1, -2 },
  { 164, 6, 3, 6, 0, -7 },
  { 167, 3, 3, 5, 0, -3 },
  { 169, 11, 14, 8, -1, -14 },
  { 189, 9, 15, 10, 1, -15 },
  { 206, 7, 14, 10, 2, -14 },
  { 219, 11, 14, 10, -1, -14 },
  { 239, 10, 14, 10, 0, -14 },
  { 257, 10, 14, 10, 0, -14 },
  { 275, 10, 14, 10, 0, -14 },
  { 293, 10, 15, 10, 1, -15 },
  { 312, 10, 14, 10, 1, -14 },
  { 330, 10, 15, 10, 0, -15 },
  { 349, 9, 15, 10, 1, -15 },
  { 366, 5, 11, 5, 0, -11 },
  { 373, 6, 14, 5, -1, -11 },
  { 384, 9, 10, 11, 1, -12 },
  { 396, 9, 6, 11, 1, -10 },
  { 403, 9, 10, 11, 1, -12 },
  { 415, 8, 14, 8, 1, -14 },
  { 429, 14, 16, 16, 1, -14 },
  { 457, 11, 14, 11, -1, -14 },
  { 477, 11, 14, 11, 0, -14 },
  { 497, 11, 15, 11, 1, -15 },
  { 518, 12, 14, 12, 0, -14 },
  { 539, 11, 14, 10, 0, -14 },
  { 559, 11, 14, 10, 0, -14 },
  { 579, 12, 15, 13, 1, -15 },
  { 602, 13, 14, 13, 0, -14 },
  { 625, 9, 14, 7, -1, -14 },
  { 641, 9, 18, 6, -3, -14 },
  { 662, 13, 14, 11, 0, -14 },
  { 685, 8, 14, 9, 0, -14 },
  { 699, 17, 14, 16, 0, -14 },
  { 729, 14, 14, 14, 0, -14 },
  { 754, 12, 15, 13, 1, -15 },
  { 777, 11, 14, 11, 0, -14 },
  { 797, 12, 18, 13, 1, -15 },
  { 824, 11, 14, 11, 0, -14 },
  { 844, 10, 14, 10, 0, -14 },
  { 862, 9, 14, 10, 2, -14 },
  { 878, 12, 14, 13, 1, -14 },
  { 899, 11, 14, 11, 2, -14 },
  { 919, 16, 14, 16, 2, -14 },
  { 947, 13, 14, 11, -1, -14 },
  { 970, 10, 14, 10, 2, -14 },
  { 988, 12, 14, 10, -1, -14 },
  { 1009, 9, 17, 6, -1, -14 },
  { 1029, 5, 14, 8, 2, -14 },
  { 1038, 8, 17, 6, -1, -14 },
  { 1055, 10, 9, 10, 0, -14 },
  { 1067, 8, 1, 7, -2, 2 },
  { 1068, 4, 3, 6, 3, -15 },
  { 1070, 10, 11, 11, 1, -11 },
  { 1084, 10, 15, 11, 0, -15 },
  { 1103, 8, 11, 9, 1, -11 },
  { 1114, 11, 15, 11, 1, -15 },
  { 1135, 9, 11, 10, 1, -11 },
  { 1148, 11, 20, 7, -2, -15 },
  { 1176, 11, 16, 11, 0, -11 },
  { 1198, 10, 15, 11, 0, -15 },
  { 1217, 6, 15, 5, 0, -15 },
  { 1229, 9, 20, 5, -3, -15 },
  { 1252, 11, 15, 10, 0, -15 },
  { 1273, 6, 15, 5, 0, -15 },
  { 1285, 16, 11, 16, 0, -11 },
  { 1307, 10, 11, 11, 0, -11 },
  { 1321, 9, 11, 11, 1, -11 },
  { 1334, 11, 16, 11, -1, -11 },
  { 1356, 10, 16, 11, 1, -11 },
  { 1376, 9, 11, 8, 0, -11 },
  { 1389, 9, 11, 9, 0, -11 },
  { 1402, 7, 13, 7, 1, -13 },
  { 1414, 10, 11, 11, 1, -11 },
  { 1428, 10, 11, 9, 1, -11 },
  { 1442, 15, 11, 14, 1, -11 },
  { 1463, 12, 11, 10, -1, -11 },
  { 1480, 12, 16, 10, -1, -11 },
  { 1504, 10, 11, 8, -1, -11 },
  { 1518, 8, 17, 7, 0, -14 },
  { 1535, 2, 20, 10, 4, -15 },
  { 1540, 8, 17, 7, -1, -14 },
  { 1557, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC20PT7B_H_
