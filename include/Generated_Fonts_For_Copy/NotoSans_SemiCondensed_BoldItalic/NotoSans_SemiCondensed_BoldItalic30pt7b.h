#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x10, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x79, 0xEE, 0x79, 0xCF, 0x79, 0xEF, 0x39, 0xC7, 0x38, 0xE0, 0x00,
  0xE7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xE3,
  0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80,
  0x38, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x1C,
  0x70, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x01, 0xC0, 0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xD3,
  0x0F, 0x60, 0x1E, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x9E, 0x01, 0x3C, 0x86, 0xF9, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0x03, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x0F, 0x0F, 0xE0, 0x70, 0xF7, 0x07, 0x07, 0x38, 0x70, 0x79,
  0xC3, 0x83, 0x8E, 0x38, 0x1C, 0x73, 0x80, 0xE7, 0x9C, 0x07, 0x39, 0xCF,
  0xBB, 0xDC, 0xFD, 0xFC, 0xEF, 0xF7, 0xCE, 0xF3, 0x9C, 0xE7, 0x1C, 0x0F,
  0x38, 0xE0, 0x71, 0xCF, 0x07, 0x1E, 0x78, 0x78, 0xF3, 0x83, 0x87, 0xBC,
  0x38, 0x3F, 0xC3, 0xC0, 0xFE, 0x3C, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0,
  0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x1F, 0x7F,
  0xC7, 0x9E, 0xFB, 0xEF, 0x1F, 0xF3, 0xC3, 0xF8, 0xF0, 0xFE, 0x3C, 0x1F,
  0x0F, 0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xE7, 0xC0, 0x7B, 0xDD,
  0xEF, 0x73, 0x80, 0x03, 0xE0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x18, 0xE0,
  0x7B, 0x81, 0xFF, 0xFB, 0xFF, 0xC1, 0xFF, 0x1F, 0x80, 0xF7, 0x07, 0xDC,
  0x0E, 0x78, 0x10, 0xE0, 0x02, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x3C, 0x79,
  0xE3, 0xCF, 0x1E, 0x78, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x13, 0xFF, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x0F, 0x78, 0x3D, 0xE0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E, 0xF0,
  0xF3, 0xC7, 0xCF, 0xBE, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x03, 0xE0,
  0xF8, 0x7F, 0x1F, 0xEF, 0xFD, 0xF7, 0x99, 0xE2, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F,
  0x1F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x01,
  0xF0, 0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xC3, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x79, 0x00, 0xF3, 0x87, 0xE7, 0xFF,
  0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xBC, 0x0F, 0x78, 0x3C, 0xF0,
  0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x40,
  0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x80, 0xF9, 0xE7, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0x3C, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x79, 0xE0, 0xF7, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF,
  0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xE3, 0xE7,
  0xC3, 0xFF, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0x8F, 0x0F, 0x7C, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0x83,
  0xFF, 0x87, 0x8F, 0x1E, 0x1F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0xF9, 0xE1,
  0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x3C, 0x7D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x7D, 0xE1,
  0xF7, 0x8F, 0xDF, 0xFE, 0x7F, 0xF8, 0xFD, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0x88, 0x7C, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x04, 0x1F,
  0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x78,
  0xF8, 0xF8, 0xF0, 0x01, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x3C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x01, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0xC0, 0xF8, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0x61, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x02, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xF0, 0x3C,
  0x0F, 0x00, 0x38, 0x78, 0x00, 0xF1, 0xC1, 0xE1, 0xCE, 0x1F, 0xE7, 0x38,
  0xFF, 0x9D, 0xC7, 0x9C, 0x77, 0x3C, 0x71, 0xDC, 0xE1, 0xC7, 0xE3, 0x8F,
  0x1F, 0x8E, 0x38, 0xEE, 0x78, 0xE3, 0xB8, 0xE7, 0x9C, 0xE3, 0xFF, 0xF3,
  0x8F, 0xDF, 0x8F, 0x1E, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x18, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x07,
  0x9C, 0x03, 0xCE, 0x03, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xE0, 0xF0, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3E, 0x07, 0x9E, 0x03,
  0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E,
  0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xE1, 0xF8, 0x30, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x04, 0x1F, 0xDE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x7E,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7,
  0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3, 0xC0,
  0xF0, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xF8, 0x31, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x3F, 0xDE, 0x1F, 0xCF, 0x0F, 0xE7, 0x87, 0xF3, 0xC0, 0x79, 0xE0,
  0x7C, 0xF0, 0x3C, 0x7C, 0x1E, 0x3F, 0x9F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0x80, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x3C, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3E, 0x07, 0x83, 0xC0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x2F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0x83, 0xE0, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E,
  0x7C, 0x03, 0xDF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x77, 0x07, 0xF8, 0x3B, 0x83, 0xB8, 0x3D, 0xC3, 0xFC, 0x1E, 0xE1,
  0xDE, 0x0F, 0x71, 0xEF, 0x07, 0xB8, 0xE7, 0x87, 0x9C, 0xF7, 0x83, 0xCE,
  0x73, 0xC1, 0xE7, 0x79, 0xE0, 0xF3, 0xB8, 0xF0, 0x71, 0xFC, 0xF0, 0x78,
  0xFC, 0x78, 0x3C, 0x7E, 0x3C, 0x1E, 0x3E, 0x1E, 0x0F, 0x1F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC3, 0xF8, 0x3C, 0x1F,
  0xC1, 0xE0, 0xFE, 0x0F, 0x07, 0x70, 0x78, 0x3B, 0xC3, 0xC3, 0xDE, 0x3C,
  0x1E, 0xF1, 0xE0, 0xF3, 0xCF, 0x07, 0x9E, 0x78, 0x78, 0xF3, 0xC3, 0xC7,
  0xBC, 0x1E, 0x1F, 0xE0, 0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x78, 0x3F, 0x83,
  0xC0, 0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1,
  0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0xF9, 0xE0, 0x3E, 0x78,
  0x1F, 0x1F, 0x07, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xE1, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x1F, 0x1E, 0x0F, 0x8F, 0x1F, 0x87, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x1F, 0x78, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0xF9, 0xE0, 0x3E, 0x78, 0x1F,
  0x1F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07,
  0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x0F, 0x1E, 0x1F, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3C, 0xF8, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3E, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xF8, 0x7F,
  0xE1, 0xF0, 0xC3, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF9, 0x01, 0xF3, 0xEF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xF4, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0x81, 0xF3,
  0xC0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x78, 0x1E, 0x3C, 0x0F,
  0x1E, 0x07, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0xF8, 0xF0, 0x7C, 0x7E, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x00,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78,
  0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xC0,
  0xF3, 0xC0, 0x77, 0x80, 0x77, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x1F,
  0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x1E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C,
  0xF1, 0xFC, 0x7C, 0xF1, 0xDC, 0x78, 0xF3, 0xDC, 0x78, 0xF3, 0x9C, 0xF0,
  0xF7, 0x9C, 0xF0, 0xF7, 0x9D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1D, 0xE0,
  0xEE, 0x1F, 0xC0, 0xEE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8,
  0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF8,
  0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8,
  0x1E, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xE1, 0xE3, 0xC7,
  0xC7, 0x8F, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE4, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xF1, 0xE3, 0xC0, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xEE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x78, 0x70, 0x71, 0xC0, 0xE7, 0x81,
  0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFE, 0xF9, 0xE3, 0xCF, 0x1C, 0x03, 0x00,
  0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xCF, 0x87, 0x9E, 0x0F, 0x3C,
  0x1E, 0xF8, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x8F, 0x9F, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCC, 0x07, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7C, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xE7, 0xC7, 0xFF, 0x8E, 0xFE, 0x3D,
  0xF8, 0x00, 0x01, 0xC0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xE1, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x61, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x03, 0x1E, 0x0F, 0xDE, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3E, 0x7C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0,
  0x7F, 0x70, 0x3E, 0xF0, 0x01, 0xC0, 0x1F, 0xC1, 0xFF, 0x8F, 0xDF, 0x3C,
  0x3D, 0xF0, 0xF7, 0x87, 0x9F, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x87, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x2F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x01, 0x80, 0x07, 0xEF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x3E,
  0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C,
  0x78, 0x7C, 0x78, 0x7C, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0xE3, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xCE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C, 0x78, 0xF0,
  0xF3, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0xF8, 0x79,
  0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x00, 0x03, 0x03,
  0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC3,
  0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE0,
  0x00, 0x30, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x2F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x02, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x9E,
  0x03, 0xDF, 0x03, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3E, 0xF8, 0x1E, 0x3C, 0x0F, 0x1F, 0x07, 0x8F, 0x83, 0xC3, 0xC3,
  0xC1, 0xF0, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE0, 0x00, 0x38, 0x18, 0x1D, 0xF9, 0xF8, 0x7F, 0xFB,
  0xF8, 0xFF, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xE3, 0xCF, 0x87, 0x87,
  0x9F, 0x0F, 0x0F, 0x3C, 0x3C, 0x1E, 0x78, 0x78, 0x7C, 0xF0, 0xF0, 0xF3,
  0xE1, 0xE1, 0xE7, 0x83, 0xC3, 0xCF, 0x0F, 0x07, 0x9E, 0x1E, 0x1F, 0x3C,
  0x3C, 0x3C, 0xF0, 0x78, 0x78, 0x00, 0x18, 0x1D, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x7C,
  0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0xF8,
  0x78, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x7D, 0xF0, 0xF7,
  0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB,
  0xE7, 0xC7, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x18, 0x07, 0x7E, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0x8F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3F,
  0xFC, 0x3F, 0xF8, 0x79, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x1F, 0xBC, 0x7F,
  0xF9, 0xFF, 0xF3, 0xE7, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0x3E, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3E, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x77, 0xC7, 0xBC, 0x3F, 0xE1, 0xFF,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x7F, 0xC7,
  0xFC, 0x7F, 0xE3, 0xC1, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x61, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0x00,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x07, 0xFE, 0xFF, 0xBF, 0xF1, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF9, 0x1F,
  0xE1, 0xFC, 0x3F, 0x80, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xE3,
  0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xF0, 0xF3, 0xC3,
  0xE7, 0x87, 0xCF, 0x9F, 0x1F, 0xFE, 0x1F, 0xDC, 0x1F, 0x38, 0xF0, 0x7F,
  0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0,
  0xF7, 0x83, 0xDE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF0, 0xF8, 0x7F, 0x8F, 0xC7, 0xBC, 0x7E, 0x3D, 0xE3, 0xF3,
  0xEF, 0x3B, 0x9E, 0x79, 0xDC, 0xF3, 0xDF, 0xEF, 0x1E, 0xEF, 0x78, 0xF7,
  0x7F, 0x87, 0xF3, 0xFC, 0x3F, 0x9D, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC1, 0xE3,
  0xE0, 0x79, 0xF0, 0x1F, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1F,
  0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xC3, 0xF0, 0xF8, 0x0F, 0x07, 0xC3, 0xC1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x1C, 0xF0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xF0, 0x0F,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3F, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x3E, 0x07,
  0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 7, 13, 3, -21 },
  { 35, 18, 21, 18, 0, -21 },
  { 83, 15, 25, 15, 0, -23 },
  { 130, 21, 22, 24, 2, -22 },
  { 188, 18, 22, 19, 1, -22 },
  { 238, 5, 7, 8, 3, -21 },
  { 243, 11, 26, 9, 1, -21 },
  { 279, 11, 27, 9, -2, -22 },
  { 317, 14, 14, 15, 2, -23 },
  { 342, 14, 15, 16, 1, -18 },
  { 369, 7, 8, 8, -2, -4 },
  { 376, 9, 4, 9, 0, -10 },
  { 381, 5, 5, 8, 0, -5 },
  { 385, 15, 22, 12, -1, -22 },
  { 427, 14, 22, 15, 1, -22 },
  { 466, 11, 21, 15, 3, -21 },
  { 495, 16, 22, 15, -1, -22 },
  { 539, 15, 22, 15, 0, -22 },
  { 581, 15, 21, 15, 0, -21 },
  { 621, 15, 21, 15, 0, -21 },
  { 661, 15, 22, 15, 1, -22 },
  { 703, 16, 21, 15, 1, -21 },
  { 745, 15, 22, 15, 0, -22 },
  { 787, 14, 22, 15, 1, -22 },
  { 826, 8, 17, 8, 0, -17 },
  { 843, 10, 21, 8, -2, -17 },
  { 870, 14, 15, 16, 1, -18 },
  { 897, 14, 9, 16, 1, -15 },
  { 913, 14, 15, 16, 1, -18 },
  { 940, 12, 22, 12, 2, -22 },
  { 973, 22, 25, 23, 1, -22 },
  { 1042, 17, 21, 17, -2, -21 },
  { 1087, 17, 21, 17, 0, -21 },
  { 1132, 17, 22, 16, 1, -22 },
  { 1179, 18, 21, 19, 0, -21 },
  { 1227, 16, 21, 15, 0, -21 },
  { 1269, 16, 21, 14, 0, -21 },
  { 1311, 17, 22, 19, 2, -22 },
  { 1358, 20, 21, 19, 0, -21 },
  { 1411, 14, 21, 11, -1, -21 },
  { 1448, 15, 27, 9, -5, -21 },
  { 1499, 19, 21, 17, 0, -21 },
  { 1549, 12, 21, 14, 0, -21 },
  { 1581, 25, 21, 24, 0, -21 },
  { 1647, 21, 21, 21, 0, -21 },
  { 1703, 18, 22, 20, 1, -22 },
  { 1753, 17, 21, 17, 0, -21 },
  { 1798, 18, 27, 20, 1, -22 },
  { 1859, 16, 21, 17, 0, -21 },
  { 1901, 15, 22, 15, 0, -22 },
  { 1943, 15, 21, 14, 2, -21 },
  { 1983, 17, 21, 19, 2, -21 },
  { 2028, 16, 21, 16, 3, -21 },
  { 2070, 24, 21, 25, 3, -21 },
  { 2133, 21, 21, 16, -2, -21 },
  { 2189, 15, 21, 15, 3, -21 },
  { 2229, 17, 21, 14, -1, -21 },
  { 2274, 13, 26, 9, -1, -21 },
  { 2317, 7, 22, 12, 3, -22 },
  { 2337, 12, 26, 9, -2, -21 },
  { 2376, 15, 14, 15, 0, -22 },
  { 2403, 12, 2, 11, -3, 3 },
  { 2406, 6, 5, 9, 4, -23 },
  { 2410, 15, 17, 16, 1, -17 },
  { 2442, 15, 23, 16, 0, -23 },
  { 2486, 13, 17, 13, 1, -17 },
  { 2514, 16, 23, 16, 1, -23 },
  { 2560, 14, 17, 15, 1, -17 },
  { 2590, 17, 30, 10, -3, -23 },
  { 2654, 16, 24, 16, 0, -17 },
  { 2702, 15, 23, 17, 0, -23 },
  { 2746, 9, 23, 8, 0, -23 },
  { 2772, 13, 30, 8, -4, -23 },
  { 2821, 17, 23, 15, 0, -23 },
  { 2870, 9, 23, 8, 0, -23 },
  { 2896, 23, 17, 25, 0, -17 },
  { 2945, 15, 17, 17, 0, -17 },
  { 2977, 14, 17, 16, 1, -17 },
  { 3007, 16, 24, 16, -1, -17 },
  { 3055, 15, 24, 16, 1, -17 },
  { 3100, 13, 17, 12, 0, -17 },
  { 3128, 13, 17, 13, 0, -17 },
  { 3156, 11, 20, 11, 1, -20 },
  { 3184, 15, 16, 16, 1, -16 },
  { 3214, 14, 16, 14, 2, -16 },
  { 3242, 21, 16, 22, 2, -16 },
  { 3284, 18, 16, 15, -2, -16 },
  { 3320, 18, 23, 14, -2, -16 },
  { 3372, 14, 16, 13, -1, -16 },
  { 3400, 12, 26, 10, 0, -21 },
  { 3439, 3, 30, 15, 6, -23 },
  { 3451, 12, 26, 10, -2, -21 },
  { 3490, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC30PT7B_H_
