#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xB4, 0x2B, 0xD5, 0xF5, 0x70, 0x13, 0xD8, 0xC3,
  0x59, 0x88, 0x20, 0xC9, 0xA7, 0xB5, 0xA5, 0x53, 0x00, 0x10, 0xE7, 0x09,
  0xFA, 0x6F, 0x80, 0xC0, 0x29, 0x69, 0x30, 0x22, 0x33, 0x22, 0x2C, 0x6C,
  0x7A, 0x27, 0xC8, 0x40, 0xE0, 0xE0, 0xC0, 0x12, 0x24, 0xC8, 0x23, 0x97,
  0xAD, 0x69, 0x80, 0x75, 0xA4, 0x80, 0x23, 0xC4, 0x22, 0x23, 0xC0, 0x23,
  0xC4, 0xE1, 0x0B, 0x80, 0x19, 0x95, 0x6F, 0x10, 0x7A, 0x1C, 0x21, 0x70,
  0x11, 0xD0, 0xED, 0x69, 0x80, 0x78, 0x8C, 0x46, 0x60, 0x23, 0xD6, 0x6D,
  0x4B, 0xC0, 0x27, 0x55, 0x73, 0xE0, 0x40, 0xC0, 0x40, 0xE0, 0x09, 0xF0,
  0xC1, 0x80, 0xF8, 0x3E, 0x87, 0x06, 0x6C, 0x00, 0x5C, 0xA8, 0x20, 0x3C,
  0xB5, 0xAD, 0x5B, 0xC8, 0x0E, 0x00, 0x18, 0x62, 0x8E, 0x4B, 0x30, 0x7A,
  0x5C, 0xBD, 0xF8, 0x11, 0xD0, 0x8C, 0x21, 0xC0, 0x7A, 0x52, 0x9D, 0xF8,
  0x7A, 0x1C, 0x8C, 0x78, 0x7A, 0x1C, 0x8C, 0x60, 0x08, 0xF4, 0x16, 0xC9,
  0x27, 0x80, 0x6D, 0x27, 0x92, 0xCB, 0x60, 0x76, 0x44, 0x4E, 0x32, 0x22,
  0x26, 0x4C, 0x6D, 0x47, 0x1C, 0xD3, 0x60, 0x64, 0x44, 0xCF, 0x66, 0xCD,
  0xAB, 0x7F, 0x56, 0x80, 0x65, 0x95, 0xD6, 0xDA, 0x60, 0x10, 0xF4, 0xD3,
  0xCD, 0x27, 0x00, 0x7A, 0x56, 0xEC, 0x60, 0x10, 0xF4, 0xD3, 0xCD, 0x27,
  0x04, 0x18, 0x7A, 0x5E, 0xED, 0x6C, 0x13, 0xD0, 0xC3, 0x5B, 0x80, 0xF4,
  0x4C, 0xC8, 0x6D, 0x24, 0x92, 0xD9, 0xC0, 0x9D, 0xA9, 0x4C, 0x60, 0x93,
  0x6A, 0xD6, 0xED, 0x93, 0x00, 0x36, 0x70, 0x61, 0xC2, 0x99, 0x00, 0x9A,
  0xE4, 0xC8, 0x79, 0x88, 0x8C, 0x78, 0x69, 0x29, 0x30, 0xA9, 0x50, 0x31,
  0x22, 0x22, 0xE0, 0x35, 0x59, 0xF0, 0xD0, 0x6A, 0xF5, 0xA7, 0x00, 0x62,
  0x1C, 0xB5, 0xEB, 0xC0, 0x74, 0xCC, 0x60, 0x08, 0x5A, 0xBD, 0x69, 0xC0,
  0x75, 0xFC, 0x70, 0x19, 0x9C, 0x42, 0x11, 0x88, 0xC0, 0x6A, 0xF5, 0xA7,
  0x1B, 0x80, 0x62, 0x1C, 0xB5, 0x6A, 0x40, 0x61, 0x25, 0xA0, 0x30, 0x22,
  0x26, 0x44, 0xC0, 0x62, 0x16, 0xE6, 0x7A, 0x40, 0x6D, 0x25, 0xA0, 0x76,
  0xB5, 0x4E, 0xB9, 0x40, 0x72, 0xD5, 0xA9, 0x00, 0x75, 0xDD, 0x70, 0x72,
  0xD7, 0xAF, 0x42, 0x00, 0x6A, 0xF5, 0xA7, 0x18, 0x80, 0x74, 0x4C, 0x80,
  0x74, 0x62, 0xE0, 0x2F, 0x44, 0xC6, 0x4A, 0xD5, 0xA7, 0x00, 0xDA, 0x9C,
  0xC4, 0x00, 0xA7, 0xAE, 0xBC, 0xB0, 0x5B, 0x98, 0xCB, 0x00, 0x6C, 0xA3,
  0x8C, 0x30, 0x8C, 0x00, 0x72, 0x6C, 0xE0, 0x36, 0x48, 0x44, 0x40, 0xFF,
  0x80, 0x69, 0x15, 0xA0, 0xEC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 7, 7, 7, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 2, 2, 1, -6 },
  { 28, 3, 7, 3, 0, -6 },
  { 31, 4, 8, 3, -1, -7 },
  { 35, 4, 4, 4, 1, -7 },
  { 37, 5, 4, 5, 0, -5 },
  { 40, 2, 2, 2, 0, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 2, 1, 2, 0, -1 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 5, 7, 5, 0, -7 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 4, 7, 5, 0, -7 },
  { 90, 2, 5, 2, 0, -5 },
  { 92, 2, 6, 2, 0, -5 },
  { 94, 5, 5, 5, 0, -6 },
  { 98, 5, 3, 5, 0, -5 },
  { 100, 5, 5, 5, 0, -6 },
  { 104, 3, 7, 4, 1, -7 },
  { 107, 7, 7, 7, 0, -6 },
  { 114, 6, 6, 5, -1, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 5, 6, 6, 0, -6 },
  { 132, 5, 6, 4, 0, -6 },
  { 136, 5, 6, 4, 0, -6 },
  { 140, 6, 7, 6, 0, -7 },
  { 146, 6, 6, 6, 0, -6 },
  { 151, 4, 6, 3, 0, -6 },
  { 154, 4, 8, 3, -1, -6 },
  { 158, 6, 6, 5, 0, -6 },
  { 163, 4, 6, 4, 0, -6 },
  { 166, 7, 6, 7, 0, -6 },
  { 172, 6, 6, 6, 0, -6 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 6, 9, 6, 0, -7 },
  { 194, 5, 6, 5, 0, -6 },
  { 198, 5, 7, 4, 0, -7 },
  { 203, 4, 6, 4, 1, -6 },
  { 206, 6, 6, 6, 0, -6 },
  { 211, 5, 6, 5, 1, -6 },
  { 215, 7, 6, 7, 1, -6 },
  { 221, 7, 6, 5, -1, -6 },
  { 227, 4, 6, 5, 1, -6 },
  { 230, 5, 6, 4, 0, -6 },
  { 234, 3, 7, 3, 0, -6 },
  { 237, 2, 6, 4, 1, -6 },
  { 239, 4, 7, 3, -1, -6 },
  { 243, 4, 4, 5, 0, -6 },
  { 245, 4, 1, 3, -1, 1 },
  { 246, 2, 2, 3, 1, -7 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 5, 7, 5, 0, -7 },
  { 256, 4, 5, 4, 0, -5 },
  { 259, 5, 7, 5, 0, -7 },
  { 264, 4, 5, 5, 0, -5 },
  { 267, 5, 9, 3, -1, -7 },
  { 273, 5, 7, 5, 0, -5 },
  { 278, 5, 7, 5, 0, -7 },
  { 283, 3, 7, 2, 0, -7 },
  { 286, 4, 9, 2, -1, -7 },
  { 291, 5, 7, 5, 0, -7 },
  { 296, 3, 7, 2, 0, -7 },
  { 299, 7, 5, 7, 0, -5 },
  { 304, 5, 5, 5, 0, -5 },
  { 308, 4, 5, 5, 0, -5 },
  { 311, 5, 7, 5, 0, -5 },
  { 316, 5, 7, 5, 0, -5 },
  { 321, 4, 5, 3, 0, -5 },
  { 324, 4, 5, 4, 0, -5 },
  { 327, 4, 6, 3, 0, -6 },
  { 330, 5, 5, 5, 0, -5 },
  { 334, 5, 5, 4, 0, -5 },
  { 338, 6, 5, 7, 1, -5 },
  { 342, 5, 5, 4, 0, -5 },
  { 346, 6, 7, 4, -1, -5 },
  { 352, 4, 5, 4, 0, -5 },
  { 355, 4, 7, 3, 0, -6 },
  { 359, 1, 9, 4, 2, -7 },
  { 361, 3, 7, 3, 0, -6 },
  { 364, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC9PT7B_H_
