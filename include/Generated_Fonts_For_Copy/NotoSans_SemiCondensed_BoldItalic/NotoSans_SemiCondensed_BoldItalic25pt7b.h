#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xB9, 0xDC, 0xEE, 0x76,
  0x73, 0x3B, 0x9C, 0x01, 0x9C, 0x07, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x73,
  0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x97,
  0xFF, 0xCF, 0xFF, 0x83, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x33, 0x80, 0xE7,
  0x00, 0x00, 0xC0, 0x04, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0x0E, 0xC8, 0xF4,
  0x07, 0xA0, 0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x2F, 0x03, 0x79,
  0x1B, 0x9F, 0xFC, 0xFF, 0xC1, 0xFC, 0x03, 0x00, 0x18, 0x00, 0x1E, 0x03,
  0x8F, 0xC1, 0xC7, 0xF0, 0xE1, 0xCC, 0x30, 0x73, 0x1C, 0x19, 0xCE, 0x0E,
  0x73, 0x03, 0x9D, 0xDE, 0xEE, 0xEF, 0xDF, 0xB7, 0xF3, 0xDD, 0xDC, 0x0E,
  0x67, 0x03, 0x39, 0xC1, 0xCE, 0x70, 0xE3, 0x9C, 0x30, 0xEE, 0x1C, 0x3F,
  0x0E, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0E, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0x81, 0x1F, 0x8E, 0x3F,
  0xDE, 0x79, 0xDC, 0x71, 0xFC, 0xF0, 0xF8, 0x70, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xBC, 0x7B, 0x9C, 0xE7, 0x33, 0x80, 0x07, 0x87, 0x83, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x80, 0x07, 0x00,
  0xE1, 0x18, 0x3B, 0x0F, 0xFE, 0x7F, 0xC7, 0xF9, 0xF8, 0x7F, 0x06, 0x70,
  0x8C, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0xE7, 0x9C, 0xF3,
  0x80, 0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x07, 0xC1, 0xFE, 0x1F, 0xE3, 0xCE, 0x78, 0xF7, 0x8F, 0x70, 0xFF, 0x0E,
  0xF0, 0xEF, 0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0xCF, 0xF8,
  0xFF, 0x07, 0xE0, 0x03, 0xC1, 0xE1, 0xF8, 0xFE, 0xFF, 0x9D, 0xC2, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0x9E, 0x08, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xE0,
  0xFF, 0x87, 0xFC, 0x10, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0xFC, 0x0F,
  0x80, 0x7E, 0x04, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x72, 0x07, 0x9F, 0xF8,
  0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x3B, 0x83, 0x9C, 0x1D, 0xE1, 0xCF, 0x1C, 0x71, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF8, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xF8, 0x3F,
  0xE1, 0xFF, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0xF2, 0x07, 0x9F, 0xF8,
  0xFF, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xE0, 0x3C, 0x07,
  0x80, 0x73, 0x07, 0x7C, 0xFF, 0xCF, 0x9E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE,
  0x1C, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x3F, 0xF9, 0xFF, 0xDF, 0xFC,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x7B,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0x78, 0xF1, 0xC7, 0x0F, 0x78, 0x7B,
  0xC3, 0x8F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x0E, 0xE1, 0xFC, 0x3F, 0x8F, 0x79, 0xEF, 0xFD, 0xFF, 0x8C, 0xE0,
  0x3C, 0x07, 0x01, 0xE7, 0xF8, 0xFE, 0x1F, 0x80, 0x1C, 0x3C, 0xF0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x8F, 0x1E, 0x00, 0x0E, 0x0F, 0x1E,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0x70, 0x70,
  0xE0, 0xE0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFC, 0x3E, 0x0F, 0x80, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x7E, 0x3F, 0x8F, 0xC0, 0xF0,
  0x0C, 0x00, 0x1F, 0x9F, 0xF3, 0xFC, 0x87, 0x01, 0xC0, 0xF0, 0x38, 0x3E,
  0x1E, 0x07, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x01, 0xE0, 0xF0, 0x1C,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xF8, 0x78, 0x78, 0x06, 0x38, 0x01,
  0xCE, 0x3F, 0x37, 0x1F, 0xCD, 0x8E, 0x63, 0xE7, 0x18, 0xF9, 0x8E, 0x3E,
  0x63, 0x9F, 0x38, 0xC6, 0xCE, 0x73, 0xB1, 0xFF, 0xCE, 0x79, 0xE3, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x06, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01,
  0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF,
  0x8F, 0x07, 0x1C, 0x0F, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xC7, 0xFE, 0x3F, 0xE0,
  0xFF, 0xC3, 0x8F, 0x0E, 0x1E, 0x38, 0x79, 0xE1, 0xE7, 0x8F, 0x1F, 0xFC,
  0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x87, 0x86, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x82, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7,
  0x07, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xC1, 0xE3, 0x83,
  0xCF, 0x0F, 0x1E, 0x7E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0xF8, 0x63, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x71, 0xFD, 0xE3, 0xFB, 0xC7, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x1E, 0x1C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0x07, 0x0F, 0x0F,
  0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3C, 0x1C, 0x38, 0x3C, 0x38, 0x3C, 0x78, 0x3C,
  0x78, 0x38, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0x0F, 0xF0, 0xFE, 0x1F,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xE0, 0xFF, 0x0F, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x0F,
  0x0E, 0x1E, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x1D, 0xE0,
  0x1D, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x39, 0xC0, 0x39, 0xE0,
  0x79, 0xE0, 0x78, 0xE0, 0x70, 0xF0, 0x70, 0xF0, 0xF0, 0x78, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xFF, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xDC, 0x3F, 0x8E, 0xE1, 0xCC, 0xEF, 0x0E,
  0x67, 0x70, 0x73, 0x73, 0x83, 0x9B, 0x9C, 0x3C, 0xF8, 0xE1, 0xC7, 0xCF,
  0x0E, 0x3C, 0x70, 0x71, 0xE3, 0x87, 0x8E, 0x1C, 0x00, 0x0F, 0x03, 0xC3,
  0xE0, 0xE0, 0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x87, 0x87, 0xF1, 0xC1, 0xDC,
  0x70, 0x77, 0x1C, 0x3D, 0xCF, 0x0E, 0x7B, 0xC3, 0x8E, 0xE0, 0xE3, 0xB8,
  0x38, 0xFE, 0x1E, 0x1F, 0x87, 0x07, 0xC1, 0xC1, 0xF0, 0x70, 0x7C, 0x3C,
  0x0F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81,
  0xEF, 0x03, 0xDE, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E, 0x1C, 0x78, 0x71, 0xC3,
  0xC7, 0x0F, 0x3C, 0xF8, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x70,
  0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x1E, 0x3E,
  0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xC3, 0xC7, 0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x0E, 0x70, 0x39,
  0xE1, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0xF3, 0xC1, 0xE0, 0x07, 0xF0,
  0x7F, 0xC7, 0xFC, 0x3C, 0x63, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF3, 0x0F, 0x1F, 0xF8,
  0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x1E, 0x1E, 0x38, 0x3C, 0x70,
  0x79, 0xE0, 0xE3, 0xC1, 0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x38,
  0xF0, 0x71, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C,
  0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x78,
  0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xBC, 0x3C, 0x3D, 0xE1, 0xE1, 0xCF,
  0x1F, 0x0E, 0x78, 0xF8, 0xF3, 0xCF, 0xC7, 0x1E, 0x7E, 0x78, 0xF7, 0x73,
  0x87, 0xBB, 0x9C, 0x39, 0xDD, 0xC1, 0xDC, 0xEE, 0x0E, 0xE7, 0xF0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x00, 0x0E, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0x80, 0xE7, 0x80, 0x73, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0xF0, 0xE0, 0x70,
  0x78, 0x78, 0x3C, 0x00, 0xF0, 0x7B, 0x87, 0x9C, 0x3C, 0xE3, 0xC7, 0x9C,
  0x3D, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC4, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x3E, 0x07, 0xC1, 0xF8,
  0x00, 0xE7, 0x39, 0xCE, 0x71, 0xCE, 0x73, 0x9C, 0xE7, 0x1C, 0xE7, 0x39,
  0xC0, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0x80, 0x1C, 0x03,
  0xC0, 0x7C, 0x06, 0xC0, 0xEE, 0x1C, 0xE1, 0xC6, 0x38, 0x77, 0x07, 0xF0,
  0x70, 0xFF, 0xFF, 0xC0, 0xF7, 0x9C, 0x70, 0x0E, 0x31, 0xF7, 0x3F, 0xF7,
  0xDF, 0x78, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF,
  0xFC, 0xFD, 0xC7, 0xDC, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x70, 0x77, 0xC3, 0xFE, 0x3E, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xF3,
  0x87, 0x3C, 0x39, 0xE3, 0xCF, 0x1C, 0x7F, 0xE3, 0xFE, 0x3B, 0xE0, 0x07,
  0x87, 0xF3, 0xFD, 0xF1, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0F,
  0x0B, 0xFC, 0x7F, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x39, 0xC1, 0xF7, 0x0F, 0xFC, 0x79, 0xF1, 0xE3, 0xCF, 0x0E,
  0x3C, 0x38, 0xF0, 0xE3, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0xFF, 0xC3, 0xFF,
  0x07, 0xDC, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0xBC, 0x77, 0x0F, 0xE3, 0xFF,
  0xF7, 0xFC, 0xE0, 0x1C, 0x03, 0xC0, 0x7D, 0xC7, 0xF8, 0x7F, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x78, 0x01, 0xC0, 0x0F, 0xE0, 0xFF, 0x03,
  0xFC, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0x98, 0x7F, 0xC7, 0xFE,
  0x78, 0xF3, 0xC7, 0xBC, 0x39, 0xE1, 0xCF, 0x1E, 0x78, 0xF3, 0x87, 0x9E,
  0x78, 0xFF, 0xC7, 0xFE, 0x1E, 0xF0, 0x07, 0x00, 0x38, 0x83, 0xC7, 0xFC,
  0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x70, 0x77, 0xC3, 0xFF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0xE3,
  0x87, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x3C, 0x78, 0x0E,
  0x0F, 0x0E, 0x04, 0x00, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0xF1, 0xC7, 0x87, 0x3C, 0x3D, 0xE0, 0xF7, 0x03, 0xB8,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xBC, 0x1C, 0x70, 0x71, 0xE1, 0xC7,
  0x8F, 0x0F, 0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x1C, 0xE1,
  0xC3, 0xFE, 0xFC, 0x7F, 0xFF, 0x9F, 0x3E, 0x73, 0xC7, 0x8E, 0x78, 0xF1,
  0xCE, 0x1C, 0x39, 0xC3, 0x8F, 0x78, 0xF1, 0xEF, 0x1E, 0x39, 0xC3, 0x87,
  0x38, 0x70, 0xE7, 0x1E, 0x3D, 0xE3, 0xC7, 0x80, 0x1C, 0xE0, 0xEF, 0x87,
  0xFE, 0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0xF3, 0xC7,
  0x9C, 0x3C, 0xE1, 0xC7, 0x0E, 0x78, 0xF0, 0x07, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0xCF, 0x7F, 0xE7,
  0xF8, 0x7E, 0x00, 0x0E, 0x70, 0x3F, 0xE0, 0xFF, 0x87, 0xCF, 0x1E, 0x3C,
  0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0xFC,
  0x3F, 0xE1, 0xEF, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x31, 0xFF, 0x3F, 0xF7, 0x8F, 0x78, 0xF7, 0x0E, 0xF0,
  0xEF, 0x0E, 0xE1, 0xEE, 0x1C, 0xF3, 0xCF, 0xFC, 0xFD, 0xC7, 0xBC, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x1C, 0xE3, 0xB8, 0x7F,
  0x1F, 0xE3, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x00, 0x0F, 0x83, 0xFC, 0xFF, 0x1C, 0x23, 0x80, 0x78,
  0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x72, 0x0E, 0x7F, 0xCF, 0xF1, 0xFC, 0x00,
  0x0C, 0x06, 0x07, 0x07, 0xFF, 0xFF, 0xF8, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0xF1, 0xF8, 0x7C, 0x00, 0x38, 0x79, 0xC3, 0x8E,
  0x1C, 0xF1, 0xE7, 0x8F, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0xF1, 0xFF, 0x8F, 0xFC, 0x3E, 0xE0, 0xF0, 0xFF, 0x0F, 0x71, 0xE7,
  0x1E, 0x71, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0xE3, 0xC3, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0xF8,
  0xEE, 0x6C, 0xF7, 0x76, 0x73, 0xBB, 0x79, 0xD9, 0xB8, 0xFC, 0xDC, 0x7C,
  0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x80, 0x1E, 0x3C,
  0x78, 0xE0, 0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0xC0, 0x7F, 0x03, 0xDC, 0x0E, 0x78, 0x79, 0xE3, 0xC3, 0xC0, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C,
  0x07, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0xFC, 0x7F, 0xCF, 0xF8, 0x01, 0xC0,
  0xF0, 0x7C, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x1F, 0x0F, 0x83,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x03, 0xC1,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0xE0, 0x7C, 0x1E,
  0x0F, 0x87, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x83, 0xE0, 0xF0, 0x38,
  0x00, 0x78, 0x1F, 0xF7, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 9, 7, 11, 2, -18 },
  { 27, 15, 18, 15, 0, -18 },
  { 61, 13, 20, 13, 0, -19 },
  { 94, 18, 18, 20, 1, -18 },
  { 135, 16, 18, 16, 0, -18 },
  { 171, 5, 7, 6, 2, -18 },
  { 176, 9, 22, 8, 1, -18 },
  { 201, 9, 22, 8, -2, -18 },
  { 226, 11, 11, 12, 2, -19 },
  { 242, 12, 12, 13, 1, -15 },
  { 260, 6, 6, 7, -1, -3 },
  { 265, 7, 3, 8, 0, -8 },
  { 268, 4, 4, 7, 0, -4 },
  { 270, 13, 18, 10, -1, -18 },
  { 300, 12, 18, 13, 1, -18 },
  { 327, 10, 18, 13, 2, -18 },
  { 350, 14, 18, 13, -1, -18 },
  { 382, 13, 18, 13, 0, -18 },
  { 412, 13, 18, 13, 0, -18 },
  { 442, 13, 18, 13, 0, -18 },
  { 472, 12, 18, 13, 1, -18 },
  { 499, 13, 18, 13, 1, -18 },
  { 529, 13, 18, 13, 0, -18 },
  { 559, 11, 18, 13, 1, -18 },
  { 584, 7, 14, 7, 0, -14 },
  { 597, 8, 17, 7, -1, -14 },
  { 614, 12, 12, 13, 1, -15 },
  { 632, 12, 8, 13, 1, -13 },
  { 644, 12, 12, 13, 1, -15 },
  { 662, 10, 18, 10, 1, -18 },
  { 685, 18, 20, 20, 1, -18 },
  { 730, 15, 18, 14, -2, -18 },
  { 764, 14, 18, 14, 0, -18 },
  { 796, 14, 18, 14, 1, -18 },
  { 828, 15, 18, 15, 0, -18 },
  { 862, 13, 18, 12, 0, -18 },
  { 892, 13, 18, 12, 0, -18 },
  { 922, 15, 18, 16, 1, -18 },
  { 956, 16, 18, 16, 0, -18 },
  { 992, 12, 18, 9, -1, -18 },
  { 1019, 12, 23, 8, -4, -18 },
  { 1054, 16, 18, 14, 0, -18 },
  { 1090, 10, 18, 12, 0, -18 },
  { 1113, 21, 18, 20, 0, -18 },
  { 1161, 18, 18, 17, 0, -18 },
  { 1202, 15, 18, 17, 1, -18 },
  { 1236, 14, 18, 14, 0, -18 },
  { 1268, 15, 22, 17, 1, -18 },
  { 1310, 14, 18, 14, 0, -18 },
  { 1342, 13, 18, 12, 0, -18 },
  { 1372, 12, 18, 12, 2, -18 },
  { 1399, 15, 18, 16, 1, -18 },
  { 1433, 14, 18, 14, 2, -18 },
  { 1465, 21, 18, 21, 2, -18 },
  { 1513, 17, 18, 14, -1, -18 },
  { 1552, 13, 18, 13, 2, -18 },
  { 1582, 14, 18, 12, -1, -18 },
  { 1614, 11, 22, 8, -1, -18 },
  { 1645, 5, 18, 10, 3, -18 },
  { 1657, 11, 22, 8, -2, -18 },
  { 1688, 12, 11, 13, 0, -18 },
  { 1705, 9, 2, 9, -2, 2 },
  { 1708, 5, 4, 8, 4, -19 },
  { 1711, 12, 14, 14, 1, -14 },
  { 1732, 13, 19, 14, 0, -19 },
  { 1763, 10, 14, 11, 1, -14 },
  { 1781, 14, 19, 14, 1, -19 },
  { 1815, 11, 14, 13, 1, -14 },
  { 1835, 14, 25, 8, -3, -19 },
  { 1879, 13, 20, 14, 0, -14 },
  { 1912, 13, 19, 14, 0, -19 },
  { 1943, 8, 19, 7, 0, -19 },
  { 1962, 11, 25, 7, -3, -19 },
  { 1997, 14, 19, 13, 0, -19 },
  { 2031, 8, 19, 7, 0, -19 },
  { 2050, 19, 14, 20, 0, -14 },
  { 2084, 13, 14, 14, 0, -14 },
  { 2107, 11, 14, 13, 1, -14 },
  { 2127, 14, 20, 14, -1, -14 },
  { 2162, 12, 20, 14, 1, -14 },
  { 2192, 11, 14, 10, 0, -14 },
  { 2212, 11, 14, 11, 0, -14 },
  { 2232, 9, 17, 9, 1, -17 },
  { 2252, 13, 14, 14, 1, -14 },
  { 2275, 12, 14, 12, 1, -14 },
  { 2296, 17, 14, 18, 2, -14 },
  { 2326, 14, 14, 12, -1, -14 },
  { 2351, 15, 20, 12, -2, -14 },
  { 2389, 12, 14, 11, -1, -14 },
  { 2410, 10, 22, 9, 0, -18 },
  { 2438, 2, 25, 12, 5, -19 },
  { 2445, 10, 22, 9, -1, -18 },
  { 2473, 12, 4, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC25PT7B_H_
