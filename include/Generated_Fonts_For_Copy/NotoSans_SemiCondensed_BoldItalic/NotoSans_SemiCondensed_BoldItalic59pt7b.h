#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01,
  0xC0, 0x00, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0xDF, 0xE1, 0xFC, 0xFF, 0x0F,
  0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7E,
  0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xCE, 0x1E, 0x03, 0xFC, 0x70, 0x20, 0x1F, 0xE3, 0x80, 0x00,
  0xFF, 0x3C, 0x00, 0x07, 0xF9, 0xE0, 0x00, 0x3F, 0xCE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x3C, 0xFF, 0x00, 0x01, 0xC7,
  0xF8, 0x80, 0x0E, 0x3F, 0xC7, 0x00, 0x71, 0xFE, 0x3E, 0x07, 0x9F, 0xF1,
  0xFE, 0x3D, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8,
  0xFE, 0x3F, 0xF3, 0xF8, 0xFE, 0x3F, 0x1F, 0xFE, 0xFE, 0x7F, 0x9F, 0x8F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xE7, 0xFF, 0xF7, 0xFF, 0xE3, 0xF3, 0xFF, 0xFD,
  0xFF, 0xF9, 0xF8, 0xFE, 0x7F, 0x3F, 0xF8, 0xFE, 0x7F, 0x0F, 0xC7, 0xFC,
  0x3F, 0x1F, 0xC3, 0xF0, 0x38, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0x81, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF,
  0x81, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE3, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xF7, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF,
  0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF8, 0x07,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xF0, 0x07,
  0xFF, 0xC1, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF9,
  0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x08, 0x07, 0xE0, 0x03, 0x81, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7F, 0x9F, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xBF, 0x80, 0x7F, 0xC7, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0x3C, 0x0F, 0xE0, 0x02, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x8F, 0xF7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF7, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x8F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC, 0x7F, 0x81,
  0xC1, 0xFE, 0x02, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x38, 0x01,
  0xFE, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xCF, 0xFF, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x0F, 0xFC, 0x38, 0x00, 0x7F, 0xE0,
  0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFE, 0x13, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x20,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3C, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC3, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x06,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0xF0,
  0x0F, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC7, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x08, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x87,
  0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x1F,
  0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F,
  0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xF3, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xC1, 0xFF,
  0xEF, 0xF0, 0x1F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xC3, 0xFE, 0x0E, 0x01, 0xFF, 0x08, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0xFF, 0x87, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x7E, 0x1F, 0xC0,
  0xFF, 0xFF, 0x83, 0xE1, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xFC,
  0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xF0, 0x3F,
  0x03, 0xE3, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x7E, 0x0F, 0xC0, 0x7E, 0x07,
  0xE7, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE7,
  0xE1, 0xF8, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xCF, 0xC1,
  0xF8, 0x0F, 0xC0, 0xFC, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0xFC, 0x1F, 0xCF, 0xFC, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x0F, 0xFF, 0x7F, 0xFC, 0x07, 0xE0, 0xFF, 0xE7, 0xFF, 0x80,
  0x7E, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3C, 0x07,
  0xFF, 0x00, 0x08, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0x07, 0xF8,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0x01, 0xFF, 0xC0, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x7F,
  0xC0, 0x7F, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xE3,
  0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xF0,
  0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8,
  0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0,
  0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x3F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE0,
  0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xF8, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE1, 0xF9, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xF9, 0xFC, 0x3F, 0xC0,
  0x1F, 0xC1, 0xFB, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFB, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFB, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x80,
  0x3F, 0x81, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xF8,
  0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFC,
  0x03, 0xFB, 0xFC, 0x03, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xF8, 0x03, 0xF9,
  0xFC, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x07,
  0xF8, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x8F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x3F, 0xDF, 0xC0, 0x1F, 0xC0, 0x3F, 0xDF,
  0xC0, 0x1F, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x0F,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0x0F, 0xF8,
  0x00, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x81, 0x00, 0x03, 0xFE, 0x06, 0x00, 0x1F, 0xF8, 0x1F,
  0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xF9, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFC, 0xFC, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x7E, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFE, 0x3F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x1F, 0x87, 0xF8, 0x01,
  0xFC, 0x7F, 0x0F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x87, 0xE3, 0xFC, 0x00,
  0x7F, 0x3F, 0x83, 0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xC1, 0xF9, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x7E, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x3F, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x80,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xF0, 0x0F,
  0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0xFE, 0x03, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x83, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xE0, 0x07,
  0xFF, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFD, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFC,
  0x07, 0xF7, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFC, 0x3C, 0x1F, 0xF8, 0x02, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x10, 0x7F, 0xE0,
  0x18, 0x1F, 0xF8, 0x7C, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x7F, 0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x0F,
  0xF8, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x81, 0xFF,
  0x00, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x7F, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0xFF,
  0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0x7F, 0x80, 0x07, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x80, 0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC1,
  0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x03, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x3F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F,
  0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xC3, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x07, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x03, 0xFB, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFF, 0x01, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x87,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC3, 0xFE, 0x00,
  0xFC, 0x3F, 0xF8, 0x07, 0xE7, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x03, 0xFB,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE,
  0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03,
  0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xE1, 0xFF, 0x9F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7E, 0x3F, 0xFC, 0x00,
  0x7E, 0x7F, 0xFC, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xC0, 0x1F,
  0xEF, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xE0, 0x60, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0x1F, 0x80, 0x7F, 0xFE, 0xFE, 0x03, 0xFF,
  0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0xFC, 0x03,
  0xFF, 0xEF, 0xE0, 0x07, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x06,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x3F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE6, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF8, 0x1F, 0xF0,
  0x1C, 0x0F, 0xF0, 0x02, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x80, 0x07, 0xFC, 0x60, 0x03, 0xFE, 0x3E, 0x07, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x84, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x50, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0xC0,
  0x7F, 0xFF, 0x7F, 0x00, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xC7, 0xE0, 0x03,
  0xFC, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xE7, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x03,
  0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xEF, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFB, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE3,
  0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xDF, 0x83, 0xFC, 0x3F, 0x83,
  0xF7, 0xE1, 0xFE, 0x0F, 0xE0, 0xFD, 0xF8, 0x7F, 0x83, 0xF8, 0x7E, 0x7E,
  0x1F, 0xC0, 0xFE, 0x1F, 0x9F, 0x8F, 0xF0, 0x3F, 0x8F, 0xE7, 0xE3, 0xFC,
  0x0F, 0xE3, 0xF1, 0xF9, 0xFE, 0x03, 0xF9, 0xFC, 0x7E, 0x7F, 0x80, 0xFE,
  0x7E, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8F, 0xEF, 0xF0, 0x0F, 0xEF, 0xE3,
  0xFB, 0xF8, 0x03, 0xFB, 0xF0, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x3F, 0x7F,
  0x00, 0x3F, 0xFE, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x83, 0xF7, 0xF0, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03,
  0xF7, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x27, 0xFF, 0x00, 0x05,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0x90,
  0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 43, 16, 0, -42 },
  { 98, 21, 15, 25, 6, -42 },
  { 138, 34, 42, 34, 1, -42 },
  { 317, 29, 48, 30, 1, -45 },
  { 491, 42, 44, 47, 3, -43 },
  { 722, 36, 44, 38, 1, -43 },
  { 920, 10, 15, 15, 6, -42 },
  { 939, 21, 51, 19, 2, -42 },
  { 1073, 21, 52, 19, -4, -43 },
  { 1210, 26, 27, 29, 5, -45 },
  { 1298, 27, 28, 31, 3, -35 },
  { 1393, 14, 15, 16, -3, -7 },
  { 1420, 16, 7, 18, 1, -19 },
  { 1434, 10, 10, 16, 0, -9 },
  { 1447, 32, 43, 24, -3, -43 },
  { 1619, 28, 44, 30, 2, -43 },
  { 1773, 22, 42, 30, 5, -42 },
  { 1889, 32, 43, 30, -2, -43 },
  { 2061, 30, 44, 30, 0, -43 },
  { 2226, 31, 42, 30, -1, -42 },
  { 2389, 30, 43, 30, 0, -42 },
  { 2551, 29, 44, 30, 2, -43 },
  { 2711, 31, 42, 30, 2, -42 },
  { 2874, 29, 44, 30, 1, -43 },
  { 3034, 27, 44, 30, 2, -43 },
  { 3183, 15, 34, 16, 0, -33 },
  { 3247, 18, 41, 16, -3, -33 },
  { 3340, 27, 30, 31, 3, -36 },
  { 3442, 27, 18, 31, 3, -30 },
  { 3503, 27, 30, 31, 3, -36 },
  { 3605, 24, 44, 24, 3, -43 },
  { 3737, 44, 47, 46, 2, -42 },
  { 3996, 34, 42, 34, -4, -42 },
  { 4175, 32, 42, 33, 1, -42 },
  { 4343, 32, 44, 32, 3, -43 },
  { 4519, 34, 42, 36, 1, -42 },
  { 4698, 30, 42, 29, 1, -42 },
  { 4856, 30, 42, 28, 1, -42 },
  { 5014, 34, 44, 37, 3, -43 },
  { 5201, 38, 42, 38, 1, -42 },
  { 5401, 27, 42, 21, -2, -42 },
  { 5543, 28, 54, 18, -9, -42 },
  { 5732, 37, 42, 33, 1, -42 },
  { 5927, 23, 42, 28, 1, -42 },
  { 6048, 48, 42, 48, 1, -42 },
  { 6300, 40, 42, 40, 1, -42 },
  { 6510, 35, 44, 39, 3, -43 },
  { 6703, 33, 42, 33, 1, -42 },
  { 6877, 35, 53, 39, 3, -43 },
  { 7109, 31, 42, 33, 1, -42 },
  { 7272, 30, 44, 29, 0, -43 },
  { 7437, 28, 42, 28, 5, -42 },
  { 7584, 35, 43, 37, 3, -42 },
  { 7773, 32, 42, 32, 5, -42 },
  { 7941, 49, 42, 49, 5, -42 },
  { 8199, 40, 42, 32, -3, -42 },
  { 8409, 31, 42, 30, 5, -42 },
  { 8572, 34, 42, 28, -2, -42 },
  { 8751, 25, 51, 19, -2, -42 },
  { 8911, 14, 43, 24, 6, -43 },
  { 8987, 24, 51, 19, -4, -42 },
  { 9140, 28, 26, 30, 1, -42 },
  { 9231, 22, 4, 22, -5, 5 },
  { 9242, 11, 9, 19, 9, -45 },
  { 9255, 30, 34, 32, 2, -33 },
  { 9383, 30, 46, 32, 0, -45 },
  { 9556, 25, 34, 26, 2, -33 },
  { 9663, 32, 46, 32, 2, -45 },
  { 9847, 27, 34, 30, 2, -33 },
  { 9962, 33, 59, 20, -6, -45 },
  { 10206, 32, 47, 32, 0, -33 },
  { 10394, 29, 45, 33, 1, -45 },
  { 10558, 18, 45, 16, 0, -45 },
  { 10660, 26, 59, 16, -8, -45 },
  { 10852, 32, 45, 30, 1, -45 },
  { 11032, 18, 45, 16, 0, -45 },
  { 11134, 45, 33, 48, 1, -33 },
  { 11320, 29, 33, 33, 1, -33 },
  { 11440, 27, 34, 32, 2, -33 },
  { 11555, 32, 47, 32, -2, -33 },
  { 11743, 30, 47, 32, 2, -33 },
  { 11920, 25, 33, 23, 0, -33 },
  { 12024, 25, 34, 25, 0, -33 },
  { 12131, 20, 40, 22, 3, -39 },
  { 12231, 30, 33, 32, 2, -32 },
  { 12355, 28, 32, 28, 3, -32 },
  { 12467, 42, 32, 43, 4, -32 },
  { 12635, 35, 32, 29, -3, -32 },
  { 12775, 35, 46, 28, -4, -32 },
  { 12977, 28, 32, 25, -2, -32 },
  { 13089, 24, 51, 21, 0, -42 },
  { 13242, 6, 58, 29, 11, -45 },
  { 13286, 23, 51, 21, -3, -42 },
  { 13433, 27, 10, 31, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC59PT7B_H_
