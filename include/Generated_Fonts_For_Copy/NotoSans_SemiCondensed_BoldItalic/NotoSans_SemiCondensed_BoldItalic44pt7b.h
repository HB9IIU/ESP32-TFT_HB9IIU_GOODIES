#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x04, 0x00, 0x3F, 0x3F, 0x3E,
  0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03,
  0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xEC, 0xF0, 0x7F, 0x70, 0x81,
  0xF9, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0xD8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xDF, 0x80, 0x06, 0x7E, 0x00,
  0x19, 0xF8, 0xC0, 0xE7, 0xE3, 0xC3, 0xBF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x08, 0x07, 0xF8, 0x00, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x1F,
  0xFC, 0x03, 0xE0, 0x1F, 0x7C, 0x03, 0xC0, 0x3E, 0x3E, 0x07, 0xC0, 0x3E,
  0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x7C,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8,
  0x7C, 0xF8, 0x00, 0xF8, 0xF9, 0xF1, 0xF8, 0xF8, 0xF9, 0xF3, 0xFC, 0x7D,
  0xF3, 0xE7, 0xFE, 0x7F, 0xF7, 0xCF, 0xFE, 0x7F, 0xE7, 0xDF, 0x9F, 0x3F,
  0xCF, 0x9F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x3E, 0x00,
  0xF8, 0x3C, 0x3E, 0x01, 0xF0, 0x3C, 0x3E, 0x01, 0xF0, 0x3C, 0x7C, 0x03,
  0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x0F,
  0x80, 0x1F, 0xF0, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x3F, 0x0F, 0xFE, 0x0F, 0xC3, 0xFF, 0xC1, 0xF8, 0xFF, 0xFC, 0x7E, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE1, 0xFB, 0xF1, 0xFC, 0x3F, 0xFE, 0x3F, 0x83, 0xFF,
  0x87, 0xE0, 0x7F, 0xF0, 0xFC, 0x07, 0xFC, 0x1F, 0x80, 0xFF, 0x03, 0xF8,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xBF, 0xC0, 0xFF, 0xC3, 0xF8, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x04, 0x0F, 0x80, 0xE1, 0xE0, 0x1F, 0x3C, 0x07, 0xFF, 0x83, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x02, 0x3F,
  0xF0, 0x0F, 0xDE, 0x03, 0xFB, 0xE0, 0x7E, 0x7E, 0x07, 0x87, 0xC0, 0x20,
  0xFC, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x80, 0x7F,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1C, 0x7E, 0x7F, 0xFF,
  0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8,
  0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x80,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xBF,
  0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x3F,
  0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE,
  0x7F, 0xFE, 0xFF, 0x7E, 0x7E, 0xFC, 0x7C, 0xFC, 0x30, 0xFC, 0x20, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0x80, 0xC0,
  0x7F, 0x01, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xDF, 0xF0, 0x38, 0x1F, 0xC0, 0x40, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF2, 0x00, 0x3F, 0x8E, 0x01, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8,
  0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x80,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x06, 0x1F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x80, 0x0F, 0xE1, 0xC0, 0x7F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0x18, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x3F, 0x7F, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8,
  0x7F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x8F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF8, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFD, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0xCF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x3F, 0x81, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x81,
  0xFC, 0xFC, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFE, 0xFC, 0x1F, 0xEF, 0xC0, 0x7E, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x20, 0x3F, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x81, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x30, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xF1, 0xFC,
  0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x03,
  0xFE, 0x1F, 0x1E, 0x07, 0xFF, 0x1F, 0x3E, 0x1F, 0xFF, 0x0F, 0x3C, 0x1F,
  0xBF, 0x0F, 0x7C, 0x3E, 0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x0F, 0x78, 0x78,
  0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0, 0xF0,
  0x3C, 0x1E, 0xF0, 0xF0, 0x7C, 0x3E, 0xF0, 0xF0, 0x7C, 0x3C, 0xF1, 0xF0,
  0xF8, 0x7C, 0xF0, 0xF0, 0xF8, 0x78, 0xF0, 0xFB, 0xFD, 0xF8, 0xF0, 0xFF,
  0xBF, 0xF0, 0xF0, 0x7F, 0xBF, 0xE0, 0xF8, 0x3F, 0x1F, 0xC0, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x04, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF8, 0x0C, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x20, 0x7F, 0x81, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x07, 0xF8, 0x1F, 0x81, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x7E,
  0x07, 0xF8, 0x3F, 0x3F, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x70,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0x7E, 0x07, 0xFF, 0x3F, 0x83, 0xFF, 0x8F,
  0xE0, 0xFF, 0xE3, 0xF8, 0x3F, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x21, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0x80, 0x03,
  0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x07, 0xDF, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x3F, 0x7C, 0x1F,
  0x3E, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0xFD, 0xF0, 0xF9, 0xF8, 0x1F, 0x3E,
  0x1F, 0x3F, 0x03, 0xE3, 0xC7, 0xC7, 0xE0, 0xFC, 0x78, 0xF8, 0xF8, 0x1F,
  0x8F, 0x3E, 0x3F, 0x03, 0xF1, 0xF7, 0xC7, 0xE0, 0x7C, 0x3F, 0xF0, 0xFC,
  0x1F, 0x87, 0xFE, 0x1F, 0x83, 0xF0, 0xFF, 0x83, 0xE0, 0x7E, 0x1F, 0xF0,
  0xFC, 0x0F, 0xC3, 0xFC, 0x1F, 0x81, 0xF0, 0x7F, 0x83, 0xF0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xE0,
  0x3F, 0xC0, 0x1F, 0x81, 0xFF, 0x00, 0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x1F,
  0xF8, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xE0,
  0xF8, 0x0F, 0x9F, 0x87, 0xE0, 0x7E, 0x7E, 0x1F, 0x81, 0xF8, 0xF8, 0x7E,
  0x07, 0xE3, 0xF1, 0xF0, 0x1F, 0x0F, 0xC7, 0xC0, 0xFC, 0x3F, 0x3F, 0x03,
  0xF0, 0x7E, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0, 0x3F, 0x07, 0xEF, 0x80, 0xF8,
  0x0F, 0xBE, 0x07, 0xE0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0xE0, 0x7E, 0x03,
  0xFF, 0x81, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0x00, 0x7F,
  0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC,
  0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0x03, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE1, 0x00, 0x3F, 0x07, 0x83, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x7E,
  0x03, 0xF8, 0x1F, 0xC3, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F,
  0xC0, 0x7C, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x80,
  0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x0F,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0x81, 0xF8, 0xFC, 0x1F, 0xF8, 0x3F, 0x0F,
  0xC1, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0x0F, 0xC3, 0xEF, 0x87,
  0xE0, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F, 0xC7, 0xEF, 0x8F, 0xC0, 0xFC, 0x7C,
  0xF8, 0xFC, 0x0F, 0xCF, 0xCF, 0x8F, 0x80, 0xFC, 0xF8, 0xF9, 0xF8, 0x0F,
  0xCF, 0x8F, 0x9F, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF,
  0x00, 0xFF, 0xF0, 0xFB, 0xE0, 0x0F, 0xBE, 0x0F, 0xFE, 0x00, 0xFB, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x87,
  0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x02, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x08, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0x3C, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xBF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x3F, 0x1F,
  0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x01, 0xFC, 0x7E, 0x07, 0xFC, 0xF8, 0x1F,
  0xFD, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0xF8, 0x0F, 0xF9, 0xF0, 0x0F,
  0xE3, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x7E, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xDF, 0xFC, 0x1F, 0x7F, 0xE0, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x43, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xFD, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x87, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xEF, 0x80, 0x3F, 0x8F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x7E, 0x7F, 0x07, 0xCF, 0xC0, 0xFB, 0xF0,
  0x3F, 0x7E, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x04, 0x7F, 0x87, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x90, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x3F, 0x01, 0xFF, 0x3E, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0xC0, 0x3F, 0x80, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F,
  0xC0, 0x7E, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81,
  0xF8, 0xFE, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0,
  0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x00, 0x07, 0xC7, 0xF0, 0x7F, 0x01, 0xF3, 0xFE, 0x3F, 0xE0, 0x7D, 0xFF,
  0x9F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC3, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07,
  0xE3, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xC7, 0xF0, 0x1F, 0x3F,
  0xE0, 0x7D, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xC3, 0xF0,
  0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x81,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xF8, 0x7F, 0x7F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC, 0xFC, 0x3F,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xF1, 0xFC, 0x01, 0xF3, 0xFE, 0x01, 0xF7, 0xFE, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xBF, 0xE0, 0x3F, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x3E, 0x07, 0xFE, 0xF8, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x7F, 0x03, 0xEF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x78,
  0x3F, 0x01, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0x01, 0xFC, 0x7E, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF8, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x0F, 0xE3, 0xE0, 0xFC, 0x03,
  0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC1, 0xFB, 0xE0, 0x7F, 0x83,
  0xF7, 0xC1, 0xFF, 0x0F, 0xEF, 0x83, 0xFE, 0x1F, 0x9F, 0x07, 0xF8, 0x3F,
  0x3E, 0x1F, 0xF0, 0xFC, 0x7C, 0x3D, 0xE1, 0xF8, 0xF8, 0xFB, 0xC7, 0xE1,
  0xF1, 0xF7, 0x8F, 0xC3, 0xE3, 0xCF, 0x1F, 0x07, 0xCF, 0x9E, 0x7E, 0x0F,
  0x9F, 0x3C, 0xFC, 0x1F, 0x7C, 0x7B, 0xF0, 0x3E, 0xF8, 0xF7, 0xE0, 0x7D,
  0xE1, 0xEF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x01,
  0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xE0,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x17, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 16, 11, 19, 4, -31 },
  { 79, 25, 31, 26, 1, -31 },
  { 176, 22, 36, 22, 1, -33 },
  { 275, 32, 32, 35, 2, -32 },
  { 403, 27, 32, 28, 1, -32 },
  { 511, 8, 11, 11, 4, -31 },
  { 522, 16, 38, 14, 1, -31 },
  { 598, 16, 39, 14, -3, -32 },
  { 676, 19, 20, 22, 4, -34 },
  { 724, 20, 21, 23, 2, -26 },
  { 777, 10, 11, 12, -2, -5 },
  { 791, 12, 6, 14, 1, -15 },
  { 800, 8, 8, 12, 0, -7 },
  { 808, 23, 32, 18, -2, -32 },
  { 900, 21, 32, 22, 1, -32 },
  { 984, 16, 31, 22, 4, -31 },
  { 1046, 23, 32, 22, -1, -32 },
  { 1138, 22, 32, 22, 0, -32 },
  { 1226, 23, 31, 22, -1, -31 },
  { 1316, 23, 31, 22, 0, -31 },
  { 1406, 21, 32, 22, 2, -32 },
  { 1490, 23, 31, 22, 1, -31 },
  { 1580, 22, 32, 22, 1, -32 },
  { 1668, 21, 32, 22, 1, -32 },
  { 1752, 11, 25, 12, 0, -24 },
  { 1787, 13, 30, 12, -2, -24 },
  { 1836, 20, 22, 23, 2, -27 },
  { 1891, 20, 13, 23, 2, -22 },
  { 1924, 20, 22, 23, 2, -27 },
  { 1979, 17, 33, 18, 3, -32 },
  { 2050, 32, 36, 34, 2, -32 },
  { 2194, 25, 31, 25, -3, -31 },
  { 2291, 24, 31, 25, 1, -31 },
  { 2384, 24, 32, 24, 2, -32 },
  { 2480, 25, 31, 27, 1, -31 },
  { 2577, 22, 31, 22, 1, -31 },
  { 2663, 22, 31, 21, 1, -31 },
  { 2749, 26, 32, 28, 2, -32 },
  { 2853, 28, 31, 28, 1, -31 },
  { 2962, 21, 31, 16, -2, -31 },
  { 3044, 21, 40, 13, -7, -31 },
  { 3149, 28, 31, 25, 1, -31 },
  { 3258, 17, 31, 21, 1, -31 },
  { 3324, 35, 31, 36, 1, -31 },
  { 3460, 30, 31, 30, 1, -31 },
  { 3577, 26, 32, 29, 2, -32 },
  { 3681, 24, 31, 24, 1, -31 },
  { 3774, 26, 39, 29, 2, -32 },
  { 3901, 23, 31, 25, 1, -31 },
  { 3991, 22, 32, 21, 0, -32 },
  { 4079, 20, 31, 21, 4, -31 },
  { 4157, 26, 31, 28, 2, -31 },
  { 4258, 24, 31, 24, 4, -31 },
  { 4351, 36, 31, 36, 4, -31 },
  { 4491, 30, 31, 24, -3, -31 },
  { 4608, 23, 31, 23, 4, -31 },
  { 4698, 26, 31, 21, -2, -31 },
  { 4799, 18, 38, 14, -1, -31 },
  { 4885, 10, 32, 18, 5, -32 },
  { 4925, 18, 38, 14, -3, -31 },
  { 5011, 22, 20, 22, 0, -32 },
  { 5066, 17, 3, 16, -4, 4 },
  { 5073, 9, 7, 14, 6, -34 },
  { 5081, 23, 24, 24, 1, -24 },
  { 5150, 22, 33, 24, 0, -33 },
  { 5241, 18, 24, 19, 2, -24 },
  { 5295, 24, 33, 24, 2, -33 },
  { 5394, 19, 24, 22, 2, -24 },
  { 5451, 25, 45, 15, -5, -34 },
  { 5592, 24, 35, 24, 0, -24 },
  { 5697, 22, 33, 24, 0, -33 },
  { 5788, 13, 33, 12, 0, -33 },
  { 5842, 19, 44, 12, -6, -33 },
  { 5947, 25, 33, 23, 0, -33 },
  { 6051, 14, 33, 12, 0, -33 },
  { 6109, 34, 24, 36, 0, -24 },
  { 6211, 22, 24, 24, 0, -24 },
  { 6277, 20, 24, 24, 2, -24 },
  { 6337, 24, 35, 24, -2, -24 },
  { 6442, 23, 35, 24, 1, -24 },
  { 6543, 19, 24, 17, 0, -24 },
  { 6600, 19, 24, 19, 0, -24 },
  { 6657, 15, 29, 16, 2, -29 },
  { 6712, 22, 24, 24, 2, -24 },
  { 6778, 21, 24, 21, 2, -24 },
  { 6841, 31, 24, 32, 3, -24 },
  { 6934, 26, 24, 21, -2, -24 },
  { 7012, 26, 35, 21, -3, -24 },
  { 7126, 20, 24, 19, -1, -24 },
  { 7186, 18, 38, 15, 0, -31 },
  { 7272, 5, 43, 21, 8, -33 },
  { 7299, 17, 38, 15, -2, -31 },
  { 7380, 20, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC44PT7B_H_
