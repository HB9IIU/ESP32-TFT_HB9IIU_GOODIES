#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x16, 0xDF, 0xA0, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x28, 0x11, 0xF7, 0x1C, 0x38, 0xAF, 0x98, 0x20, 0x67, 0x4A, 0xA5, 0xBD,
  0xE5, 0x52, 0xE7, 0x38, 0x58, 0xA1, 0xC7, 0x7B, 0xB6, 0x3E, 0xF8, 0x12,
  0x64, 0x4C, 0xCC, 0x44, 0x31, 0x11, 0x13, 0x32, 0x6C, 0x27, 0xDF, 0xE2,
  0x00, 0x63, 0x19, 0xF6, 0x30, 0x78, 0xFC, 0x70, 0x04, 0x30, 0x84, 0x30,
  0x86, 0x30, 0x39, 0xA4, 0xD2, 0xCB, 0x6D, 0x9C, 0x37, 0xF2, 0x26, 0x66,
  0x39, 0xB0, 0x86, 0x31, 0x8C, 0x3E, 0x39, 0x30, 0x8E, 0x38, 0x69, 0xBC,
  0x0C, 0x62, 0x9E, 0x5B, 0xE1, 0x0C, 0x3C, 0xE6, 0x1C, 0x18, 0x69, 0xBC,
  0x1C, 0xC6, 0x1E, 0xCB, 0x2D, 0x9C, 0x7D, 0xF0, 0x86, 0x30, 0x86, 0x30,
  0x39, 0xB6, 0xCE, 0x7B, 0x2D, 0x9C, 0x3B, 0x52, 0x97, 0x8C, 0x5C, 0x68,
  0x05, 0x80, 0x32, 0x00, 0x06, 0xC0, 0x09, 0xF1, 0x83, 0x04, 0xFF, 0xC1,
  0xF0, 0x86, 0x0C, 0x7C, 0x40, 0xFB, 0x36, 0xC0, 0x88, 0x1E, 0x31, 0x4F,
  0x55, 0xF5, 0xF5, 0xDE, 0x40, 0x3C, 0x0C, 0x18, 0x50, 0xA3, 0x47, 0x99,
  0x63, 0x3C, 0xB6, 0x5E, 0x79, 0x3C, 0xBE, 0x3D, 0xAC, 0x20, 0x82, 0x0D,
  0x3C, 0x38, 0x79, 0x9B, 0x36, 0x49, 0xB6, 0x78, 0x3C, 0x86, 0x1E, 0x79,
  0x0C, 0x3C, 0x3C, 0x86, 0x18, 0x79, 0x0C, 0x30, 0x3D, 0xBC, 0x21, 0x9A,
  0x2D, 0xBE, 0x22, 0x4D, 0x9B, 0xE7, 0xC9, 0xB3, 0x66, 0x79, 0x08, 0xC6,
  0x31, 0x1C, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x33, 0x80, 0x26, 0x59,
  0xA3, 0xC7, 0x0B, 0x36, 0x66, 0x22, 0x66, 0x44, 0xCF, 0x31, 0x99, 0xDC,
  0xEE, 0xE5, 0x52, 0xEB, 0x6D, 0xB6, 0x33, 0x32, 0x72, 0x7A, 0x5E, 0x4E,
  0xCC, 0xCC, 0x39, 0xBC, 0xE3, 0x8E, 0x3D, 0xBC, 0x38, 0xB6, 0x5B, 0x79,
  0x0C, 0x30, 0x39, 0xBC, 0xE3, 0x8E, 0x3D, 0xBC, 0x30, 0x60, 0x38, 0xB6,
  0xDB, 0x79, 0x6D, 0xB3, 0x3D, 0xA6, 0x1C, 0x30, 0x69, 0xBC, 0xFF, 0xD8,
  0xC6, 0x21, 0x18, 0x4F, 0x3C, 0xF2, 0x8A, 0x69, 0xBC, 0xCF, 0x2D, 0xB4,
  0xF3, 0x8E, 0x30, 0x89, 0xCC, 0xA6, 0x57, 0x6A, 0xA5, 0x73, 0x31, 0x98,
  0x33, 0x16, 0x14, 0x1C, 0x18, 0x3C, 0x6C, 0xC4, 0xCF, 0x6D, 0x1C, 0x61,
  0x04, 0x30, 0x7C, 0x21, 0x8C, 0x21, 0x8C, 0x3E, 0x36, 0x64, 0x44, 0xCC,
  0x8C, 0xD9, 0x24, 0x93, 0x38, 0x84, 0x23, 0x18, 0x84, 0x27, 0x00, 0x11,
  0x8A, 0x9C, 0x80, 0xF0, 0xC0, 0x3D, 0xB4, 0xB2, 0xD9, 0xE0, 0x21, 0x87,
  0x9B, 0x4D, 0x2D, 0xAC, 0x3B, 0x11, 0x8D, 0x38, 0x04, 0x33, 0xDB, 0x4B,
  0x2D, 0x9E, 0x3B, 0x57, 0xCC, 0xB8, 0x1C, 0x43, 0x9C, 0x30, 0x82, 0x18,
  0x63, 0x0C, 0x00, 0x3D, 0xB4, 0xB2, 0xD9, 0xE1, 0xBC, 0x60, 0x21, 0x87,
  0x9B, 0x49, 0x2C, 0xB6, 0x21, 0xB4, 0xB6, 0x10, 0x33, 0x22, 0x66, 0x6C,
  0x80, 0x21, 0x86, 0xDE, 0x71, 0xCD, 0xB6, 0x2D, 0xB4, 0xB6, 0x7B, 0x36,
  0xD2, 0x49, 0x2D, 0x96, 0xD8, 0x79, 0xB4, 0x92, 0xCB, 0x60, 0x3B, 0x53,
  0x9D, 0xB8, 0x79, 0xB4, 0xD2, 0xDB, 0xCC, 0x20, 0x80, 0x35, 0xB4, 0xB2,
  0xD9, 0xE1, 0x84, 0x10, 0x7B, 0x50, 0x8C, 0x60, 0x7A, 0x18, 0x6B, 0x78,
  0x5F, 0x49, 0x30, 0x6D, 0xB4, 0x92, 0xD9, 0xE0, 0x9D, 0xAD, 0x4E, 0x60,
  0x93, 0xB6, 0xB4, 0xD4, 0xDC, 0xD8, 0x36, 0x78, 0x61, 0xC2, 0x9D, 0x80,
  0x26, 0x48, 0xB1, 0x43, 0x86, 0x0C, 0x70, 0xC0, 0x78, 0x8C, 0xCC, 0x78,
  0x19, 0x88, 0x4E, 0x61, 0x08, 0x63, 0x00, 0xFF, 0xE0, 0x30, 0x84, 0x61,
  0x9C, 0x84, 0x66, 0x00, 0xCF, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 7, 8, 6, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 7, 8, 9, 1, -8 },
  { 27, 7, 8, 7, 0, -8 },
  { 34, 2, 3, 3, 1, -8 },
  { 35, 4, 10, 3, 0, -8 },
  { 40, 4, 10, 3, -1, -8 },
  { 45, 5, 5, 5, 1, -8 },
  { 49, 5, 6, 6, 1, -7 },
  { 53, 3, 2, 3, -1, -1 },
  { 54, 3, 2, 3, 0, -4 },
  { 55, 2, 2, 3, 0, -2 },
  { 56, 6, 8, 4, -1, -8 },
  { 62, 6, 8, 6, 0, -8 },
  { 68, 4, 8, 6, 1, -8 },
  { 72, 6, 8, 6, 0, -8 },
  { 78, 6, 8, 6, 0, -8 },
  { 84, 6, 8, 6, 0, -8 },
  { 90, 6, 8, 6, 0, -8 },
  { 96, 6, 8, 6, 0, -8 },
  { 102, 6, 8, 6, 0, -8 },
  { 108, 6, 8, 6, 0, -8 },
  { 114, 5, 8, 6, 0, -8 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 4, 7, 3, -1, -6 },
  { 126, 5, 6, 6, 1, -7 },
  { 130, 5, 4, 6, 1, -6 },
  { 133, 5, 6, 6, 1, -7 },
  { 137, 4, 8, 5, 1, -8 },
  { 141, 8, 9, 9, 0, -8 },
  { 150, 7, 8, 6, -1, -8 },
  { 157, 6, 8, 6, 0, -8 },
  { 163, 6, 8, 6, 1, -8 },
  { 169, 7, 8, 7, 0, -8 },
  { 176, 6, 8, 5, 0, -8 },
  { 182, 6, 8, 5, 0, -8 },
  { 188, 6, 8, 7, 1, -8 },
  { 194, 7, 8, 7, 0, -8 },
  { 201, 5, 8, 4, 0, -8 },
  { 206, 6, 10, 3, -2, -8 },
  { 214, 7, 8, 6, 0, -8 },
  { 221, 4, 8, 5, 0, -8 },
  { 225, 9, 8, 9, 0, -8 },
  { 234, 8, 8, 8, 0, -8 },
  { 242, 6, 8, 7, 1, -8 },
  { 248, 6, 8, 6, 0, -8 },
  { 254, 6, 10, 7, 1, -8 },
  { 262, 6, 8, 6, 0, -8 },
  { 268, 6, 8, 5, 0, -8 },
  { 274, 5, 8, 5, 1, -8 },
  { 279, 6, 8, 7, 1, -8 },
  { 285, 6, 8, 6, 1, -8 },
  { 291, 9, 8, 9, 1, -8 },
  { 300, 8, 8, 6, -1, -8 },
  { 308, 6, 8, 6, 1, -8 },
  { 314, 6, 8, 5, 0, -8 },
  { 320, 4, 10, 3, 0, -8 },
  { 325, 3, 8, 4, 1, -8 },
  { 328, 5, 10, 3, -1, -8 },
  { 335, 5, 5, 6, 0, -8 },
  { 339, 4, 1, 4, -1, 1 },
  { 340, 2, 1, 3, 2, -8 },
  { 341, 6, 6, 6, 0, -6 },
  { 346, 6, 8, 6, 0, -8 },
  { 352, 5, 6, 5, 0, -6 },
  { 356, 6, 8, 6, 0, -8 },
  { 362, 5, 6, 6, 0, -6 },
  { 366, 6, 11, 4, -1, -8 },
  { 375, 6, 9, 6, 0, -6 },
  { 382, 6, 8, 6, 0, -8 },
  { 388, 3, 8, 3, 0, -8 },
  { 391, 4, 11, 3, -1, -8 },
  { 397, 6, 8, 6, 0, -8 },
  { 403, 3, 8, 3, 0, -8 },
  { 406, 9, 6, 9, 0, -6 },
  { 413, 6, 6, 6, 0, -6 },
  { 418, 5, 6, 6, 0, -6 },
  { 422, 6, 9, 6, 0, -6 },
  { 429, 6, 9, 6, 0, -6 },
  { 436, 5, 6, 4, 0, -6 },
  { 440, 5, 6, 5, 0, -6 },
  { 444, 3, 7, 4, 1, -7 },
  { 447, 6, 6, 6, 0, -6 },
  { 452, 5, 6, 5, 1, -6 },
  { 456, 8, 6, 8, 1, -6 },
  { 462, 7, 6, 5, -1, -6 },
  { 468, 7, 9, 5, -1, -6 },
  { 476, 5, 6, 5, 0, -6 },
  { 480, 5, 10, 4, 0, -8 },
  { 487, 1, 11, 5, 2, -8 },
  { 489, 5, 10, 4, -1, -8 },
  { 496, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC11PT7B_H_
