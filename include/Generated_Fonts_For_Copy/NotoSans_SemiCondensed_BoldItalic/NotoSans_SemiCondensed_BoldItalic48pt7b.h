#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x7F, 0x3F, 0xBF, 0x1F, 0x9F,
  0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xF3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0xFC,
  0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xE7, 0x38, 0x0F, 0xC6, 0x08, 0x0F, 0xCE, 0x00, 0x0F, 0xCE, 0x00, 0x0F,
  0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x33, 0xF8, 0x00,
  0x71, 0xF8, 0xC0, 0x73, 0xF8, 0xF0, 0x73, 0xF8, 0xFF, 0x7F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x01, 0xFE, 0x00,
  0x1F, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xF0, 0x03, 0xE0, 0x3F, 0xFE,
  0x01, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x01, 0xF0,
  0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x83, 0xE0, 0x0F,
  0x83, 0xE1, 0xF0, 0x03, 0xE1, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF3, 0xE7,
  0xFC, 0xF9, 0xF9, 0xF3, 0xFF, 0xBF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0x3E,
  0x7F, 0xFD, 0xFF, 0x9F, 0x3F, 0x3F, 0x3F, 0xCF, 0xCF, 0x87, 0xC3, 0xC3,
  0xE7, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x3F, 0x00,
  0x3E, 0x1F, 0x0F, 0xC0, 0x1F, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0xF8,
  0x03, 0xE0, 0xFC, 0x7E, 0x01, 0xF0, 0x3F, 0x1F, 0x00, 0xF8, 0x0F, 0xC7,
  0xC0, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x00, 0x7F, 0xF8, 0x0F, 0x80, 0x1F,
  0xFC, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x1F, 0xC3, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x07, 0xE3, 0xFF,
  0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF1, 0xFC, 0x3F, 0xBF, 0x8F, 0xC1, 0xFF,
  0xF8, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x3F, 0x80, 0xFF, 0xC1,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xF9,
  0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC,
  0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x04, 0x07, 0xC0, 0x18, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0xEF, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x04, 0x3F, 0xF0, 0x03, 0xF7, 0xC0, 0x3F,
  0xBE, 0x03, 0xF8, 0xF8, 0x07, 0x87, 0xE0, 0x1C, 0x3F, 0x00, 0x41, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7C, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x0F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x87, 0xE0, 0xFE, 0x0F, 0xE7, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xBF, 0x1F,
  0xCF, 0xC3, 0xE7, 0xF0, 0x61, 0xFC, 0x10, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xC0, 0x3F,
  0x80, 0x40, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xE0, 0xFF, 0x01, 0x80, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0xC0, 0x07,
  0xF8, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xCF, 0xC0,
  0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xE1, 0xFC,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x20, 0x01, 0xFE, 0x18, 0x01, 0xFF, 0x0F, 0xC3, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x1F, 0xDF, 0xF8,
  0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xE7,
  0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0,
  0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xF9, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xE1, 0xFC,
  0x07, 0xF3, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xCF, 0xF0,
  0x7F, 0x87, 0xF0, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE,
  0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0,
  0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0x81, 0xFF, 0x3F, 0x00, 0xF8, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x18, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7E, 0x03, 0x80, 0x00, 0x18, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x07, 0xF8, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C,
  0x7C, 0x0F, 0xFF, 0x8F, 0x8F, 0x83, 0xFF, 0xE1, 0xF3, 0xE0, 0xFF, 0xFC,
  0x3E, 0x7C, 0x3F, 0x0F, 0x87, 0xDF, 0x07, 0xC1, 0xF0, 0xFB, 0xE1, 0xF0,
  0x7C, 0x1F, 0x7C, 0x3E, 0x0F, 0x83, 0xFF, 0x0F, 0x81, 0xF0, 0x7F, 0xE1,
  0xF0, 0x3E, 0x0F, 0x7C, 0x3E, 0x0F, 0x83, 0xEF, 0x8F, 0x81, 0xF0, 0x7D,
  0xF1, 0xF0, 0x3E, 0x1F, 0x3E, 0x3E, 0x0F, 0xC3, 0xE7, 0xC7, 0xC1, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7F, 0x3F, 0x1F, 0x0F, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF,
  0xBF, 0xF0, 0x7C, 0x1F, 0xE3, 0xFC, 0x0F, 0xC0, 0xF0, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0x00, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xF0, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC3,
  0xE0, 0x3F, 0xE0, 0x08, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x03, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x3F,
  0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0x7F, 0x83, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xC0,
  0x7F, 0xC0, 0x0C, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xC7, 0xF0,
  0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x7F, 0x07, 0xFF,
  0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x7F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0xC0, 0x01, 0xF9, 0xFE, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xFB, 0xF0, 0x3E, 0x7E,
  0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0x1F, 0xDF,
  0x87, 0xE7, 0xE0, 0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x7E, 0x3E, 0x3F, 0x3F,
  0x80, 0xFC, 0x7C, 0x7C, 0x7F, 0x01, 0xF8, 0xF9, 0xF8, 0xFC, 0x07, 0xF1,
  0xF3, 0xE1, 0xF8, 0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0x1F, 0x87, 0xDF, 0x0F,
  0xE0, 0x3F, 0x0F, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xF8, 0x3F, 0x01, 0xFC,
  0x3F, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0xE0, 0xFC, 0x07, 0xE0, 0xFF, 0x83,
  0xF8, 0x0F, 0xC1, 0xFF, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0x80, 0xFF,
  0x80, 0x0F, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x1F,
  0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x07,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF0, 0x3F, 0x01,
  0xF9, 0xF8, 0x1F, 0x80, 0xFC, 0xFC, 0x0F, 0xC0, 0x7E, 0x7E, 0x0F, 0xE0,
  0x3F, 0x3F, 0x87, 0xE0, 0x1F, 0x8F, 0xC3, 0xF0, 0x1F, 0xC7, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0xFE, 0x03, 0xF0, 0x7E, 0x7E,
  0x01, 0xF8, 0x3F, 0x3F, 0x01, 0xFC, 0x1F, 0xDF, 0x80, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0xFF,
  0xF0, 0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xE0, 0x0F,
  0xFE, 0x03, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87,
  0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFB, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC7, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xF1, 0xF8, 0x0F, 0xF0, 0x08, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x08, 0x00, 0xFE, 0x07,
  0x00, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFE,
  0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x3F, 0x81, 0xF8,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xFE, 0x03, 0xF0, 0xFE,
  0x07, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xBE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xBE, 0x0F, 0xC0, 0xFE, 0x1F, 0xBE, 0x0F, 0xC0,
  0xFE, 0x1F, 0x3E, 0x1F, 0xC0, 0xFE, 0x3F, 0x3E, 0x1F, 0x80, 0xFE, 0x3F,
  0x3E, 0x3F, 0x80, 0xFE, 0x7E, 0x3E, 0x3F, 0x00, 0xFE, 0x7E, 0x3E, 0x7F,
  0x00, 0xFE, 0x7C, 0x3E, 0x7F, 0x00, 0xFC, 0xFC, 0x3E, 0x7E, 0x00, 0x7C,
  0xF8, 0x3E, 0xFE, 0x00, 0x7D, 0xF8, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03,
  0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE1, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x3F, 0x03, 0xFF,
  0x3E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE3,
  0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0xC7,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x30, 0x00, 0xFC, 0xFF, 0x00,
  0x7E, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0x3F, 0xF0, 0x1F, 0x8F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xE0, 0xC3,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0x0F, 0xF8,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x1F, 0xC0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xFD, 0xF8, 0x07, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x7E, 0x00, 0x7F, 0x1F, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xF9, 0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8,
  0x0F, 0xDF, 0xC1, 0xFE, 0xFC, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x04, 0x7F, 0x80, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x3F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0xE3, 0xF0, 0x0F, 0xFC, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x02, 0x00, 0x3F, 0x80, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x70, 0x03, 0xF3, 0xFC,
  0x03, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x00, 0x10, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x23, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x81,
  0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0x1F, 0xE0, 0xFF, 0x00, 0xF9, 0xFF, 0x8F, 0xFC, 0x0F, 0xDF,
  0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF1, 0xFF, 0x8F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0x0F, 0xF0, 0x7F,
  0x81, 0xF8, 0x7F, 0x03, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xF8,
  0x7F, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC,
  0x07, 0xF1, 0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x70, 0x03, 0xE3, 0xFC, 0x03, 0xE7, 0xFE, 0x07, 0xEF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0x07, 0xF8,
  0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFE, 0x3F, 0x8F, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF,
  0xC0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xFC, 0x7F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x1F, 0xE0, 0x03, 0xE7, 0xFE, 0x00,
  0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF,
  0xF8, 0x03, 0xF3, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFE, 0x3F, 0x03, 0xFF, 0x3E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x1F,
  0x80, 0xF9, 0xFC, 0x0F, 0xDF, 0xE0, 0x7E, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x3E, 0x1F, 0xC0, 0x41,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x80, 0x1F, 0xCE, 0x03,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xBF,
  0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x84, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x3F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xE0, 0x7F, 0xF7, 0xE0, 0x7F, 0xE7,
  0xE0, 0x3F, 0xC7, 0xC0, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F,
  0xBF, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F,
  0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x01, 0xFE, 0x07,
  0xEF, 0xC0, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0xFE, 0xFC, 0x1F, 0xF0,
  0x3F, 0x3F, 0x07, 0xFC, 0x1F, 0xCF, 0xC3, 0xFF, 0x07, 0xE3, 0xF0, 0xFB,
  0xC3, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x3F, 0x1F, 0x7C, 0x7F, 0x0F, 0xC7,
  0xDF, 0x1F, 0x83, 0xF3, 0xF7, 0xC7, 0xE0, 0xFC, 0xF9, 0xF3, 0xF8, 0x3F,
  0x3E, 0x7C, 0xFC, 0x0F, 0xDF, 0x1F, 0x3F, 0x03, 0xF7, 0xC7, 0xDF, 0x80,
  0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0xF8, 0x7D, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0x81, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0x80, 0x04, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0xA0, 0x01,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 35, 13, 0, -34 },
  { 67, 17, 12, 21, 5, -34 },
  { 93, 28, 34, 28, 1, -34 },
  { 212, 24, 39, 24, 1, -36 },
  { 329, 34, 35, 38, 3, -35 },
  { 478, 29, 35, 31, 1, -35 },
  { 605, 8, 12, 12, 5, -34 },
  { 617, 18, 42, 15, 1, -34 },
  { 712, 18, 43, 15, -4, -35 },
  { 809, 21, 22, 24, 4, -37 },
  { 867, 22, 24, 26, 2, -29 },
  { 933, 11, 12, 13, -2, -6 },
  { 950, 13, 6, 15, 1, -16 },
  { 960, 8, 8, 13, 0, -7 },
  { 968, 25, 35, 19, -2, -35 },
  { 1078, 23, 35, 24, 1, -35 },
  { 1179, 18, 34, 24, 4, -34 },
  { 1256, 25, 35, 24, -1, -35 },
  { 1366, 24, 35, 24, 0, -35 },
  { 1471, 25, 34, 24, -1, -34 },
  { 1578, 25, 34, 24, 0, -34 },
  { 1685, 23, 35, 24, 2, -35 },
  { 1786, 25, 34, 24, 2, -34 },
  { 1893, 24, 35, 24, 1, -35 },
  { 1998, 23, 35, 24, 1, -35 },
  { 2099, 12, 28, 13, 0, -27 },
  { 2141, 16, 33, 13, -3, -27 },
  { 2207, 22, 24, 26, 2, -29 },
  { 2273, 22, 14, 26, 2, -24 },
  { 2312, 22, 24, 26, 2, -29 },
  { 2378, 19, 36, 20, 3, -35 },
  { 2464, 35, 38, 37, 2, -34 },
  { 2631, 27, 34, 27, -3, -34 },
  { 2746, 26, 34, 27, 1, -34 },
  { 2857, 27, 35, 26, 2, -35 },
  { 2976, 28, 34, 30, 1, -34 },
  { 3095, 24, 34, 24, 1, -34 },
  { 3197, 24, 34, 23, 1, -34 },
  { 3299, 28, 35, 30, 2, -35 },
  { 3422, 30, 34, 31, 1, -34 },
  { 3550, 22, 34, 17, -2, -34 },
  { 3644, 23, 44, 15, -8, -34 },
  { 3771, 30, 34, 27, 1, -34 },
  { 3899, 18, 34, 23, 1, -34 },
  { 3976, 39, 34, 39, 1, -34 },
  { 4142, 33, 34, 33, 1, -34 },
  { 4283, 29, 35, 32, 2, -35 },
  { 4410, 26, 34, 27, 1, -34 },
  { 4521, 29, 43, 32, 2, -35 },
  { 4677, 25, 34, 27, 1, -34 },
  { 4784, 25, 35, 23, 0, -35 },
  { 4894, 23, 34, 23, 4, -34 },
  { 4992, 28, 34, 30, 3, -34 },
  { 5111, 26, 34, 26, 4, -34 },
  { 5222, 40, 34, 40, 4, -34 },
  { 5392, 33, 34, 26, -3, -34 },
  { 5533, 25, 34, 25, 4, -34 },
  { 5640, 28, 34, 23, -2, -34 },
  { 5759, 19, 42, 15, -1, -34 },
  { 5859, 11, 35, 19, 5, -35 },
  { 5908, 19, 42, 15, -3, -34 },
  { 6008, 24, 21, 24, 0, -34 },
  { 6071, 18, 3, 18, -4, 4 },
  { 6078, 10, 8, 15, 7, -37 },
  { 6088, 24, 27, 26, 2, -27 },
  { 6169, 25, 36, 26, 0, -36 },
  { 6282, 20, 27, 21, 2, -27 },
  { 6350, 26, 36, 26, 2, -36 },
  { 6467, 21, 27, 24, 2, -27 },
  { 6538, 27, 49, 16, -5, -37 },
  { 6704, 26, 39, 26, 0, -27 },
  { 6831, 24, 36, 26, 0, -36 },
  { 6939, 15, 37, 13, 0, -37 },
  { 7009, 21, 49, 13, -6, -37 },
  { 7138, 27, 36, 25, 0, -36 },
  { 7260, 15, 36, 13, 0, -36 },
  { 7328, 37, 27, 39, 0, -27 },
  { 7453, 24, 27, 26, 0, -27 },
  { 7534, 22, 27, 26, 2, -27 },
  { 7609, 27, 38, 26, -2, -27 },
  { 7738, 24, 39, 26, 2, -27 },
  { 7855, 21, 27, 18, 0, -27 },
  { 7926, 20, 27, 21, 0, -27 },
  { 7994, 17, 32, 18, 2, -32 },
  { 8062, 24, 26, 26, 2, -26 },
  { 8140, 22, 26, 23, 3, -26 },
  { 8212, 34, 26, 35, 3, -26 },
  { 8323, 28, 26, 23, -2, -26 },
  { 8414, 28, 38, 23, -3, -26 },
  { 8547, 22, 26, 20, -1, -26 },
  { 8619, 20, 42, 17, 0, -34 },
  { 8724, 5, 48, 23, 9, -37 },
  { 8754, 20, 42, 17, -3, -34 },
  { 8859, 22, 8, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC48PT7B_H_
