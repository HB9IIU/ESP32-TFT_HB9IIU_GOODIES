#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_BoldItalic
// Headers: 67

#include "NotoSans_SemiCondensed_BoldItalic6pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic7pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic8pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic9pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic10pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic11pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic12pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic13pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic14pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic15pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic16pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic17pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic18pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic19pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic20pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic21pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic22pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic23pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic24pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic25pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic26pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic27pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic28pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic29pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic30pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic31pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic32pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic33pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic34pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic35pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic36pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic37pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic38pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic39pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic40pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic41pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic42pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic43pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic44pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic45pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic46pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic47pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic48pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic49pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic50pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic51pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic52pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic53pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic54pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic55pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic56pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic57pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic58pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic59pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic60pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic61pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic62pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic63pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic64pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic65pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic66pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic67pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic68pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic69pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic70pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic71pt7b.h"
#include "NotoSans_SemiCondensed_BoldItalic72pt7b.h"
