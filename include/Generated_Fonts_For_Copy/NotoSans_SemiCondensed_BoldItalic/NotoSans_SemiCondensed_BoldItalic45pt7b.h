#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x3F,
  0x1F, 0x9F, 0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0xF8, 0x78, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3C,
  0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE0, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0x30, 0xC1, 0xFC,
  0xC0, 0x07, 0xE7, 0x00, 0x1F, 0xDC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0x7F, 0x00, 0x1C,
  0xFC, 0x80, 0x67, 0xF3, 0x01, 0x9F, 0xCF, 0x8E, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0x00,
  0x3E, 0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xE0, 0x3E, 0x01, 0xF9, 0xF0,
  0x1F, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x7C, 0x3E,
  0x0F, 0x80, 0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x87, 0xC0, 0x07, 0xC7, 0xC7, 0xC0, 0x07, 0xC3, 0xE7, 0xC3, 0x83, 0xE3,
  0xF3, 0xC7, 0xF8, 0xF9, 0xF3, 0xE7, 0xFE, 0x7F, 0xFB, 0xE7, 0xFF, 0x3F,
  0xF9, 0xE7, 0xFF, 0x8F, 0xF9, 0xF3, 0xE7, 0xC3, 0xF9, 0xF3, 0xE1, 0xF0,
  0x20, 0xF1, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x7C,
  0x00, 0x78, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x0F,
  0x80, 0x3C, 0x0F, 0x8F, 0x80, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x03, 0xE7,
  0xE0, 0x1E, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x3F,
  0xE0, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xF3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x07, 0xE1, 0xFF, 0xC0, 0xFC, 0x7F, 0xFC, 0x3F, 0x1F, 0xDF,
  0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x3F, 0xFF, 0x3F, 0x83, 0xFF, 0xC7,
  0xF0, 0x7F, 0xF8, 0xFC, 0x07, 0xFE, 0x1F, 0x80, 0xFF, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xF3, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x06, 0x0F, 0x80, 0xF1,
  0xF0, 0x3F, 0xBC, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xDF, 0x03, 0xF1,
  0xF0, 0x3E, 0x3E, 0x03, 0x87, 0xE0, 0x20, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x80, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1C, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x1F, 0x83,
  0xF8, 0x7E, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E,
  0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0x7E, 0x3F, 0x3F, 0x0E, 0x3F, 0x86, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xF0, 0xFE, 0x01, 0xC0, 0x7F, 0x01, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xF0, 0x7F, 0x80, 0x80, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE2, 0x00, 0x1F, 0xC7, 0x00, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xF9, 0xF8,
  0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x08, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF1, 0x00, 0x1F, 0xC3,
  0xC0, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x1E, 0x01, 0xF9, 0xFE, 0x07, 0xEF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0x8F, 0xF0, 0x7E, 0x3F, 0x81, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xCF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE3, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7E, 0x3F, 0x83, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0,
  0xFF, 0x3F, 0xDF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF7, 0xE0,
  0xFF, 0x3F, 0x00, 0xC3, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE1, 0x01, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x03,
  0x00, 0x00, 0x78, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC,
  0xE0, 0x7E, 0x40, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0xF8,
  0x0F, 0x0F, 0x81, 0xFF, 0xC7, 0x8F, 0x83, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF,
  0xE1, 0xF7, 0xC1, 0xF0, 0xF0, 0xFB, 0xE1, 0xF0, 0xF8, 0x7D, 0xE1, 0xF0,
  0x7C, 0x3F, 0xF0, 0xF8, 0x3C, 0x1E, 0xF8, 0x78, 0x1E, 0x0F, 0x7C, 0x7C,
  0x1F, 0x07, 0xBC, 0x3E, 0x0F, 0x87, 0xDE, 0x1E, 0x07, 0x83, 0xCF, 0x0F,
  0x07, 0xC3, 0xE7, 0x87, 0x83, 0xE1, 0xF3, 0xC3, 0xE3, 0xF1, 0xF1, 0xE1,
  0xFF, 0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0xF8, 0x7C, 0x3F, 0xCF, 0xF0, 0x3E,
  0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF0, 0x78, 0x1F,
  0xE0, 0x04, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x08, 0x0F, 0xF8, 0x3C, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFC, 0xFF, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x07,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x78, 0x3F, 0xE0, 0x04, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F,
  0xFE, 0x7F, 0x07, 0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0xE0, 0x7F, 0xF3, 0xF8,
  0x3F, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF8, 0x0F,
  0xC1, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0x0F, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFD,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xDE,
  0x07, 0xEF, 0xC0, 0xF9, 0xF0, 0x7D, 0xF8, 0x1F, 0x9F, 0x0F, 0xDF, 0x81,
  0xF9, 0xF0, 0xF9, 0xF8, 0x1F, 0x9F, 0x1F, 0x9F, 0x81, 0xF9, 0xF1, 0xF1,
  0xF8, 0x1F, 0x1F, 0x3F, 0x3F, 0x03, 0xF1, 0xF3, 0xE3, 0xF0, 0x3F, 0x1F,
  0x7E, 0x3F, 0x03, 0xF1, 0xF7, 0xC3, 0xF0, 0x3F, 0x1F, 0x7C, 0x3E, 0x03,
  0xE1, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0x07,
  0xE0, 0x7E, 0x1F, 0xF0, 0x7E, 0x07, 0xC1, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x01, 0xF8,
  0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0,
  0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07,
  0xFF, 0x01, 0xF8, 0x1F, 0xFE, 0x03, 0xE0, 0x3F, 0x7E, 0x0F, 0xC0, 0x7E,
  0xFC, 0x1F, 0x80, 0xF9, 0xF8, 0x3F, 0x01, 0xF1, 0xF0, 0x7E, 0x07, 0xE3,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE3, 0xF0, 0x1F, 0x8F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xCF, 0xC0, 0x7C, 0x1F, 0x9F, 0x81, 0xF8, 0x3F, 0x3E, 0x03, 0xF0, 0x7E,
  0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x01, 0xFF,
  0xE0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x01, 0xF8, 0x07, 0xFE,
  0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xE0,
  0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F,
  0xE3, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0x0E, 0x03, 0xF8, 0x04, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0x00,
  0x1F, 0xC1, 0x80, 0x3F, 0x83, 0xC1, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xF1,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xF0, 0x0F,
  0xEF, 0xC0, 0x3F, 0x80, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xF3, 0xF0, 0x1F,
  0xE0, 0x3F, 0x1F, 0x81, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xF8, 0x1F, 0x87,
  0xE0, 0x7F, 0xC0, 0xFC, 0x3F, 0x07, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0xF0,
  0x7E, 0x0F, 0xC3, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x7C, 0x3F, 0x03, 0xF1,
  0xFB, 0xE1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0xC0, 0xFC, 0x7C, 0xF8, 0xFC,
  0x07, 0xE7, 0xE7, 0xC7, 0xE0, 0x3F, 0x3E, 0x3E, 0x7E, 0x01, 0xFB, 0xF1,
  0xF3, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0x7E, 0xF8, 0x7D, 0xF8, 0x03,
  0xFF, 0x83, 0xEF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0xFB, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE7, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0x87,
  0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x0F, 0xF1, 0xF0, 0x7F, 0xEF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xBF, 0xE3, 0xF8, 0x3F, 0x9F,
  0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFE, 0xFC, 0x1F, 0xF3, 0xE0, 0x3F, 0x8F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0xE0, 0x3F, 0x7F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0x87, 0xF8, 0x7F, 0x0F,
  0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3E, 0xFF, 0xE0, 0x7C, 0xFF, 0x81,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xC7, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x08,
  0x7F, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xFC, 0xFC,
  0x07, 0xFE, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xEF, 0x80, 0x1F, 0x8F, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x3F,
  0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x3F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x10, 0xFF,
  0x9F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0xFF, 0x1F, 0x01, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xF9, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xC0, 0x1F, 0xC0, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE3, 0xE0, 0x1F, 0x9F, 0xE0, 0x3F, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0,
  0x1F, 0x8F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x00, 0x03, 0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0xFF, 0x0F, 0xF0,
  0x1F, 0x3F, 0xF3, 0xFF, 0x03, 0xEF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xF3, 0xFF, 0x9F, 0xC3, 0xFC, 0x3F, 0xC1, 0xF8, 0x7F, 0x07,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0xFC, 0x7F,
  0x03, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x01, 0xF8,
  0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xC1, 0xF0, 0x0F, 0x8F, 0xF0, 0x1F,
  0x3F, 0xF0, 0x3E, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x1F, 0xC3, 0xFC,
  0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x7F, 0x03,
  0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFC, 0x7F, 0x3F, 0x83, 0xF7, 0xF0,
  0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF,
  0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0xF8, 0xFF, 0x00, 0x7C, 0xFF, 0xC0, 0x3E, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xF1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0x7F, 0xC0, 0x3F,
  0x9F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x7F,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xF7, 0xE0, 0x3F, 0x9F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x83,
  0xEF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x10, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x83, 0x07, 0xE0, 0x20, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x60, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xDF, 0x07, 0xFE, 0x7C, 0x1F, 0xF3, 0xE0, 0x3F, 0x8F,
  0x80, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC,
  0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7F,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xE0, 0x7E, 0xFC, 0x1F,
  0xE0, 0xFE, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x3F, 0xE0, 0xFC, 0xFC, 0x3F,
  0xE1, 0xF8, 0xFC, 0x7F, 0xE1, 0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0xFB,
  0xE3, 0xF0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xF3,
  0xE7, 0xC0, 0xF9, 0xF3, 0xEF, 0xC0, 0xF9, 0xE3, 0xEF, 0xC0, 0xFB, 0xE3,
  0xEF, 0x80, 0xFB, 0xE3, 0xFF, 0x80, 0xFB, 0xC3, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xDF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x27, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x00, 0x0C, 0x00, 0x09, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0xD0, 0x00, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 33, 12, 0, -32 },
  { 59, 17, 11, 19, 4, -32 },
  { 83, 26, 32, 26, 1, -32 },
  { 187, 22, 37, 23, 1, -34 },
  { 289, 33, 33, 36, 2, -33 },
  { 426, 27, 33, 29, 1, -33 },
  { 538, 8, 11, 11, 4, -32 },
  { 549, 16, 39, 14, 1, -32 },
  { 627, 16, 40, 14, -3, -33 },
  { 707, 19, 20, 22, 4, -34 },
  { 755, 21, 22, 24, 2, -27 },
  { 813, 10, 11, 12, -2, -5 },
  { 827, 12, 6, 14, 1, -15 },
  { 836, 8, 8, 12, 0, -7 },
  { 844, 24, 32, 18, -2, -32 },
  { 940, 22, 33, 23, 1, -33 },
  { 1031, 17, 32, 23, 4, -32 },
  { 1099, 24, 33, 23, -1, -33 },
  { 1198, 23, 33, 23, 0, -33 },
  { 1293, 24, 32, 23, -1, -32 },
  { 1389, 23, 32, 23, 0, -32 },
  { 1481, 22, 33, 23, 2, -33 },
  { 1572, 24, 32, 23, 1, -32 },
  { 1668, 22, 33, 23, 1, -33 },
  { 1759, 21, 33, 23, 1, -33 },
  { 1846, 12, 26, 12, 0, -25 },
  { 1885, 14, 31, 12, -2, -25 },
  { 1940, 21, 23, 24, 2, -28 },
  { 2001, 21, 14, 24, 2, -23 },
  { 2038, 21, 23, 24, 2, -28 },
  { 2099, 17, 34, 19, 3, -33 },
  { 2172, 33, 36, 35, 2, -32 },
  { 2321, 26, 32, 26, -3, -32 },
  { 2425, 24, 32, 26, 1, -32 },
  { 2521, 25, 33, 25, 2, -33 },
  { 2625, 26, 32, 28, 1, -32 },
  { 2729, 23, 32, 22, 1, -32 },
  { 2821, 23, 32, 22, 1, -32 },
  { 2913, 26, 33, 28, 2, -33 },
  { 3021, 28, 32, 29, 1, -32 },
  { 3133, 21, 32, 16, -2, -32 },
  { 3217, 21, 42, 14, -7, -32 },
  { 3328, 28, 32, 25, 1, -32 },
  { 3440, 17, 32, 21, 1, -32 },
  { 3508, 36, 32, 37, 1, -32 },
  { 3652, 31, 32, 31, 1, -32 },
  { 3776, 27, 33, 30, 2, -33 },
  { 3888, 25, 32, 25, 1, -32 },
  { 3988, 27, 41, 30, 2, -33 },
  { 4127, 24, 32, 25, 1, -32 },
  { 4223, 23, 33, 22, 0, -33 },
  { 4318, 21, 32, 22, 4, -32 },
  { 4402, 26, 32, 28, 3, -32 },
  { 4506, 24, 32, 24, 4, -32 },
  { 4602, 37, 32, 37, 4, -32 },
  { 4750, 31, 32, 25, -3, -32 },
  { 4874, 23, 32, 23, 4, -32 },
  { 4966, 26, 32, 22, -2, -32 },
  { 5070, 18, 39, 14, -1, -32 },
  { 5158, 10, 32, 18, 5, -32 },
  { 5198, 18, 39, 14, -3, -32 },
  { 5286, 22, 20, 23, 0, -32 },
  { 5341, 17, 3, 17, -4, 4 },
  { 5348, 9, 7, 14, 7, -34 },
  { 5356, 22, 25, 24, 2, -25 },
  { 5425, 23, 34, 25, 0, -34 },
  { 5523, 19, 25, 20, 2, -25 },
  { 5583, 24, 34, 25, 2, -34 },
  { 5685, 20, 25, 23, 2, -25 },
  { 5748, 25, 45, 15, -5, -34 },
  { 5889, 24, 36, 25, 0, -25 },
  { 5997, 23, 34, 25, 0, -34 },
  { 6095, 14, 34, 12, 0, -34 },
  { 6155, 20, 45, 12, -6, -34 },
  { 6268, 25, 34, 23, 0, -34 },
  { 6375, 14, 34, 12, 0, -34 },
  { 6435, 35, 25, 37, 0, -25 },
  { 6545, 23, 25, 25, 0, -25 },
  { 6617, 20, 25, 24, 2, -25 },
  { 6680, 25, 36, 25, -2, -25 },
  { 6793, 22, 36, 25, 2, -25 },
  { 6892, 19, 25, 17, 0, -25 },
  { 6952, 19, 25, 19, 0, -25 },
  { 7012, 16, 30, 17, 2, -30 },
  { 7072, 22, 25, 25, 2, -25 },
  { 7141, 22, 25, 21, 2, -25 },
  { 7210, 32, 25, 33, 3, -25 },
  { 7310, 26, 25, 22, -2, -25 },
  { 7392, 27, 36, 21, -3, -25 },
  { 7514, 21, 25, 19, -1, -25 },
  { 7580, 19, 39, 16, 0, -32 },
  { 7673, 5, 44, 22, 8, -34 },
  { 7701, 18, 39, 16, -2, -32 },
  { 7789, 21, 8, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC45PT7B_H_
