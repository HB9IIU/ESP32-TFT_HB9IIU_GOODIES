#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0xFB, 0xE7, 0xDE, 0x3E, 0xF1,
  0xEF, 0x8F, 0x7C, 0x7B, 0xC7, 0xDE, 0x3C, 0xF1, 0xE7, 0x0F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0x84, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC4, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38,
  0x70, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0x31, 0x87, 0xCC, 0x01, 0xF7, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0x7E, 0x01, 0xDF, 0xA0, 0x67, 0xCE, 0x1B, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x7F, 0xC0,
  0x7C, 0x1F, 0xF8, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF9, 0xE0, 0xF8, 0x1E,
  0x3C, 0x1E, 0x03, 0xC7, 0x87, 0x80, 0xF8, 0xF1, 0xF0, 0x1F, 0x1E, 0x3C,
  0x03, 0xC7, 0xCF, 0x00, 0x78, 0xF3, 0xE3, 0x0F, 0x1E, 0x79, 0xFD, 0xF7,
  0xDE, 0x7F, 0xBF, 0xF7, 0xDF, 0xFB, 0xFC, 0xF7, 0xCF, 0x3F, 0x3C, 0xF1,
  0xE1, 0x0F, 0x9E, 0x3C, 0x01, 0xE7, 0xC7, 0x80, 0x78, 0xF0, 0xF0, 0x1F,
  0x1E, 0x3E, 0x03, 0xC3, 0xC7, 0xC0, 0xF0, 0x78, 0xF0, 0x3E, 0x0F, 0x3E,
  0x07, 0x81, 0xF7, 0x81, 0xE0, 0x3F, 0xF0, 0x7C, 0x03, 0xFC, 0x1F, 0x00,
  0x3F, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0x8F, 0xFC, 0x3E,
  0x3F, 0xFC, 0xFC, 0xFC, 0xF9, 0xF3, 0xF1, 0xFF, 0xE7, 0xE1, 0xFF, 0x8F,
  0x83, 0xFE, 0x1F, 0x03, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xC0, 0xFF, 0x0F, 0xC0, 0x7D,
  0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF3, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x08,
  0x3C, 0x07, 0x1E, 0x03, 0xEF, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC3, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x03, 0xF3, 0xC0, 0xF1,
  0xE0, 0x30, 0xF8, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x38, 0xFB, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF3, 0xF1, 0xF8, 0x7C,
  0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C,
  0x0F, 0xDF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x07,
  0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0xC7, 0xE3,
  0xF3, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFE,
  0x3F, 0x7C, 0x38, 0xF8, 0x63, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7C, 0x7F, 0x03, 0x83, 0xF0, 0x20, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0x0F, 0xC0, 0x81, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x20, 0x07, 0xE7, 0x03, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x3F, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF9, 0x00, 0x7E, 0x3C, 0x3F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0xC0, 0x1F, 0x7F, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7E, 0x0F, 0x9F, 0x81, 0xF3,
  0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3,
  0xF3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xC1,
  0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x7E,
  0x0F, 0xC7, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF9, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x1F, 0xFF, 0x87, 0xE3, 0xE3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x07, 0xDF,
  0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0x8F, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0xEF, 0x87, 0xF7, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC2, 0x07, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x3F, 0x8F, 0xE3, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x1F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x0F, 0xC8, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x7F, 0x0F, 0x1E, 0x0F, 0xFC, 0xF3, 0xC3,
  0xFF, 0x87, 0x3C, 0x3C, 0x78, 0x73, 0xC7, 0x87, 0x87, 0x78, 0xF8, 0x78,
  0xF7, 0x8F, 0x0F, 0x0F, 0x78, 0xF0, 0xF0, 0xF7, 0x1E, 0x0F, 0x0F, 0xF1,
  0xE0, 0xF1, 0xEF, 0x1E, 0x1E, 0x1E, 0xF1, 0xE1, 0xE3, 0xCF, 0x1F, 0x3E,
  0x7C, 0xF0, 0xFF, 0xFF, 0x87, 0x8F, 0xE7, 0xF0, 0x78, 0x7C, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x1F, 0x80,
  0x70, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF0,
  0x78, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x07,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC7, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F,
  0x1F, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xE0, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xE7, 0xE0,
  0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0xF0, 0x7F,
  0x00, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x04, 0x0F, 0xF3, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0x0F, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0xE1, 0xF0, 0x7F, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xC3, 0xC1, 0xFC, 0x01, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0B, 0xF0, 0x7F,
  0xCF, 0xC1, 0xFF, 0x3F, 0x0F, 0xFC, 0xFC, 0x3F, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0,
  0x7C, 0x1F, 0xE3, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xC0, 0xFC, 0x07,
  0xC1, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x0F,
  0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xDE, 0x07, 0xFE, 0x0F, 0x78, 0x1E, 0xF8,
  0x7D, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xDF, 0x07, 0xDE, 0x1F, 0x7C, 0x1F,
  0x78, 0x79, 0xF0, 0xF9, 0xE3, 0xE7, 0xC3, 0xE7, 0x8F, 0x3E, 0x0F, 0x9E,
  0x7C, 0xF8, 0x3E, 0x79, 0xE3, 0xE0, 0xF1, 0xE7, 0x8F, 0x87, 0xC7, 0xBC,
  0x7E, 0x1F, 0x1E, 0xF1, 0xF0, 0x7C, 0x7F, 0x87, 0xC1, 0xF1, 0xFE, 0x1F,
  0x07, 0x87, 0xF8, 0x7C, 0x3E, 0x1F, 0xC3, 0xE0, 0xF8, 0x7F, 0x0F, 0x83,
  0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xC1,
  0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x0F, 0xF8, 0x0F,
  0x83, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3D, 0xF0, 0x7C, 0x1F, 0x7C,
  0x1F, 0x07, 0xDF, 0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C, 0xF8, 0xF8, 0x1F,
  0x3E, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xE3, 0xE0, 0xF8, 0x7D, 0xF0,
  0x3E, 0x1F, 0x7C, 0x0F, 0x87, 0xDF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x3F,
  0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0x80, 0x7F, 0x83, 0xE0,
  0x1F, 0xE0, 0xF8, 0x07, 0xF0, 0x3E, 0x01, 0xFC, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00,
  0x7C, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x1F,
  0xCF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0xFF, 0x07, 0xE0, 0xFC, 0x3E, 0x07, 0xE1,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x07,
  0xE1, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80,
  0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xE0, 0xFE, 0x1F, 0xCF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x07, 0xE1, 0xF0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xC0, 0x00, 0x0C,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xC7,
  0x83, 0xF0, 0x10, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x30, 0x0F, 0xC7, 0xC7, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8,
  0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xCF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0,
  0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F,
  0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x0F,
  0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x7E, 0xF8,
  0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0xC0, 0xF8, 0xF8,
  0x1F, 0xC0, 0xF8, 0xF8, 0x3F, 0xC1, 0xF8, 0xF8, 0x3F, 0xC1, 0xF0, 0x78,
  0x3F, 0xC3, 0xF0, 0x78, 0x7F, 0xC3, 0xE0, 0x78, 0x7B, 0xC3, 0xE0, 0x78,
  0xFB, 0xC7, 0xC0, 0x78, 0xF3, 0xC7, 0xC0, 0x79, 0xF3, 0xCF, 0xC0, 0x79,
  0xF3, 0xCF, 0x80, 0x79, 0xE3, 0xCF, 0x80, 0x7B, 0xE3, 0xDF, 0x00, 0x7B,
  0xC3, 0xDF, 0x00, 0x7F, 0xC3, 0xDE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF7,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xE0,
  0xFC, 0x7E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x00, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x7C,
  0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0xF8, 0x03, 0xE0, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF9, 0xF9, 0xF1, 0xE3, 0xE3, 0xC0, 0x01, 0xF1,
  0xE0, 0xFF, 0x3C, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFD, 0xFE, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E,
  0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF8,
  0xFE, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xEF, 0x01, 0xF1, 0xE0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0x81, 0xFF, 0xF8,
  0x3E, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0x7E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x03, 0xF3,
  0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E, 0x7F, 0x1F, 0x8F,
  0xFF, 0xE1, 0xEF, 0xFC, 0x3D, 0xFF, 0x0F, 0x9F, 0x80, 0x01, 0xFE, 0x03,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xCE, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x04, 0x7E, 0x18, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x01, 0xF3, 0xE0, 0x3F, 0xDF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF9,
  0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xBC, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF8, 0x3E, 0x7C, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x04, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF1, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x04, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0xF0, 0x3F, 0xCF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0x87, 0xE1, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFD, 0xF0, 0x0F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x80, 0x7E, 0x0E, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCF,
  0x81, 0xFF, 0xF8, 0x3E, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0x7E, 0x1F, 0x87,
  0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F,
  0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xCF, 0xC1, 0xF0,
  0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x4F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F,
  0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xBF, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0x8F, 0x83, 0xE0, 0x3E, 0xFF,
  0x1F, 0xE0, 0xFF, 0xFE, 0xFF, 0x83, 0xDF, 0xFF, 0xFE, 0x0F, 0xE7, 0xFD,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E,
  0x1F, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x0F, 0x8F,
  0xC1, 0xF0, 0x7E, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xE0,
  0xF8, 0x1F, 0x1F, 0x83, 0xE0, 0x7C, 0x7E, 0x0F, 0x83, 0xF1, 0xF0, 0x3E,
  0x0F, 0x87, 0xC1, 0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0xF8, 0xFC, 0x1F, 0x07,
  0xE0, 0x07, 0x8F, 0x81, 0xF7, 0xF8, 0x3E, 0xFF, 0x87, 0xBF, 0xF0, 0xFE,
  0x7E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F,
  0xCF, 0xC1, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0x9F, 0x8F, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7E, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC1,
  0xFB, 0xF0, 0x7C, 0x7E, 0x7F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x1F, 0x7F, 0x80, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8,
  0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC7, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0xFF, 0x03, 0xF3, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF1,
  0xE0, 0xFF, 0x3C, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xF9, 0xFE, 0x7E, 0x1F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF8,
  0xFE, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0x7C, 0x1F, 0xFF, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x8F,
  0x0F, 0xBF, 0x0F, 0xBF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xF2, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0x06, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFE, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x84, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0xC7, 0xC3, 0xF0, 0xF8, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xDE, 0x07, 0xF3, 0xC0, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB,
  0xE0, 0x7C, 0xF8, 0x3F, 0x1E, 0x0F, 0x87, 0x87, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x83, 0xFF, 0x07, 0xF0, 0x7F,
  0xE0, 0xFE, 0x1F, 0x7C, 0x1F, 0xC3, 0xEF, 0x87, 0xF8, 0xFD, 0xF0, 0xFF,
  0x1F, 0x3E, 0x3D, 0xE3, 0xE3, 0xC7, 0xBC, 0xF8, 0x79, 0xF7, 0x9F, 0x0F,
  0x3C, 0xE7, 0xC1, 0xE7, 0x9C, 0xF8, 0x3D, 0xE7, 0x9E, 0x07, 0xBC, 0xF7,
  0xC0, 0xF7, 0x9E, 0xF8, 0x1F, 0xE3, 0xDE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x1F,
  0x80, 0xF8, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0,
  0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x01, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3E, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x08, 0x00, 0xBF, 0xC0,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFA, 0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 27, 10, 0, -27 },
  { 42, 13, 10, 16, 4, -27 },
  { 59, 23, 27, 22, 0, -27 },
  { 137, 18, 31, 19, 1, -29 },
  { 207, 27, 28, 30, 2, -28 },
  { 302, 23, 28, 24, 1, -28 },
  { 383, 6, 10, 10, 4, -27 },
  { 391, 14, 33, 12, 1, -27 },
  { 449, 14, 34, 12, -3, -28 },
  { 509, 17, 17, 19, 3, -29 },
  { 546, 17, 19, 20, 2, -23 },
  { 587, 9, 10, 10, -2, -5 },
  { 599, 10, 5, 12, 1, -13 },
  { 606, 7, 6, 10, 0, -6 },
  { 612, 20, 27, 15, -2, -27 },
  { 680, 18, 28, 19, 1, -28 },
  { 743, 15, 27, 19, 3, -27 },
  { 794, 20, 28, 19, -1, -28 },
  { 864, 19, 28, 19, 0, -28 },
  { 931, 19, 27, 19, 0, -27 },
  { 996, 19, 27, 19, 0, -27 },
  { 1061, 19, 28, 19, 1, -28 },
  { 1128, 20, 27, 19, 1, -27 },
  { 1196, 19, 28, 19, 1, -28 },
  { 1263, 18, 28, 19, 1, -28 },
  { 1326, 10, 21, 10, 0, -21 },
  { 1353, 12, 26, 10, -2, -21 },
  { 1392, 17, 19, 20, 2, -23 },
  { 1433, 17, 11, 20, 2, -19 },
  { 1457, 17, 19, 20, 2, -23 },
  { 1498, 15, 28, 16, 2, -28 },
  { 1551, 28, 30, 30, 1, -27 },
  { 1656, 21, 27, 22, -2, -27 },
  { 1727, 20, 27, 22, 1, -27 },
  { 1795, 21, 28, 21, 2, -28 },
  { 1869, 22, 27, 23, 1, -27 },
  { 1944, 19, 27, 19, 1, -27 },
  { 2009, 19, 27, 18, 1, -27 },
  { 2074, 22, 28, 24, 2, -28 },
  { 2151, 24, 27, 24, 1, -27 },
  { 2232, 17, 27, 14, -1, -27 },
  { 2290, 18, 35, 11, -6, -27 },
  { 2369, 24, 27, 21, 1, -27 },
  { 2450, 14, 27, 18, 1, -27 },
  { 2498, 30, 27, 31, 1, -27 },
  { 2600, 26, 27, 26, 1, -27 },
  { 2688, 22, 28, 25, 2, -28 },
  { 2765, 21, 27, 21, 1, -27 },
  { 2836, 22, 34, 25, 2, -28 },
  { 2930, 20, 27, 21, 1, -27 },
  { 2998, 19, 28, 18, 0, -28 },
  { 3065, 18, 27, 18, 3, -27 },
  { 3126, 23, 27, 24, 2, -27 },
  { 3204, 21, 27, 21, 3, -27 },
  { 3275, 32, 27, 31, 3, -27 },
  { 3383, 26, 27, 21, -2, -27 },
  { 3471, 20, 27, 20, 3, -27 },
  { 3539, 21, 27, 18, -1, -27 },
  { 3610, 16, 33, 12, -1, -27 },
  { 3676, 9, 27, 15, 4, -27 },
  { 3707, 16, 33, 12, -3, -27 },
  { 3773, 19, 17, 19, 0, -27 },
  { 3814, 15, 3, 14, -4, 3 },
  { 3820, 7, 6, 12, 6, -29 },
  { 3826, 19, 21, 21, 1, -21 },
  { 3876, 19, 29, 21, 0, -29 },
  { 3945, 16, 21, 17, 1, -21 },
  { 3987, 21, 29, 21, 1, -29 },
  { 4064, 18, 21, 19, 1, -21 },
  { 4112, 21, 38, 13, -4, -29 },
  { 4212, 20, 30, 21, 0, -21 },
  { 4287, 19, 29, 21, 0, -29 },
  { 4356, 12, 29, 10, 0, -29 },
  { 4400, 17, 38, 10, -5, -29 },
  { 4481, 21, 29, 20, 0, -29 },
  { 4558, 12, 29, 10, 0, -29 },
  { 4602, 30, 21, 31, 0, -21 },
  { 4681, 19, 21, 21, 0, -21 },
  { 4731, 18, 21, 20, 1, -21 },
  { 4779, 21, 30, 21, -2, -21 },
  { 4858, 19, 30, 21, 1, -21 },
  { 4930, 16, 21, 15, 0, -21 },
  { 4972, 16, 21, 16, 0, -21 },
  { 5014, 13, 25, 14, 2, -25 },
  { 5055, 19, 21, 21, 2, -21 },
  { 5105, 18, 21, 18, 2, -21 },
  { 5153, 27, 21, 28, 2, -21 },
  { 5224, 22, 21, 18, -2, -21 },
  { 5282, 23, 30, 18, -3, -21 },
  { 5369, 18, 21, 16, -1, -21 },
  { 5417, 16, 33, 13, 0, -27 },
  { 5483, 4, 38, 18, 7, -29 },
  { 5502, 15, 33, 13, -2, -27 },
  { 5564, 17, 7, 20, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC38PT7B_H_
