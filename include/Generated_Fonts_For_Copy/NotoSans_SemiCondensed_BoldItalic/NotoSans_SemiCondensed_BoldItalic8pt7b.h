#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xB8, 0x31, 0x9E, 0xAE, 0x50, 0x27, 0x63, 0xDE, 0x65,
  0xAB, 0x57, 0x2D, 0x30, 0x32, 0x9C, 0xDB, 0x7C, 0xC0, 0x29, 0x49, 0x30,
  0x24, 0x92, 0x70, 0x5F, 0x30, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x24,
  0xC8, 0x35, 0xD9, 0xBE, 0x79, 0x25, 0x80, 0x75, 0x12, 0x4E, 0x75, 0x36,
  0x3E, 0x13, 0x7A, 0xF2, 0x74, 0x63, 0x3E, 0x34, 0x6D, 0x96, 0x71, 0x22,
  0x4C, 0x35, 0x76, 0x9E, 0x65, 0xD7, 0x2E, 0x42, 0x42, 0x80, 0x16, 0xE1,
  0xFF, 0x86, 0x3C, 0x69, 0x24, 0x0C, 0x39, 0x17, 0xED, 0xBD, 0x03, 0x00,
  0x33, 0x55, 0xF9, 0x72, 0xD4, 0xED, 0x78, 0x3B, 0x51, 0x8C, 0x38, 0x72,
  0xD2, 0xBD, 0x70, 0x74, 0x56, 0xCE, 0x74, 0x56, 0xC8, 0x3B, 0x51, 0xBD,
  0x38, 0x4A, 0x52, 0xFD, 0x48, 0x69, 0x25, 0x80, 0x32, 0x22, 0x64, 0x48,
  0x4A, 0x98, 0xCF, 0x48, 0x49, 0x2D, 0xC0, 0x66, 0xD9, 0xB3, 0xAB, 0x55,
  0x80, 0x65, 0xA6, 0x9A, 0x9A, 0x40, 0x32, 0x53, 0x9D, 0xB8, 0x72, 0xD4,
  0xEC, 0x40, 0x32, 0x53, 0x9D, 0xB8, 0xC0, 0x75, 0x56, 0xF9, 0x35, 0x42,
  0x2E, 0xE9, 0x69, 0x00, 0x4A, 0x52, 0xAD, 0x38, 0x9A, 0xAE, 0xCC, 0xB6,
  0xDB, 0xB6, 0xDA, 0x40, 0x4A, 0x98, 0xC6, 0x48, 0xBA, 0xCC, 0x88, 0x71,
  0x24, 0xCE, 0x69, 0x29, 0x30, 0xAA, 0x90, 0x32, 0x22, 0x22, 0xC0, 0x22,
  0x59, 0xE0, 0xC0, 0x7D, 0x9E, 0x44, 0x75, 0xDE, 0x7C, 0x86, 0x18, 0x9D,
  0xA9, 0x70, 0x7F, 0x86, 0x19, 0x1C, 0x42, 0x21, 0x18, 0x7D, 0x9E, 0x2E,
  0x44, 0x75, 0x9B, 0x45, 0xE0, 0x20, 0x96, 0x96, 0x42, 0x54, 0xCE, 0x58,
  0x55, 0xE0, 0x7D, 0x59, 0x6B, 0x75, 0x9B, 0x7D, 0x96, 0x75, 0xDE, 0x88,
  0x7D, 0x9E, 0x22, 0x6B, 0x40, 0xE8, 0xF0, 0x5D, 0x6C, 0x55, 0xBD, 0xD6,
  0x64, 0xF5, 0xE5, 0x94, 0x76, 0x6A, 0x69, 0x8C, 0x42, 0x60, 0x76, 0x4E,
  0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 6, 6, 6, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 2, 1, -6 },
  { 21, 3, 7, 3, 0, -6 },
  { 24, 3, 7, 3, -1, -6 },
  { 27, 3, 4, 4, 1, -6 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 4, 6, 3, 0, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 3, 6, 4, 1, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 6, 4, 0, -6 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 4, 2, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -5 },
  { 75, 4, 6, 3, 0, -6 },
  { 78, 6, 7, 6, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 5, 6, 4, 0, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 4, 6, 4, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 3, 6, 3, 0, -6 },
  { 116, 4, 8, 2, -1, -6 },
  { 120, 5, 6, 4, 0, -6 },
  { 124, 3, 6, 4, 0, -6 },
  { 127, 7, 6, 7, 0, -6 },
  { 133, 6, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 4, 0, -6 },
  { 146, 5, 7, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 3, 6, 4, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 6, 4, 1, -6 },
  { 167, 6, 6, 7, 1, -6 },
  { 172, 5, 6, 4, 0, -6 },
  { 176, 4, 6, 4, 1, -6 },
  { 179, 4, 6, 4, 0, -6 },
  { 182, 3, 7, 3, 0, -6 },
  { 185, 2, 6, 3, 1, -6 },
  { 187, 4, 7, 3, -1, -6 },
  { 191, 4, 4, 4, 0, -6 },
  { 193, 3, 1, 3, -1, 0 },
  { 194, 2, 1, 3, 1, -6 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 5, 6, 4, 0, -6 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 5, 8, 3, -1, -6 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -6 },
  { 219, 2, 6, 2, 0, -6 },
  { 221, 3, 8, 2, -1, -6 },
  { 224, 5, 6, 4, 0, -6 },
  { 228, 2, 6, 2, 0, -6 },
  { 230, 6, 4, 7, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 6, 4, 0, -4 },
  { 240, 4, 6, 4, 0, -4 },
  { 243, 3, 4, 3, 0, -4 },
  { 245, 3, 4, 3, 0, -4 },
  { 247, 3, 5, 3, 0, -5 },
  { 249, 4, 4, 4, 0, -4 },
  { 251, 4, 4, 4, 0, -4 },
  { 253, 6, 4, 6, 0, -4 },
  { 256, 4, 4, 4, 0, -4 },
  { 258, 5, 6, 4, -1, -4 },
  { 262, 4, 4, 3, 0, -4 },
  { 264, 3, 7, 3, 0, -6 },
  { 267, 1, 8, 4, 1, -6 },
  { 268, 3, 7, 3, 0, -6 },
  { 271, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC8PT7B_H_
