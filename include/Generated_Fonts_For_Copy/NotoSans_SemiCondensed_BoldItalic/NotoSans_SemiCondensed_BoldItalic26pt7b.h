#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0xF7, 0xFB, 0xF9, 0xDC,
  0xEE, 0x77, 0x33, 0x38, 0x01, 0xCC, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x9C,
  0x03, 0x18, 0x07, 0x39, 0x3F, 0xFE, 0x3F, 0xFE, 0x06, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x39, 0xC0,
  0x39, 0xC0, 0x39, 0x80, 0x73, 0x80, 0x00, 0x40, 0x06, 0x00, 0xF8, 0x1F,
  0xF1, 0xFF, 0x8F, 0xD8, 0x76, 0x03, 0xB0, 0x1F, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0x7A, 0x0B, 0xCC, 0xDE, 0x7F, 0xE7, 0xFE, 0x0F,
  0xE0, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x03, 0x83, 0xE0, 0x70, 0xFE,
  0x1C, 0x39, 0xC7, 0x07, 0x38, 0xE0, 0xE7, 0x38, 0x18, 0xEE, 0x07, 0x39,
  0xC0, 0xE7, 0x77, 0xCF, 0xDD, 0xFD, 0xFB, 0xBB, 0x9C, 0xEE, 0x70, 0x39,
  0xCE, 0x07, 0x39, 0xC1, 0xC6, 0x38, 0x70, 0xCE, 0x0E, 0x1F, 0xC3, 0x83,
  0xF0, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0F, 0xF0, 0x0F, 0xC0, 0x3E, 0x1D, 0xFE,
  0x7B, 0xFC, 0xEF, 0x3F, 0xDC, 0x3F, 0x38, 0x7E, 0x78, 0xF8, 0xFF, 0xF9,
  0xFF, 0xF1, 0xFC, 0xF0, 0xFF, 0xEE, 0xEE, 0xC0, 0x03, 0x83, 0x83, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0x83, 0xC3, 0xC0,
  0x07, 0x00, 0x70, 0x47, 0x06, 0x70, 0xFE, 0x77, 0xFF, 0x0F, 0xF1, 0xF0,
  0x3B, 0x07, 0xB8, 0x33, 0xC0, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x3C, 0xE7, 0x9C, 0xF3, 0x80, 0x7F, 0x7E, 0x7E, 0xFE, 0x77, 0xFD, 0xE0,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xFE, 0x1F, 0xF3, 0xEF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1E, 0xE3, 0xCF, 0x3C, 0xFF, 0x87,
  0xF0, 0x7E, 0x00, 0x01, 0xC1, 0xF0, 0xFC, 0x7E, 0x7F, 0xBF, 0xE6, 0x78,
  0x9E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0xC3, 0xDF, 0x0C, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0x87, 0xFE, 0x1D, 0xF0, 0x87, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x0F, 0xE0, 0x7C, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xD0, 0x3C, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xB8, 0x1F, 0xC1, 0xDE, 0x1C, 0xE1, 0xE7,
  0x0E, 0x78, 0xE3, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x04, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x90, 0x3C, 0xFF, 0xE7, 0xFE, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x83, 0xFC, 0x3E, 0x23, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x78, 0x7F,
  0xE7, 0xFF, 0x3E, 0x79, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xC7, 0x9E, 0x78,
  0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0x79, 0xE3,
  0xDE, 0x0F, 0xE0, 0x7E, 0x0F, 0xF8, 0xFB, 0xC7, 0x8F, 0x38, 0x7B, 0xC3,
  0xDE, 0x1E, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x81, 0xFE, 0x3F, 0xE3,
  0xCF, 0x78, 0xF7, 0x0F, 0x70, 0xFF, 0x0F, 0xF1, 0xF7, 0xFF, 0x7F, 0xE3,
  0xEE, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0xFF, 0x0F, 0xE0, 0xFC, 0x00,
  0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x1E,
  0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E,
  0x1F, 0x87, 0xE0, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xF0, 0x1F, 0x0F, 0xE3, 0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x07,
  0xF9, 0xFF, 0x18, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x78, 0x1F, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0x80, 0xE1, 0xC0,
  0x0E, 0x70, 0x71, 0xCC, 0x7F, 0xBB, 0x9E, 0xE7, 0x63, 0x9C, 0xFC, 0xE3,
  0x9F, 0x9C, 0x63, 0xF3, 0x1C, 0x6E, 0x63, 0x9D, 0xCC, 0xF3, 0xB9, 0xFF,
  0xE7, 0x1E, 0xF8, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x20, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x03, 0x9E, 0x0F, 0x3C, 0x1C, 0x78,
  0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0x07, 0x9E, 0x0F, 0x38, 0x0E, 0xF0,
  0x1F, 0xE0, 0x38, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x73, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x1E, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xE1,
  0xE3, 0xC3, 0x83, 0x87, 0x07, 0x1E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFD, 0xE3, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x10, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x78, 0x3C, 0xF0, 0x79,
  0xE0, 0xF3, 0xC3, 0xE7, 0x07, 0x9E, 0x1F, 0x3C, 0xFC, 0x7F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x08, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFE, 0xE3, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF1, 0xFB, 0xC3, 0xF7, 0x8F, 0xEF, 0x03, 0xDE,
  0x07, 0x3E, 0x1E, 0x3C, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x83,
  0xC3, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38,
  0x1C, 0x3C, 0x1E, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x0F, 0x07, 0x87,
  0x87, 0x83, 0xC7, 0x81, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0,
  0x3B, 0xC0, 0x1D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0x9E,
  0x01, 0xCF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x3C, 0x3C,
  0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC1,
  0x7F, 0xCF, 0xFB, 0xFF, 0x00, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8,
  0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x76, 0x0F, 0xC1, 0xD8, 0x7F,
  0x07, 0x71, 0xDC, 0x1D, 0xC7, 0xF0, 0xF7, 0x3B, 0xC3, 0xDC, 0xEE, 0x0E,
  0x77, 0x38, 0x39, 0xDC, 0xE0, 0xE7, 0xE7, 0x87, 0x9F, 0x9E, 0x1C, 0x7C,
  0x70, 0x71, 0xF1, 0xC1, 0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x00, 0x0F, 0x81,
  0xC3, 0xE0, 0x70, 0xF8, 0x3C, 0x3E, 0x0F, 0x1F, 0xC3, 0x87, 0xF0, 0xE1,
  0xDC, 0x38, 0x77, 0x1E, 0x1D, 0xE7, 0x8F, 0x39, 0xC3, 0xCE, 0x70, 0xE3,
  0xDC, 0x38, 0xFF, 0x0E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x70, 0x7E,
  0x1C, 0x0F, 0x8F, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xBE, 0x3E, 0x1E, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x3C, 0x78,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x3C,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xBE, 0x3E, 0x1E, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8,
  0x7C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xC3, 0x9F,
  0x1E, 0x3C, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x1C, 0x7C, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF8, 0x39, 0xE0, 0xE3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC1,
  0xEF, 0x07, 0x80, 0x01, 0xE0, 0x7F, 0xC7, 0xFE, 0x3E, 0xE1, 0xE0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x98, 0x3C, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0x9C, 0x1E,
  0x70, 0x79, 0xC3, 0xC7, 0x0F, 0x1C, 0x78, 0x71, 0xE1, 0xCF, 0x07, 0x3C,
  0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xEF, 0x07, 0x87, 0xBC,
  0x3E, 0x1C, 0xF0, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x1F, 0x8E, 0x3C, 0xEE,
  0x78, 0xF3, 0xB9, 0xC3, 0xCE, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x0E, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xDE, 0x00, 0xF3, 0x80, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F,
  0x0F, 0x81, 0xE0, 0xF0, 0x3D, 0xC1, 0xE7, 0x0F, 0x1E, 0x3C, 0x79, 0xE1,
  0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF,
  0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xE3, 0x8E, 0x38,
  0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x78, 0xE3, 0x8E, 0x38, 0xE3, 0xC0,
  0x07, 0xE0, 0xFC, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x7E, 0x07, 0x70, 0x39, 0x83, 0x8E, 0x1C, 0x71, 0xC3,
  0x9C, 0x0D, 0xE0, 0x70, 0xFF, 0xFF, 0xE0, 0xF7, 0x9C, 0x70, 0x1F, 0x39,
  0xFF, 0xCF, 0xFC, 0xF1, 0xE7, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1,
  0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0xC7, 0xFC, 0x3E, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFF, 0x1F, 0xF9,
  0xE3, 0xCF, 0x0E, 0x78, 0x73, 0x87, 0x9C, 0x3D, 0xE1, 0xEF, 0x1E, 0x78,
  0xF3, 0xFF, 0x1F, 0xF9, 0xCF, 0x00, 0x0F, 0xE3, 0xF8, 0xFF, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC2, 0x7F, 0xC7, 0xF8,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE1, 0xF7, 0x8F, 0xFE, 0x3F, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x07, 0xFC, 0x1F,
  0x70, 0x0F, 0xC1, 0xFE, 0x3C, 0xF7, 0x8F, 0x70, 0xFF, 0x3E, 0xFF, 0xCF,
  0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x4F, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x3E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F,
  0xDC, 0x7F, 0xF1, 0xFF, 0x8F, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0x80,
  0x1E, 0x00, 0x78, 0x83, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFF, 0x1F,
  0xF9, 0xF1, 0xCF, 0x0E, 0x78, 0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xCF, 0x0E,
  0x78, 0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xC0, 0x06, 0x0F, 0x0F, 0x0E, 0x00,
  0x00, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x07, 0xE0,
  0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x47, 0x8F, 0x0E, 0x3C, 0x1C, 0xF0, 0x7B, 0xC0, 0xF7, 0x01,
  0xDE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x79, 0xE0, 0xE3,
  0xC1, 0xC3, 0x87, 0x87, 0x80, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0x1D, 0xF3, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xE7, 0xC7, 0x3C,
  0x78, 0x73, 0xC7, 0x8F, 0x38, 0x78, 0xF3, 0x87, 0x0F, 0x78, 0x70, 0xE7,
  0x8F, 0x0E, 0x78, 0xF1, 0xE7, 0x0F, 0x1E, 0x70, 0xE1, 0xEF, 0x1E, 0x1C,
  0x1D, 0xF0, 0xFF, 0xC7, 0xFE, 0x7C, 0x73, 0xC3, 0x9E, 0x3C, 0xE1, 0xE7,
  0x0F, 0x78, 0x73, 0xC3, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x78, 0x70, 0x0F,
  0xC3, 0xFE, 0x3F, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xEF, 0x1E, 0xF1, 0xEF, 0xFC, 0x7F, 0x83, 0xF0, 0x0E, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC7, 0x8F, 0x1E, 0x1C, 0x78, 0x71, 0xC3, 0xC7, 0x0F, 0x3C, 0x3C,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFC, 0x3F, 0xF1, 0xEF, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xB9, 0xFF, 0xCF, 0xFC,
  0xF1, 0xE7, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x8F, 0x3C,
  0x79, 0xFF, 0x87, 0xFC, 0x3E, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x1D, 0xE3, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x00,
  0x1F, 0xE7, 0xFC, 0xF3, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7A, 0x0F, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0x0E, 0x0E, 0x07, 0x0F,
  0xFF, 0xFF, 0xFC, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0xF9, 0xFC, 0x7E, 0x00, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0xF0, 0xE7, 0x8F,
  0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0xCF,
  0xFC, 0x3E, 0xE0, 0xF0, 0x7B, 0x87, 0x9C, 0x38, 0xE3, 0xC7, 0x1C, 0x39,
  0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0,
  0x1E, 0x00, 0xE1, 0xE3, 0xF8, 0xF8, 0xEE, 0x3E, 0x7B, 0x9F, 0x9E, 0xE7,
  0xE7, 0x3B, 0xBB, 0xCE, 0xEE, 0xE3, 0xB3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x00, 0x1E, 0x3E,
  0x3C, 0x78, 0x39, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xF7, 0x81, 0xCF, 0x07, 0x8F, 0x1E, 0x1E,
  0x00, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xFC, 0x7F,
  0xCF, 0xFC, 0x00, 0x20, 0x7C, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x03, 0xC1, 0xF0,
  0x3E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x0F,
  0xC3, 0xC1, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0xF8, 0x3C, 0x0E,
  0x00, 0x7E, 0x1F, 0xFF, 0xFF, 0xF8, 0x1E,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 16, 19, 15, 0, -19 },
  { 66, 13, 22, 13, 0, -20 },
  { 102, 19, 19, 21, 1, -19 },
  { 148, 15, 19, 17, 1, -19 },
  { 184, 4, 7, 7, 3, -19 },
  { 188, 9, 23, 8, 1, -19 },
  { 214, 9, 23, 8, -2, -19 },
  { 240, 12, 12, 13, 2, -20 },
  { 258, 12, 12, 14, 1, -15 },
  { 276, 6, 6, 7, -1, -3 },
  { 281, 8, 4, 8, 0, -9 },
  { 285, 5, 4, 7, 0, -4 },
  { 288, 14, 19, 11, -1, -19 },
  { 322, 12, 19, 13, 1, -19 },
  { 351, 10, 19, 13, 2, -19 },
  { 375, 14, 19, 13, -1, -19 },
  { 409, 13, 19, 13, 0, -19 },
  { 440, 13, 19, 13, 0, -19 },
  { 471, 13, 19, 13, 0, -19 },
  { 502, 13, 19, 13, 1, -19 },
  { 533, 13, 19, 13, 1, -19 },
  { 564, 13, 19, 13, 0, -19 },
  { 595, 12, 19, 13, 1, -19 },
  { 624, 7, 14, 7, 0, -14 },
  { 637, 8, 17, 7, -1, -14 },
  { 654, 12, 13, 14, 1, -16 },
  { 674, 12, 8, 14, 1, -13 },
  { 686, 12, 13, 14, 1, -16 },
  { 706, 11, 19, 11, 1, -19 },
  { 733, 19, 21, 20, 1, -19 },
  { 783, 15, 19, 15, -2, -19 },
  { 819, 15, 19, 15, 0, -19 },
  { 855, 15, 19, 14, 1, -19 },
  { 891, 15, 19, 16, 0, -19 },
  { 927, 14, 19, 13, 0, -19 },
  { 961, 14, 19, 12, 0, -19 },
  { 995, 15, 19, 16, 1, -19 },
  { 1031, 17, 19, 17, 0, -19 },
  { 1072, 12, 19, 9, -1, -19 },
  { 1101, 12, 24, 8, -4, -19 },
  { 1137, 17, 19, 14, 0, -19 },
  { 1178, 11, 19, 12, 0, -19 },
  { 1205, 22, 19, 21, 0, -19 },
  { 1258, 18, 19, 18, 0, -19 },
  { 1301, 16, 19, 17, 1, -19 },
  { 1339, 15, 19, 14, 0, -19 },
  { 1375, 16, 23, 17, 1, -19 },
  { 1421, 14, 19, 15, 0, -19 },
  { 1455, 13, 19, 13, 0, -19 },
  { 1486, 12, 19, 13, 2, -19 },
  { 1515, 16, 19, 16, 1, -19 },
  { 1553, 14, 19, 14, 2, -19 },
  { 1587, 22, 19, 21, 2, -19 },
  { 1640, 18, 19, 14, -2, -19 },
  { 1683, 14, 19, 13, 2, -19 },
  { 1717, 15, 19, 13, -1, -19 },
  { 1753, 11, 23, 8, -1, -19 },
  { 1785, 6, 19, 11, 3, -19 },
  { 1800, 11, 23, 8, -2, -19 },
  { 1832, 13, 12, 13, 0, -19 },
  { 1852, 10, 2, 10, -2, 2 },
  { 1855, 5, 4, 8, 4, -20 },
  { 1858, 13, 14, 14, 1, -14 },
  { 1881, 13, 20, 14, 0, -20 },
  { 1914, 11, 14, 11, 1, -14 },
  { 1934, 14, 20, 14, 1, -20 },
  { 1969, 12, 14, 13, 1, -14 },
  { 1990, 15, 26, 9, -3, -20 },
  { 2039, 14, 20, 14, 0, -14 },
  { 2074, 13, 20, 14, 0, -20 },
  { 2107, 8, 20, 7, 0, -20 },
  { 2127, 11, 26, 7, -3, -20 },
  { 2163, 15, 20, 13, 0, -20 },
  { 2201, 8, 20, 7, 0, -20 },
  { 2221, 20, 14, 21, 0, -14 },
  { 2256, 13, 14, 14, 0, -14 },
  { 2279, 12, 14, 14, 1, -14 },
  { 2300, 14, 20, 14, -1, -14 },
  { 2335, 13, 20, 14, 1, -14 },
  { 2368, 11, 14, 10, 0, -14 },
  { 2388, 11, 14, 11, 0, -14 },
  { 2408, 9, 17, 10, 1, -17 },
  { 2428, 13, 14, 14, 1, -14 },
  { 2451, 13, 14, 12, 1, -14 },
  { 2474, 18, 14, 19, 2, -14 },
  { 2506, 15, 14, 13, -1, -14 },
  { 2533, 16, 20, 12, -2, -14 },
  { 2573, 12, 14, 11, -1, -14 },
  { 2594, 11, 23, 9, 0, -19 },
  { 2626, 3, 26, 13, 5, -20 },
  { 2636, 10, 23, 9, -1, -19 },
  { 2665, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC26PT7B_H_
