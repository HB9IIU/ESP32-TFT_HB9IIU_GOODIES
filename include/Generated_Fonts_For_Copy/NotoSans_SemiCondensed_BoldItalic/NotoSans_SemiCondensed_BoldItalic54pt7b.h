#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x30, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xF9,
  0xE1, 0x80, 0xFF, 0x38, 0x00, 0x1F, 0xE7, 0x00, 0x03, 0xFC, 0xE0, 0x00,
  0x7F, 0x9C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x73, 0xFC, 0x00, 0x0E, 0x7F, 0x80, 0x01, 0xCF, 0xF1, 0x00,
  0x39, 0xFE, 0x30, 0x0F, 0x3F, 0xC7, 0x81, 0xCF, 0xF0, 0xFF, 0x3F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x7E, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0xF0, 0xFC, 0x3F, 0x3F, 0x1F, 0xF3, 0xF1,
  0xF8, 0xFC, 0xFF, 0xEF, 0xCF, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F,
  0xFF, 0x7F, 0xFC, 0xFC, 0xFF, 0xFD, 0xFF, 0xE7, 0xE7, 0xF3, 0xF3, 0xFF,
  0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0xFC, 0x1F, 0x00, 0x07, 0xE3, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x07, 0xE3, 0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0x07, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F,
  0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xC3, 0xF8, 0x7F, 0xDF, 0xF3, 0xFC, 0x7F,
  0xC7, 0xF9, 0xFC, 0x3F, 0xC1, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xFE, 0x1F,
  0xE0, 0x3F, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x1F,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9,
  0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x20, 0x1F, 0x80, 0x38, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0x9F, 0x00, 0x7F, 0xDE, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x03,
  0x07, 0xFF, 0x80, 0x0F, 0xEF, 0x80, 0x1F, 0xEF, 0xC0, 0x3F, 0xCF, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0x07, 0xF0, 0x02, 0x07, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0x1F,
  0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xE0,
  0x1F, 0xC7, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x3F, 0xC1,
  0xFC, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xDF, 0xC7, 0xFB, 0xFC, 0x3E,
  0x3F, 0x83, 0xC3, 0xF8, 0x10, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xE0, 0x1F, 0x81, 0xFF,
  0x00, 0x78, 0x07, 0xF8, 0x03, 0x00, 0x3F, 0xC0, 0x08, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xBF, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0x80, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC6, 0x00, 0x0F, 0xF8, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x20, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x80, 0x01,
  0xFF, 0x0C, 0x00, 0x3F, 0xE0, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x18, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0xFE, 0x7F,
  0xE0, 0x3F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFE, 0x3F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x00,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xF0,
  0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xCF, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xF0, 0x1F, 0xF9, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x80,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0x7E, 0x1F, 0xE3, 0x80, 0x7F, 0x10, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF, 0xFC, 0x3E, 0x1F,
  0x81, 0xFF, 0xFC, 0x3F, 0x1F, 0x03, 0xFF, 0xFC, 0x3F, 0x3F, 0x07, 0xF0,
  0xF8, 0x3F, 0x3E, 0x0F, 0xE0, 0xF8, 0x3F, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0x7C, 0x1F,
  0x01, 0xF0, 0x3E, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x03, 0xF0,
  0x7E, 0xFC, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0xF8,
  0x3E, 0x07, 0xE0, 0xFC, 0xF8, 0x3E, 0x0F, 0xE1, 0xF8, 0xF8, 0x3F, 0x0F,
  0xE1, 0xF8, 0xF8, 0x3F, 0x3F, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFC, 0x1F, 0xF9, 0xFF, 0xC0, 0xFC, 0x1F, 0xF1, 0xFF, 0x80, 0x7C, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3C, 0x0F, 0xFC, 0x00,
  0x40, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x80,
  0x7F, 0xF0, 0x7C, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x3C, 0x07, 0xFE, 0x00, 0x10, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF3, 0xFE, 0x07, 0xFF,
  0xE7, 0xF8, 0x0F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0x1F, 0xE0, 0x3F, 0xFE,
  0x3F, 0xC0, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x18, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xE0,
  0x3F, 0xBF, 0x80, 0x7F, 0x7E, 0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x7F,
  0x7F, 0x00, 0xFE, 0x7E, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0xFE, 0x7F,
  0x00, 0xFE, 0x7E, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE1, 0xFC, 0xFE, 0x00,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x01, 0xFC,
  0x7E, 0x3F, 0x0F, 0xE0, 0x1F, 0xC7, 0xE3, 0xF1, 0xFE, 0x01, 0xFC, 0x7E,
  0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0xFC,
  0x1F, 0xC0, 0x3F, 0x87, 0xEF, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0xF8, 0x3F,
  0xC0, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F,
  0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x80, 0x7F,
  0x7F, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F,
  0x00, 0xFE, 0x7F, 0x03, 0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0x80, 0x7F, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x3F, 0x80, 0x7F, 0x03, 0xF9,
  0xFC, 0x03, 0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0xC0, 0xFE, 0x7F, 0x00, 0xFE,
  0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x00, 0xFF, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0x7F, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0x38, 0x07, 0xFC, 0x00, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x40, 0x01, 0xFE, 0x07, 0x00, 0x3F,
  0xC0, 0x7E, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFF, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xFF, 0x81, 0xFC,
  0x0F, 0xE0, 0xFD, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xDF, 0x83, 0xFC, 0x0F,
  0xE1, 0xFD, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x0F, 0xE1,
  0xF9, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x9F, 0x87, 0xF0, 0x0F, 0xE3, 0xF1,
  0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE1, 0xF9,
  0xFE, 0x00, 0xFE, 0xFE, 0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC1, 0xF9, 0xFC,
  0x00, 0xFE, 0xFC, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC1, 0xFB, 0xF8, 0x00,
  0xFF, 0xF8, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xC7, 0xF0, 0x07, 0xFC, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x07, 0xFF, 0x3F, 0x81, 0xFF, 0xF7, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xF0, 0xFF, 0x87,
  0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xF7, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0x9F, 0x80,
  0x3F, 0xC3, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC7,
  0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0xDF, 0xFC, 0x03, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7E, 0x7F, 0xF8, 0x07,
  0xE7, 0xFF, 0x00, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0x1E, 0x0F, 0xF8, 0x08, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x10, 0x7F, 0xC0, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xF7,
  0xE0, 0x07, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0,
  0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x07, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x30, 0x7F, 0xC1, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x02, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x37, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x1F, 0xFC, 0xFE, 0x01, 0xFF, 0xF7, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFD, 0xFC, 0x00, 0xFF, 0xCF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x01, 0x80, 0x0F, 0xF0, 0x0F, 0x81, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0x9F, 0xFC, 0x03, 0xFB,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFE,
  0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x03,
  0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xDF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10,
  0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x7C, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x7F, 0xF8,
  0x0F, 0xCF, 0xFF, 0x3F, 0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0xE7, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x0F, 0xF8, 0x03, 0xF1, 0xFF, 0xC0, 0x3F, 0x3F, 0xFE,
  0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xE0, 0x7F,
  0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0x00, 0x3F, 0x7F, 0xFC, 0x00,
  0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F,
  0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFD, 0xFF,
  0xF0, 0x07, 0xF7, 0xFF, 0x80, 0x1F, 0xCF, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xFC, 0x08, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x07, 0xFF, 0x3F,
  0x81, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE,
  0x7F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFC,
  0x03, 0xFF, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x00, 0x41, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF1, 0xFC, 0x0F, 0xE7,
  0xF8, 0x1F, 0xDF, 0xE0, 0x3F, 0x7F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFC, 0x0E, 0x0F, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x20, 0x03,
  0xFC, 0x70, 0x0F, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xA0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE,
  0xFC, 0x0F, 0xFF, 0xBF, 0x81, 0xFF, 0xF7, 0xE0, 0x1F, 0xFC, 0xFC, 0x01,
  0xFE, 0x1F, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0,
  0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F,
  0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x83, 0xFC,
  0x3F, 0x07, 0xFF, 0x07, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F, 0xE0, 0xFC, 0x3F,
  0x7C, 0x3F, 0x81, 0xF8, 0x7C, 0xF8, 0x7F, 0x03, 0xF1, 0xF9, 0xF1, 0xFE,
  0x07, 0xE3, 0xF3, 0xE3, 0xF8, 0x0F, 0xCF, 0xC7, 0xC7, 0xF0, 0x1F, 0x9F,
  0x8F, 0x9F, 0xC0, 0x3F, 0x3F, 0x1F, 0x3F, 0x80, 0x7E, 0xFC, 0x3E, 0xFE,
  0x00, 0xFD, 0xF8, 0x7D, 0xFC, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F,
  0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0xFF, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x10, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x80, 0x07, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 40, 15, 0, -39 },
  { 86, 20, 14, 23, 5, -39 },
  { 121, 31, 39, 32, 1, -39 },
  { 273, 27, 44, 27, 1, -41 },
  { 422, 38, 39, 43, 3, -39 },
  { 608, 33, 40, 34, 1, -39 },
  { 773, 9, 14, 14, 5, -39 },
  { 789, 19, 48, 17, 2, -39 },
  { 903, 20, 48, 17, -4, -39 },
  { 1023, 24, 24, 27, 4, -41 },
  { 1095, 24, 26, 29, 3, -32 },
  { 1173, 13, 14, 14, -3, -7 },
  { 1196, 15, 7, 17, 1, -18 },
  { 1210, 9, 9, 14, 0, -8 },
  { 1221, 29, 39, 22, -3, -39 },
  { 1363, 26, 40, 27, 1, -39 },
  { 1493, 20, 39, 27, 5, -39 },
  { 1591, 29, 39, 27, -2, -39 },
  { 1733, 27, 40, 27, 0, -39 },
  { 1868, 28, 39, 27, -1, -39 },
  { 2005, 28, 40, 27, 0, -39 },
  { 2145, 26, 40, 27, 2, -39 },
  { 2275, 28, 39, 27, 2, -39 },
  { 2412, 27, 40, 27, 1, -39 },
  { 2547, 26, 40, 27, 1, -39 },
  { 2677, 14, 31, 15, 0, -30 },
  { 2732, 17, 37, 15, -3, -30 },
  { 2811, 24, 27, 29, 3, -33 },
  { 2892, 24, 16, 29, 3, -27 },
  { 2940, 24, 27, 29, 3, -33 },
  { 3021, 21, 40, 22, 3, -39 },
  { 3126, 40, 44, 42, 2, -39 },
  { 3346, 30, 39, 31, -3, -39 },
  { 3493, 30, 39, 31, 1, -39 },
  { 3640, 29, 40, 30, 3, -39 },
  { 3785, 31, 39, 33, 1, -39 },
  { 3937, 28, 39, 26, 1, -39 },
  { 4074, 28, 39, 26, 1, -39 },
  { 4211, 31, 40, 34, 3, -39 },
  { 4366, 34, 39, 35, 1, -39 },
  { 4532, 25, 39, 19, -2, -39 },
  { 4654, 25, 50, 16, -8, -39 },
  { 4811, 34, 39, 30, 1, -39 },
  { 4977, 21, 39, 25, 1, -39 },
  { 5080, 44, 39, 44, 1, -39 },
  { 5295, 37, 39, 37, 1, -39 },
  { 5476, 32, 40, 36, 3, -39 },
  { 5636, 30, 39, 30, 1, -39 },
  { 5783, 32, 48, 36, 3, -39 },
  { 5975, 29, 39, 30, 1, -39 },
  { 6117, 28, 40, 26, 0, -39 },
  { 6257, 26, 39, 26, 4, -39 },
  { 6384, 32, 40, 34, 3, -39 },
  { 6544, 29, 39, 29, 5, -39 },
  { 6686, 44, 39, 44, 5, -39 },
  { 6901, 37, 39, 30, -3, -39 },
  { 7082, 28, 39, 28, 5, -39 },
  { 7219, 31, 39, 26, -2, -39 },
  { 7371, 22, 48, 17, -1, -39 },
  { 7503, 12, 39, 22, 6, -39 },
  { 7562, 22, 48, 17, -4, -39 },
  { 7694, 27, 25, 27, 0, -39 },
  { 7779, 21, 3, 20, -5, 5 },
  { 7787, 11, 8, 17, 8, -41 },
  { 7798, 27, 31, 29, 2, -30 },
  { 7903, 28, 42, 29, 0, -41 },
  { 8050, 23, 31, 24, 2, -30 },
  { 8140, 29, 42, 29, 2, -41 },
  { 8293, 24, 31, 27, 2, -30 },
  { 8386, 30, 54, 18, -6, -41 },
  { 8589, 29, 43, 30, 0, -30 },
  { 8745, 28, 41, 30, 0, -41 },
  { 8889, 16, 41, 15, 0, -41 },
  { 8971, 24, 54, 15, -7, -41 },
  { 9133, 31, 41, 28, 0, -41 },
  { 9292, 17, 41, 15, 0, -41 },
  { 9380, 42, 30, 44, 0, -30 },
  { 9538, 28, 30, 30, 0, -30 },
  { 9643, 25, 31, 29, 2, -30 },
  { 9740, 30, 43, 29, -2, -30 },
  { 9902, 27, 43, 29, 2, -30 },
  { 10048, 23, 30, 21, 0, -30 },
  { 10135, 23, 31, 23, 0, -30 },
  { 10225, 18, 37, 20, 3, -36 },
  { 10309, 27, 30, 30, 2, -29 },
  { 10411, 25, 29, 25, 3, -29 },
  { 10502, 39, 29, 39, 3, -29 },
  { 10644, 32, 29, 26, -3, -29 },
  { 10760, 33, 42, 26, -4, -29 },
  { 10934, 25, 29, 23, -1, -29 },
  { 11025, 22, 48, 19, 0, -39 },
  { 11157, 6, 53, 26, 10, -41 },
  { 11197, 22, 48, 19, -3, -39 },
  { 11329, 24, 9, 29, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC54PT7B_H_
