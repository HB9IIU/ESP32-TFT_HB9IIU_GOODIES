#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0xFC, 0x3E, 0x07, 0x80, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E,
  0x71, 0xCF, 0x1C, 0xF3, 0xCE, 0x3C, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xCF,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x07, 0xE0, 0x3F, 0xF1, 0xFF, 0xE3, 0xFF,
  0x8F, 0xB3, 0x1E, 0x60, 0x3C, 0xC0, 0x7D, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xBE, 0x03, 0x7D, 0x06, 0xFB, 0x8D,
  0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x07, 0xE0, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x70, 0x7F, 0x01, 0xE0, 0xFF, 0x07, 0x83, 0xDE,
  0x0E, 0x07, 0x1C, 0x3C, 0x1E, 0x78, 0xF0, 0x3C, 0xF1, 0xC0, 0x71, 0xE7,
  0x80, 0xE3, 0xDE, 0x01, 0xC7, 0x39, 0xF3, 0x9E, 0xF7, 0xF7, 0xFB, 0xDF,
  0xEF, 0xE7, 0x39, 0xEF, 0x9E, 0xF3, 0xC0, 0x79, 0xC7, 0x80, 0xE3, 0x8E,
  0x03, 0xCF, 0x1C, 0x0F, 0x1E, 0x78, 0x1C, 0x3C, 0xF0, 0x78, 0x79, 0xC1,
  0xE0, 0xFF, 0x83, 0x80, 0xFE, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x79, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0xF3, 0xFE, 0x3C, 0xFB, 0xE7, 0xBE, 0x7D, 0xF7, 0xC7, 0xFC, 0xF0,
  0xFF, 0x1E, 0x0F, 0xE3, 0xE1, 0xF8, 0x7E, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xF3, 0xF0, 0x7D, 0xE7, 0x9E, 0x71, 0xCF, 0x3C, 0x01, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C,
  0x00, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x78, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x38, 0x10, 0xE0, 0x63,
  0x83, 0xEE, 0x0F, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x7E, 0x03, 0xFC, 0x3E,
  0x70, 0x79, 0xE0, 0xC7, 0x80, 0x18, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0xDF, 0xFF, 0xF0, 0x39,
  0xEF, 0xFE, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1,
  0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xDF, 0x07, 0xBC, 0x1F, 0x78, 0x3E, 0xF0, 0x79,
  0xE1, 0xF3, 0xE7, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x3E, 0x07, 0xE1, 0xFE, 0x3F, 0xEF, 0xFE, 0xFB, 0xC7, 0x3C,
  0x23, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0x70, 0xF8, 0x30, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x04, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x80, 0x7C, 0xFB, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xDE,
  0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x7C, 0x3C, 0x7C,
  0x78, 0x78, 0x70, 0x78, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x08, 0xFC, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x80, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0xF0,
  0x7B, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x7C, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7D, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xF9,
  0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x87, 0x8F, 0x1F, 0x1F, 0x7C, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x03, 0xFF, 0x0F, 0x9F, 0x3E, 0x1E, 0x78, 0x3E, 0xF0,
  0x7D, 0xE0, 0xFB, 0xC1, 0xE7, 0xC7, 0xCF, 0xFF, 0x0F, 0xFE, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x87,
  0xDF, 0x0F, 0xBC, 0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xF1, 0xFB, 0xFF, 0xE7,
  0xFF, 0xC7, 0xF7, 0x87, 0xDF, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC7, 0x7F, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x06, 0x0F, 0x1F,
  0x1F, 0x1F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78,
  0xFC, 0xF8, 0xF8, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x3E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80,
  0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7C, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xF7, 0xFF, 0x20, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07,
  0xE0, 0x3C, 0x0F, 0x80, 0x1E, 0x0E, 0x00, 0x0E, 0x1E, 0x1F, 0x8E, 0x3C,
  0x7F, 0xCF, 0x38, 0xFF, 0xC7, 0x78, 0xE3, 0xC7, 0x71, 0xE3, 0x8F, 0x71,
  0xC3, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3, 0x87, 0x8E, 0xE3, 0x87, 0x1E, 0xE3,
  0x8F, 0x1C, 0xE3, 0xCF, 0x3C, 0xF3, 0xFF, 0xF8, 0xF1, 0xF3, 0xF0, 0x70,
  0xE1, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x78,
  0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1F, 0x07,
  0xC7, 0xC1, 0xE0, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x80,
  0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3C,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x0F, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C,
  0x3C, 0x0F, 0x0F, 0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xE1, 0xF8, 0x31, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x02, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x78, 0x1F,
  0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x0F, 0x87, 0x83, 0xF1,
  0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0x81, 0x8F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x87, 0xFB, 0xE1, 0xFE, 0xF8, 0x7F, 0x3C, 0x3F, 0xCF, 0x01, 0xF3,
  0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0xC1, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x7C, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0x1F,
  0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0,
  0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0xF0, 0x07, 0xCF,
  0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFB, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x07,
  0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xDE, 0x1F, 0xE1,
  0xEF, 0x1E, 0xF0, 0xEF, 0x0F, 0x78, 0xF7, 0x87, 0xBC, 0x73, 0xC3, 0xDE,
  0x79, 0xE1, 0xEF, 0x3D, 0xF1, 0xE7, 0xBC, 0xF0, 0xF3, 0xDE, 0x78, 0x78,
  0xFE, 0x3C, 0x3C, 0x7F, 0x1E, 0x3E, 0x3F, 0x1F, 0x1E, 0x1F, 0x8F, 0x0F,
  0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xC3, 0xC3, 0xE0, 0x07, 0xE0, 0x3C,
  0x1F, 0x80, 0xF0, 0x7E, 0x03, 0xC1, 0xF8, 0x0F, 0x0F, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0x78, 0xF8, 0x79, 0xE3,
  0xC1, 0xE7, 0x8F, 0x07, 0x9F, 0x3C, 0x1E, 0x3C, 0xF0, 0xF8, 0xF7, 0xC3,
  0xC3, 0xDE, 0x0F, 0x0F, 0xF8, 0x3C, 0x1F, 0xE0, 0xF0, 0x7F, 0x87, 0xC1,
  0xFE, 0x1E, 0x03, 0xF0, 0x78, 0x0F, 0xC1, 0xE0, 0x3F, 0x0F, 0x80, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07,
  0xCF, 0x81, 0xF7, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0,
  0x3E, 0xF0, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xCF, 0x81, 0xF7, 0xE0,
  0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0xBE,
  0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF1, 0xF0, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F, 0xBF, 0x87,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x81, 0xF3, 0xC0, 0xF9, 0xF0, 0x78, 0xF8,
  0x3C, 0x3C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xF3, 0xC0,
  0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x86, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0xC0, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x78,
  0x78, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x3E, 0x1E,
  0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x01,
  0xE7, 0x81, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E,
  0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0,
  0x7B, 0xC0, 0xF8, 0x3E, 0xF0, 0x7E, 0x0F, 0x3C, 0x1F, 0x83, 0xCF, 0x0F,
  0xE1, 0xF3, 0xC3, 0xF8, 0x78, 0xF1, 0xFE, 0x3E, 0x3C, 0x7F, 0x8F, 0x0F,
  0x1D, 0xE3, 0xC3, 0xCF, 0x79, 0xE0, 0xF3, 0xDE, 0x78, 0x3D, 0xE7, 0xBE,
  0x0F, 0x79, 0xEF, 0x03, 0xDC, 0x7B, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x87,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F,
  0x7C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xF7, 0x80, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF0, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3E, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0xF8, 0x7C, 0xF0,
  0x7D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0xF0, 0x70,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xBC, 0x07, 0x3C, 0x0F,
  0x1C, 0x1E, 0x1C, 0x1E, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0x9E, 0x3C, 0x70, 0x03, 0x80, 0x0F,
  0xEF, 0x1F, 0xEF, 0x1F, 0xFF, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xF8, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x38, 0x0F,
  0x7E, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7E, 0x7C, 0x7F, 0xFC, 0x77, 0xF8, 0xF3, 0xE0, 0x01, 0xF0, 0x1F,
  0xF1, 0xFF, 0x87, 0xFE, 0x3E, 0x11, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x8F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x38, 0xF0, 0x3F, 0xBC, 0x1F,
  0xEF, 0x07, 0xFF, 0xC3, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x87, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xE0, 0xFD, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xF9, 0xE0, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xEF, 0x87, 0xDF, 0x0F,
  0x3C, 0x7E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x0C, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0x10, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFB, 0xC3, 0xFD, 0xE1,
  0xFF, 0xF1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F,
  0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x86, 0x0F, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x1C, 0x0F, 0x7E, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F,
  0x0F, 0x1F, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8,
  0x7C, 0x07, 0x81, 0xF0, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x08, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x04, 0x3C, 0x3E, 0x0F, 0x1F, 0x07,
  0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x78, 0x78, 0x1E, 0x1F, 0x07, 0x87, 0xC3, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E, 0x07, 0x3F, 0x1F, 0x83, 0xBF, 0xDF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xF9, 0xFC, 0xF8, 0xF8, 0x7C, 0x7C, 0x78, 0x3C,
  0x3E, 0x3C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x07,
  0x83, 0xC7, 0x83, 0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xE0, 0xF1, 0xE0,
  0xF0, 0x78, 0xF0, 0x78, 0x7C, 0x78, 0x7C, 0x3E, 0x7C, 0x3E, 0x1E, 0x00,
  0x00, 0x1C, 0x0E, 0x7E, 0x0E, 0xFF, 0x1F, 0xFF, 0x1F, 0x8F, 0x1F, 0x0F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C,
  0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xEF, 0x87, 0xDF,
  0x0F, 0xBC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x87,
  0xDF, 0x0F, 0x9F, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x0E,
  0x03, 0x9F, 0x81, 0xDF, 0xE1, 0xFF, 0xF0, 0xFC, 0xF8, 0x7C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x3E, 0xF8,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xEF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFD, 0xF8,
  0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1C,
  0x3D, 0xE0, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFE, 0x3E, 0x10, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7C, 0x01, 0xF2, 0x07, 0xCE, 0x3F, 0x3F, 0xF8, 0xFF, 0xC1,
  0xFE, 0x00, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF1, 0x3F, 0xE7, 0xFE, 0xFF,
  0xE3, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xD0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x1E, 0x0F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC,
  0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0x78, 0xF0, 0x3F, 0xE0, 0xFB,
  0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x3E, 0x3C, 0x78, 0x79, 0xF0, 0x73,
  0xC0, 0xF7, 0x81, 0xFE, 0x03, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF0, 0xFC, 0x3F, 0xE1, 0xF8, 0x7B, 0xC3, 0xF1,
  0xE7, 0x8F, 0xE3, 0xCF, 0x1F, 0xCF, 0x9E, 0x7F, 0x9E, 0x3C, 0xEF, 0x7C,
  0x79, 0xDE, 0xF0, 0xF7, 0xBD, 0xE1, 0xEE, 0x7F, 0x83, 0xFC, 0xEF, 0x07,
  0xF1, 0xDC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E,
  0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xF3, 0xC0,
  0x3E, 0x78, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0xFC, 0x1F, 0x00, 0x0F, 0x03,
  0xE1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x1F, 0x3E,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF0, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x38, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x07, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xE0, 0x00, 0x3E, 0x02, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 23, 9, 0, -23 },
  { 30, 12, 8, 14, 3, -23 },
  { 42, 19, 23, 19, 0, -23 },
  { 97, 15, 26, 16, 1, -24 },
  { 146, 23, 23, 26, 2, -23 },
  { 213, 19, 23, 20, 1, -23 },
  { 268, 6, 8, 8, 3, -23 },
  { 274, 11, 28, 10, 1, -23 },
  { 313, 11, 28, 10, -2, -23 },
  { 352, 14, 15, 16, 3, -25 },
  { 379, 14, 15, 17, 2, -19 },
  { 406, 8, 8, 9, -2, -4 },
  { 414, 9, 4, 10, 0, -11 },
  { 419, 6, 5, 9, 0, -5 },
  { 423, 17, 23, 13, -2, -23 },
  { 472, 15, 23, 16, 1, -23 },
  { 516, 12, 23, 16, 3, -23 },
  { 551, 17, 23, 16, -1, -23 },
  { 600, 16, 23, 16, 0, -23 },
  { 646, 16, 23, 16, 0, -23 },
  { 692, 16, 23, 16, 0, -23 },
  { 738, 16, 23, 16, 1, -23 },
  { 784, 17, 23, 16, 1, -23 },
  { 833, 15, 23, 16, 1, -23 },
  { 877, 15, 23, 16, 1, -23 },
  { 921, 8, 18, 9, 0, -18 },
  { 939, 10, 22, 9, -2, -18 },
  { 967, 15, 17, 17, 1, -20 },
  { 999, 14, 10, 17, 2, -16 },
  { 1017, 14, 17, 17, 2, -20 },
  { 1047, 12, 23, 13, 2, -23 },
  { 1082, 24, 26, 25, 1, -23 },
  { 1160, 18, 23, 18, -2, -23 },
  { 1212, 18, 23, 18, 0, -23 },
  { 1264, 17, 23, 18, 2, -23 },
  { 1313, 19, 23, 20, 0, -23 },
  { 1368, 17, 23, 16, 0, -23 },
  { 1417, 17, 23, 15, 0, -23 },
  { 1466, 18, 23, 20, 2, -23 },
  { 1518, 21, 23, 20, 0, -23 },
  { 1579, 14, 23, 11, -1, -23 },
  { 1620, 15, 30, 10, -5, -23 },
  { 1677, 20, 23, 18, 1, -23 },
  { 1735, 13, 23, 15, 0, -23 },
  { 1773, 25, 23, 26, 1, -23 },
  { 1845, 22, 23, 22, 0, -23 },
  { 1909, 18, 23, 21, 2, -23 },
  { 1961, 18, 23, 18, 0, -23 },
  { 2013, 18, 28, 21, 2, -23 },
  { 2076, 17, 23, 18, 1, -23 },
  { 2125, 16, 23, 16, 0, -23 },
  { 2171, 15, 23, 15, 3, -23 },
  { 2215, 19, 23, 20, 2, -23 },
  { 2270, 17, 23, 17, 3, -23 },
  { 2319, 26, 23, 26, 3, -23 },
  { 2394, 22, 23, 18, -2, -23 },
  { 2458, 16, 23, 16, 3, -23 },
  { 2504, 18, 23, 15, -1, -23 },
  { 2556, 13, 28, 10, -1, -23 },
  { 2602, 8, 23, 13, 3, -23 },
  { 2625, 13, 28, 10, -2, -23 },
  { 2671, 16, 15, 16, 0, -23 },
  { 2701, 12, 2, 12, -3, 3 },
  { 2704, 6, 6, 10, 5, -25 },
  { 2709, 16, 18, 17, 1, -18 },
  { 2745, 16, 24, 17, 0, -24 },
  { 2793, 14, 18, 14, 1, -18 },
  { 2825, 18, 24, 17, 1, -24 },
  { 2879, 15, 18, 16, 1, -18 },
  { 2913, 17, 32, 11, -3, -24 },
  { 2981, 17, 26, 18, 0, -18 },
  { 3037, 16, 24, 18, 0, -24 },
  { 3085, 10, 24, 9, 0, -24 },
  { 3115, 14, 32, 9, -4, -24 },
  { 3171, 18, 24, 17, 0, -24 },
  { 3225, 10, 24, 9, 0, -24 },
  { 3255, 25, 18, 26, 0, -18 },
  { 3312, 16, 18, 18, 0, -18 },
  { 3348, 15, 18, 17, 1, -18 },
  { 3382, 17, 26, 17, -1, -18 },
  { 3438, 16, 26, 17, 1, -18 },
  { 3490, 14, 18, 12, 0, -18 },
  { 3522, 14, 18, 14, 0, -18 },
  { 3554, 12, 21, 12, 1, -21 },
  { 3586, 16, 17, 18, 1, -17 },
  { 3620, 15, 17, 15, 2, -17 },
  { 3652, 23, 17, 23, 2, -17 },
  { 3701, 19, 17, 16, -2, -17 },
  { 3742, 19, 25, 15, -2, -17 },
  { 3802, 15, 17, 14, -1, -17 },
  { 3834, 13, 28, 11, 0, -23 },
  { 3880, 3, 31, 16, 6, -24 },
  { 3892, 13, 28, 11, -2, -23 },
  { 3938, 15, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC32PT7B_H_
