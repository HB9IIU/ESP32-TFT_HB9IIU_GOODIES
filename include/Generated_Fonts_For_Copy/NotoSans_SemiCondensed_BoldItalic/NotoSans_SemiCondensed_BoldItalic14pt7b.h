#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x60, 0xCC, 0x7A, 0xD7, 0xA0, 0x0B, 0x1A, 0x12,
  0x7F, 0x34, 0x34, 0xFF, 0x2C, 0x68, 0x58, 0x04, 0x18, 0xFB, 0x56, 0x87,
  0x07, 0x0E, 0x9D, 0xF8, 0x81, 0x00, 0x71, 0xB4, 0xCD, 0x22, 0x50, 0xBF,
  0xBA, 0xB1, 0x6C, 0xDB, 0x26, 0x90, 0xC0, 0x1E, 0x1B, 0x0D, 0x87, 0xC1,
  0x83, 0xCD, 0xBD, 0x9C, 0xFE, 0x3D, 0x80, 0x69, 0x60, 0x18, 0x8C, 0xC6,
  0x31, 0x18, 0xC6, 0x10, 0xC0, 0x10, 0xC6, 0x31, 0x8C, 0x62, 0x31, 0x99,
  0x80, 0x18, 0x4F, 0x4F, 0x73, 0x61, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0,
  0x36, 0x6C, 0x7F, 0xF0, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0xC0, 0x1C, 0x7D, 0x9B, 0x36, 0x78, 0xF3, 0xE6, 0x7C, 0xF0, 0x19,
  0xFE, 0xB1, 0x98, 0xC6, 0x33, 0x00, 0x3C, 0xFC, 0x98, 0x30, 0xC3, 0x0C,
  0x30, 0xFD, 0xF8, 0x3C, 0x7C, 0x18, 0x33, 0xC7, 0x83, 0x06, 0xFD, 0xF0,
  0x06, 0x1C, 0x79, 0xE2, 0xCD, 0xBF, 0xFF, 0x18, 0x30, 0x3E, 0x7C, 0xC3,
  0x07, 0xC9, 0x83, 0x06, 0xFD, 0xF0, 0x0E, 0x7C, 0xC3, 0x47, 0xCC, 0xD9,
  0xE6, 0x7C, 0xF0, 0x3F, 0x7E, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0xE0, 0x1E, 0x6D, 0x99, 0xB3, 0xCF, 0xB3, 0x62, 0xEC, 0xF0, 0x3C, 0xFD,
  0x9B, 0x36, 0xEF, 0xC3, 0x06, 0xF9, 0xE0, 0x27, 0x20, 0x00, 0xCC, 0x11,
  0xC4, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04, 0x33, 0xB8, 0xE0, 0xE0, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x1D, 0xCC, 0x20, 0x7E, 0xC6, 0x33,
  0x31, 0x00, 0xC6, 0x00, 0x1F, 0x0C, 0x66, 0x0F, 0x7B, 0x92, 0xED, 0xBA,
  0x6A, 0xFE, 0x92, 0x30, 0x87, 0xE0, 0x06, 0x0F, 0x0F, 0x1B, 0x1B, 0x33,
  0x3F, 0x7F, 0x63, 0xC3, 0x3E, 0x3F, 0x33, 0x33, 0x7E, 0x7E, 0x66, 0x66,
  0x7E, 0xFC, 0x3E, 0xFD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0x3E,
  0x3F, 0x33, 0x33, 0x63, 0x63, 0x63, 0x66, 0x7E, 0xF8, 0x3E, 0x7C, 0xC1,
  0x87, 0xCF, 0x98, 0x30, 0x7D, 0xF0, 0x3E, 0x7C, 0xC1, 0x87, 0xCF, 0x98,
  0x30, 0x61, 0x80, 0x1F, 0x7E, 0x60, 0xC0, 0xCE, 0xDE, 0xC6, 0xC6, 0xFC,
  0x7C, 0x31, 0x98, 0xCC, 0x66, 0x67, 0xF3, 0xF9, 0x8C, 0xC6, 0x66, 0x63,
  0x00, 0x7C, 0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0xC0, 0x0C, 0x30, 0xC3,
  0x1C, 0x61, 0x86, 0x18, 0xC3, 0x3C, 0xE0, 0x33, 0x99, 0x8D, 0x87, 0x87,
  0xC3, 0xE1, 0xB0, 0xD8, 0x4E, 0x63, 0x00, 0x30, 0xC3, 0x0C, 0x61, 0x86,
  0x18, 0x7F, 0xE0, 0x38, 0x73, 0x8E, 0x38, 0xE2, 0x9E, 0x69, 0x66, 0xB4,
  0x6A, 0xC6, 0xEC, 0x4C, 0xCC, 0xCC, 0x38, 0xCE, 0x23, 0x98, 0xB6, 0x6D,
  0x9B, 0x66, 0x51, 0x9C, 0x47, 0x31, 0xC0, 0x3E, 0x7F, 0x63, 0xC3, 0xC3,
  0xC3, 0xC6, 0xC6, 0xFC, 0x78, 0x3E, 0x3F, 0x33, 0x33, 0x67, 0x7E, 0x60,
  0x60, 0x60, 0xC0, 0x3E, 0x7F, 0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC,
  0x78, 0x18, 0x0C, 0x3E, 0x3F, 0x33, 0x33, 0x6E, 0x7C, 0x6C, 0x6C, 0x6E,
  0xC6, 0x3E, 0x7D, 0x83, 0x83, 0x83, 0x83, 0x06, 0xFD, 0xF0, 0xFF, 0xF8,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x63, 0x63, 0x67, 0x66, 0xC6,
  0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0xC3, 0xC6, 0xC6, 0xCC, 0x4C, 0x58, 0x58,
  0x70, 0x70, 0x60, 0xC6, 0x3C, 0x66, 0xCE, 0x6C, 0xEC, 0xDE, 0xCD, 0x68,
  0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0x39, 0xC6, 0x61, 0xB0, 0x78, 0x0E,
  0x07, 0x01, 0xE0, 0xD8, 0x66, 0x38, 0xC0, 0xC6, 0xD9, 0xB3, 0xC7, 0x8E,
  0x08, 0x30, 0x60, 0xC0, 0x3F, 0x7E, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60,
  0xFC, 0xFC, 0x39, 0x88, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0xC0, 0xC4, 0x66,
  0x66, 0x62, 0x23, 0x1C, 0xA0, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x38,
  0x08, 0x38, 0x71, 0xA6, 0x58, 0xC0, 0xF8, 0xC8, 0x80, 0x1B, 0x3E, 0x66,
  0x66, 0x66, 0xEC, 0x7C, 0x7C, 0x30, 0x60, 0xC1, 0xE7, 0xEC, 0xD9, 0xB3,
  0x67, 0xDB, 0xE0, 0x1C, 0xF6, 0x18, 0x63, 0x87, 0x9E, 0x03, 0x03, 0x03,
  0x1A, 0x3E, 0x66, 0x66, 0x66, 0xCC, 0x6C, 0x7C, 0x1C, 0x7D, 0x9B, 0x67,
  0x98, 0x19, 0x3E, 0x03, 0x07, 0x0C, 0x0E, 0x1E, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0xF0, 0x1B, 0x3E, 0x66, 0x66, 0x66, 0xEC, 0x7C,
  0x7C, 0x0C, 0x98, 0xF8, 0x30, 0x60, 0xC1, 0xE7, 0xEE, 0xD9, 0xB3, 0x67,
  0x9B, 0x30, 0x13, 0x03, 0x66, 0x66, 0x6C, 0xC0, 0x04, 0x30, 0x03, 0x08,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x33, 0x80, 0x30, 0x30, 0x30, 0x33, 0x66,
  0x6C, 0x78, 0x78, 0x7C, 0xCC, 0xCC, 0x33, 0x33, 0x66, 0x66, 0x6C, 0xC0,
  0x2C, 0xC7, 0xFD, 0xD9, 0xB3, 0x36, 0x66, 0xC9, 0xB3, 0x36, 0x66, 0x2C,
  0x7D, 0xDB, 0x36, 0x6C, 0xF3, 0x66, 0x1C, 0x7D, 0x9B, 0x36, 0x78, 0xDF,
  0x3C, 0x16, 0x1F, 0x33, 0x33, 0x33, 0x33, 0x76, 0x7C, 0x60, 0x60, 0xE0,
  0x1B, 0x3E, 0x66, 0x66, 0x66, 0xCC, 0x7C, 0x7C, 0x0C, 0x0C, 0x18, 0x2D,
  0xF7, 0x18, 0x61, 0x8C, 0x30, 0x39, 0xF6, 0x1C, 0x38, 0x69, 0xBC, 0x67,
  0xFC, 0xCC, 0xCE, 0xE0, 0x67, 0x9B, 0x36, 0x6C, 0xDB, 0x3E, 0x7C, 0xCF,
  0x3D, 0xB6, 0xF3, 0xCE, 0x38, 0xCC, 0xF7, 0x6D, 0xDB, 0xF4, 0xFF, 0x3B,
  0xCE, 0xE3, 0x38, 0x33, 0x37, 0x1E, 0x1C, 0x1C, 0x3C, 0x7C, 0xE6, 0x33,
  0x33, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x18, 0x30, 0x30, 0xE0, 0x7D, 0xF1,
  0x8C, 0x31, 0x8F, 0xBE, 0x1C, 0x63, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x86,
  0x18, 0xFF, 0xFC, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xCC, 0x30, 0x86, 0x38,
  0xE6, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 6, 1, -10 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 10, 10, 11, 1, -10 },
  { 43, 9, 10, 9, 0, -10 },
  { 55, 3, 4, 4, 1, -10 },
  { 57, 5, 12, 4, 0, -10 },
  { 65, 5, 12, 4, -1, -10 },
  { 73, 6, 7, 7, 1, -11 },
  { 79, 6, 6, 7, 1, -8 },
  { 84, 4, 4, 4, -1, -2 },
  { 86, 4, 2, 4, 0, -5 },
  { 87, 2, 2, 4, 0, -2 },
  { 88, 8, 10, 6, -1, -10 },
  { 98, 7, 10, 7, 0, -10 },
  { 107, 5, 10, 7, 1, -10 },
  { 114, 7, 10, 7, 0, -10 },
  { 123, 7, 10, 7, 0, -10 },
  { 132, 7, 10, 7, 0, -10 },
  { 141, 7, 10, 7, 0, -10 },
  { 150, 7, 10, 7, 0, -10 },
  { 159, 8, 10, 7, 0, -10 },
  { 169, 7, 10, 7, 0, -10 },
  { 178, 7, 10, 7, 0, -10 },
  { 187, 4, 8, 4, 0, -8 },
  { 191, 5, 10, 4, -1, -8 },
  { 198, 6, 8, 7, 1, -9 },
  { 204, 6, 4, 7, 1, -7 },
  { 207, 6, 8, 7, 1, -9 },
  { 213, 5, 10, 6, 1, -10 },
  { 220, 10, 11, 11, 1, -10 },
  { 234, 8, 10, 8, -1, -10 },
  { 244, 8, 10, 8, 0, -10 },
  { 254, 7, 10, 8, 1, -10 },
  { 263, 8, 10, 9, 0, -10 },
  { 273, 7, 10, 7, 0, -10 },
  { 282, 7, 10, 7, 0, -10 },
  { 291, 8, 10, 9, 1, -10 },
  { 301, 9, 10, 9, 0, -10 },
  { 313, 6, 10, 5, 0, -10 },
  { 321, 6, 13, 4, -2, -10 },
  { 331, 9, 10, 8, 0, -10 },
  { 343, 6, 10, 7, 0, -10 },
  { 351, 12, 10, 11, 0, -10 },
  { 366, 10, 10, 10, 0, -10 },
  { 379, 8, 10, 9, 1, -10 },
  { 389, 8, 10, 8, 0, -10 },
  { 399, 8, 12, 9, 1, -10 },
  { 411, 8, 10, 8, 0, -10 },
  { 421, 7, 10, 7, 0, -10 },
  { 430, 7, 10, 7, 1, -10 },
  { 439, 8, 10, 9, 1, -10 },
  { 449, 8, 10, 8, 1, -10 },
  { 459, 12, 10, 12, 1, -10 },
  { 474, 10, 10, 8, -1, -10 },
  { 487, 7, 10, 7, 1, -10 },
  { 496, 8, 10, 7, 0, -10 },
  { 506, 5, 12, 4, 0, -10 },
  { 514, 4, 10, 6, 1, -10 },
  { 519, 6, 12, 4, -1, -10 },
  { 528, 7, 6, 7, 0, -10 },
  { 534, 5, 1, 5, -1, 1 },
  { 535, 3, 3, 4, 2, -11 },
  { 537, 8, 8, 8, 0, -8 },
  { 545, 7, 11, 8, 0, -11 },
  { 555, 6, 8, 6, 0, -8 },
  { 561, 8, 11, 8, 0, -11 },
  { 572, 7, 8, 7, 0, -8 },
  { 579, 8, 14, 5, -2, -11 },
  { 593, 8, 11, 8, 0, -8 },
  { 604, 7, 11, 8, 0, -11 },
  { 614, 4, 11, 4, 0, -11 },
  { 620, 6, 14, 4, -2, -11 },
  { 631, 8, 11, 7, 0, -11 },
  { 642, 4, 11, 4, 0, -11 },
  { 648, 11, 8, 11, 0, -8 },
  { 659, 7, 8, 8, 0, -8 },
  { 666, 7, 8, 7, 0, -8 },
  { 673, 8, 11, 8, -1, -8 },
  { 684, 8, 11, 8, 0, -8 },
  { 695, 6, 8, 5, 0, -8 },
  { 701, 6, 8, 6, 0, -8 },
  { 707, 4, 9, 5, 1, -9 },
  { 712, 7, 8, 8, 1, -8 },
  { 719, 6, 8, 7, 1, -8 },
  { 725, 10, 8, 10, 1, -8 },
  { 735, 8, 8, 7, -1, -8 },
  { 743, 8, 11, 7, -1, -8 },
  { 754, 6, 8, 6, 0, -8 },
  { 760, 6, 12, 5, 0, -10 },
  { 769, 1, 14, 7, 3, -11 },
  { 771, 6, 12, 5, -1, -10 },
  { 780, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC14PT7B_H_
