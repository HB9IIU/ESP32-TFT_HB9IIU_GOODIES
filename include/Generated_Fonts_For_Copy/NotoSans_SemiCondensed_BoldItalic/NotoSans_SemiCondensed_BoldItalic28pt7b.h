#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0x00, 0x00, 0x78, 0x7C, 0x3E, 0x1E, 0x00,
  0x73, 0xDC, 0xEF, 0x3B, 0x8E, 0xE7, 0xB9, 0xCE, 0x70, 0x01, 0xC7, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0xFF, 0xFE,
  0x7F, 0xFF, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x07, 0xFF,
  0xE7, 0xFF, 0xF0, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E,
  0x70, 0x07, 0x38, 0x00, 0x00, 0x60, 0x01, 0x80, 0x3F, 0x83, 0xFF, 0x1F,
  0xFC, 0x7B, 0x61, 0xE8, 0x07, 0xA0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x0D, 0xE0, 0x37, 0x90, 0xDE, 0x72, 0xF9, 0xFF, 0xCF,
  0xFE, 0x0F, 0xE0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0xC3,
  0xF0, 0x38, 0x7F, 0x07, 0x0F, 0x78, 0xE0, 0xE7, 0x8E, 0x0E, 0x71, 0xC0,
  0xE7, 0x38, 0x0E, 0x73, 0x80, 0xEF, 0x77, 0xCF, 0xEE, 0xFE, 0xFE, 0xEF,
  0xE7, 0x9D, 0xEF, 0x03, 0x9C, 0xE0, 0x39, 0xCE, 0x07, 0x1C, 0xE0, 0xE3,
  0xCE, 0x0E, 0x3D, 0xE1, 0xC1, 0xFC, 0x38, 0x1F, 0x87, 0x80, 0xF0, 0x03,
  0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0,
  0x7B, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC3, 0xCF, 0xE3, 0xCF, 0xF9,
  0xEF, 0x3F, 0xE7, 0x8F, 0xF3, 0xC7, 0xF1, 0xE1, 0xF0, 0xF1, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x07, 0xE7, 0xC0, 0x7B, 0xBD, 0xEE, 0x73, 0x80, 0x03,
  0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0x03,
  0x80, 0x1C, 0x10, 0xE0, 0xE6, 0x0F, 0xFF, 0xBF, 0xFC, 0x3F, 0xE3, 0xF0,
  0x3F, 0x83, 0xDE, 0x0C, 0x70, 0x23, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0xE7, 0x9C, 0xF3, 0x8E, 0x00,
  0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x87,
  0xFE, 0x7C, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDE, 0x3C, 0xF3, 0xE7,
  0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0xC3, 0xF1, 0xF8, 0xFE, 0xFF, 0xBD,
  0xE6, 0x79, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8,
  0x79, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x00, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC3, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0xC1, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x83, 0xDE, 0x0E, 0x70, 0x73,
  0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE7, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x60, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0xC1, 0xF3,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xCF,
  0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF9, 0xE1, 0xFF,
  0x87, 0xFC, 0x0F, 0xE0, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0xFF, 0xC7,
  0x8F, 0x1E, 0x1C, 0x78, 0xF1, 0xE3, 0xC3, 0xDE, 0x0F, 0xF0, 0x1F, 0x01,
  0xFE, 0x0F, 0xBC, 0x78, 0xF9, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0x78, 0xF1,
  0xFF, 0xC7, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0x79, 0xF7,
  0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xFB, 0xCF, 0xDF, 0xFC, 0x7F,
  0xE1, 0xEF, 0x00, 0x70, 0x07, 0x80, 0x78, 0x87, 0xC7, 0xFC, 0x3F, 0xC1,
  0xF8, 0x00, 0x04, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x9F, 0x3E, 0x78, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x03,
  0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x0F, 0x00,
  0x40, 0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0x31, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xF8, 0xF8, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x1E, 0x1E, 0x38, 0xE3, 0xFC,
  0xEE, 0x3F, 0xC7, 0x73, 0xCE, 0x3B, 0x1C, 0x71, 0xB9, 0xC3, 0x8D, 0xCE,
  0x38, 0xEE, 0x71, 0xC7, 0x73, 0x8E, 0x73, 0x9E, 0xF7, 0x9C, 0xFD, 0xF8,
  0xE3, 0xCF, 0x83, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x18, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xEE, 0x01, 0xEE, 0x01, 0xEE, 0x03, 0xCE, 0x03, 0xCE, 0x07, 0x8F,
  0x07, 0x8F, 0x0F, 0x0F, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x07, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0x3F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x3C, 0x78, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x8E, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x30, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xEF,
  0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F,
  0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8,
  0xF0, 0xF8, 0x79, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x08, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF0, 0xE1,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x7F,
  0x9E, 0x3F, 0x9F, 0x1F, 0xCF, 0x81, 0xE7, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x7E, 0x3C, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0x83,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x87, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x83, 0xC3, 0xE0, 0xF0, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xF8,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0x87, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0x9F,
  0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0xC3, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0xFD, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xDE, 0x1D,
  0xC3, 0xB8, 0x3B, 0x8E, 0xF0, 0xF7, 0x1D, 0xE1, 0xEE, 0x73, 0xC3, 0xDC,
  0xE7, 0x87, 0x3F, 0x8E, 0x0E, 0x7F, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF8,
  0xF0, 0xF1, 0xF1, 0xC1, 0xC3, 0xC3, 0x87, 0x87, 0x8F, 0x00, 0x07, 0x80,
  0xF0, 0xFC, 0x0E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F, 0xC1, 0xE1, 0xFE,
  0x1C, 0x1F, 0xE1, 0xC1, 0xEE, 0x3C, 0x1C, 0xE3, 0xC1, 0xCF, 0x3C, 0x3C,
  0xF3, 0x83, 0xC7, 0x38, 0x3C, 0x7F, 0x83, 0x87, 0xF8, 0x38, 0x7F, 0x87,
  0x83, 0xF0, 0x78, 0x3F, 0x07, 0x83, 0xF0, 0x70, 0x3F, 0x0F, 0x01, 0xE0,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xE1, 0xE0, 0xF9, 0xF0,
  0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xFF,
  0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0x7C,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0x3F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x1E, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xE1, 0xE0, 0xF9, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xFF, 0x01,
  0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x79,
  0xF0, 0xF1, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x03, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xF7, 0xC1, 0xE0, 0x03, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC7, 0xC6, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x20, 0x3C, 0xE3,
  0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x83,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0xF8,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0xE0, 0x3F, 0xC0,
  0x7B, 0x81, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0,
  0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x3F, 0xC0, 0xF0, 0x7B, 0x83, 0xE0, 0xF7, 0x07, 0xC3, 0xCE, 0x1F,
  0x87, 0x9C, 0x3F, 0x1E, 0x38, 0xFE, 0x3C, 0x71, 0xDC, 0x70, 0xE3, 0xB9,
  0xE1, 0xCF, 0x73, 0xC3, 0x9C, 0xEF, 0x07, 0x79, 0xDE, 0x0E, 0xE3, 0xB8,
  0x1D, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x81, 0xE0,
  0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xBE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E,
  0x3E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x80, 0xF0, 0x7F, 0xC1,
  0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE1, 0xCF, 0x07, 0xBC, 0x1F, 0xE0, 0x7F,
  0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x7E, 0x0F, 0xE0,
  0xE3, 0xCF, 0x3C, 0x71, 0xC7, 0x1C, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8F,
  0x3C, 0xF1, 0xC7, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0xFE, 0x0F, 0xE0, 0x00, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xF0,
  0x1D, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E,
  0xF0, 0x1C, 0x7F, 0xFF, 0xFC, 0xF9, 0xE3, 0x87, 0x02, 0x00, 0x3E, 0x71,
  0xFF, 0xCF, 0xFE, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0xBE, 0x1E, 0xF0, 0x73,
  0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xF3, 0xFF, 0x87, 0xEE, 0x0F, 0x38,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x81, 0xEF,
  0x87, 0xFF, 0x1F, 0xFC, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0x83, 0xDE, 0x1F, 0x78, 0x79, 0xF3, 0xE7, 0xFF, 0x1F, 0xF8, 0xE7,
  0xC0, 0x01, 0x00, 0xFF, 0x1F, 0xE3, 0xFE, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x8F, 0xF8, 0x7F, 0x83,
  0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x47,
  0x83, 0xEF, 0x0F, 0xFE, 0x3F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF,
  0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xE3, 0xFF,
  0x83, 0xFF, 0x03, 0xCE, 0x00, 0x00, 0x80, 0x7F, 0x07, 0xFC, 0x7D, 0xF7,
  0xC7, 0xBC, 0x3D, 0xE3, 0xDF, 0xFE, 0xFF, 0xC7, 0xF8, 0x3C, 0x01, 0xE0,
  0x0F, 0x02, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x0F, 0x9C, 0x3F, 0xF8, 0xFF, 0xE3, 0xE3,
  0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC7, 0xC7, 0x8F, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0x78, 0x00, 0xF0, 0x01,
  0xC2, 0x07, 0x87, 0xBF, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0xC1, 0xEF, 0x87,
  0xFF, 0x1F, 0xFC, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x3C, 0xF0, 0xF0,
  0x07, 0x07, 0xC3, 0xC0, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x00,
  0x00, 0x70, 0x07, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x01, 0x1E, 0x1E,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x79, 0xF0, 0x78, 0xF0,
  0x70, 0xF0, 0xF0, 0xF8, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x00, 0x00, 0x20, 0x20, 0x73, 0xE7, 0xE1, 0xDF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1E, 0x3E, 0x3C, 0xF8, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF,
  0x0F, 0x0E, 0x3C, 0x38, 0x78, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1E,
  0x1E, 0x78, 0x78, 0xF1, 0xE1, 0xC3, 0xC7, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C,
  0x00, 0x20, 0x73, 0xE1, 0xDF, 0xC7, 0xFF, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1,
  0xE7, 0x07, 0x3C, 0x3C, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xE7, 0xC7,
  0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF,
  0x1E, 0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x00, 0x10, 0x1C, 0xF8, 0x3B, 0xF8,
  0x7F, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x38,
  0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xE7, 0xC7, 0xFF, 0x0E, 0xFC, 0x3D, 0xF0,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x02, 0x00, 0x3E, 0x71, 0xFF, 0xCF, 0xFE, 0x3C, 0x79, 0xE1,
  0xE7, 0x87, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1,
  0xF3, 0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x31, 0xEF, 0x1D, 0xE1,
  0xFE, 0x1F, 0xA3, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x01, 0x01, 0xFF, 0x3F, 0xF3,
  0xEE, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x06, 0x03, 0x80, 0xE0, 0x78,
  0x7F, 0xDF, 0xFF, 0xF8, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xFE, 0x1F, 0x87, 0xE0, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCE, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0xF3, 0xC3,
  0xCF, 0x1F, 0x3C, 0x7C, 0xFF, 0xE1, 0xFB, 0x87, 0xCE, 0x00, 0xE0, 0xFF,
  0x07, 0xB8, 0x79, 0xC3, 0xCF, 0x3C, 0x79, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7,
  0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0xE1,
  0xF1, 0xFE, 0x1F, 0x1E, 0xE3, 0xF1, 0xCE, 0x3F, 0x3C, 0xE7, 0x73, 0xCE,
  0x77, 0x78, 0xE7, 0x77, 0x8E, 0xE7, 0x70, 0xEE, 0x7F, 0x0E, 0xE7, 0xE0,
  0xFC, 0x6E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78,
  0x00, 0x1E, 0x1F, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0x78, 0x0E, 0x0F, 0x87, 0x07, 0x83,
  0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0,
  0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xF0, 0x3E, 0x03, 0xE0,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07,
  0xC0, 0xF0, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x7C, 0x07, 0xC0, 0xBC,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1F,
  0x01, 0xE0, 0x7E, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 20, 8, 0, -20 },
  { 24, 10, 7, 12, 3, -20 },
  { 33, 17, 20, 16, 0, -20 },
  { 76, 14, 23, 14, 0, -21 },
  { 117, 20, 20, 22, 2, -20 },
  { 167, 17, 20, 18, 1, -20 },
  { 210, 5, 7, 7, 3, -20 },
  { 215, 10, 24, 9, 1, -20 },
  { 245, 10, 24, 9, -2, -20 },
  { 275, 13, 12, 14, 2, -21 },
  { 295, 13, 14, 15, 1, -17 },
  { 318, 6, 7, 8, -1, -3 },
  { 324, 8, 3, 9, 0, -9 },
  { 327, 5, 4, 8, 0, -4 },
  { 330, 15, 20, 11, -1, -20 },
  { 368, 13, 20, 14, 1, -20 },
  { 401, 10, 20, 14, 3, -20 },
  { 426, 15, 20, 14, -1, -20 },
  { 464, 14, 20, 14, 0, -20 },
  { 499, 14, 20, 14, 0, -20 },
  { 534, 14, 20, 14, 0, -20 },
  { 569, 14, 20, 14, 1, -20 },
  { 604, 15, 20, 14, 1, -20 },
  { 642, 14, 20, 14, 0, -20 },
  { 677, 13, 20, 14, 1, -20 },
  { 710, 7, 16, 8, 0, -16 },
  { 724, 9, 20, 8, -2, -16 },
  { 747, 13, 14, 15, 1, -17 },
  { 770, 13, 8, 15, 1, -14 },
  { 783, 13, 14, 15, 1, -17 },
  { 806, 11, 20, 12, 2, -20 },
  { 834, 21, 22, 22, 1, -20 },
  { 892, 16, 20, 16, -2, -20 },
  { 932, 16, 20, 16, 0, -20 },
  { 972, 16, 20, 15, 1, -20 },
  { 1012, 17, 20, 17, 0, -20 },
  { 1055, 15, 20, 14, 0, -20 },
  { 1093, 15, 20, 13, 0, -20 },
  { 1131, 17, 20, 18, 1, -20 },
  { 1174, 18, 20, 18, 0, -20 },
  { 1219, 13, 20, 10, -1, -20 },
  { 1252, 13, 26, 8, -4, -20 },
  { 1295, 18, 20, 16, 0, -20 },
  { 1340, 11, 20, 13, 0, -20 },
  { 1368, 23, 20, 23, 0, -20 },
  { 1426, 20, 20, 19, 0, -20 },
  { 1476, 17, 20, 19, 1, -20 },
  { 1519, 16, 20, 16, 0, -20 },
  { 1559, 17, 25, 19, 1, -20 },
  { 1613, 15, 20, 16, 0, -20 },
  { 1651, 14, 20, 14, 0, -20 },
  { 1686, 14, 20, 14, 2, -20 },
  { 1721, 16, 20, 18, 2, -20 },
  { 1761, 15, 20, 15, 3, -20 },
  { 1799, 23, 20, 23, 3, -20 },
  { 1857, 19, 20, 15, -2, -20 },
  { 1905, 14, 20, 14, 3, -20 },
  { 1940, 16, 20, 14, -1, -20 },
  { 1980, 12, 24, 9, -1, -20 },
  { 2016, 6, 20, 11, 3, -20 },
  { 2031, 12, 24, 9, -2, -20 },
  { 2067, 14, 13, 14, 0, -20 },
  { 2090, 11, 2, 10, -3, 2 },
  { 2093, 6, 4, 9, 4, -21 },
  { 2096, 14, 16, 15, 1, -16 },
  { 2124, 14, 21, 15, 0, -21 },
  { 2161, 12, 16, 12, 1, -16 },
  { 2185, 15, 21, 15, 1, -21 },
  { 2225, 13, 16, 14, 1, -16 },
  { 2251, 16, 28, 9, -3, -21 },
  { 2307, 15, 23, 15, 0, -16 },
  { 2351, 14, 21, 15, 0, -21 },
  { 2388, 9, 21, 8, 0, -21 },
  { 2412, 13, 28, 8, -4, -21 },
  { 2458, 16, 21, 14, 0, -21 },
  { 2500, 9, 21, 8, 0, -21 },
  { 2524, 22, 16, 23, 0, -16 },
  { 2568, 14, 16, 15, 0, -16 },
  { 2596, 13, 16, 15, 1, -16 },
  { 2622, 15, 23, 15, -1, -16 },
  { 2666, 14, 23, 15, 1, -16 },
  { 2707, 12, 16, 11, 0, -16 },
  { 2731, 12, 16, 12, 0, -16 },
  { 2755, 10, 19, 10, 1, -19 },
  { 2779, 14, 15, 15, 1, -15 },
  { 2806, 13, 15, 13, 2, -15 },
  { 2831, 20, 15, 20, 2, -15 },
  { 2869, 16, 15, 14, -1, -15 },
  { 2899, 17, 22, 13, -2, -15 },
  { 2946, 13, 15, 12, -1, -15 },
  { 2971, 12, 24, 10, 0, -20 },
  { 3007, 3, 27, 14, 5, -21 },
  { 3018, 12, 24, 10, -2, -20 },
  { 3054, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC28PT7B_H_
