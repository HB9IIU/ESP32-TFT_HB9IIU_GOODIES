#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00,
  0x3C, 0xFB, 0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xE7, 0x8E,
  0x3C, 0xF1, 0xE0, 0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x01,
  0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x03, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0x80, 0x0E, 0x1C,
  0x00, 0x71, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC,
  0x3E, 0xCC, 0x1E, 0x62, 0x1F, 0x30, 0x0F, 0x98, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xDF, 0x00,
  0x6F, 0x90, 0x37, 0xCC, 0x33, 0xE7, 0xDF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0F,
  0xC0, 0x3E, 0x0F, 0xE0, 0x1E, 0x0F, 0xF8, 0x1E, 0x0F, 0xBC, 0x1E, 0x07,
  0x9E, 0x0F, 0x03, 0xCF, 0x0F, 0x03, 0xC7, 0x8F, 0x01, 0xE3, 0xC7, 0x80,
  0xF1, 0xE7, 0x80, 0x78, 0xF7, 0x80, 0x3C, 0xF3, 0xDF, 0x9E, 0x7B, 0xDF,
  0xEF, 0xFB, 0xCF, 0xFB, 0xF9, 0xEF, 0x3C, 0xF9, 0xE7, 0x9E, 0x01, 0xE7,
  0x8F, 0x00, 0xF3, 0xC7, 0x80, 0xF1, 0xE3, 0xC0, 0xF0, 0xF3, 0xC0, 0x78,
  0x71, 0xE0, 0x78, 0x38, 0xF0, 0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0xF8, 0x3C,
  0x07, 0xF8, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF3, 0xE0, 0x07, 0xBF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x0F, 0x9F, 0xF8, 0x79, 0xFF, 0xE7, 0xCF, 0x9F, 0x3C,
  0xF8, 0x7F, 0xE7, 0xC3, 0xFE, 0x3E, 0x0F, 0xE1, 0xF0, 0x7F, 0x0F, 0x83,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xC7, 0xE0,
  0x3D, 0xF7, 0xDE, 0x79, 0xE7, 0x9C, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0x82, 0x0E, 0x07, 0x1C, 0x0F, 0xF8,
  0x3F, 0xFF, 0xBF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0x01, 0xFF, 0x07,
  0xCE, 0x07, 0x1E, 0x06, 0x3E, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF0, 0xF8,
  0x78, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0x9F, 0x07, 0xCF,
  0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xC1, 0xFE, 0x1F,
  0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0xCF, 0x3E, 0x31, 0xE1, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x78, 0x7C, 0x06,
  0x0F, 0xC0, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x06, 0x0F, 0xC1, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0xC0, 0x7E, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x3C, 0xF8, 0x1E,
  0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x02, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF2,
  0x00, 0xF8, 0xC0, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x7C, 0x1F,
  0x7F, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E,
  0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xC7, 0xC7, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3,
  0xFB, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F,
  0x0F, 0xDF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xF9,
  0xF0, 0xF8, 0xFC, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF,
  0x83, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xDE, 0x1F, 0xBE, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x80, 0x00, 0x0F, 0xE1, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x30, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x7F, 0xCF,
  0x3C, 0x3F, 0xF3, 0xCF, 0x1F, 0x78, 0x77, 0x8F, 0x0E, 0x1D, 0xE3, 0xC7,
  0x8F, 0x71, 0xE1, 0xE3, 0xDC, 0x78, 0x70, 0xFF, 0x1C, 0x1C, 0x3B, 0xC7,
  0x0F, 0x1E, 0xF1, 0xC3, 0xC7, 0xBC, 0x71, 0xF3, 0xCF, 0x1F, 0xFF, 0xE3,
  0xC7, 0xF7, 0xF0, 0x70, 0xF8, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x0F,
  0xBE, 0x00, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE1, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x87, 0xC1, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xCF, 0x83, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x18, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x8F, 0xE0, 0xF8, 0x7E, 0x1F,
  0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3,
  0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E,
  0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC3, 0xF8, 0xFC, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xE0, 0xE1, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC3, 0xFE, 0xF8, 0x3F, 0xCF, 0x87,
  0xFC, 0xF8, 0x7F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0xC0, 0xF8, 0xFE, 0x0F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x1F,
  0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xC0, 0xFC, 0x1E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x7E,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xFC, 0x1E, 0xF0, 0xF7, 0xC3, 0xEF, 0x0F, 0x7C, 0x3E, 0xF1, 0xE7, 0x83,
  0xCF, 0x1E, 0xF8, 0x3C, 0xF3, 0xCF, 0x83, 0xCF, 0x3C, 0xF8, 0x7C, 0xF7,
  0x8F, 0x07, 0xCF, 0x78, 0xF0, 0x78, 0xFF, 0x1F, 0x07, 0x8F, 0xF1, 0xF0,
  0x78, 0xFE, 0x1F, 0x0F, 0x87, 0xE1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07,
  0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x0F, 0xE0, 0x1E,
  0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3C,
  0x1F, 0xF0, 0x3C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C,
  0x1E, 0x78, 0x78, 0x3E, 0x7C, 0xF8, 0x3E, 0x7C, 0xF8, 0x3C, 0x3C, 0xF8,
  0x3C, 0x3C, 0xF0, 0x3C, 0x3E, 0xF0, 0x7C, 0x3E, 0xF0, 0x7C, 0x1F, 0xF0,
  0x78, 0x1F, 0xF0, 0x78, 0x1F, 0xE0, 0xF8, 0x1F, 0xE0, 0xF8, 0x0F, 0xE0,
  0xF8, 0x0F, 0xE0, 0xF0, 0x0F, 0xE0, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC3, 0xF1, 0xF8, 0x1F,
  0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE,
  0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0xFE,
  0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC,
  0x7C, 0x1F, 0x1F, 0x0F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0x8F, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF0, 0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xC3, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE2, 0x01, 0xF8,
  0xE0, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x1E, 0x07,
  0xC3, 0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE1, 0xF0, 0x3C, 0x3E,
  0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x7B, 0xE0,
  0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFF,
  0xC0, 0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x03, 0xEF, 0x83,
  0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xF3, 0xE0, 0xFE, 0x1F, 0x1F, 0x0F, 0xF0,
  0xF8, 0xF8, 0x7F, 0x87, 0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x3D, 0xE3, 0xE1,
  0xF3, 0xEF, 0x3E, 0x0F, 0x9E, 0x79, 0xF0, 0x7C, 0xF3, 0xCF, 0x03, 0xEF,
  0x1E, 0xF8, 0x1F, 0x78, 0xF7, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x3D, 0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xFB, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xCF, 0x80,
  0x0F, 0x8F, 0x80, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0xC1,
  0xF9, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0,
  0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x08, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x78,
  0x07, 0xBC, 0x07, 0x8E, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xC0,
  0x71, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0xF9, 0xF1, 0xE1, 0xE1, 0xC0, 0x07, 0xE3, 0xC3, 0xFD, 0xF1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x8F, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xEF, 0x03, 0xF3, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xBF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F,
  0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F,
  0x87, 0xC7, 0xE3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0xFF, 0x0F, 0x1F,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF0, 0x47, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x04, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE7, 0xC1, 0xFE,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x1F, 0x87, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xF7, 0x80, 0xFC, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0x9F, 0x3E, 0x0F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x7E, 0x7F, 0xFE,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x08,
  0x7E, 0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3E, 0x20, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF9, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1,
  0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7E, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x20, 0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0xBF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xE1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0x8F, 0x83, 0xE0, 0x00, 0x80, 0x78, 0x1F, 0x83, 0xE0,
  0x7C, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF7,
  0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x83, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0x3F, 0x0F, 0xC1, 0xEF, 0xF3, 0xFC, 0x3F, 0xFE, 0xFF, 0x87, 0xFF,
  0xFF, 0xF1, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x87, 0xC7, 0xC1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x1F, 0x1E, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x78, 0xF8, 0x3E,
  0x1F, 0x1F, 0x07, 0x83, 0xE3, 0xE1, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F, 0x9F,
  0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1E, 0x0F, 0x8F, 0x07, 0xC1,
  0xF3, 0xE0, 0xF8, 0x3E, 0x00, 0x0F, 0x3F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x8F, 0x83, 0xE0,
  0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F,
  0x7C, 0x0F, 0x7C, 0x0F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xE0, 0x07, 0x9F, 0x80, 0xF7, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x0F,
  0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xBF, 0xC1, 0xF3, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xC3, 0xFD, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xF7, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x3E, 0x1E, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x43, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xFC,
  0x7F, 0xF1, 0xF9, 0xE3, 0xE0, 0x47, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x20, 0x3E,
  0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x78, 0x3E,
  0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xEF, 0x03,
  0xF3, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0x78, 0xF8, 0x79, 0xF0, 0x79, 0xF0, 0x7B, 0xE0,
  0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x3F, 0x07, 0xBE, 0x1F,
  0x87, 0xDF, 0x1F, 0xC3, 0xEF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xF3, 0xE7,
  0xF9, 0xF1, 0xF3, 0xBC, 0xF8, 0xFB, 0xDE, 0x78, 0x7D, 0xEF, 0x7C, 0x3E,
  0xE7, 0xBC, 0x1F, 0xF3, 0xDE, 0x0F, 0x71, 0xFF, 0x07, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x1F, 0x01, 0xF1, 0xF8,
  0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F,
  0x03, 0xF0, 0xF8, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C,
  0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3D, 0xF0,
  0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00,
  0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x01,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x80, 0x10,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 25, 10, 0, -25 },
  { 36, 13, 9, 15, 3, -25 },
  { 51, 21, 25, 20, 0, -25 },
  { 117, 17, 29, 18, 1, -27 },
  { 179, 25, 25, 28, 2, -25 },
  { 258, 21, 25, 22, 1, -25 },
  { 324, 6, 9, 9, 3, -25 },
  { 331, 13, 31, 11, 1, -25 },
  { 382, 13, 31, 11, -3, -25 },
  { 433, 15, 16, 17, 3, -27 },
  { 463, 16, 17, 19, 2, -21 },
  { 497, 8, 9, 9, -2, -4 },
  { 506, 9, 5, 11, 1, -12 },
  { 512, 6, 5, 9, 0, -5 },
  { 516, 19, 25, 14, -2, -25 },
  { 576, 17, 25, 18, 1, -25 },
  { 630, 13, 25, 18, 3, -25 },
  { 671, 19, 25, 18, -1, -25 },
  { 731, 18, 25, 18, 0, -25 },
  { 788, 18, 25, 18, 0, -25 },
  { 845, 18, 25, 18, 0, -25 },
  { 902, 17, 25, 18, 1, -25 },
  { 956, 18, 25, 18, 1, -25 },
  { 1013, 17, 25, 18, 1, -25 },
  { 1067, 16, 25, 18, 1, -25 },
  { 1117, 9, 19, 9, 0, -19 },
  { 1139, 11, 24, 9, -2, -19 },
  { 1172, 16, 17, 19, 2, -21 },
  { 1206, 16, 11, 19, 2, -18 },
  { 1228, 16, 17, 19, 2, -21 },
  { 1262, 14, 25, 14, 2, -25 },
  { 1306, 26, 28, 27, 1, -25 },
  { 1397, 20, 25, 20, -2, -25 },
  { 1460, 19, 25, 20, 1, -25 },
  { 1520, 19, 25, 19, 2, -25 },
  { 1580, 20, 25, 22, 1, -25 },
  { 1643, 18, 25, 17, 1, -25 },
  { 1700, 17, 25, 17, 1, -25 },
  { 1754, 20, 25, 22, 2, -25 },
  { 1817, 22, 25, 22, 1, -25 },
  { 1886, 16, 25, 13, -1, -25 },
  { 1936, 17, 32, 11, -6, -25 },
  { 2004, 22, 25, 20, 1, -25 },
  { 2073, 13, 25, 16, 1, -25 },
  { 2114, 28, 25, 28, 1, -25 },
  { 2202, 24, 25, 24, 1, -25 },
  { 2277, 20, 25, 23, 2, -25 },
  { 2340, 19, 25, 19, 1, -25 },
  { 2400, 20, 31, 23, 2, -25 },
  { 2478, 18, 25, 20, 1, -25 },
  { 2535, 18, 25, 17, 0, -25 },
  { 2592, 16, 25, 17, 3, -25 },
  { 2642, 21, 25, 22, 2, -25 },
  { 2708, 19, 25, 19, 3, -25 },
  { 2768, 29, 25, 29, 3, -25 },
  { 2859, 24, 25, 19, -2, -25 },
  { 2934, 18, 25, 18, 3, -25 },
  { 2991, 20, 25, 17, -1, -25 },
  { 3054, 14, 31, 11, -1, -25 },
  { 3109, 8, 25, 14, 4, -25 },
  { 3134, 14, 31, 11, -2, -25 },
  { 3189, 17, 16, 18, 0, -25 },
  { 3223, 13, 2, 13, -3, 3 },
  { 3227, 7, 6, 11, 5, -27 },
  { 3233, 18, 19, 19, 1, -19 },
  { 3276, 18, 27, 19, 0, -27 },
  { 3337, 15, 19, 15, 1, -19 },
  { 3373, 19, 27, 19, 1, -27 },
  { 3438, 16, 19, 18, 1, -19 },
  { 3476, 20, 35, 12, -4, -27 },
  { 3564, 19, 27, 19, 0, -19 },
  { 3629, 18, 27, 19, 0, -27 },
  { 3690, 11, 27, 10, 0, -27 },
  { 3728, 15, 35, 10, -4, -27 },
  { 3794, 20, 27, 18, 0, -27 },
  { 3862, 11, 27, 10, 0, -27 },
  { 3900, 27, 19, 29, 0, -19 },
  { 3965, 18, 19, 19, 0, -19 },
  { 4008, 16, 19, 19, 1, -19 },
  { 4046, 19, 27, 19, -1, -19 },
  { 4111, 18, 27, 19, 1, -19 },
  { 4172, 15, 19, 13, 0, -19 },
  { 4208, 15, 19, 15, 0, -19 },
  { 4244, 12, 23, 13, 2, -23 },
  { 4279, 18, 19, 19, 1, -19 },
  { 4322, 16, 19, 16, 2, -19 },
  { 4360, 25, 19, 25, 2, -19 },
  { 4420, 21, 19, 17, -2, -19 },
  { 4470, 22, 27, 17, -3, -19 },
  { 4545, 16, 19, 15, -1, -19 },
  { 4583, 15, 31, 12, 0, -25 },
  { 4642, 4, 35, 17, 6, -27 },
  { 4660, 14, 31, 12, -2, -25 },
  { 4715, 16, 6, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC35PT7B_H_
