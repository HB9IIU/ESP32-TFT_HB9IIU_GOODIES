#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB4, 0x1A, 0x16, 0x7F, 0x7F,
  0x2C, 0xFE, 0x68, 0x48, 0x58, 0x08, 0x3C, 0xF3, 0x87, 0x07, 0x87, 0x4E,
  0xF8, 0x40, 0x80, 0x73, 0x79, 0x2D, 0x17, 0xEE, 0xF8, 0xA4, 0xD6, 0x4A,
  0x47, 0x00, 0x1C, 0x36, 0x34, 0x3C, 0x7B, 0x7B, 0xCE, 0xEE, 0x7F, 0x7C,
  0x19, 0x88, 0xC4, 0x23, 0x18, 0xC2, 0x18, 0x30, 0xC6, 0x31, 0x8C, 0x46,
  0x23, 0x30, 0x12, 0x4F, 0xCF, 0xD1, 0x60, 0x20, 0x82, 0x3F, 0x20, 0x82,
  0x00, 0x2D, 0x60, 0xF0, 0xF0, 0x06, 0x08, 0x30, 0xC1, 0x86, 0x0C, 0x30,
  0xC0, 0x3C, 0xC9, 0x9B, 0x2C, 0xD9, 0xB3, 0x7C, 0x70, 0x3B, 0xF4, 0x63,
  0x18, 0xC4, 0x60, 0x3C, 0xDC, 0x10, 0x61, 0x86, 0x18, 0x7E, 0xF8, 0x7C,
  0x4C, 0x10, 0xE3, 0x81, 0x83, 0x4E, 0xF8, 0x0E, 0x38, 0x71, 0x66, 0xD9,
  0x3F, 0x0C, 0x18, 0x3E, 0x41, 0x83, 0xC7, 0xC1, 0x83, 0x4C, 0xF8, 0x1E,
  0x61, 0x83, 0xE6, 0xD9, 0xB3, 0x3E, 0x78, 0x7E, 0x0C, 0x30, 0x61, 0x86,
  0x0C, 0x30, 0xE0, 0x3C, 0xCD, 0x99, 0xE3, 0x8D, 0xB3, 0x66, 0x78, 0x3D,
  0xB6, 0x5B, 0x7C, 0xF0, 0xEE, 0xF0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06,
  0x64, 0xC0, 0x04, 0x76, 0x30, 0x70, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0x83,
  0x83, 0x87, 0x73, 0x08, 0x00, 0xFC, 0xC6, 0x66, 0x60, 0x18, 0xC0, 0x1F,
  0x8C, 0x36, 0x75, 0x2D, 0x52, 0x54, 0xBD, 0x79, 0x2C, 0x61, 0x0F, 0x80,
  0x0E, 0x0A, 0x1A, 0x1A, 0x32, 0x3E, 0x7E, 0x63, 0xC3, 0x3E, 0x6C, 0x9B,
  0xF7, 0xCC, 0xD9, 0xBE, 0xF8, 0x3E, 0xCB, 0x06, 0x0C, 0x18, 0x30, 0x7C,
  0x78, 0x3E, 0x36, 0x23, 0x63, 0x63, 0x66, 0x66, 0x7C, 0xF8, 0x3E, 0x60,
  0x83, 0xE7, 0xCC, 0x18, 0x3C, 0xF8, 0x3E, 0x60, 0x83, 0x07, 0xCC, 0x18,
  0x20, 0xC0, 0x3E, 0xC7, 0x06, 0x0D, 0xF9, 0xB3, 0x7E, 0x7C, 0x33, 0x99,
  0x88, 0xCF, 0xE7, 0xE3, 0x31, 0x98, 0x8C, 0xC6, 0x00, 0x79, 0x8C, 0x62,
  0x31, 0x8C, 0xF0, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xCF, 0x30,
  0x33, 0x36, 0x2C, 0x78, 0x78, 0x78, 0x6C, 0x4C, 0xCE, 0x31, 0x88, 0xC6,
  0x31, 0x8F, 0xF8, 0x38, 0xE7, 0x38, 0xE5, 0x3D, 0xE7, 0xAC, 0xFD, 0x97,
  0x22, 0x6C, 0xC9, 0x80, 0x31, 0x9C, 0xCE, 0x6D, 0x26, 0xF3, 0x79, 0x3C,
  0x8C, 0xC6, 0x00, 0x3E, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0x3E,
  0x6C, 0x8B, 0x37, 0xEF, 0x18, 0x20, 0xC0, 0x3E, 0xCF, 0x1E, 0x3C, 0x78,
  0xF3, 0xFE, 0x78, 0x30, 0x70, 0x3E, 0x6C, 0x9B, 0x37, 0xCD, 0x1B, 0x26,
  0xCE, 0x3E, 0xC9, 0x83, 0x83, 0x83, 0x03, 0x7C, 0xF0, 0xFC, 0xC3, 0x08,
  0x61, 0x86, 0x18, 0xC0, 0x66, 0xCD, 0x1E, 0x3C, 0xD9, 0xB3, 0x7E, 0xF8,
  0xC7, 0x9B, 0x36, 0x4D, 0x8A, 0x1C, 0x30, 0x60, 0xCC, 0x79, 0x9B, 0x33,
  0x6E, 0x4D, 0x59, 0xEA, 0x39, 0xC7, 0x38, 0xC6, 0x00, 0x39, 0x8D, 0x87,
  0x83, 0x81, 0xC0, 0xE0, 0xD8, 0xCC, 0xE6, 0x00, 0xCE, 0x99, 0xE3, 0x87,
  0x0C, 0x18, 0x30, 0x60, 0x7E, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x7E, 0xF8,
  0x39, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x38, 0xC9, 0x26, 0xD9, 0x20, 0x38,
  0xC6, 0x31, 0x08, 0xC6, 0x31, 0x38, 0x18, 0x63, 0xDB, 0x47, 0x10, 0xF8,
  0xCC, 0x3E, 0xDD, 0x92, 0x6C, 0xCF, 0x9F, 0x00, 0x30, 0x60, 0x83, 0xE6,
  0x6C, 0xD9, 0xA6, 0xED, 0xF0, 0x3D, 0x96, 0x10, 0xC1, 0xA7, 0x80, 0x03,
  0x06, 0x06, 0x3E, 0x6E, 0x64, 0x44, 0xCC, 0x6C, 0x7C, 0x3D, 0x96, 0xDE,
  0xC1, 0xA7, 0x80, 0x0E, 0x38, 0x61, 0xE1, 0x06, 0x0C, 0x18, 0x30, 0xC1,
  0x87, 0x0C, 0x00, 0x3E, 0xDD, 0x92, 0x6C, 0xDF, 0x9F, 0x04, 0x99, 0xE0,
  0x30, 0x60, 0xC3, 0xE7, 0x6C, 0xD9, 0x26, 0xCD, 0x98, 0x33, 0x06, 0x66,
  0x64, 0xCC, 0x0C, 0x30, 0x02, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x3C, 0xE0,
  0x30, 0x60, 0x83, 0x36, 0xCF, 0x1E, 0x3C, 0xC9, 0x98, 0x33, 0x36, 0x66,
  0x64, 0xCC, 0x7D, 0xDD, 0xB6, 0x6D, 0xB3, 0x4C, 0xF3, 0x2C, 0xD8, 0x7C,
  0xED, 0x9B, 0x24, 0xD9, 0xB3, 0x00, 0x3D, 0xB6, 0x51, 0xCD, 0xB7, 0x80,
  0x3E, 0x33, 0x33, 0x33, 0x26, 0x76, 0x7C, 0x60, 0x60, 0xC0, 0x3E, 0xDD,
  0x92, 0x2C, 0xDD, 0x9F, 0x04, 0x18, 0x30, 0x7D, 0xE6, 0x18, 0x43, 0x0C,
  0x00, 0x7D, 0xA6, 0x0C, 0x1A, 0x6F, 0x00, 0x26, 0xFC, 0xCC, 0xCE, 0xE0,
  0xCF, 0x3C, 0xB6, 0x9B, 0xEF, 0x80, 0x8F, 0x6D, 0xBC, 0xF3, 0x8C, 0x00,
  0xD9, 0xCC, 0xAE, 0xD5, 0x4A, 0xE7, 0x73, 0x30, 0x37, 0x36, 0x1C, 0x18,
  0x3C, 0x6C, 0xEE, 0x33, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0x70,
  0xE0, 0x7C, 0x63, 0x0C, 0x63, 0x2F, 0x00, 0x19, 0x8C, 0x66, 0x61, 0x8C,
  0x63, 0x18, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xC6, 0x21, 0x8C, 0xC6, 0x23,
  0x30, 0xC7, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 3, 6, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 9, 9, 10, 1, -9 },
  { 38, 8, 9, 8, 0, -9 },
  { 47, 2, 3, 3, 1, -9 },
  { 48, 5, 11, 4, 0, -9 },
  { 55, 5, 11, 4, -1, -9 },
  { 62, 6, 6, 6, 1, -10 },
  { 67, 6, 7, 7, 1, -8 },
  { 73, 3, 4, 3, -1, -2 },
  { 75, 4, 1, 4, 0, -4 },
  { 76, 2, 2, 3, 0, -2 },
  { 77, 7, 9, 5, -1, -9 },
  { 85, 7, 9, 7, 0, -9 },
  { 93, 5, 9, 7, 1, -9 },
  { 99, 7, 9, 7, 0, -9 },
  { 107, 7, 9, 7, 0, -9 },
  { 115, 7, 9, 7, 0, -9 },
  { 123, 7, 9, 7, 0, -9 },
  { 131, 7, 9, 7, 0, -9 },
  { 139, 7, 9, 7, 0, -9 },
  { 147, 7, 9, 7, 0, -9 },
  { 155, 6, 9, 7, 0, -9 },
  { 162, 3, 7, 4, 0, -7 },
  { 165, 4, 9, 4, -1, -7 },
  { 170, 6, 7, 7, 1, -8 },
  { 176, 6, 4, 7, 1, -7 },
  { 179, 6, 7, 7, 1, -8 },
  { 185, 5, 9, 5, 1, -9 },
  { 191, 10, 10, 10, 0, -9 },
  { 204, 8, 9, 7, -1, -9 },
  { 213, 7, 9, 7, 0, -9 },
  { 221, 7, 9, 7, 1, -9 },
  { 229, 8, 9, 8, 0, -9 },
  { 238, 7, 9, 6, 0, -9 },
  { 246, 7, 9, 6, 0, -9 },
  { 254, 7, 9, 8, 1, -9 },
  { 262, 9, 9, 8, 0, -9 },
  { 273, 5, 9, 5, 0, -9 },
  { 279, 6, 12, 4, -2, -9 },
  { 288, 8, 9, 7, 0, -9 },
  { 297, 5, 9, 6, 0, -9 },
  { 303, 11, 9, 11, 0, -9 },
  { 316, 9, 9, 9, 0, -9 },
  { 327, 7, 9, 9, 1, -9 },
  { 335, 7, 9, 7, 0, -9 },
  { 343, 7, 11, 9, 1, -9 },
  { 353, 7, 9, 7, 0, -9 },
  { 361, 7, 9, 6, 0, -9 },
  { 369, 6, 9, 6, 1, -9 },
  { 376, 7, 9, 8, 1, -9 },
  { 384, 7, 9, 7, 1, -9 },
  { 392, 11, 9, 11, 1, -9 },
  { 405, 9, 9, 7, -1, -9 },
  { 416, 7, 9, 7, 1, -9 },
  { 424, 7, 9, 6, 0, -9 },
  { 432, 5, 11, 4, 0, -9 },
  { 439, 3, 9, 5, 1, -9 },
  { 443, 5, 11, 4, -1, -9 },
  { 450, 6, 6, 7, 0, -9 },
  { 455, 5, 1, 5, -1, 1 },
  { 456, 3, 2, 4, 2, -10 },
  { 457, 7, 7, 7, 0, -7 },
  { 464, 7, 10, 7, 0, -10 },
  { 473, 6, 7, 6, 0, -7 },
  { 479, 8, 10, 7, 0, -10 },
  { 489, 6, 7, 7, 0, -7 },
  { 495, 7, 13, 4, -1, -10 },
  { 507, 7, 10, 7, 0, -7 },
  { 516, 7, 10, 7, 0, -10 },
  { 525, 4, 10, 4, 0, -10 },
  { 530, 6, 13, 4, -2, -10 },
  { 540, 7, 10, 7, 0, -10 },
  { 549, 4, 10, 4, 0, -10 },
  { 554, 10, 7, 11, 0, -7 },
  { 563, 7, 7, 7, 0, -7 },
  { 570, 6, 7, 7, 0, -7 },
  { 576, 8, 10, 7, -1, -7 },
  { 586, 7, 10, 7, 0, -7 },
  { 595, 6, 7, 5, 0, -7 },
  { 601, 6, 7, 6, 0, -7 },
  { 607, 4, 9, 5, 1, -9 },
  { 612, 6, 7, 7, 1, -7 },
  { 618, 6, 7, 6, 1, -7 },
  { 624, 9, 7, 9, 1, -7 },
  { 632, 8, 7, 6, -1, -7 },
  { 639, 8, 10, 6, -1, -7 },
  { 649, 6, 7, 5, 0, -7 },
  { 655, 5, 11, 5, 0, -9 },
  { 662, 2, 13, 6, 2, -10 },
  { 666, 5, 11, 5, -1, -9 },
  { 673, 6, 3, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC13PT7B_H_
