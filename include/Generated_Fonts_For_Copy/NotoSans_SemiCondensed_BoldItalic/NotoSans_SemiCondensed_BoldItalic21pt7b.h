#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x31, 0xC0, 0x00, 0x73, 0xCE,
  0x00, 0x77, 0x66, 0xEE, 0xEE, 0xCC, 0x07, 0x70, 0x33, 0x01, 0x98, 0x0C,
  0xC3, 0xFF, 0x9F, 0xF8, 0x33, 0x03, 0x30, 0x19, 0x87, 0xFF, 0x3F, 0xF8,
  0x66, 0x03, 0x30, 0x19, 0x81, 0x98, 0x00, 0x01, 0x00, 0x20, 0x3F, 0x8F,
  0xE3, 0xA4, 0x74, 0x0E, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x17, 0x42, 0xEE,
  0xF9, 0xFF, 0x1F, 0xC0, 0x40, 0x18, 0x00, 0x3C, 0x1C, 0xFC, 0x71, 0x98,
  0xC3, 0x33, 0x0E, 0xEE, 0x19, 0xD8, 0x33, 0x6F, 0x7F, 0xDF, 0x7B, 0x66,
  0x0C, 0xCC, 0x3B, 0x98, 0x67, 0x71, 0x8E, 0xC7, 0x0F, 0x9C, 0x1E, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0x38, 0x39, 0xC1, 0xDC, 0x0F, 0xE0, 0x3E, 0x03,
  0xC7, 0x3F, 0x3B, 0x9F, 0x9C, 0xF9, 0xC3, 0xC7, 0x3E, 0x3F, 0xF0, 0xFB,
  0xC0, 0x76, 0xEE, 0xC0, 0x0E, 0x38, 0x61, 0xC7, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC0, 0x0E, 0x06, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0xF0, 0x0C, 0x06, 0x33, 0x1F, 0xB7, 0xF9, 0xFD, 0xF1, 0xDC, 0x26,
  0x02, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x39, 0x9C, 0xEE, 0x60, 0x7D, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x1F, 0x0F,
  0xE3, 0xB9, 0xC7, 0x71, 0xF8, 0x7E, 0x3B, 0x8E, 0xE3, 0xB8, 0xEC, 0x7B,
  0x9C, 0xEF, 0x3F, 0x87, 0xC0, 0x07, 0x1E, 0x3E, 0xFE, 0xEE, 0x4E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x07, 0xC1, 0xFE, 0x1C,
  0xE0, 0x8F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0xFF, 0xC0, 0x1F, 0x87, 0xF8, 0x67, 0x80,
  0x70, 0x1C, 0x03, 0x87, 0xE0, 0xF8, 0x07, 0x80, 0x70, 0x07, 0x01, 0xCC,
  0x79, 0xFE, 0x3F, 0x80, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xFC, 0x3B,
  0x06, 0xE1, 0x9C, 0x73, 0x9C, 0x73, 0xFF, 0x7F, 0xE0, 0x70, 0x0E, 0x01,
  0x80, 0x0F, 0xE3, 0xF8, 0x7F, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xE1, 0xFC,
  0x03, 0xC0, 0x38, 0x0E, 0x01, 0xCC, 0x79, 0xFE, 0x3F, 0x80, 0x07, 0xC7,
  0xF3, 0xC4, 0xE0, 0x70, 0x19, 0x8F, 0xF3, 0xFE, 0xE3, 0xB8, 0xEE, 0x3B,
  0x9E, 0xE7, 0x3F, 0x87, 0xC0, 0x7F, 0xEF, 0xF9, 0xFF, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0xC3, 0xF8, 0xF3, 0x9C, 0x73, 0x8E, 0x3B, 0x87, 0xE0,
  0xF8, 0x3B, 0x8E, 0x73, 0x87, 0x70, 0xEF, 0x38, 0xFF, 0x0F, 0xC0, 0x1F,
  0x1F, 0xDC, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0x7F, 0x9D, 0xC1, 0xC0,
  0xE9, 0xE7, 0xE3, 0xE0, 0x19, 0xCE, 0x70, 0x00, 0x00, 0x03, 0xBD, 0xC0,
  0x0C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x1C, 0x63, 0x8C, 0x00,
  0x00, 0x40, 0x70, 0x7C, 0x7C, 0x78, 0x38, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xF8, 0xF8, 0xF8, 0x38, 0x08,
  0x00, 0x3E, 0x7F, 0x67, 0x03, 0x07, 0x0F, 0x1E, 0x38, 0x30, 0x70, 0x00,
  0x00, 0x60, 0xF0, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x31, 0xC0, 0x37,
  0x3F, 0x6C, 0xFC, 0xFB, 0x99, 0xE6, 0x33, 0xCC, 0xE7, 0x99, 0x9B, 0x33,
  0x36, 0x7B, 0xCC, 0x67, 0x1C, 0x00, 0x1C, 0x08, 0x1F, 0xF0, 0x0F, 0x80,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE1, 0xC6,
  0x1C, 0x63, 0xFE, 0x3F, 0xE7, 0x06, 0x70, 0x7F, 0x07, 0xE0, 0x70, 0x1F,
  0xC1, 0xFE, 0x1C, 0xF1, 0xC7, 0x18, 0x73, 0x8E, 0x3F, 0xC3, 0xF8, 0x39,
  0xC7, 0x0E, 0x70, 0xE7, 0x1E, 0x73, 0xC7, 0xF8, 0xFF, 0x00, 0x07, 0xF1,
  0xFE, 0x3E, 0x63, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x79, 0x87, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFF,
  0x07, 0xFC, 0x38, 0xE1, 0xC7, 0x1C, 0x3C, 0xE1, 0xC7, 0x0E, 0x38, 0x73,
  0xC3, 0x9C, 0x38, 0xE3, 0xC7, 0xFC, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x70, 0x0F, 0xF1, 0xFC, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0xF0, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E,
  0x01, 0xC0, 0x70, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0xF1, 0xFF, 0x3E, 0x63, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xEF, 0x1C, 0x79, 0xC7,
  0xFC, 0x3F, 0x80, 0x1E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xE0, 0xE3, 0xFF, 0x0F, 0xFC, 0x38, 0x71, 0xE1, 0xC7, 0x0F, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x00, 0x1F, 0xC7, 0xF0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x1F, 0x8F,
  0xE0, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x3F, 0x0F,
  0x80, 0x1C, 0x3C, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x19, 0xC0, 0xEE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0xC1,
  0xC7, 0x0E, 0x1E, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x7F, 0x7F, 0xFF, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF1, 0xF8, 0xD8, 0xFC, 0xFC, 0x7E, 0x6E,
  0x33, 0x77, 0x19, 0xB3, 0x1C, 0xFB, 0x8E, 0x79, 0xC7, 0x3C, 0xE3, 0x1C,
  0x73, 0x8E, 0x70, 0x1E, 0x0E, 0x3C, 0x18, 0x7C, 0x70, 0xF8, 0xE1, 0xF1,
  0xC7, 0x63, 0x8E, 0xE6, 0x1D, 0xDC, 0x33, 0xB8, 0xE3, 0x71, 0xC7, 0xC3,
  0x8F, 0x87, 0x0F, 0x0C, 0x1E, 0x38, 0x3C, 0x00, 0x07, 0xC1, 0xFE, 0x3E,
  0xF3, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xEF, 0x1E, 0x7B, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1,
  0xC7, 0x1C, 0x73, 0x87, 0x38, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x3E, 0xF3, 0x87,
  0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x1E,
  0x7B, 0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1F,
  0xC1, 0xFE, 0x1D, 0xE1, 0xCF, 0x1C, 0xE3, 0x8E, 0x39, 0xE3, 0xFC, 0x3F,
  0x83, 0x38, 0x73, 0x87, 0x38, 0x71, 0xC7, 0x1C, 0xE1, 0xE0, 0x0F, 0xE3,
  0xF8, 0xF3, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0E, 0x41, 0xCE, 0xF9, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xEF, 0xF8, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x00, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x8F, 0x3C, 0x3F,
  0xC0, 0xFC, 0x00, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x39,
  0xC7, 0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0xF1, 0xDC, 0x78, 0xEE, 0x7C, 0xE7, 0x3E,
  0x73, 0xBF, 0x31, 0xDF, 0xB8, 0xED, 0xDC, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F,
  0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x38, 0xE0,
  0xE7, 0x03, 0xBC, 0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3F, 0x01, 0xDC, 0x0E, 0x70, 0x39, 0xC1, 0xC3, 0x8E, 0x0E, 0x00, 0xE1,
  0xFC, 0x3B, 0x8E, 0x3B, 0x87, 0x70, 0xFC, 0x1F, 0x83, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x7F, 0xC7, 0xFC, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x7C, 0x7C, 0x00, 0xE7, 0x18, 0xC6, 0x39, 0xCE, 0x71, 0x8C, 0x63,
  0x9C, 0xE0, 0x1F, 0x1F, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0xF8, 0xF0, 0x03, 0x01, 0xC0, 0x70,
  0x3E, 0x1D, 0x86, 0x63, 0x1D, 0xC3, 0xE0, 0xC0, 0xFF, 0xE7, 0x30, 0x0C,
  0x0F, 0xB7, 0xFD, 0xCF, 0xF3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0xB9, 0xCF,
  0xB1, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x98, 0x77, 0x8F, 0xF9,
  0xC7, 0x38, 0xE6, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE7, 0x3F, 0xE7, 0x78,
  0x0E, 0x1F, 0xDF, 0xCE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0x3F,
  0x8F, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0xDC, 0x7F, 0x9F, 0xF3,
  0x9E, 0xE3, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCE, 0x3F, 0xC3, 0xD8,
  0x0E, 0x1F, 0xDE, 0xEE, 0x3E, 0x3F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0xBF,
  0xCF, 0xC0, 0x01, 0xE0, 0x7C, 0x0E, 0x83, 0x80, 0x70, 0x3F, 0x87, 0xF0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x03, 0xE0, 0x78, 0x0E, 0x00, 0x06, 0x03, 0xEC, 0xFF, 0x9C,
  0xF7, 0x9C, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0xCE, 0x71, 0xFE, 0x1D, 0xC0,
  0x38, 0x0E, 0x33, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x98, 0x77, 0x8F, 0xF9, 0xC7, 0x38, 0xE7, 0x39, 0xC7, 0x38, 0xE7,
  0x1C, 0xE3, 0x98, 0xE7, 0x1C, 0x0C, 0x71, 0xC0, 0x04, 0xE3, 0x8E, 0x38,
  0xE7, 0x1C, 0x71, 0xCE, 0x38, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x08, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x2F, 0x1F, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x13, 0x8E, 0x39, 0xC3, 0xB8, 0x3F, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x77,
  0x07, 0x38, 0x63, 0x8E, 0x3C, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0x01, 0x86, 0x3F, 0xDF, 0x3F,
  0xFF, 0x38, 0xE7, 0x38, 0xE7, 0x39, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71,
  0xC6, 0x71, 0x8E, 0x63, 0x8E, 0xE3, 0x8E, 0x01, 0x87, 0x78, 0xFF, 0x9C,
  0x73, 0x8E, 0x71, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0x8E, 0x71, 0xC0,
  0x0E, 0x1F, 0x9F, 0xEE, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xBF,
  0xCF, 0x80, 0x00, 0xC1, 0xFE, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0x87, 0x38,
  0x63, 0x8E, 0x38, 0xE3, 0x9C, 0x3F, 0xC7, 0x78, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x0F, 0xB7, 0xFD, 0xCF, 0xE3, 0xB8, 0xEE,
  0x3B, 0x8E, 0xE3, 0xB9, 0xCF, 0xF1, 0xDC, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x00, 0x01, 0x9D, 0xCF, 0xC7, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x00, 0x0E, 0x1F, 0xCF, 0xCE, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x47, 0xBF, 0x9F, 0x80, 0x18, 0x30, 0xE7, 0xFF, 0xEE, 0x1C,
  0x38, 0x61, 0xC3, 0x87, 0x2F, 0x8F, 0x00, 0x71, 0xDC, 0x77, 0x1D, 0xC7,
  0xE3, 0xB8, 0xEE, 0x3B, 0x9E, 0xE7, 0x3F, 0xC7, 0xB0, 0xE1, 0xF8, 0xEE,
  0x3B, 0x9C, 0x67, 0x1B, 0x86, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x00, 0xE3,
  0x8F, 0xCF, 0x1B, 0x9E, 0x77, 0x7C, 0xEE, 0xDB, 0x9D, 0xB7, 0x3F, 0x6C,
  0x7C, 0xF8, 0xF9, 0xE0, 0xE3, 0xC1, 0xC7, 0x00, 0x1C, 0xF1, 0xCE, 0x0D,
  0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3B, 0x87, 0x38, 0xF1,
  0xC0, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x19, 0xC0, 0xCE, 0x06, 0xE0, 0x37,
  0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x5E, 0x01,
  0xE0, 0x1E, 0x00, 0x1F, 0xC7, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0xE0, 0x78, 0x1F, 0xCF, 0xF0, 0x07, 0x87, 0x83, 0x81, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0xF8, 0x78, 0x1C, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x78,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0E, 0x0F, 0x0F, 0x1E, 0x18, 0x38, 0x38, 0x38, 0x30,
  0xF0, 0xE0, 0x78, 0x7F, 0xF8, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 6, 0, -15 },
  { 13, 8, 5, 9, 2, -15 },
  { 18, 13, 15, 12, 0, -15 },
  { 43, 11, 17, 11, 0, -16 },
  { 67, 15, 15, 17, 1, -15 },
  { 96, 13, 15, 13, 0, -15 },
  { 121, 4, 5, 5, 2, -15 },
  { 124, 7, 18, 7, 1, -15 },
  { 140, 8, 18, 7, -2, -15 },
  { 158, 9, 10, 10, 2, -16 },
  { 170, 10, 11, 11, 1, -13 },
  { 184, 5, 6, 6, -1, -3 },
  { 188, 6, 3, 7, 0, -7 },
  { 191, 4, 3, 6, 0, -3 },
  { 193, 11, 15, 9, -1, -15 },
  { 214, 10, 15, 11, 1, -15 },
  { 233, 8, 15, 11, 2, -15 },
  { 248, 12, 15, 11, -1, -15 },
  { 271, 11, 15, 11, 0, -15 },
  { 292, 11, 15, 11, 0, -15 },
  { 313, 11, 15, 11, 0, -15 },
  { 334, 10, 15, 11, 1, -15 },
  { 353, 11, 15, 11, 1, -15 },
  { 374, 11, 15, 11, 0, -15 },
  { 395, 9, 15, 11, 1, -15 },
  { 412, 5, 12, 6, 0, -12 },
  { 420, 6, 15, 6, -1, -12 },
  { 432, 10, 11, 11, 1, -13 },
  { 446, 10, 7, 11, 1, -11 },
  { 455, 10, 11, 11, 1, -13 },
  { 469, 8, 15, 9, 1, -15 },
  { 484, 15, 17, 16, 1, -15 },
  { 516, 12, 15, 12, -1, -15 },
  { 539, 12, 15, 12, 0, -15 },
  { 562, 12, 15, 12, 1, -15 },
  { 585, 13, 15, 13, 0, -15 },
  { 610, 11, 15, 10, 0, -15 },
  { 631, 11, 15, 10, 0, -15 },
  { 652, 12, 15, 13, 1, -15 },
  { 675, 14, 15, 13, 0, -15 },
  { 702, 10, 15, 8, -1, -15 },
  { 721, 10, 19, 6, -3, -15 },
  { 745, 14, 15, 12, 0, -15 },
  { 772, 8, 15, 10, 0, -15 },
  { 787, 17, 15, 17, 0, -15 },
  { 819, 15, 15, 14, 0, -15 },
  { 848, 12, 15, 14, 1, -15 },
  { 871, 12, 15, 12, 0, -15 },
  { 894, 12, 19, 14, 1, -15 },
  { 923, 12, 15, 12, 0, -15 },
  { 946, 11, 15, 10, 0, -15 },
  { 967, 10, 15, 10, 2, -15 },
  { 986, 13, 15, 13, 1, -15 },
  { 1011, 11, 15, 11, 2, -15 },
  { 1032, 17, 15, 17, 2, -15 },
  { 1064, 14, 15, 11, -1, -15 },
  { 1091, 11, 15, 11, 2, -15 },
  { 1112, 12, 15, 10, -1, -15 },
  { 1135, 9, 18, 7, -1, -15 },
  { 1156, 5, 15, 9, 2, -15 },
  { 1166, 8, 18, 7, -1, -15 },
  { 1184, 10, 9, 11, 0, -15 },
  { 1196, 8, 1, 8, -2, 2 },
  { 1197, 4, 3, 7, 3, -16 },
  { 1199, 10, 12, 11, 1, -12 },
  { 1214, 11, 16, 11, 0, -16 },
  { 1236, 9, 12, 9, 1, -12 },
  { 1250, 11, 16, 11, 1, -16 },
  { 1272, 9, 12, 11, 1, -12 },
  { 1286, 11, 21, 7, -2, -16 },
  { 1315, 11, 17, 11, 0, -12 },
  { 1339, 11, 16, 12, 0, -16 },
  { 1361, 6, 16, 6, 0, -16 },
  { 1373, 9, 21, 6, -3, -16 },
  { 1397, 12, 16, 11, 0, -16 },
  { 1421, 7, 16, 6, 0, -16 },
  { 1435, 16, 12, 17, 0, -12 },
  { 1459, 11, 12, 12, 0, -12 },
  { 1476, 9, 12, 11, 1, -12 },
  { 1490, 12, 17, 11, -1, -12 },
  { 1516, 10, 17, 11, 1, -12 },
  { 1538, 9, 12, 8, 0, -12 },
  { 1552, 9, 12, 9, 0, -12 },
  { 1566, 7, 14, 8, 1, -14 },
  { 1579, 10, 11, 12, 1, -11 },
  { 1593, 10, 11, 10, 1, -11 },
  { 1607, 15, 11, 15, 1, -11 },
  { 1628, 12, 11, 10, -1, -11 },
  { 1645, 13, 16, 10, -2, -11 },
  { 1671, 10, 11, 9, -1, -11 },
  { 1685, 9, 18, 7, 0, -15 },
  { 1706, 2, 21, 10, 4, -16 },
  { 1712, 8, 18, 7, -1, -15 },
  { 1730, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC21PT7B_H_
