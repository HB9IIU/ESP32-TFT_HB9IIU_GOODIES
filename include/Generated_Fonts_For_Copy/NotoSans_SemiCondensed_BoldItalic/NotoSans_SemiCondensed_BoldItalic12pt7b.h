#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB5, 0x60, 0x16, 0x28, 0x53,
  0xF2, 0x9F, 0xBF, 0x2C, 0x50, 0x08, 0xF7, 0x5C, 0x38, 0x7A, 0xFE, 0x20,
  0x80, 0x62, 0xE6, 0xB4, 0xA8, 0xFF, 0xD5, 0x2D, 0x6F, 0xC6, 0x18, 0x3C,
  0x24, 0x3C, 0x33, 0x7E, 0xCE, 0xCC, 0x7E, 0x7E, 0x19, 0x88, 0xC4, 0x23,
  0x18, 0xC2, 0x10, 0x31, 0x11, 0x11, 0x13, 0x26, 0xC0, 0x37, 0x1E, 0xED,
  0x00, 0x21, 0x3E, 0x42, 0x10, 0x6B, 0x00, 0xFC, 0xF0, 0x06, 0x08, 0x30,
  0xC1, 0x86, 0x08, 0x30, 0xC0, 0x18, 0xF6, 0xDB, 0x4F, 0x3C, 0xB6, 0x70,
  0x19, 0xB5, 0x63, 0x10, 0x8C, 0x60, 0x19, 0xF4, 0xC3, 0x18, 0xC6, 0x30,
  0xF8, 0x19, 0xF0, 0xC3, 0x30, 0x60, 0xA6, 0xF0, 0x0C, 0x31, 0xCA, 0x6B,
  0x6F, 0xC6, 0x10, 0x3C, 0xF2, 0x18, 0x78, 0x20, 0xA6, 0xF0, 0x0C, 0xF6,
  0x1C, 0x7F, 0x3C, 0xD6, 0x70, 0x7E, 0xF8, 0x30, 0x41, 0x86, 0x0C, 0x30,
  0xE0, 0x18, 0xF6, 0x5B, 0x31, 0xEC, 0xF2, 0x78, 0x19, 0xF6, 0xD3, 0x6D,
  0xF0, 0xA6, 0xF0, 0x2C, 0x01, 0xB0, 0x13, 0x00, 0x00, 0x64, 0xC0, 0x1B,
  0xB1, 0xC3, 0x84, 0xF8, 0x3F, 0xF0, 0x83, 0x06, 0xEC, 0x40, 0x6F, 0x13,
  0x6C, 0x0C, 0xC0, 0x06, 0x0D, 0xC8, 0x29, 0xD5, 0x2E, 0xB7, 0x56, 0xB6,
  0x60, 0x1F, 0x00, 0x0E, 0x1C, 0x78, 0xF3, 0x67, 0xDF, 0xB3, 0xC6, 0x38,
  0x7C, 0x9B, 0x27, 0x8D, 0x93, 0x26, 0xF8, 0x19, 0xFE, 0x30, 0xC2, 0x08,
  0x32, 0x78, 0x38, 0x7C, 0x9B, 0x36, 0x6C, 0xD1, 0xAE, 0xF8, 0x3C, 0xF2,
  0x18, 0x79, 0x84, 0x10, 0xF8, 0x3C, 0xF2, 0x18, 0x79, 0xE4, 0x10, 0xC0,
  0x1E, 0xFB, 0x86, 0x0D, 0xD3, 0xA3, 0x64, 0x78, 0x33, 0x33, 0x22, 0x66,
  0x7E, 0x66, 0x46, 0x44, 0xCC, 0x7B, 0xCC, 0x42, 0x31, 0x8C, 0xE0, 0x0C,
  0x30, 0x86, 0x18, 0x61, 0x84, 0x30, 0xCE, 0x10, 0x33, 0x26, 0x2C, 0x78,
  0x78, 0x78, 0x58, 0x4C, 0xCC, 0x31, 0x08, 0xC6, 0x31, 0x08, 0xF8, 0x30,
  0xCC, 0x73, 0x19, 0xCA, 0x73, 0x95, 0xE5, 0xD9, 0x74, 0xD9, 0x00, 0x31,
  0x31, 0x33, 0x7B, 0x7B, 0x4A, 0x4E, 0x4E, 0xC6, 0x18, 0xFB, 0x1E, 0x3C,
  0x70, 0xA3, 0x6C, 0x78, 0x38, 0x7C, 0x9B, 0x37, 0xCF, 0x10, 0x20, 0xC0,
  0x18, 0xFB, 0x1E, 0x3C, 0x70, 0xA3, 0x6C, 0x70, 0x30, 0x60, 0x38, 0x78,
  0x9B, 0x27, 0xCF, 0x16, 0x26, 0xCC, 0x18, 0xF6, 0x18, 0x30, 0x61, 0xA6,
  0xF0, 0xFF, 0xE2, 0x18, 0x61, 0x86, 0x10, 0xC0, 0x66, 0x8F, 0x16, 0x6C,
  0xD9, 0xA2, 0x6C, 0xF0, 0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x3C, 0x30, 0x60,
  0xCC, 0xF3, 0x3D, 0xDB, 0x76, 0xDD, 0x3F, 0xCE, 0xE3, 0xB8, 0xCE, 0x00,
  0x31, 0x13, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x64, 0xE6, 0xCF, 0x35, 0x94,
  0x71, 0x86, 0x18, 0x40, 0x7D, 0xF0, 0xC6, 0x31, 0x86, 0x30, 0xF8, 0x39,
  0x98, 0xC6, 0x21, 0x18, 0xC5, 0x30, 0xD9, 0x24, 0x9B, 0x60, 0x39, 0xC6,
  0x21, 0x08, 0xC6, 0x21, 0x38, 0x10, 0x63, 0x8A, 0x4F, 0x10, 0xF8, 0xD0,
  0x35, 0xF6, 0xD3, 0xCF, 0x66, 0x80, 0x30, 0x86, 0x9F, 0x6D, 0x34, 0xF2,
  0xF8, 0x1D, 0xE6, 0x10, 0xC1, 0x27, 0x00, 0x06, 0x0C, 0xD3, 0xE6, 0xC9,
  0xB3, 0x6C, 0x78, 0x19, 0xF6, 0xDE, 0xC1, 0x27, 0x80, 0x1C, 0x61, 0xCE,
  0x30, 0xC3, 0x08, 0x61, 0x8E, 0x30, 0x35, 0xF6, 0xD3, 0xCF, 0x66, 0x86,
  0xBB, 0xC0, 0x30, 0x86, 0x9F, 0x6D, 0xB4, 0xF2, 0xD8, 0x32, 0x66, 0x66,
  0x4C, 0xC0, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xCE, 0x38, 0x30,
  0x41, 0x9B, 0x67, 0x8E, 0x1E, 0x6C, 0xCC, 0x32, 0x66, 0x66, 0x4C, 0xC0,
  0x69, 0xBF, 0xDB, 0x2D, 0xB4, 0xDE, 0x4F, 0x64, 0x69, 0xF6, 0xDB, 0x4F,
  0x2C, 0x80, 0x19, 0xF6, 0xD3, 0xCD, 0x67, 0x80, 0x34, 0x7C, 0xD9, 0x32,
  0x6D, 0x9F, 0x30, 0x41, 0x80, 0x15, 0xF6, 0xD3, 0xCF, 0x66, 0x86, 0x18,
  0x60, 0x6B, 0xD8, 0xC4, 0x63, 0x00, 0x33, 0xD8, 0xE3, 0x4B, 0xC0, 0x67,
  0xEC, 0xC8, 0x8E, 0x65, 0x96, 0xD3, 0x4F, 0x66, 0x80, 0x8C, 0xE5, 0x6A,
  0x73, 0x00, 0x99, 0x9B, 0xAA, 0xAE, 0xEC, 0xCC, 0xCC, 0x36, 0x6C, 0x70,
  0xC3, 0x85, 0xBB, 0x00, 0x22, 0x4C, 0x91, 0x63, 0x87, 0x0C, 0x18, 0xE1,
  0x80, 0x7B, 0xC4, 0x66, 0x63, 0xC0, 0x09, 0xCC, 0x42, 0x61, 0x8C, 0x43,
  0x18, 0xFF, 0xFF, 0xFF, 0x21, 0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xFD,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 7, 9, 7, 0, -9 },
  { 17, 6, 10, 6, 0, -9 },
  { 25, 8, 9, 10, 1, -9 },
  { 34, 8, 9, 8, 0, -9 },
  { 43, 2, 4, 3, 1, -9 },
  { 44, 5, 11, 4, 0, -9 },
  { 51, 4, 11, 4, -1, -9 },
  { 57, 5, 5, 6, 1, -9 },
  { 61, 5, 6, 6, 1, -7 },
  { 65, 3, 3, 3, -1, -1 },
  { 67, 3, 2, 4, 0, -4 },
  { 68, 2, 2, 3, 0, -2 },
  { 69, 7, 9, 5, -1, -9 },
  { 77, 6, 9, 6, 0, -9 },
  { 84, 5, 9, 6, 1, -9 },
  { 90, 6, 9, 6, 0, -9 },
  { 97, 6, 9, 6, 0, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 6, 9, 6, 0, -9 },
  { 125, 7, 9, 6, 0, -9 },
  { 133, 6, 9, 6, 0, -9 },
  { 140, 6, 9, 6, 0, -9 },
  { 147, 3, 7, 3, 0, -7 },
  { 150, 4, 9, 3, -1, -7 },
  { 155, 5, 6, 6, 1, -7 },
  { 159, 5, 4, 6, 1, -6 },
  { 162, 5, 6, 6, 1, -7 },
  { 166, 4, 9, 5, 1, -9 },
  { 171, 9, 10, 9, 0, -9 },
  { 183, 7, 9, 7, -1, -9 },
  { 191, 7, 9, 7, 0, -9 },
  { 199, 6, 9, 7, 1, -9 },
  { 206, 7, 9, 7, 0, -9 },
  { 214, 6, 9, 6, 0, -9 },
  { 221, 6, 9, 6, 0, -9 },
  { 228, 7, 9, 8, 1, -9 },
  { 236, 8, 9, 8, 0, -9 },
  { 245, 5, 9, 4, 0, -9 },
  { 251, 6, 12, 4, -2, -9 },
  { 260, 8, 9, 7, 0, -9 },
  { 269, 5, 9, 6, 0, -9 },
  { 275, 10, 9, 10, 0, -9 },
  { 287, 8, 9, 8, 0, -9 },
  { 296, 7, 9, 8, 1, -9 },
  { 304, 7, 9, 7, 0, -9 },
  { 312, 7, 11, 8, 1, -9 },
  { 322, 7, 9, 7, 0, -9 },
  { 330, 6, 9, 6, 0, -9 },
  { 337, 6, 9, 6, 1, -9 },
  { 344, 7, 9, 8, 1, -9 },
  { 352, 7, 9, 7, 1, -9 },
  { 360, 10, 9, 10, 1, -9 },
  { 372, 8, 9, 7, -1, -9 },
  { 381, 6, 9, 6, 1, -9 },
  { 388, 6, 9, 6, 0, -9 },
  { 395, 5, 11, 4, 0, -9 },
  { 402, 3, 9, 5, 1, -9 },
  { 406, 5, 11, 4, -1, -9 },
  { 413, 6, 6, 6, 0, -9 },
  { 418, 5, 1, 4, -1, 1 },
  { 419, 2, 2, 4, 2, -9 },
  { 420, 6, 7, 7, 0, -7 },
  { 426, 6, 9, 7, 0, -9 },
  { 433, 6, 7, 5, 0, -7 },
  { 439, 7, 9, 7, 0, -9 },
  { 447, 6, 7, 6, 0, -7 },
  { 453, 6, 12, 4, -1, -9 },
  { 462, 6, 10, 7, 0, -7 },
  { 470, 6, 9, 7, 0, -9 },
  { 477, 4, 9, 3, 0, -9 },
  { 482, 6, 12, 3, -2, -9 },
  { 491, 7, 9, 6, 0, -9 },
  { 499, 4, 9, 3, 0, -9 },
  { 504, 9, 7, 10, 0, -7 },
  { 512, 6, 7, 7, 0, -7 },
  { 518, 6, 7, 6, 0, -7 },
  { 524, 7, 10, 7, -1, -7 },
  { 533, 6, 10, 7, 0, -7 },
  { 541, 5, 7, 5, 0, -7 },
  { 546, 5, 7, 5, 0, -7 },
  { 551, 4, 8, 4, 1, -8 },
  { 555, 6, 7, 7, 0, -7 },
  { 561, 5, 7, 6, 1, -7 },
  { 566, 8, 7, 9, 1, -7 },
  { 573, 7, 7, 6, -1, -7 },
  { 580, 7, 10, 6, -1, -7 },
  { 589, 5, 7, 5, 0, -7 },
  { 594, 5, 11, 4, 0, -9 },
  { 601, 2, 12, 6, 2, -9 },
  { 604, 5, 11, 4, -1, -9 },
  { 611, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC12PT7B_H_
