#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F,
  0x00, 0x3E, 0x79, 0xE3, 0xDF, 0x3E, 0xF9, 0xF7, 0x8F, 0x3C, 0x79, 0xE3,
  0xCF, 0x1C, 0x70, 0xE7, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E,
  0x1C, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x80, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x87,
  0x00, 0x0E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x3E, 0xC6, 0x1E,
  0x60, 0x1F, 0x30, 0x07, 0xD8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xDF, 0x80, 0x67, 0xD0, 0x33,
  0xEC, 0x1B, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x03,
  0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x07, 0x80, 0x1E, 0x07,
  0xF8, 0x07, 0x03, 0xFE, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x78, 0xF0, 0x70,
  0x1E, 0x3C, 0x3C, 0x07, 0x8F, 0x1E, 0x03, 0xC7, 0x87, 0x00, 0xF1, 0xE3,
  0xC0, 0x3C, 0x79, 0xE0, 0x0F, 0x1E, 0x71, 0xE3, 0xCF, 0x3D, 0xFC, 0xFF,
  0xDE, 0x7F, 0xBF, 0xE7, 0x3F, 0xE7, 0xF3, 0xDF, 0x3C, 0xF9, 0xE7, 0x8F,
  0x00, 0x71, 0xE3, 0xC0, 0x3C, 0xF1, 0xF0, 0x1E, 0x3C, 0x78, 0x07, 0x0F,
  0x1E, 0x03, 0xC3, 0xC7, 0x81, 0xE0, 0xF3, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C,
  0x0F, 0xF8, 0x1E, 0x01, 0xFE, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xC7, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x7C, 0x7F, 0xC3, 0xE3,
  0xFF, 0x8F, 0x9F, 0xBE, 0x7C, 0x7C, 0xFD, 0xF3, 0xE1, 0xFF, 0x8F, 0x83,
  0xFE, 0x3E, 0x0F, 0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x8F, 0x80, 0x7D, 0xE7, 0xBE,
  0xF3, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x01, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x61, 0xE0, 0x79,
  0xC0, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x1F,
  0xE0, 0x3E, 0xF0, 0x7C, 0xF0, 0x38, 0xF8, 0x18, 0x78, 0x00, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x11, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E,
  0x7C, 0x1F, 0x3E, 0x0F, 0xBF, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE,
  0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xE7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xFE,
  0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0x1F, 0x7C, 0x79, 0xF0, 0x87, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7E, 0xFE, 0x0E, 0x0F, 0xC0, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x07, 0x8F, 0xC1, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x80, 0x3F, 0x30, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xEF,
  0x00, 0xF7, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x07, 0x8F, 0x83,
  0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x80, 0x3F, 0x38, 0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xF0, 0x83, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x9E,
  0x03, 0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xEF, 0xC7, 0xE1, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xCF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC,
  0xFC, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7,
  0xC1, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF1, 0xF0, 0x7C,
  0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x83,
  0xF7, 0xE7, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xBE, 0x0F, 0xBE, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x84, 0x0F, 0xC3, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0x87, 0xC7, 0xE3, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x38, 0x7C,
  0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xF0, 0x3F, 0x0E, 0x1E, 0x1F, 0xF9, 0xE7, 0x87, 0xFE, 0x3C, 0xE1,
  0xE3, 0xC7, 0xBC, 0x78, 0x78, 0xF7, 0x8F, 0x0E, 0x1E, 0xE3, 0xC3, 0xC3,
  0x9C, 0x78, 0x78, 0x77, 0x8F, 0x0F, 0x1E, 0xF1, 0xE1, 0xC3, 0xDE, 0x38,
  0x78, 0xF3, 0xC7, 0x9F, 0x1E, 0x78, 0xFF, 0xFF, 0x8F, 0x0F, 0xDF, 0xE0,
  0xF1, 0xF1, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07, 0x9E, 0x00,
  0xF9, 0xE0, 0x0F, 0x9E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xE0,
  0x3E, 0x1E, 0x07, 0xC1, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF9, 0xF8, 0x7F,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF7, 0xC1, 0xFC,
  0x04, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x7F, 0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x7E,
  0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x1F, 0x8F, 0xDF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xBE, 0x0F, 0xE0, 0x10, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC3, 0xFE, 0x7E, 0x1F, 0xF3, 0xE0, 0xFF, 0x9F, 0x0F, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xF8, 0x3F, 0x07, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0,
  0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F,
  0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00,
  0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F,
  0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFE,
  0x07, 0xBC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xBC, 0x1E,
  0xF8, 0x3D, 0xE1, 0xF7, 0x83, 0xEF, 0x0F, 0x7C, 0x1F, 0x78, 0xFB, 0xE0,
  0xFB, 0xC7, 0x9F, 0x07, 0x9E, 0x7C, 0xF8, 0x3C, 0x73, 0xC7, 0x83, 0xE3,
  0xFE, 0x7C, 0x1F, 0x1F, 0xE3, 0xE0, 0xF8, 0xFF, 0x1F, 0x07, 0x87, 0xF0,
  0xF8, 0x3C, 0x3F, 0x87, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x1E, 0x0F,
  0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3C, 0x1F,
  0x78, 0x3C, 0x1E, 0x7C, 0x7C, 0x1E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E,
  0x3C, 0x78, 0x3E, 0x3E, 0x78, 0x3C, 0x3E, 0xF8, 0x3C, 0x3E, 0xF8, 0x7C,
  0x1E, 0xF8, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0xF8,
  0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0xF0,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x7E,
  0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0xBE, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x3F, 0x1F, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E,
  0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x3F,
  0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE0, 0xF9, 0xFC, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F,
  0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x9F, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xE0, 0x21, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x80, 0x3E, 0x3C, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03,
  0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7E,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0x80,
  0xF8, 0x78, 0x0F, 0x87, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3E, 0x03, 0xEF, 0x80,
  0xF8, 0x0F, 0xBE, 0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0x7E,
  0x07, 0xCF, 0x83, 0xF8, 0x3E, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x7F, 0x87,
  0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x8F, 0xF8, 0x7C, 0x3E, 0x3D, 0xE3, 0xE0,
  0xF8, 0xF7, 0x8F, 0x83, 0xE7, 0x9E, 0x7C, 0x0F, 0x9E, 0x79, 0xF0, 0x3E,
  0xF9, 0xE7, 0x80, 0xFB, 0xC7, 0xBE, 0x03, 0xEF, 0x1E, 0xF8, 0x0F, 0xF8,
  0x7B, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF1, 0xF8, 0x00,
  0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xEF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC0, 0x3F,
  0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xF8,
  0x07, 0xFF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x7C, 0x0F, 0x0F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x07, 0xCF,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x1C, 0x1E, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x7B, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xFC, 0xF9,
  0xF1, 0xF1, 0xE3, 0xC0, 0x03, 0xE3, 0xC1, 0xFC, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0x9F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x0F, 0xCF,
  0xC3, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFB, 0xE0, 0xFC,
  0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x0F, 0xBF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F,
  0x9F, 0x87, 0xE7, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1E, 0xFF, 0x0F,
  0x1F, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x8C,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x1E, 0x7C, 0x07, 0xF7, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0x7D, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x08,
  0x7F, 0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x7F, 0x3C, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFC, 0xFE, 0x3F, 0x0F, 0x87, 0xC1, 0xF1, 0xF8,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0x7C, 0x0F, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x84, 0x03, 0xE0, 0xFB, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x0F, 0xBF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x9F, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xCF, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF8,
  0x1F, 0x3F, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x1F, 0x07, 0xC0, 0xF3, 0xF8, 0xFE, 0x0F,
  0x7F, 0xDF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xCF, 0xF3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x1F, 0x87, 0xE1, 0xF1, 0xF0, 0x7C, 0x1F, 0x1F, 0x07, 0xC1, 0xF1,
  0xF0, 0x78, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F,
  0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0x8F, 0x83,
  0xE0, 0xF8, 0x0F, 0x1F, 0x03, 0xCF, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x0F,
  0xCF, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xF9, 0xF0, 0x7D,
  0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFC, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xC7, 0xC0, 0x3C, 0xFE, 0x03,
  0xDF, 0xF0, 0x3F, 0xFF, 0x03, 0xF1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1E, 0xFF, 0x03, 0xE7, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE3, 0xC1, 0xFC, 0xF0,
  0xFF, 0xBC, 0x7F, 0xFF, 0x1F, 0x9F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFB, 0xC0, 0xFD, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0x9E, 0x1E, 0x7C, 0x3D, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xF0,
  0xC7, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x60, 0x7C, 0xFF, 0xF9, 0xFF,
  0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF,
  0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7,
  0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x7C, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1,
  0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xDE, 0x3F, 0xCF, 0x0F, 0xCF, 0x00,
  0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F,
  0x7C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x07, 0xFE, 0x0F,
  0xC3, 0xEF, 0x87, 0xF0, 0xFB, 0xE1, 0xFC, 0x3E, 0xF8, 0xFF, 0x1F, 0x3E,
  0x3F, 0xC7, 0xCF, 0x8E, 0xF3, 0xE3, 0xE7, 0xBC, 0xF8, 0xF9, 0xEF, 0x7C,
  0x3E, 0xF3, 0xDF, 0x0F, 0xBC, 0xE7, 0x83, 0xEF, 0x3B, 0xE0, 0xFF, 0x8E,
  0xF0, 0x1F, 0xE3, 0xBC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F,
  0x87, 0xE1, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E,
  0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xF0, 0x7E, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x18, 0x01,
  0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 13, 10, 16, 3, -26 },
  { 54, 22, 26, 21, 0, -26 },
  { 126, 17, 29, 18, 1, -27 },
  { 188, 26, 26, 29, 2, -26 },
  { 273, 22, 26, 23, 1, -26 },
  { 345, 6, 10, 9, 4, -26 },
  { 353, 13, 32, 11, 1, -26 },
  { 405, 13, 32, 11, -3, -26 },
  { 457, 16, 17, 18, 3, -28 },
  { 491, 16, 17, 19, 2, -21 },
  { 525, 9, 9, 10, -2, -4 },
  { 536, 9, 5, 11, 1, -12 },
  { 542, 6, 6, 10, 0, -6 },
  { 547, 19, 26, 15, -2, -26 },
  { 609, 17, 26, 18, 1, -26 },
  { 665, 14, 26, 18, 3, -26 },
  { 711, 19, 26, 18, -1, -26 },
  { 773, 18, 26, 18, 0, -26 },
  { 832, 18, 26, 18, 0, -26 },
  { 891, 18, 26, 18, 0, -26 },
  { 950, 18, 26, 18, 1, -26 },
  { 1009, 19, 26, 18, 1, -26 },
  { 1071, 17, 26, 18, 1, -26 },
  { 1127, 17, 26, 18, 1, -26 },
  { 1183, 9, 20, 10, 0, -20 },
  { 1206, 11, 25, 10, -2, -20 },
  { 1241, 16, 18, 19, 2, -22 },
  { 1277, 16, 11, 19, 2, -18 },
  { 1299, 16, 18, 19, 2, -22 },
  { 1335, 14, 26, 15, 2, -26 },
  { 1381, 27, 29, 28, 1, -26 },
  { 1479, 20, 26, 21, -2, -26 },
  { 1544, 19, 26, 20, 1, -26 },
  { 1606, 20, 26, 20, 2, -26 },
  { 1671, 20, 26, 22, 1, -26 },
  { 1736, 18, 26, 18, 1, -26 },
  { 1795, 18, 26, 17, 1, -26 },
  { 1854, 21, 26, 23, 2, -26 },
  { 1923, 23, 26, 23, 1, -26 },
  { 1998, 16, 26, 13, -1, -26 },
  { 2050, 17, 34, 11, -6, -26 },
  { 2123, 22, 26, 20, 1, -26 },
  { 2195, 14, 26, 17, 1, -26 },
  { 2241, 29, 26, 29, 1, -26 },
  { 2336, 24, 26, 25, 1, -26 },
  { 2414, 21, 26, 24, 2, -26 },
  { 2483, 20, 26, 20, 1, -26 },
  { 2548, 21, 32, 24, 2, -26 },
  { 2632, 19, 26, 20, 1, -26 },
  { 2694, 18, 26, 18, 0, -26 },
  { 2753, 17, 26, 17, 3, -26 },
  { 2809, 21, 26, 23, 2, -26 },
  { 2878, 20, 26, 20, 3, -26 },
  { 2943, 30, 26, 30, 3, -26 },
  { 3041, 24, 26, 20, -2, -26 },
  { 3119, 19, 26, 18, 3, -26 },
  { 3181, 20, 26, 17, -1, -26 },
  { 3246, 15, 32, 11, -1, -26 },
  { 3306, 8, 26, 15, 4, -26 },
  { 3332, 14, 32, 11, -2, -26 },
  { 3388, 18, 16, 18, 0, -26 },
  { 3424, 14, 3, 13, -3, 3 },
  { 3430, 7, 6, 11, 5, -28 },
  { 3436, 18, 20, 20, 1, -20 },
  { 3481, 18, 27, 20, 0, -27 },
  { 3542, 16, 20, 16, 1, -20 },
  { 3582, 20, 27, 20, 1, -27 },
  { 3650, 17, 20, 18, 1, -20 },
  { 3693, 20, 37, 12, -4, -28 },
  { 3786, 19, 29, 20, 0, -20 },
  { 3855, 18, 27, 20, 0, -27 },
  { 3916, 11, 27, 10, 0, -27 },
  { 3954, 16, 36, 10, -5, -27 },
  { 4026, 20, 27, 19, 0, -27 },
  { 4094, 11, 27, 10, 0, -27 },
  { 4132, 28, 20, 29, 0, -20 },
  { 4202, 18, 20, 20, 0, -20 },
  { 4247, 17, 20, 19, 1, -20 },
  { 4290, 20, 29, 20, -2, -20 },
  { 4363, 18, 29, 20, 1, -20 },
  { 4429, 15, 20, 14, 0, -20 },
  { 4467, 15, 20, 16, 0, -20 },
  { 4505, 12, 24, 13, 2, -24 },
  { 4541, 17, 20, 20, 2, -20 },
  { 4584, 17, 20, 17, 2, -20 },
  { 4627, 26, 20, 26, 2, -20 },
  { 4692, 21, 20, 18, -2, -20 },
  { 4745, 22, 29, 17, -3, -20 },
  { 4825, 17, 20, 15, -1, -20 },
  { 4868, 15, 32, 13, 0, -26 },
  { 4928, 4, 35, 18, 7, -27 },
  { 4946, 14, 32, 13, -2, -26 },
  { 5002, 16, 6, 19, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC36PT7B_H_
