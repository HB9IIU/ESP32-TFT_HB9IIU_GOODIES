#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0x7C, 0xF7, 0xCF, 0x79, 0xF7,
  0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xF3, 0xC0, 0x00, 0x71, 0xC0,
  0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x78,
  0x01, 0xC7, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC8, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x8E, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x5E, 0x3E,
  0xC4, 0x3E, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0x7C, 0x03, 0x3C, 0x83, 0x3C, 0xE3,
  0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x38, 0x3F, 0x80, 0xE0, 0xFF, 0x03, 0xC3,
  0xFE, 0x07, 0x07, 0x9C, 0x1C, 0x0E, 0x38, 0x78, 0x3C, 0x70, 0xE0, 0x78,
  0xE3, 0x80, 0xF3, 0xCF, 0x01, 0xC7, 0x9C, 0x03, 0x8E, 0x73, 0xF7, 0xBD,
  0xEF, 0xFF, 0xF3, 0xBF, 0xEF, 0xCE, 0x79, 0xCF, 0x3D, 0xE3, 0x80, 0x73,
  0xC7, 0x01, 0xC7, 0x9E, 0x07, 0x8E, 0x3C, 0x1E, 0x1C, 0x78, 0x38, 0x38,
  0xE0, 0xF0, 0x73, 0xC3, 0xC0, 0xFF, 0x07, 0x01, 0xFE, 0x1E, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0x8F,
  0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0xBE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0x1F, 0xE1, 0xE3, 0xFF, 0x3E, 0x7D,
  0xF3, 0xCF, 0x8F, 0xFC, 0xF8, 0xFF, 0x8F, 0x07, 0xF8, 0xF0, 0x7F, 0x0F,
  0x87, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFC, 0xFC,
  0x7D, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x18, 0xE0, 0xFB, 0x83, 0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F,
  0x07, 0xDC, 0x3E, 0x78, 0x39, 0xE0, 0x43, 0xC0, 0x08, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0,
  0x7F, 0xDF, 0xE7, 0xFB, 0xFE, 0x39, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0x3E, 0x3E, 0x1E, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFF, 0x1F, 0xE7, 0xFE,
  0xFD, 0xE7, 0xBE, 0x63, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x07, 0x8F, 0x81, 0x81, 0xF0, 0x40, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x61, 0xF8, 0x20, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x90, 0x0F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x03, 0xDF, 0x03, 0xCF, 0x83,
  0xC7, 0x81, 0xE3, 0xC1, 0xE3, 0xE1, 0xE1, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x98, 0x1F, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7D, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x1E,
  0x1F, 0x1F, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7C, 0xFC, 0xF8, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xFC, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x01, 0xF0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0xC3, 0xDF, 0x07, 0xBE, 0x0F,
  0x7C, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFF, 0xCF,
  0xEF, 0x07, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0x0F, 0xC7, 0xE3, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x1E, 0x0F,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x1C, 0x1F, 0xE7, 0x3C, 0x7F, 0xE7, 0x38,
  0xF9, 0xC7, 0x78, 0xE1, 0xC7, 0x71, 0xE3, 0xC7, 0x71, 0xC3, 0xC7, 0xF3,
  0xC3, 0x87, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF3,
  0xCF, 0xBC, 0xF1, 0xFF, 0xF8, 0xF1, 0xFB, 0xF0, 0x70, 0x20, 0x40, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x87, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF,
  0xC0, 0x1F, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x78, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC1,
  0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x3E,
  0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xC7, 0x0F, 0xC0,
  0x43, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x20, 0x7F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3,
  0xE0, 0xFC, 0x3C, 0x1F, 0x87, 0xC7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x3C, 0x7F,
  0x01, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0x7C, 0x3F, 0xCF, 0x87, 0xF9, 0xF0, 0xFF, 0x3E, 0x1F, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7E, 0x0F, 0x87, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC,
  0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x01,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0x80, 0x78, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x03,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xDE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x7B,
  0xC3, 0xFE, 0x1E, 0xF0, 0xF3, 0x87, 0x3C, 0x3C, 0xE3, 0xDF, 0x0F, 0x38,
  0xE7, 0xC3, 0xCE, 0x79, 0xE1, 0xF3, 0x9C, 0x78, 0x78, 0xEF, 0x1E, 0x1E,
  0x3B, 0x8F, 0x87, 0x8F, 0xE3, 0xC3, 0xE3, 0xF0, 0xF0, 0xF0, 0xFC, 0x3C,
  0x3C, 0x3F, 0x0F, 0x0F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0x07, 0xE0,
  0x1E, 0x0F, 0xC0, 0x3C, 0x1F, 0x80, 0xF8, 0x3F, 0x81, 0xE0, 0x7F, 0x03,
  0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x1F, 0x07, 0xFC, 0x3E, 0x0F, 0x78, 0x78,
  0x1E, 0xF0, 0xF0, 0x7D, 0xF1, 0xE0, 0xF3, 0xE7, 0xC1, 0xE3, 0xCF, 0x83,
  0xC7, 0x9E, 0x0F, 0x8F, 0xBC, 0x1F, 0x0F, 0x78, 0x3C, 0x1E, 0xF0, 0x78,
  0x3F, 0xC0, 0xF0, 0x7F, 0x83, 0xE0, 0x7F, 0x07, 0xC0, 0xFE, 0x0F, 0x01,
  0xFC, 0x1E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC, 0x7E, 0x0F, 0xCF, 0x80, 0xFB,
  0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF,
  0x01, 0xF3, 0xE0, 0x7E, 0x7E, 0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x78, 0xFE, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC,
  0xFC, 0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x7E, 0x7E, 0x1F,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0xCF, 0x87,
  0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0x3C, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xC7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFC, 0x70, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x20, 0x1F, 0x18, 0x1F, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C,
  0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0xF8, 0x7C, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F,
  0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1F, 0x07,
  0x8F, 0x81, 0xE3, 0xE0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0xFE, 0x03,
  0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0x78, 0x1F, 0x83, 0xEF, 0x03, 0xF0, 0x79,
  0xE0, 0xFE, 0x1F, 0x3C, 0x1F, 0xC3, 0xE7, 0x87, 0xF8, 0x78, 0xF0, 0xFF,
  0x1F, 0x1E, 0x1D, 0xE3, 0xC3, 0xC7, 0xBC, 0xF8, 0x78, 0xF7, 0x9E, 0x0F,
  0x3C, 0xF3, 0xC1, 0xE7, 0x9E, 0xF8, 0x3D, 0xE3, 0xDE, 0x07, 0xBC, 0x7F,
  0xC0, 0xF7, 0x8F, 0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x3C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xCF, 0x07, 0xC7, 0x87, 0xC3,
  0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x0E, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xF9, 0xE7, 0xCF, 0x1C, 0x07, 0xE7, 0x87, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xE3, 0xE3, 0xF3, 0xF0, 0xF9, 0xF0, 0x78, 0xF8, 0x3C, 0x78,
  0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0xC7, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0x78, 0x1F, 0x3C, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x7C, 0x0F, 0x7F, 0x07, 0xFF, 0x87, 0xF7, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F,
  0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xE3, 0xFB, 0xF1, 0xFF, 0xF0, 0xEF, 0xF0,
  0xF3, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0xBE, 0x0F, 0xEF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xF8, 0xFC, 0x7C, 0x1F, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x7F,
  0x07, 0xFF, 0x81, 0xFE, 0xE0, 0x3F, 0x78, 0x00, 0x03, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF8, 0xF9, 0xF3, 0xE1, 0xEF, 0x83, 0xDF, 0x0F, 0xBD, 0xFE, 0xFF,
  0xF9, 0xFF, 0xE3, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x0C,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF3, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x1F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xBC, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x30, 0x3E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x7C, 0x0F, 0x7F, 0x07, 0xFF, 0xC7, 0xFF, 0xE3,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F,
  0x1E, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0x0F, 0x0F, 0x81, 0xE3, 0xE0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC1, 0xF0, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0x0F, 0x3E, 0x1F, 0x03,
  0x9F, 0xCF, 0xE0, 0xEF, 0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0x8F, 0xC7,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x1E, 0x3E, 0x1F,
  0x07, 0x8F, 0x87, 0xC3, 0xE3, 0xC1, 0xF0, 0xF8, 0xF0, 0x78, 0x3C, 0x7C,
  0x1E, 0x0F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xE0, 0xF8, 0x7C,
  0x78, 0x3C, 0x1E, 0x3E, 0x1F, 0x07, 0x80, 0x0F, 0x3E, 0x07, 0x3F, 0x83,
  0xBF, 0xE3, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E,
  0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xE7, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x7C, 0x1E, 0x00, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xBC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xDF, 0x0F,
  0x9F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x07, 0x9F, 0x01, 0xFF,
  0xE0, 0x77, 0xF8, 0x3F, 0xBF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C,
  0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3E, 0x3E,
  0x0F, 0x8F, 0xC7, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3D, 0xFC, 0x1F, 0x7E,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE7, 0x87, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xE3, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x3C,
  0x78, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0x78, 0x1F, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x3C, 0x3D, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xC8,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0xF1, 0xFF, 0x8F, 0xCE, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF2, 0x07, 0xCF,
  0x3F, 0x3F, 0xF8, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x01, 0xC0, 0x38, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xEC, 0x7F, 0x8F, 0xF0,
  0xFE, 0x00, 0x1E, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE1,
  0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E,
  0x0F, 0x8F, 0x07, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xF7, 0xF0, 0xFF, 0x78,
  0x7F, 0xB8, 0x1F, 0x3C, 0x00, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xF7, 0x83,
  0xEF, 0x0F, 0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0x79, 0xE0, 0xF7, 0xC1,
  0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xF8, 0x00, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x3E, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x3C, 0xF1, 0xFC, 0x7C, 0xF1, 0xDC, 0x78, 0xF3, 0xDC, 0xF8,
  0xF3, 0xDC, 0xF0, 0xF3, 0x9D, 0xF0, 0xF7, 0x9D, 0xE0, 0xF7, 0x1D, 0xE0,
  0xF7, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xBC, 0x00, 0xFB, 0xC0, 0x1F, 0x3E, 0x03, 0xE3,
  0xE0, 0x7E, 0x1E, 0x0F, 0xC1, 0xF0, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C,
  0xF8, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x1C, 0x03, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80,
  0x00, 0x7E, 0x03, 0xFF, 0xDF, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 14, 3, -24 },
  { 45, 20, 24, 19, 0, -24 },
  { 105, 16, 27, 17, 1, -25 },
  { 159, 23, 24, 26, 2, -24 },
  { 228, 20, 24, 21, 1, -24 },
  { 288, 6, 9, 8, 3, -24 },
  { 295, 12, 29, 10, 1, -24 },
  { 339, 11, 29, 10, -2, -24 },
  { 379, 14, 15, 16, 3, -25 },
  { 406, 15, 16, 18, 2, -20 },
  { 436, 8, 8, 9, -2, -4 },
  { 444, 10, 4, 10, 0, -11 },
  { 449, 6, 5, 9, 0, -5 },
  { 453, 18, 24, 13, -2, -24 },
  { 507, 16, 24, 17, 1, -24 },
  { 555, 12, 24, 17, 3, -24 },
  { 591, 18, 24, 17, -1, -24 },
  { 645, 17, 24, 17, 0, -24 },
  { 696, 17, 24, 17, 0, -24 },
  { 747, 17, 24, 17, 0, -24 },
  { 798, 16, 24, 17, 1, -24 },
  { 846, 17, 24, 17, 1, -24 },
  { 897, 16, 24, 17, 1, -24 },
  { 945, 15, 24, 17, 1, -24 },
  { 990, 9, 18, 9, 0, -18 },
  { 1011, 11, 22, 9, -2, -18 },
  { 1042, 15, 16, 18, 2, -20 },
  { 1072, 15, 10, 18, 2, -17 },
  { 1091, 15, 16, 18, 2, -20 },
  { 1121, 13, 24, 14, 2, -24 },
  { 1160, 24, 27, 26, 1, -24 },
  { 1241, 19, 24, 19, -2, -24 },
  { 1298, 19, 24, 19, 0, -24 },
  { 1355, 18, 24, 18, 2, -24 },
  { 1409, 20, 24, 20, 0, -24 },
  { 1469, 17, 24, 16, 0, -24 },
  { 1520, 17, 24, 16, 0, -24 },
  { 1571, 19, 24, 21, 2, -24 },
  { 1628, 22, 24, 21, 0, -24 },
  { 1694, 15, 24, 12, -1, -24 },
  { 1739, 16, 31, 10, -5, -24 },
  { 1801, 20, 24, 18, 1, -24 },
  { 1861, 13, 24, 15, 0, -24 },
  { 1900, 26, 24, 27, 1, -24 },
  { 1978, 23, 24, 23, 0, -24 },
  { 2047, 19, 24, 22, 2, -24 },
  { 2104, 19, 24, 18, 0, -24 },
  { 2161, 19, 30, 22, 2, -24 },
  { 2233, 17, 24, 19, 1, -24 },
  { 2284, 17, 24, 16, 0, -24 },
  { 2335, 15, 24, 16, 3, -24 },
  { 2380, 19, 24, 21, 2, -24 },
  { 2437, 18, 24, 18, 3, -24 },
  { 2491, 27, 24, 27, 3, -24 },
  { 2572, 23, 24, 18, -2, -24 },
  { 2641, 17, 24, 17, 3, -24 },
  { 2692, 19, 24, 16, -1, -24 },
  { 2749, 14, 29, 10, -1, -24 },
  { 2800, 8, 24, 13, 3, -24 },
  { 2824, 13, 29, 10, -2, -24 },
  { 2872, 16, 15, 17, 0, -24 },
  { 2902, 13, 2, 12, -3, 3 },
  { 2906, 6, 5, 10, 5, -25 },
  { 2910, 17, 18, 18, 1, -18 },
  { 2949, 17, 25, 18, 0, -25 },
  { 3003, 14, 18, 15, 1, -18 },
  { 3035, 18, 25, 18, 1, -25 },
  { 3092, 15, 18, 17, 1, -18 },
  { 3126, 19, 33, 11, -4, -25 },
  { 3205, 18, 26, 18, 0, -18 },
  { 3264, 17, 25, 18, 0, -25 },
  { 3318, 10, 25, 9, 0, -25 },
  { 3350, 14, 33, 9, -4, -25 },
  { 3408, 19, 25, 17, 0, -25 },
  { 3468, 10, 25, 9, 0, -25 },
  { 3500, 26, 18, 27, 0, -18 },
  { 3559, 17, 18, 18, 0, -18 },
  { 3598, 15, 18, 18, 1, -18 },
  { 3632, 18, 26, 18, -1, -18 },
  { 3691, 17, 26, 18, 1, -18 },
  { 3747, 14, 18, 13, 0, -18 },
  { 3779, 14, 18, 14, 0, -18 },
  { 3811, 11, 22, 12, 2, -22 },
  { 3842, 17, 18, 18, 1, -18 },
  { 3881, 15, 18, 16, 2, -18 },
  { 3915, 24, 18, 24, 2, -18 },
  { 3969, 20, 18, 16, -2, -18 },
  { 4014, 19, 26, 16, -2, -18 },
  { 4076, 15, 18, 14, -1, -18 },
  { 4110, 14, 29, 12, 0, -24 },
  { 4161, 4, 32, 16, 6, -25 },
  { 4177, 13, 29, 12, -2, -24 },
  { 4225, 15, 5, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC33PT7B_H_
