#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xF1, 0xFF,
  0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0x3F, 0x80, 0x1F,
  0xF8, 0xF0, 0x78, 0x03, 0xFF, 0x1F, 0x01, 0x00, 0x3F, 0xF1, 0xE0, 0x00,
  0x03, 0xFF, 0x1E, 0x00, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x03, 0xFF, 0x1E,
  0x00, 0x00, 0x3F, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x7F, 0xF0, 0x00, 0x01, 0xE3,
  0xFF, 0x00, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x01, 0xE3, 0xFF, 0x00, 0x00,
  0x1E, 0x3F, 0xF0, 0x40, 0x03, 0xE3, 0xFF, 0x07, 0x00, 0x3C, 0x3F, 0xF0,
  0x7E, 0x03, 0xC7, 0xFF, 0x07, 0xFC, 0x3D, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC7, 0xF8, 0x07, 0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFF, 0xFC, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F,
  0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0xBF, 0xFF, 0xE3,
  0xFC, 0xFF, 0xDF, 0xF3, 0xFF, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x7F, 0xFE,
  0x3F, 0xC7, 0xFC, 0x3F, 0xC7, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xBF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x04, 0x00, 0xFE, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x17,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x3F, 0xF9,
  0xFE, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x78, 0x0F, 0xF8, 0x00, 0x20, 0x1F,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFB, 0xFE,
  0x3F, 0xFC, 0xFF, 0x87, 0xFE, 0x7F, 0xE0, 0xFE, 0x1F, 0xF8, 0x3F, 0x07,
  0xFE, 0x07, 0x81, 0xFF, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x1C, 0x00, 0x7F,
  0xF0, 0x01, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0xFE,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x80, 0x00, 0x3F, 0xFC, 0x0E, 0x00,
  0x07, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x83, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xEF, 0xFF, 0xE0,
  0x0F, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x17, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xCF, 0xF8, 0x01, 0xFF,
  0xC7, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0x0E, 0x00, 0x3F, 0xF0, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0xFE, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x3F,
  0x83, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xF1, 0xFC, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE7, 0xF0, 0x3F,
  0xC0, 0x3F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF3, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xEF, 0xF0, 0x7F, 0x80, 0x3F, 0x80,
  0xFF, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x9F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x3F, 0x81,
  0xFC, 0x07, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xF8, 0x7F,
  0x83, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xFF,
  0x9F, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0x80, 0x1F, 0xFF, 0x00,
  0x01, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0xFF, 0xF8, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x1F,
  0xFF, 0x80, 0x01, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x01,
  0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF,
  0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0xFF, 0x8F, 0xE0, 0x1F,
  0xF3, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFE,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xC7, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xEF, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xCF, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00,
  0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x00,
  0x60, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x40, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0xFF, 0xE0,
  0x1F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x1F,
  0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xFC,
  0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFD, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC,
  0x07, 0xFB, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x7F,
  0xE0, 0x07, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE3, 0xFE,
  0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC3, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8,
  0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xCF, 0xF0, 0x3F, 0xCF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xFB,
  0xFE, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFC, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF,
  0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0xFF,
  0x80, 0x0F, 0xFF, 0xE7, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF,
  0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xF8, 0x00, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFC, 0x01, 0x81, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x04,
  0x0F, 0xFE, 0x00, 0x30, 0x3F, 0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF,
  0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xC7, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0xFF, 0x00,
  0x03, 0xFF, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F,
  0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0xFF, 0xE0, 0x01, 0xC0, 0x7F,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xC3, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x3C, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x20, 0x00, 0x0F, 0xFE, 0x00,
  0x70, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F,
  0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0xF8, 0x01, 0xFF,
  0xBF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xDF,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x43, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0x3F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF9, 0xFF,
  0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x00, 0xFE, 0x1F,
  0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F,
  0xE7, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xDF,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xE0,
  0x00, 0x0F, 0xE1, 0xFF, 0xF0, 0x00, 0x1F, 0xE3, 0xFF, 0xF8, 0x00, 0x1F,
  0xE7, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xC3,
  0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0xFE,
  0xFF, 0x80, 0x0F, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0x7F,
  0xCF, 0xFE, 0x01, 0xFF, 0x3F, 0xF8, 0x07, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x60, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x30, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x87, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x40, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x00,
  0x3F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF7, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE7,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xC7, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFE,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFE, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0xC0, 0x7F,
  0xC3, 0xFC, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xCF, 0xE1, 0xFF, 0x80,
  0x7F, 0xC7, 0xF8, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x8F, 0xE3, 0xFF,
  0x00, 0x7F, 0xC7, 0xF1, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x1F, 0xE3,
  0xFE, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xE0, 0x07, 0xFD, 0xFE, 0x1F,
  0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFC,
  0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x80, 0x07, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0x81, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x04, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x47,
  0xFF, 0xE0, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xB8, 0x00, 0x3F,
  0xFF, 0x8C, 0x00, 0x01, 0xFF, 0xC2, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 22, 52, 20, 0, -51 },
  { 144, 26, 18, 31, 7, -51 },
  { 203, 42, 51, 42, 1, -51 },
  { 471, 36, 59, 36, 1, -55 },
  { 737, 51, 53, 58, 4, -52 },
  { 1075, 44, 53, 46, 1, -52 },
  { 1367, 12, 18, 18, 7, -51 },
  { 1394, 26, 62, 23, 2, -51 },
  { 1596, 26, 63, 23, -5, -52 },
  { 1801, 31, 33, 36, 6, -55 },
  { 1929, 33, 35, 38, 3, -43 },
  { 2074, 17, 19, 19, -4, -9 },
  { 2115, 20, 9, 22, 1, -24 },
  { 2138, 12, 12, 19, 0, -11 },
  { 2156, 38, 53, 29, -3, -52 },
  { 2408, 34, 53, 36, 2, -52 },
  { 2634, 26, 51, 37, 7, -51 },
  { 2800, 38, 52, 36, -2, -52 },
  { 3047, 36, 53, 36, 0, -52 },
  { 3286, 37, 51, 37, -1, -51 },
  { 3522, 36, 52, 36, 1, -51 },
  { 3756, 35, 53, 36, 3, -52 },
  { 3988, 38, 51, 36, 2, -51 },
  { 4231, 36, 53, 36, 1, -52 },
  { 4470, 34, 53, 36, 2, -52 },
  { 4696, 19, 41, 19, 0, -40 },
  { 4794, 23, 50, 19, -4, -40 },
  { 4938, 33, 36, 38, 3, -44 },
  { 5087, 33, 21, 38, 3, -36 },
  { 5174, 33, 36, 38, 3, -44 },
  { 5323, 28, 53, 30, 4, -52 },
  { 5509, 53, 58, 56, 3, -52 },
  { 5894, 41, 51, 41, -4, -51 },
  { 6156, 40, 51, 41, 1, -51 },
  { 6411, 39, 53, 40, 4, -52 },
  { 6670, 42, 51, 44, 1, -51 },
  { 6938, 37, 51, 35, 1, -51 },
  { 7174, 37, 51, 34, 1, -51 },
  { 7410, 42, 53, 45, 4, -52 },
  { 7689, 46, 51, 46, 1, -51 },
  { 7983, 32, 51, 26, -2, -51 },
  { 8187, 34, 66, 22, -11, -51 },
  { 8468, 46, 51, 40, 1, -51 },
  { 8762, 28, 51, 34, 1, -51 },
  { 8941, 59, 51, 59, 1, -51 },
  { 9318, 49, 51, 49, 1, -51 },
  { 9631, 42, 53, 48, 4, -52 },
  { 9910, 40, 51, 40, 1, -51 },
  { 10165, 42, 64, 48, 4, -52 },
  { 10501, 39, 51, 40, 1, -51 },
  { 10750, 37, 53, 35, 0, -52 },
  { 10996, 34, 51, 35, 6, -51 },
  { 11213, 43, 52, 45, 4, -51 },
  { 11493, 40, 51, 39, 6, -51 },
  { 11748, 60, 51, 59, 6, -51 },
  { 12131, 49, 51, 39, -4, -51 },
  { 12444, 37, 51, 37, 6, -51 },
  { 12680, 41, 51, 35, -2, -51 },
  { 12942, 30, 62, 23, -2, -51 },
  { 13175, 16, 53, 29, 8, -52 },
  { 13281, 29, 62, 23, -5, -51 },
  { 13506, 35, 33, 37, 1, -52 },
  { 13651, 28, 5, 27, -7, 6 },
  { 13669, 15, 11, 23, 10, -55 },
  { 13690, 37, 41, 39, 2, -40 },
  { 13880, 36, 56, 39, 1, -55 },
  { 14132, 30, 41, 32, 3, -40 },
  { 14286, 39, 56, 39, 3, -55 },
  { 14559, 32, 41, 37, 3, -40 },
  { 14723, 40, 72, 24, -8, -55 },
  { 15083, 39, 57, 39, 0, -40 },
  { 15361, 36, 55, 40, 1, -55 },
  { 15609, 21, 55, 20, 1, -55 },
  { 15754, 31, 72, 20, -9, -55 },
  { 16033, 40, 55, 37, 1, -55 },
  { 16308, 21, 55, 20, 1, -55 },
  { 16453, 55, 40, 59, 1, -40 },
  { 16728, 36, 40, 40, 1, -40 },
  { 16908, 33, 41, 38, 3, -40 },
  { 17078, 40, 57, 39, -3, -40 },
  { 17363, 37, 57, 39, 2, -40 },
  { 17627, 30, 40, 28, 1, -40 },
  { 17777, 31, 41, 31, 0, -40 },
  { 17936, 25, 49, 26, 3, -48 },
  { 18090, 36, 40, 39, 3, -39 },
  { 18270, 34, 39, 34, 4, -39 },
  { 18436, 52, 39, 52, 4, -39 },
  { 18690, 42, 39, 35, -4, -39 },
  { 18895, 43, 56, 34, -5, -39 },
  { 19196, 34, 39, 30, -2, -39 },
  { 19362, 30, 62, 25, 0, -51 },
  { 19595, 8, 71, 35, 13, -55 },
  { 19666, 29, 62, 25, -4, -51 },
  { 19891, 34, 12, 38, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC72PT7B_H_
