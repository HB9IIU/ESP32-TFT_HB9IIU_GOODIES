#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x00, 0x7E, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE1, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1F,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x98, 0xC1, 0xF9, 0x80,
  0x1F, 0xB8, 0x01, 0xFB, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xEF, 0xC0, 0x0C, 0xFC, 0x80, 0xCF, 0xCC, 0x0C, 0xFC, 0xFD,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x3F, 0x80, 0x1E, 0x03, 0xFE, 0x01, 0xF0, 0x3F, 0xF0, 0x0F,
  0x03, 0xEF, 0x80, 0xF0, 0x1E, 0x3C, 0x0F, 0x81, 0xF1, 0xF0, 0xF8, 0x0F,
  0x8F, 0x07, 0x80, 0x78, 0x78, 0x7C, 0x03, 0xC3, 0xC7, 0xC0, 0x3E, 0x3E,
  0x3C, 0x01, 0xF1, 0xF3, 0xE0, 0x0F, 0x8F, 0x3E, 0x3E, 0x7C, 0xF9, 0xE7,
  0xFB, 0xEF, 0xDF, 0x7F, 0xEF, 0xFD, 0xF7, 0xFF, 0x7F, 0xCF, 0x3E, 0x79,
  0xFC, 0xFB, 0xE3, 0xC3, 0x8F, 0x9F, 0x1E, 0x00, 0x78, 0xF0, 0xF0, 0x07,
  0xC7, 0x87, 0x80, 0x7C, 0x7C, 0x3C, 0x03, 0xC3, 0xE3, 0xE0, 0x3E, 0x1F,
  0x1F, 0x03, 0xE0, 0xF8, 0xF0, 0x1E, 0x07, 0xCF, 0x81, 0xF0, 0x3F, 0xF8,
  0x1F, 0x00, 0xFF, 0xC0, 0xF0, 0x07, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xFC, 0x3F, 0x1F, 0xFF, 0x1F, 0x9F, 0x9F, 0xDF, 0x8F, 0xC7,
  0xEF, 0x8F, 0xC3, 0xFF, 0xC7, 0xE0, 0xFF, 0xC3, 0xF0, 0x3F, 0xE1, 0xF8,
  0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7F, 0xBF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0xC0, 0xFF, 0x87, 0xF0, 0x7E, 0xFD, 0xF3,
  0xE7, 0xCF, 0x1E, 0x7C, 0xF9, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x83, 0xE0, 0x30, 0xF0, 0x1F, 0x3C, 0x07, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xDF, 0x07, 0xE3, 0xC0, 0x78, 0xF8, 0x0C, 0x3E, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x3C, 0xFF, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xC3, 0xE1, 0xF8, 0x3E, 0x1F, 0x83,
  0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7F, 0x7C, 0x7D, 0xF8, 0xE3, 0xF0,
  0x87, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0x3C, 0x1F, 0x80, 0x40, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xE3, 0xFC, 0x0C, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0xC0, 0x1F, 0xC7, 0xEF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0x7C, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x79, 0xF0, 0x07,
  0xCF, 0x80, 0x7C, 0xFC, 0x07, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x18,
  0x07, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE8, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x08, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x7C, 0x03,
  0xEF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xFB, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xFC,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFB, 0xF8, 0x7E, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x0F, 0x8F, 0xE3, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x9F,
  0xC7, 0xE1, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x1F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xCF, 0xC7, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC3, 0xFE, 0xF8, 0x3F, 0xBF, 0x01, 0xC7, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x1E, 0x7F, 0x83,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3C, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x30, 0x1E, 0x1E, 0x0F, 0xFE,
  0x78, 0xF0, 0x7F, 0xF1, 0xF7, 0xC3, 0xFF, 0xC3, 0xDE, 0x1F, 0x0F, 0x0F,
  0x78, 0x78, 0x7C, 0x3F, 0xE3, 0xE1, 0xE1, 0xEF, 0x0F, 0x07, 0x87, 0xBC,
  0x7C, 0x1E, 0x1E, 0xF1, 0xE0, 0xF8, 0x7B, 0xC7, 0x83, 0xC3, 0xEF, 0x1E,
  0x0F, 0x0F, 0x3C, 0x78, 0x7C, 0x7C, 0xF1, 0xF3, 0xF1, 0xE3, 0xC7, 0xFF,
  0xFF, 0x0F, 0x0F, 0xF7, 0xF8, 0x3C, 0x3F, 0x9F, 0xC0, 0xF8, 0x18, 0x1C,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x00,
  0x3F, 0x80, 0x78, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xBF, 0x03,
  0xF8, 0x04, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x01, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFC, 0x3F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x1F, 0x81, 0xFC, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFE,
  0xFC, 0x0F, 0xF0, 0x0C, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xFC, 0xFE, 0x0F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFE, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xCF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F,
  0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xF9, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xBE, 0x07,
  0xFE, 0x07, 0xDF, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0x83, 0xEF, 0x81,
  0xF3, 0xC1, 0xF7, 0xC0, 0xF9, 0xE1, 0xF3, 0xE0, 0x7C, 0xF0, 0xFB, 0xF0,
  0x7E, 0x78, 0xF9, 0xF8, 0x3F, 0x3C, 0x7C, 0xF8, 0x1F, 0x1E, 0x7C, 0x7C,
  0x0F, 0x8F, 0x3E, 0x3E, 0x07, 0xC7, 0xBE, 0x3F, 0x07, 0xE3, 0xDF, 0x1F,
  0x83, 0xE1, 0xFF, 0x0F, 0x81, 0xF0, 0xFF, 0x87, 0xC0, 0xF8, 0x7F, 0x87,
  0xE0, 0x7C, 0x3F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC1, 0xF0, 0x3E, 0x0F, 0xE0,
  0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x7F, 0x80, 0x3E, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0x3E,
  0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xFC, 0x07, 0xC0, 0xFF,
  0xE0, 0x7C, 0x0F, 0xFE, 0x0F, 0xC0, 0xFB, 0xE0, 0xFC, 0x0F, 0xBE, 0x0F,
  0x81, 0xF3, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x81, 0xF1, 0xF1, 0xF8, 0x1F,
  0x1F, 0x1F, 0x83, 0xF1, 0xF9, 0xF0, 0x3F, 0x0F, 0x9F, 0x03, 0xE0, 0xF9,
  0xF0, 0x3E, 0x0F, 0xDF, 0x03, 0xE0, 0xFF, 0xF0, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x7F, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x03,
  0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xF8, 0x03, 0xFC, 0x0F, 0x80, 0x1F, 0xC0,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x0F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F,
  0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x3F,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE7, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFD, 0xF0, 0x3F, 0x80, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x10, 0x03, 0xF0, 0x60, 0x3F, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0xBE, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xC0, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00,
  0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07,
  0xDF, 0x01, 0xFC, 0x07, 0xEF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x03,
  0xF3, 0xE0, 0x7F, 0x81, 0xF9, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x3F, 0xE0,
  0xFC, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0x1F, 0x78, 0x7E, 0x1F, 0x0F, 0xFC,
  0x3F, 0x0F, 0x87, 0xBE, 0x1F, 0x07, 0xC7, 0xDF, 0x1F, 0x83, 0xE3, 0xEF,
  0x8F, 0x81, 0xF3, 0xE7, 0xCF, 0xC0, 0xF9, 0xF3, 0xE7, 0xC0, 0x7D, 0xF1,
  0xF3, 0xE0, 0x3E, 0xF8, 0xFB, 0xF0, 0x1F, 0x78, 0x3D, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF,
  0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x00, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC3, 0xC0, 0x78,
  0x3C, 0x0F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x7C,
  0x01, 0xFF, 0xC0, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x7E, 0x3E,
  0x1F, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xE7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFC, 0x1F, 0xDF, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xE7, 0xC0,
  0x7E, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE7, 0x80, 0x3E, 0x7F, 0x01, 0xF7, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F,
  0xE7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3C, 0xFF, 0x83, 0xE3, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x87, 0xF0, 0xC3, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x81, 0x07, 0xFB, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF1, 0xF8, 0x07, 0xFB, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xF0, 0x07, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0xFE, 0x3F,
  0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0xC3, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x21, 0xFC, 0x1C, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC8, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x10, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xF9, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F,
  0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x08, 0x03,
  0xF0, 0x30, 0x1F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE3, 0xC0, 0x3E, 0x7F, 0x01, 0xF7, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x07, 0xE1,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3E, 0x07,
  0xE3, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x02, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xBF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x07, 0x8F, 0xE1, 0xFC, 0x07, 0x9F, 0xF3, 0xFE, 0x0F, 0xBF, 0xF7,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF3, 0xFE, 0x3F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x81, 0xF0,
  0x3F, 0x1F, 0x83, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0x03, 0xF0,
  0x7E, 0x3F, 0x03, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0x7C, 0x3F, 0x07, 0xE0,
  0x7C, 0x3E, 0x07, 0xE0, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xC0,
  0xFC, 0x7E, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x7F, 0x01, 0xE7,
  0xFC, 0x1F, 0x7F, 0xF0, 0xFF, 0xFF, 0x87, 0xF8, 0xFC, 0x3F, 0x87, 0xE1,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x07,
  0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E,
  0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C,
  0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x8F, 0xCF, 0xE1, 0xF9, 0xF8,
  0x1F, 0x7F, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xC0,
  0x7E, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF, 0xC3,
  0xF9, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xC7, 0xF0, 0x07, 0xBF, 0xF0, 0x1F, 0x7F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x9F, 0xC0, 0xFF, 0xFF, 0x81, 0xF7,
  0xFE, 0x03, 0xEF, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xE7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xC0, 0x7E, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xC1, 0xF3, 0xE0, 0x7D, 0xF8, 0x3E, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFC, 0x18, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x40, 0x3F, 0x3C, 0x3F, 0x9F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC4,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0x83, 0xF1, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F, 0x83, 0xF8,
  0xFC, 0x3F, 0x8F, 0xCF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F,
  0x03, 0xF1, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xC7, 0xC0,
  0xFC, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C,
  0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07,
  0xDF, 0x80, 0x3D, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x81, 0xFF, 0xC1, 0xFC, 0x1F, 0xBE, 0x0F, 0xE0, 0xFD, 0xF0, 0xFF, 0x0F,
  0xCF, 0x87, 0xF8, 0x7E, 0x7C, 0x7F, 0xC3, 0xE3, 0xE3, 0xDE, 0x3F, 0x1F,
  0x1E, 0xF1, 0xF0, 0xF9, 0xF7, 0x9F, 0x87, 0xCF, 0x3C, 0xF8, 0x3E, 0xF9,
  0xE7, 0xC1, 0xF7, 0x8F, 0x7C, 0x0F, 0xBC, 0x7B, 0xE0, 0x7F, 0xE3, 0xDF,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0xFC,
  0x03, 0xF1, 0xFC, 0x03, 0xF1, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFB, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x0F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 15, 10, 18, 4, -29 },
  { 68, 24, 29, 24, 1, -29 },
  { 155, 20, 33, 21, 1, -31 },
  { 238, 29, 30, 33, 2, -30 },
  { 347, 25, 30, 26, 1, -30 },
  { 441, 7, 10, 10, 4, -29 },
  { 450, 15, 35, 13, 1, -29 },
  { 516, 15, 36, 13, -3, -30 },
  { 584, 18, 18, 20, 3, -31 },
  { 625, 19, 19, 22, 2, -24 },
  { 671, 10, 10, 11, -2, -5 },
  { 684, 11, 6, 13, 1, -14 },
  { 693, 7, 6, 11, 0, -6 },
  { 699, 22, 30, 17, -2, -30 },
  { 782, 20, 30, 21, 1, -30 },
  { 857, 15, 29, 21, 4, -29 },
  { 912, 22, 30, 21, -1, -30 },
  { 995, 21, 30, 21, 0, -30 },
  { 1074, 21, 29, 21, 0, -29 },
  { 1151, 21, 29, 21, 0, -29 },
  { 1228, 21, 30, 21, 1, -30 },
  { 1307, 22, 29, 21, 1, -29 },
  { 1387, 20, 30, 21, 1, -30 },
  { 1462, 19, 30, 21, 1, -30 },
  { 1534, 11, 23, 11, 0, -23 },
  { 1566, 13, 28, 11, -2, -23 },
  { 1612, 19, 21, 22, 2, -25 },
  { 1662, 19, 13, 22, 2, -21 },
  { 1693, 19, 21, 22, 2, -25 },
  { 1743, 16, 30, 17, 2, -30 },
  { 1803, 30, 33, 32, 2, -29 },
  { 1927, 24, 29, 23, -3, -29 },
  { 2014, 22, 29, 23, 1, -29 },
  { 2094, 23, 30, 23, 2, -30 },
  { 2181, 23, 29, 25, 1, -29 },
  { 2265, 21, 29, 20, 1, -29 },
  { 2342, 21, 29, 20, 1, -29 },
  { 2419, 24, 30, 26, 2, -30 },
  { 2509, 26, 29, 26, 1, -29 },
  { 2604, 18, 29, 15, -1, -29 },
  { 2670, 19, 38, 12, -6, -29 },
  { 2761, 26, 29, 23, 1, -29 },
  { 2856, 16, 29, 19, 1, -29 },
  { 2914, 33, 29, 33, 1, -29 },
  { 3034, 28, 29, 28, 1, -29 },
  { 3136, 24, 30, 27, 2, -30 },
  { 3226, 22, 29, 23, 1, -29 },
  { 3306, 24, 37, 27, 2, -30 },
  { 3417, 22, 29, 23, 1, -29 },
  { 3497, 21, 30, 20, 0, -30 },
  { 3576, 20, 29, 20, 3, -29 },
  { 3649, 24, 29, 26, 2, -29 },
  { 3736, 22, 29, 22, 4, -29 },
  { 3816, 33, 29, 34, 4, -29 },
  { 3936, 28, 29, 22, -2, -29 },
  { 4038, 21, 29, 21, 4, -29 },
  { 4115, 23, 29, 20, -1, -29 },
  { 4199, 17, 35, 13, -1, -29 },
  { 4274, 10, 30, 17, 4, -30 },
  { 4312, 17, 35, 13, -3, -29 },
  { 4387, 20, 18, 21, 0, -29 },
  { 4432, 16, 2, 15, -4, 4 },
  { 4436, 8, 6, 13, 6, -31 },
  { 4442, 21, 23, 22, 1, -23 },
  { 4503, 21, 31, 22, 0, -31 },
  { 4585, 18, 23, 18, 1, -23 },
  { 4637, 23, 31, 22, 1, -31 },
  { 4727, 19, 23, 21, 1, -23 },
  { 4782, 22, 41, 14, -4, -31 },
  { 4895, 22, 33, 22, 0, -23 },
  { 4986, 21, 31, 23, 0, -31 },
  { 5068, 12, 31, 11, 0, -31 },
  { 5115, 18, 41, 11, -5, -31 },
  { 5208, 23, 31, 21, 0, -31 },
  { 5298, 13, 31, 11, 0, -31 },
  { 5349, 32, 23, 34, 0, -23 },
  { 5441, 21, 23, 23, 0, -23 },
  { 5502, 19, 23, 22, 1, -23 },
  { 5557, 23, 33, 22, -2, -23 },
  { 5652, 21, 33, 22, 1, -23 },
  { 5739, 18, 23, 16, 0, -23 },
  { 5791, 17, 23, 18, 0, -23 },
  { 5840, 14, 27, 15, 2, -27 },
  { 5888, 20, 22, 22, 2, -22 },
  { 5943, 20, 22, 19, 2, -22 },
  { 5998, 29, 22, 30, 3, -22 },
  { 6078, 24, 22, 20, -2, -22 },
  { 6144, 25, 32, 20, -3, -22 },
  { 6244, 19, 22, 17, -1, -22 },
  { 6297, 17, 35, 14, 0, -29 },
  { 6372, 4, 40, 20, 8, -31 },
  { 6392, 16, 35, 14, -2, -29 },
  { 6462, 19, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC41PT7B_H_
