#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x7D, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3E, 0x78, 0xFB, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC8, 0xF0,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xB1, 0x83, 0xE6, 0x00, 0x7C, 0xC0,
  0x0F, 0x98, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x6F, 0xC0, 0x0C, 0xF8,
  0x03, 0x9F, 0x30, 0x77, 0xE7, 0x8D, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x07, 0x80, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F,
  0x03, 0xFF, 0x81, 0xE0, 0x3C, 0xF8, 0x3C, 0x07, 0xCF, 0x83, 0xC0, 0x78,
  0xF8, 0x78, 0x07, 0x8F, 0x8F, 0x00, 0xF8, 0xF0, 0xF0, 0x0F, 0x8F, 0x1E,
  0x00, 0xF0, 0xF3, 0xC0, 0x0F, 0x1F, 0x3C, 0xFC, 0xF1, 0xE7, 0x9F, 0xEF,
  0xFE, 0xF3, 0xFE, 0x7F, 0xCF, 0x7F, 0xF7, 0xF9, 0xE7, 0x8F, 0x3F, 0x3C,
  0xF8, 0xF0, 0x03, 0xCF, 0x0F, 0x00, 0x78, 0xF1, 0xF0, 0x0F, 0x0F, 0x1F,
  0x00, 0xF1, 0xF1, 0xE0, 0x1E, 0x1F, 0x1E, 0x03, 0xC1, 0xF3, 0xE0, 0x3C,
  0x1F, 0x3E, 0x07, 0x81, 0xF7, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF,
  0x81, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x1F, 0xF8,
  0x3E, 0x3F, 0xFC, 0x7E, 0x7F, 0x7C, 0x7C, 0x7E, 0x7E, 0xFC, 0xFC, 0x3F,
  0xF8, 0xFC, 0x3F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFB,
  0xF8, 0x1F, 0xF1, 0xFC, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0xBC, 0xF3, 0xC0,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0x0F, 0x03, 0xC7,
  0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFE, 0x01, 0xFF, 0x03, 0xF3, 0xC0, 0xF9, 0xE0, 0x38, 0xF8, 0x08, 0x3C,
  0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x8F,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE,
  0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0,
  0xFD, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F,
  0xCF, 0x81, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x87, 0xF7, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xF9, 0xF1,
  0xC7, 0xC2, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xC1,
  0xF8, 0x0C, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xF0,
  0x30, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x80, 0x1F, 0x8F, 0x07, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x83, 0xE1,
  0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xB0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0xC0, 0x3F, 0x8F, 0x8F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFC, 0x60, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x7E, 0x03, 0xEF, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0x9F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F,
  0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7C, 0x3F, 0x07, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0x3F, 0x0F, 0xC3, 0xF3,
  0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7,
  0xE1, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xDF, 0xCF,
  0xC3, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xCF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x1F, 0xEF, 0x83, 0xF3, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC3, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x1F, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x3C, 0x7E, 0x30, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x10, 0x0F, 0x1F, 0x07,
  0xFC, 0x78, 0xF0, 0xFF, 0xE3, 0xCF, 0x0F, 0xFF, 0x1E, 0x78, 0x78, 0x78,
  0xF7, 0xC7, 0x87, 0x87, 0xBC, 0x3C, 0x3C, 0x3D, 0xE3, 0xC1, 0xE1, 0xEF,
  0x1E, 0x0F, 0x0F, 0x78, 0xF0, 0xF0, 0xF3, 0x8F, 0x07, 0x87, 0xBC, 0x7C,
  0x7C, 0x79, 0xE3, 0xE3, 0xE3, 0xCF, 0x0F, 0x7F, 0x7C, 0x3C, 0x7F, 0xBF,
  0xE1, 0xE1, 0xF9, 0xFC, 0x0F, 0x07, 0x87, 0xC0, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7C, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F,
  0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE1,
  0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03,
  0xF1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x10, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x04, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x9F,
  0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xC1, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC,
  0x03, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xFF, 0x9F, 0x83, 0xFF,
  0x3F, 0x07, 0xFE, 0x7E, 0x0F, 0xF8, 0xFC, 0x3F, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0xC0, 0x7C, 0x1F,
  0x81, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF0,
  0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x0F, 0x8F, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xF0, 0x7D, 0xE0, 0x7B, 0xE0, 0xFB, 0xC1, 0xF7, 0xC1, 0xF7, 0x83,
  0xDF, 0x83, 0xEF, 0x0F, 0xBE, 0x0F, 0x9E, 0x1E, 0x7C, 0x1F, 0x3C, 0x7C,
  0xF8, 0x3E, 0x7C, 0xF1, 0xF0, 0x7C, 0xFB, 0xE7, 0xE0, 0xF9, 0xF7, 0x8F,
  0x83, 0xE3, 0xFF, 0x1F, 0x07, 0xC7, 0xFC, 0x3E, 0x0F, 0x8F, 0xF8, 0x7C,
  0x1F, 0x0F, 0xE1, 0xF8, 0x3E, 0x1F, 0xC3, 0xE0, 0xF8, 0x3F, 0x07, 0xC1,
  0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00,
  0x07, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x1F, 0xE0,
  0x3F, 0x07, 0xF8, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0xFF, 0x80, 0xF8, 0x3F,
  0xF0, 0x3E, 0x0F, 0x7C, 0x1F, 0x87, 0xDF, 0x07, 0xC1, 0xF7, 0xE1, 0xF0,
  0x7C, 0xF8, 0x7C, 0x1F, 0x3E, 0x1F, 0x07, 0xCF, 0x8F, 0x83, 0xF1, 0xF3,
  0xE0, 0xF8, 0x7C, 0xF8, 0x3E, 0x1F, 0x3E, 0x0F, 0x87, 0xCF, 0x83, 0xE0,
  0xFB, 0xC1, 0xF0, 0x3F, 0xF0, 0x7C, 0x0F, 0xFC, 0x1F, 0x03, 0xFF, 0x07,
  0xC0, 0x7F, 0xC1, 0xF0, 0x1F, 0xE0, 0xF8, 0x07, 0xF8, 0x3E, 0x01, 0xFE,
  0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F,
  0x87, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x1F, 0x81,
  0xFC, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F, 0x87,
  0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x1F, 0x83, 0xF8,
  0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x0F, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3,
  0xF0, 0x7E, 0x1F, 0x07, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x0C,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x88, 0x01, 0xF0, 0xE0, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x7C,
  0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x7E,
  0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x03, 0xCF, 0x80, 0x1E, 0x7C,
  0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x0F, 0xC0,
  0x7E, 0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0xFC, 0xF8, 0x1F, 0xC0,
  0xF8, 0xF8, 0x3F, 0xC0, 0xF8, 0xF8, 0x3F, 0xC1, 0xF8, 0xF8, 0x3F, 0xC1,
  0xF0, 0xF8, 0x7B, 0xC3, 0xF0, 0xF8, 0x7B, 0xC3, 0xE0, 0xF8, 0xFB, 0xC3,
  0xE0, 0xF8, 0xF3, 0xC7, 0xC0, 0xF9, 0xF3, 0xC7, 0xC0, 0xF9, 0xF3, 0xCF,
  0xC0, 0xF9, 0xE3, 0xCF, 0x80, 0xFB, 0xE3, 0xCF, 0x80, 0xFB, 0xC3, 0xDF,
  0x00, 0xF7, 0xC3, 0xDF, 0x00, 0xF7, 0x83, 0xFE, 0x00, 0xF7, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xF8, 0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F,
  0x87, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xE7,
  0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x3E, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x3C, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0xE0,
  0x00, 0x3F, 0x9F, 0x07, 0xFD, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x3F, 0x87, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xDF, 0x01, 0xF9, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC3, 0x00, 0x7D, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x7F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7B, 0xFE, 0x0F, 0x9F, 0xC0, 0x00, 0x78, 0x00, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x10, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x04, 0x3F, 0x0C, 0x1F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xE1, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x03, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF9, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xDF, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F,
  0x7E, 0x0F, 0xDF, 0xBF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x81, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x09, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xE7, 0xC0, 0xFF, 0xBE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE3, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x04, 0x01, 0xF8, 0x38, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC3, 0x00, 0x7D, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0x00, 0xC0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x27, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x04, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x0F,
  0x83, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0x00, 0x07, 0x00, 0x60, 0x1E, 0x7F, 0x0F, 0xE0, 0xFB, 0xFE, 0x7F,
  0xC3, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0xF1, 0xF0,
  0xFC, 0x3F, 0x87, 0xC7, 0xE0, 0xFC, 0x1F, 0x1F, 0x83, 0xF0, 0x7C, 0x7E,
  0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0x3E, 0x3F, 0x07,
  0xE0, 0xF8, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x8F, 0x81, 0xF0,
  0x7E, 0x3E, 0x0F, 0xC1, 0xF1, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F,
  0x1F, 0x03, 0xE0, 0xFC, 0x7C, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x0F, 0x80,
  0x00, 0x07, 0x00, 0x79, 0xFC, 0x0F, 0xBF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0x7C, 0x1F, 0x9F, 0x9F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x9F, 0xC0, 0x3E, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x7F, 0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0x9F, 0x07, 0xFD, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xF8, 0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xDF, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x83, 0xCF, 0x83, 0xEF, 0xC1,
  0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xF8, 0x10, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x80, 0x7C, 0x70, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x23, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0x03,
  0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC3, 0xF8,
  0xFC, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0x78, 0x3F, 0xCF, 0x03, 0xF3, 0xE0,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xC1, 0xF0,
  0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81,
  0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xF8, 0x1F, 0x83, 0xFF, 0x83, 0xF8, 0x3E, 0xF8, 0x3F, 0x83,
  0xE7, 0x83, 0xF8, 0x7E, 0x78, 0x7F, 0x87, 0xC7, 0x87, 0xF8, 0xFC, 0x78,
  0xF7, 0x8F, 0x87, 0x8F, 0x78, 0xF8, 0x78, 0xF7, 0x9F, 0x07, 0x9E, 0x79,
  0xF0, 0x79, 0xE7, 0xBE, 0x07, 0xBE, 0x7B, 0xE0, 0x7B, 0xC7, 0xBE, 0x07,
  0xBC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0xF0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x03,
  0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xC8, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 28, 11, 0, -28 },
  { 43, 14, 10, 17, 4, -28 },
  { 61, 23, 28, 23, 0, -28 },
  { 142, 19, 32, 20, 1, -30 },
  { 218, 28, 28, 31, 2, -28 },
  { 316, 24, 28, 25, 1, -28 },
  { 400, 6, 10, 10, 4, -28 },
  { 408, 14, 34, 12, 1, -28 },
  { 468, 14, 34, 12, -3, -28 },
  { 528, 17, 18, 19, 3, -30 },
  { 567, 18, 19, 21, 2, -23 },
  { 610, 9, 10, 10, -2, -5 },
  { 622, 10, 5, 12, 1, -13 },
  { 629, 7, 6, 10, 0, -6 },
  { 635, 21, 28, 16, -2, -28 },
  { 709, 19, 28, 20, 1, -28 },
  { 776, 14, 28, 20, 4, -28 },
  { 825, 21, 28, 20, -1, -28 },
  { 899, 20, 28, 20, 0, -28 },
  { 969, 20, 28, 20, 0, -28 },
  { 1039, 20, 28, 20, 0, -28 },
  { 1109, 20, 28, 20, 1, -28 },
  { 1179, 21, 28, 20, 1, -28 },
  { 1253, 19, 28, 20, 1, -28 },
  { 1320, 18, 28, 20, 1, -28 },
  { 1383, 10, 22, 11, 0, -22 },
  { 1411, 12, 27, 11, -2, -22 },
  { 1452, 18, 20, 21, 2, -24 },
  { 1497, 18, 12, 21, 2, -20 },
  { 1524, 18, 20, 21, 2, -24 },
  { 1569, 16, 28, 16, 2, -28 },
  { 1625, 29, 31, 30, 1, -28 },
  { 1738, 22, 28, 22, -2, -28 },
  { 1815, 21, 28, 22, 1, -28 },
  { 1889, 21, 28, 21, 2, -28 },
  { 1963, 22, 28, 24, 1, -28 },
  { 2040, 20, 28, 19, 1, -28 },
  { 2110, 20, 28, 19, 1, -28 },
  { 2180, 23, 28, 25, 2, -28 },
  { 2261, 25, 28, 25, 1, -28 },
  { 2349, 17, 28, 14, -1, -28 },
  { 2409, 18, 36, 12, -6, -28 },
  { 2490, 24, 28, 22, 1, -28 },
  { 2574, 15, 28, 18, 1, -28 },
  { 2627, 31, 28, 32, 1, -28 },
  { 2736, 26, 28, 27, 1, -28 },
  { 2827, 23, 28, 26, 2, -28 },
  { 2908, 21, 28, 22, 1, -28 },
  { 2982, 23, 35, 26, 2, -28 },
  { 3083, 20, 28, 22, 1, -28 },
  { 3153, 20, 28, 19, 0, -28 },
  { 3223, 19, 28, 19, 3, -28 },
  { 3290, 23, 28, 24, 2, -28 },
  { 3371, 21, 28, 21, 4, -28 },
  { 3445, 32, 28, 32, 4, -28 },
  { 3557, 26, 28, 21, -2, -28 },
  { 3648, 20, 28, 20, 4, -28 },
  { 3718, 22, 28, 19, -1, -28 },
  { 3795, 16, 34, 12, -1, -28 },
  { 3863, 9, 28, 16, 4, -28 },
  { 3895, 16, 34, 12, -3, -28 },
  { 3963, 19, 18, 20, 0, -28 },
  { 4006, 16, 3, 15, -4, 3 },
  { 4012, 8, 6, 12, 6, -30 },
  { 4018, 20, 22, 21, 1, -22 },
  { 4073, 20, 30, 21, 0, -30 },
  { 4148, 17, 22, 17, 1, -22 },
  { 4195, 22, 30, 21, 1, -30 },
  { 4278, 18, 22, 20, 1, -22 },
  { 4328, 22, 39, 13, -4, -30 },
  { 4436, 21, 31, 21, 0, -22 },
  { 4518, 20, 30, 21, 0, -30 },
  { 4593, 12, 30, 11, 0, -30 },
  { 4638, 17, 39, 11, -5, -30 },
  { 4721, 22, 30, 20, 0, -30 },
  { 4804, 12, 30, 11, 0, -30 },
  { 4849, 30, 22, 32, 0, -22 },
  { 4932, 20, 22, 21, 0, -22 },
  { 4987, 18, 22, 21, 1, -22 },
  { 5037, 22, 31, 21, -2, -22 },
  { 5123, 20, 31, 21, 1, -22 },
  { 5201, 17, 22, 15, 0, -22 },
  { 5248, 17, 22, 17, 0, -22 },
  { 5295, 13, 26, 14, 2, -26 },
  { 5338, 19, 21, 21, 2, -21 },
  { 5388, 19, 21, 18, 2, -21 },
  { 5438, 28, 21, 28, 2, -21 },
  { 5512, 23, 21, 19, -2, -21 },
  { 5573, 24, 30, 19, -3, -21 },
  { 5663, 18, 21, 16, -1, -21 },
  { 5711, 16, 34, 14, 0, -28 },
  { 5779, 4, 39, 19, 7, -30 },
  { 5799, 15, 34, 14, -2, -28 },
  { 5863, 18, 7, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC39PT7B_H_
