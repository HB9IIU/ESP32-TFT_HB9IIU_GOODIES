#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0xB0, 0xFA, 0x3C, 0xA7, 0xCC, 0xF9, 0x47, 0x00, 0x11,
  0xDA, 0xC3, 0x1F, 0xCC, 0x40, 0xE5, 0x53, 0xC6, 0xF2, 0xAB, 0xB3, 0x00,
  0x38, 0xA3, 0x9D, 0xDF, 0x67, 0xC0, 0xE0, 0x36, 0x44, 0xCC, 0xCC, 0x40,
  0x31, 0x11, 0x32, 0x24, 0xC0, 0x2A, 0xFE, 0xA0, 0x21, 0x3E, 0x42, 0x00,
  0x78, 0xE0, 0x70, 0x18, 0x88, 0xC4, 0x62, 0x00, 0x3A, 0x53, 0xBD, 0xE9,
  0xC0, 0x3E, 0xA6, 0x64, 0x40, 0x7A, 0x46, 0x66, 0x63, 0xC0, 0x78, 0x46,
  0xE1, 0xCB, 0xC0, 0x19, 0xCC, 0xAF, 0xFC, 0xC0, 0x3B, 0x18, 0xE1, 0xCB,
  0xC0, 0x3B, 0x15, 0xFD, 0xE9, 0xC0, 0x7C, 0x61, 0x0C, 0x21, 0x8C, 0x00,
  0x7A, 0x5E, 0xED, 0xED, 0xC0, 0x7A, 0x56, 0xF1, 0x0B, 0x80, 0x4C, 0x05,
  0x80, 0x23, 0x00, 0x06, 0xC0, 0x09, 0xB0, 0x60, 0x80, 0xF8, 0x3E, 0xC3,
  0x86, 0xE8, 0x00, 0xE3, 0x6C, 0x88, 0x80, 0x1E, 0x63, 0x5D, 0x65, 0xAA,
  0xB6, 0x40, 0x38, 0x0C, 0x51, 0x49, 0x3D, 0x9C, 0x40, 0x39, 0xB4, 0x9E,
  0x4B, 0x6F, 0x00, 0x3D, 0x84, 0x10, 0xC1, 0x27, 0x80, 0x39, 0xB6, 0xD3,
  0x4F, 0x6F, 0x00, 0x3B, 0x1A, 0xE4, 0x63, 0xC0, 0x3B, 0x18, 0xE4, 0x63,
  0x00, 0x7E, 0x21, 0x79, 0xCB, 0xC0, 0x26, 0xC9, 0x93, 0xE4, 0xD9, 0x32,
  0x00, 0x72, 0x66, 0x44, 0xE0, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0xE0, 0x2D,
  0xA5, 0x1C, 0x53, 0x6D, 0x80, 0x26, 0x64, 0x4C, 0xF0, 0x33, 0x73, 0x57,
  0x57, 0x5A, 0xDA, 0xD6, 0x22, 0xED, 0x52, 0xA5, 0xDB, 0xB3, 0x00, 0x3D,
  0x94, 0x51, 0xCD, 0x37, 0x80, 0x39, 0xB6, 0xDE, 0x43, 0x0C, 0x00, 0x3D,
  0x94, 0x51, 0xCD, 0x37, 0x86, 0x18, 0x3B, 0x5A, 0xF5, 0x6F, 0x60, 0x7A,
  0x18, 0x61, 0x4B, 0xC0, 0xFB, 0x10, 0x84, 0x63, 0x00, 0xCE, 0x77, 0x39,
  0x4B, 0x80, 0x8C, 0xE5, 0x6A, 0x73, 0x00, 0x9B, 0x9A, 0xAA, 0xAE, 0xEC,
  0xCC, 0xC8, 0x36, 0x28, 0x60, 0xC3, 0x8D, 0x33, 0x00, 0x9E, 0xB8, 0xC4,
  0x23, 0x00, 0x78, 0xCC, 0x46, 0x63, 0xC0, 0x74, 0x44, 0x4C, 0x88, 0xC0,
  0xAD, 0x54, 0x31, 0x13, 0x22, 0x22, 0xE0, 0x11, 0x95, 0x90, 0xF0, 0xD0,
  0x23, 0xD3, 0xBD, 0xB8, 0x23, 0x1C, 0xF4, 0xA7, 0x76, 0x1B, 0x91, 0x8C,
  0x38, 0x0C, 0x32, 0x9E, 0x4B, 0x6D, 0x9C, 0x13, 0xD7, 0xEC, 0x38, 0x0C,
  0x63, 0x1E, 0x20, 0x82, 0x18, 0x63, 0x00, 0x23, 0xD3, 0xBD, 0xB8, 0x5E,
  0x23, 0x1C, 0xF4, 0xAF, 0x7A, 0x2C, 0xA4, 0xB6, 0x13, 0x12, 0x22, 0x66,
  0x4C, 0x21, 0x86, 0x56, 0x71, 0xCD, 0x36, 0x2D, 0xA4, 0xB6, 0x12, 0x7F,
  0x4B, 0x5B, 0xDA, 0xD2, 0x13, 0xD2, 0xBD, 0xE8, 0x13, 0xD3, 0xBD, 0xB8,
  0x13, 0xD2, 0x9D, 0xFA, 0x10, 0x23, 0xD3, 0xBD, 0xB8, 0x46, 0x17, 0x44,
  0xCC, 0x27, 0x47, 0x3E, 0x26, 0xF4, 0x4C, 0x60, 0x6A, 0x57, 0xB7, 0x00,
  0xBA, 0xEC, 0xC0, 0xB7, 0x6B, 0x66, 0xC9, 0x80, 0x2C, 0xE3, 0x0E, 0xC8,
  0x2C, 0xA3, 0x8C, 0x30, 0x8E, 0x00, 0x72, 0x6C, 0xF0, 0x32, 0x26, 0xC4,
  0x44, 0x40, 0xFF, 0xC0, 0x31, 0x33, 0x32, 0x2E, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 4, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 7, 7, 8, 1, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 2, 3, 1, -7 },
  { 31, 4, 9, 3, 0, -7 },
  { 36, 4, 9, 3, -1, -7 },
  { 41, 4, 5, 5, 1, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 5, 7, 4, 0, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 4, 7, 5, 1, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 6, 7, 5, 0, -7 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 3, 6, 3, 0, -6 },
  { 109, 4, 7, 3, -1, -6 },
  { 113, 5, 5, 5, 0, -6 },
  { 117, 5, 3, 5, 0, -5 },
  { 119, 5, 5, 5, 0, -6 },
  { 123, 4, 7, 4, 1, -7 },
  { 127, 8, 8, 8, 0, -7 },
  { 135, 6, 7, 6, -1, -7 },
  { 141, 6, 7, 6, 0, -7 },
  { 147, 6, 7, 5, 0, -7 },
  { 153, 6, 7, 6, 0, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 5, 7, 6, 1, -7 },
  { 174, 7, 7, 6, 0, -7 },
  { 181, 4, 7, 4, 0, -7 },
  { 185, 5, 9, 3, -2, -7 },
  { 191, 6, 7, 6, 0, -7 },
  { 197, 4, 7, 5, 0, -7 },
  { 201, 8, 7, 8, 0, -7 },
  { 208, 7, 7, 7, 0, -7 },
  { 215, 6, 7, 7, 0, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 6, 9, 7, 0, -7 },
  { 234, 5, 7, 6, 0, -7 },
  { 239, 5, 7, 5, 0, -7 },
  { 244, 5, 7, 5, 1, -7 },
  { 249, 5, 7, 6, 1, -7 },
  { 254, 5, 7, 5, 1, -7 },
  { 259, 8, 7, 8, 1, -7 },
  { 266, 7, 7, 5, -1, -7 },
  { 273, 5, 7, 5, 1, -7 },
  { 278, 5, 7, 5, 0, -7 },
  { 283, 4, 9, 3, 0, -7 },
  { 288, 2, 7, 4, 1, -7 },
  { 290, 4, 9, 3, -1, -7 },
  { 295, 5, 4, 5, 0, -7 },
  { 298, 4, 1, 4, -1, 1 },
  { 299, 2, 2, 3, 1, -8 },
  { 300, 5, 6, 5, 0, -6 },
  { 304, 5, 8, 5, 0, -8 },
  { 309, 5, 6, 4, 0, -6 },
  { 313, 6, 8, 5, 0, -8 },
  { 319, 5, 6, 5, 0, -6 },
  { 323, 6, 10, 3, -1, -8 },
  { 331, 5, 8, 5, 0, -6 },
  { 336, 5, 8, 6, 0, -8 },
  { 341, 3, 8, 3, 0, -8 },
  { 344, 4, 10, 3, -1, -8 },
  { 349, 6, 8, 5, 0, -8 },
  { 355, 3, 8, 3, 0, -8 },
  { 358, 8, 6, 8, 0, -6 },
  { 364, 5, 6, 6, 0, -6 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 5, 8, 5, 0, -6 },
  { 377, 5, 8, 5, 0, -6 },
  { 382, 4, 6, 4, 0, -6 },
  { 385, 4, 6, 4, 0, -6 },
  { 388, 4, 7, 4, 0, -7 },
  { 392, 5, 5, 5, 0, -5 },
  { 396, 4, 5, 5, 1, -5 },
  { 399, 7, 5, 7, 1, -5 },
  { 404, 6, 5, 5, -1, -5 },
  { 408, 6, 7, 5, -1, -5 },
  { 414, 4, 5, 4, 0, -5 },
  { 417, 4, 9, 3, 0, -7 },
  { 422, 1, 10, 5, 2, -8 },
  { 424, 4, 9, 3, -1, -7 },
  { 429, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC10PT7B_H_
