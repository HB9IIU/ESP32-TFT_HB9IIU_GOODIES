#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF9, 0xE1, 0xE0, 0x0F, 0xF8,
  0xF0, 0x20, 0x07, 0xF8, 0x70, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x03, 0xFE,
  0x3C, 0x00, 0x01, 0xFF, 0x9E, 0x00, 0x00, 0xFF, 0xCF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xCF, 0xFC, 0x00, 0x01, 0xE7, 0xFE, 0x00, 0x00, 0xE3, 0xFF,
  0x00, 0x00, 0xF1, 0xFF, 0x04, 0x00, 0x78, 0xFF, 0x83, 0x80, 0x3C, 0x7F,
  0xC3, 0xF0, 0x1E, 0x7F, 0xE1, 0xFF, 0x8E, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0xC3,
  0xFC, 0xFF, 0x1F, 0xFF, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0xFE, 0x7F, 0xBF,
  0xE7, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0x8F, 0xF7, 0xF9, 0xFF, 0xF8, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0xE3,
  0xFC, 0x7F, 0x0F, 0xF1, 0xFF, 0x87, 0xF1, 0xFE, 0x1F, 0xE0, 0x78, 0x1F,
  0xC3, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x7F, 0x80, 0x00, 0xFE,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xDF, 0xF8, 0x7F, 0xC1,
  0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF3, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x87,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F,
  0xA0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x40, 0x1F, 0xC0, 0x03, 0x00, 0xFE, 0x00, 0x3E,
  0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xF9, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1E, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFD,
  0xFC, 0x00, 0x7F, 0xE7, 0xF0, 0x07, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0x01, 0xFE, 0x00,
  0x18, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x0F, 0xC7, 0xFC, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xCF, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFD,
  0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x7F,
  0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xF7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x3F, 0x8F, 0xF8, 0x1F, 0x0F, 0xF8, 0x1C, 0x0F, 0xF8,
  0x08, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xF0,
  0x1F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x3F, 0xF0, 0x01,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x07,
  0xFF, 0x80, 0x1E, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC2, 0x00, 0x00, 0xFF, 0xE1, 0xC0, 0x00, 0xFF, 0xE0, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFA, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x78, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x04, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x07, 0xFF, 0x81,
  0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x1C, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xF8, 0x03,
  0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF1,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF1,
  0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F,
  0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC,
  0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0x7F, 0xC0, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xF3, 0xFE, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xC7, 0x80, 0x3F,
  0xF0, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x81, 0xF8, 0x1F, 0xC0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0,
  0x3F, 0xE0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0xFC,
  0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x9F,
  0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xCF, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xE7,
  0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF3,
  0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF1, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xC3, 0xFC,
  0x3F, 0x81, 0xFE, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xFD, 0xFF, 0xFC,
  0x07, 0xE0, 0x7F, 0xFE, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC,
  0x01, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x78, 0x03, 0xFF,
  0xC0, 0x01, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x20, 0x03, 0xFF, 0xC0, 0x0E,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0x0F, 0xFC,
  0x03, 0xFF, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0C, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xE0,
  0x03, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFE,
  0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0x00,
  0x3F, 0xCF, 0xE0, 0x0F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xF3, 0xF8, 0x0F,
  0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x3F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xF0,
  0x03, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFD, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFB, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE1, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xF1, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x40, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x10, 0x00, 0x0F,
  0xFC, 0x07, 0x00, 0x07, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x3F, 0x81,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF3,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFE, 0x3F, 0x87, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0xFE,
  0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x03, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x3F, 0xBF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFF,
  0xC7, 0xF8, 0x03, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xE7,
  0xF8, 0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xF0, 0x01, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0xFE,
  0x00, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xC0, 0xFF, 0xE0,
  0x08, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x20, 0x7F, 0xE0, 0x0C, 0x07, 0xFF, 0x03, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1C, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xEF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xE0, 0x01, 0xFF,
  0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0xC1, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x01,
  0xFF, 0x8F, 0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x81, 0xFF, 0x80, 0x1E, 0x07, 0xFF, 0xC3,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x08, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x04, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xE0,
  0x03, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xF0, 0x00,
  0x7F, 0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0C,
  0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x1E, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xF8, 0x01, 0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x08, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0x00,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x80,
  0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x3F, 0x8F, 0xFF,
  0xC0, 0x3F, 0xCF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x00,
  0x3F, 0x9F, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xFF, 0xE0, 0x03, 0xFE,
  0x7F, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x0F, 0xFC, 0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xC0,
  0x0F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xF7, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xF0, 0x07,
  0xFF, 0xCF, 0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x07, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0xF0, 0x3F, 0xCF, 0xFC, 0x07,
  0xFB, 0xFF, 0x80, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x70, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF1, 0xFC, 0x0F, 0xFC, 0x03, 0xC0, 0xFF, 0xC0, 0x08, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x1F,
  0xF0, 0xC0, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x10, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF,
  0x3F, 0xC0, 0x3F, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0x0F, 0xE0, 0x03, 0xFF,
  0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xDF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xEF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xF7, 0xE0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xBF, 0x83,
  0xFE, 0x0F, 0xF8, 0x7F, 0x7F, 0x07, 0xFC, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE3, 0xF9, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xF3, 0xF8, 0x7F,
  0x80, 0xFF, 0x9F, 0xE7, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x1F, 0xCF, 0xF8, 0x03, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0,
  0x07, 0xF3, 0xF8, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0xFE, 0xFF, 0x80,
  0x1F, 0xDF, 0xC1, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x83, 0xFB, 0xFC, 0x00,
  0x7F, 0x7E, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x7F, 0xF0, 0x00,
  0x17, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC8, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 20, 48, 18, 0, -47 },
  { 121, 24, 17, 29, 6, -47 },
  { 172, 38, 47, 39, 1, -47 },
  { 396, 33, 54, 33, 1, -50 },
  { 619, 47, 49, 53, 4, -48 },
  { 907, 41, 49, 42, 1, -48 },
  { 1159, 12, 17, 17, 6, -47 },
  { 1185, 24, 57, 21, 2, -47 },
  { 1356, 24, 58, 21, -5, -48 },
  { 1530, 29, 31, 33, 5, -51 },
  { 1643, 30, 32, 35, 3, -39 },
  { 1763, 15, 17, 18, -3, -8 },
  { 1795, 18, 8, 20, 1, -22 },
  { 1813, 11, 11, 18, 0, -10 },
  { 1829, 35, 48, 27, -3, -48 },
  { 2039, 31, 49, 33, 2, -48 },
  { 2229, 24, 47, 34, 6, -47 },
  { 2370, 35, 48, 33, -2, -48 },
  { 2580, 33, 49, 33, 0, -48 },
  { 2783, 34, 47, 34, -1, -47 },
  { 2983, 33, 48, 33, 1, -47 },
  { 3181, 33, 49, 33, 2, -48 },
  { 3384, 35, 47, 33, 2, -47 },
  { 3590, 33, 49, 33, 1, -48 },
  { 3793, 31, 49, 33, 2, -48 },
  { 3983, 17, 38, 18, 0, -37 },
  { 4064, 21, 46, 18, -4, -37 },
  { 4185, 30, 34, 35, 3, -41 },
  { 4313, 30, 20, 35, 3, -33 },
  { 4388, 30, 34, 35, 3, -41 },
  { 4516, 26, 49, 27, 4, -48 },
  { 4676, 49, 53, 51, 2, -47 },
  { 5001, 38, 47, 38, -4, -47 },
  { 5225, 36, 47, 37, 1, -47 },
  { 5437, 36, 49, 36, 3, -48 },
  { 5658, 38, 47, 41, 1, -47 },
  { 5882, 34, 47, 32, 1, -47 },
  { 6082, 34, 47, 32, 1, -47 },
  { 6282, 39, 49, 42, 3, -48 },
  { 6521, 42, 47, 42, 1, -47 },
  { 6768, 30, 47, 24, -2, -47 },
  { 6945, 31, 61, 20, -10, -47 },
  { 7182, 42, 47, 37, 1, -47 },
  { 7429, 26, 47, 31, 1, -47 },
  { 7582, 54, 47, 54, 1, -47 },
  { 7900, 45, 47, 45, 1, -47 },
  { 8165, 39, 49, 44, 3, -48 },
  { 8404, 37, 47, 37, 1, -47 },
  { 8622, 39, 59, 44, 3, -48 },
  { 8910, 35, 47, 37, 1, -47 },
  { 9116, 34, 49, 32, 0, -48 },
  { 9325, 32, 47, 32, 5, -47 },
  { 9513, 39, 48, 41, 4, -47 },
  { 9747, 36, 47, 36, 6, -47 },
  { 9959, 54, 47, 54, 6, -47 },
  { 10277, 45, 47, 36, -4, -47 },
  { 10542, 34, 47, 34, 6, -47 },
  { 10742, 38, 47, 32, -2, -47 },
  { 10966, 27, 57, 21, -2, -47 },
  { 11159, 15, 48, 27, 7, -48 },
  { 11249, 27, 57, 21, -5, -47 },
  { 11442, 32, 30, 34, 1, -47 },
  { 11562, 25, 4, 25, -6, 6 },
  { 11575, 13, 11, 21, 10, -51 },
  { 11593, 34, 38, 36, 2, -37 },
  { 11755, 33, 51, 36, 1, -50 },
  { 11966, 28, 38, 29, 2, -37 },
  { 12099, 36, 51, 36, 2, -50 },
  { 12329, 30, 38, 34, 2, -37 },
  { 12472, 37, 66, 22, -7, -50 },
  { 12778, 36, 53, 36, 0, -37 },
  { 13017, 33, 50, 36, 1, -50 },
  { 13224, 19, 50, 18, 1, -50 },
  { 13343, 28, 66, 18, -8, -50 },
  { 13574, 36, 50, 34, 1, -50 },
  { 13799, 20, 50, 18, 1, -50 },
  { 13924, 50, 37, 54, 1, -37 },
  { 14156, 33, 37, 36, 1, -37 },
  { 14309, 31, 38, 35, 2, -37 },
  { 14457, 37, 53, 36, -3, -37 },
  { 14703, 33, 53, 36, 2, -37 },
  { 14922, 27, 37, 25, 1, -37 },
  { 15047, 28, 38, 29, 0, -37 },
  { 15180, 23, 45, 24, 3, -44 },
  { 15310, 33, 37, 36, 3, -36 },
  { 15463, 31, 36, 31, 4, -36 },
  { 15603, 47, 36, 48, 4, -36 },
  { 15815, 38, 36, 32, -3, -36 },
  { 15986, 40, 52, 31, -5, -36 },
  { 16246, 31, 36, 28, -2, -36 },
  { 16386, 27, 57, 23, 0, -47 },
  { 16579, 7, 65, 32, 12, -50 },
  { 16636, 27, 57, 23, -4, -47 },
  { 16829, 30, 11, 35, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC66PT7B_H_
