#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1, 0xFE,
  0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F,
  0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0xF3, 0xE0, 0x1F, 0xF3, 0xC1, 0x80,
  0x7F, 0x8E, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x1F,
  0xE7, 0x80, 0x00, 0x7F, 0xDE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1D, 0xFF, 0x80,
  0x00, 0x73, 0xFE, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x0F, 0x3F, 0xE2, 0x00,
  0x38, 0xFF, 0x8E, 0x00, 0xE3, 0xFC, 0x3E, 0x07, 0x9F, 0xF0, 0xFF, 0x9F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x07,
  0xE0, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC1,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x3F, 0x8F, 0xFE, 0x7F, 0x1F, 0xC7, 0xE3, 0xFF, 0xE7, 0xF7,
  0xF9, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0xDF, 0xFF, 0x8F,
  0xC7, 0xFF, 0xF9, 0xFF, 0xF3, 0xF9, 0xFC, 0x7F, 0x3F, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE1, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0x83, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x9F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xF0, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC0,
  0x7F, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x08, 0x07, 0xF0,
  0x03, 0x81, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xF7,
  0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x81,
  0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0x80, 0x3F, 0xE7,
  0xE0, 0x1F, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3E, 0x0F, 0xE0, 0x07,
  0x03, 0xFC, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x8F, 0xF7,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFE, 0xFE, 0x3F, 0xF7,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x83, 0xC3, 0xFE, 0x06, 0x0F, 0xF0,
  0x10, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x30, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3E, 0x03,
  0xFF, 0x00, 0x60, 0x07, 0xFC, 0x01, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x88, 0x00, 0x07, 0xFC, 0x3C, 0x00, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x83, 0x00, 0x03, 0xFF, 0x07, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0x9F,
  0xF8, 0x03, 0xFC, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFD,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3,
  0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFB, 0xFC, 0x0F, 0xFF, 0xBF, 0xC0, 0x7F, 0xE7, 0xFC, 0x01, 0xF8, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x80, 0x1F, 0xF8, 0x0F, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0x01, 0xFF, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x0E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xFF,
  0x83, 0xF0, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0x0F, 0xC0, 0x7F, 0xFF, 0xC3,
  0xF1, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x1F, 0x81, 0xFF, 0x3F, 0x83, 0xF3,
  0xF8, 0x3F, 0xC1, 0xF8, 0x3F, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF3, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE,
  0x03, 0xF0, 0x3F, 0x7E, 0x0F, 0xC0, 0x7F, 0x03, 0xF7, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x7E, 0x1F, 0xC0, 0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xE0,
  0x7E, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xEF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC,
  0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0xFC,
  0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xC1, 0xFE, 0xFF, 0xEF, 0xF0, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF, 0xC0, 0x7E, 0x07, 0xFE,
  0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x00, 0x60, 0x07,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x01, 0xFF,
  0xC0, 0x06, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x30, 0x07, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xE3, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x60, 0x1F, 0xFC, 0x00, 0x04, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x1F,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x03, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x7F, 0xBF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07,
  0xF7, 0xF0, 0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x03,
  0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x1F, 0x81, 0xFC, 0xFF, 0x00,
  0x7F, 0x8F, 0xC0, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xE0, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE3, 0xF0, 0x7F, 0x1F, 0xE0, 0x0F, 0xF1, 0xF8, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFC, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7E, 0x3F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xDF, 0xC1, 0xFE,
  0x00, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xFF, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0xF0, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F,
  0xE0, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x07,
  0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xDF,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF0, 0x07, 0xF3, 0xFC, 0x07,
  0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x07,
  0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0x07,
  0xF9, 0xFC, 0x01, 0xFE, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x03,
  0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x07, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x30, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x01, 0xFF, 0x01,
  0xC0, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0,
  0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x81, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F,
  0xC0, 0x3F, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFE, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0xBF, 0x83, 0xFC,
  0x01, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF3, 0xF8, 0x7F,
  0x80, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x3F, 0x8F,
  0xF0, 0x01, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x03,
  0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF8,
  0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x1F, 0xC0,
  0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0x1F, 0xC0,
  0x0F, 0xF8, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0xFF, 0x7F, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0,
  0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xF0, 0x07, 0xF3,
  0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0,
  0x18, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x08, 0x3F, 0xF0, 0x0C, 0x07,
  0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFB, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xEF, 0xE0, 0x01, 0xFF, 0xE7, 0xF0, 0x00, 0x7F, 0xC3, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC,
  0xFF, 0x83, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x81, 0xFF, 0x80, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xFC, 0x7F, 0x00, 0x7F,
  0xFC, 0x7F, 0x00, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0x7F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x01,
  0xFF, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0xFF, 0x7F, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE3, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0x9F, 0xFF, 0x1F, 0xFF, 0x00, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFE, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC3, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE3, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0x00,
  0xFE, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE3, 0xFF, 0x80,
  0x03, 0xF9, 0xFF, 0xE0, 0x00, 0xFE, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xF8, 0x00, 0xFF,
  0x7F, 0xFC, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07,
  0xFC, 0x0C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F,
  0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFE,
  0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x1F, 0xCF, 0xF8, 0x07, 0xF7, 0xFE, 0x01, 0xFD, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xC1, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xF0, 0x3F, 0xE0, 0x18, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x80, 0x07, 0xFC, 0x38, 0x01, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x60,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFF,
  0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0x01, 0xFF, 0xF3, 0xF8, 0x07, 0xFF,
  0x1F, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFB,
  0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFB, 0xFC, 0x07, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF9, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xC7,
  0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xFF, 0x81, 0xFE, 0x1F, 0xC1,
  0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x7E, 0x0F, 0xF0, 0x7F, 0x07, 0xEF,
  0xC3, 0xFC, 0x0F, 0xE1, 0xFD, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x3F, 0x0F,
  0xF0, 0x3F, 0x8F, 0xE7, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0xFC, 0x7F, 0x80,
  0xFE, 0x3F, 0x1F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE3, 0xF3, 0xFC, 0x03, 0xF9,
  0xF8, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x0F, 0xDF, 0xE0, 0x0F, 0xEF, 0xC1,
  0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x90, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 18, 44, 16, 0, -43 },
  { 100, 21, 16, 26, 6, -43 },
  { 142, 35, 43, 35, 1, -43 },
  { 331, 30, 49, 30, 1, -46 },
  { 515, 43, 44, 48, 3, -43 },
  { 752, 37, 44, 38, 1, -43 },
  { 956, 10, 16, 15, 6, -43 },
  { 976, 21, 52, 19, 2, -43 },
  { 1113, 21, 53, 19, -4, -44 },
  { 1253, 26, 28, 30, 5, -46 },
  { 1344, 27, 29, 32, 3, -36 },
  { 1442, 14, 15, 16, -3, -7 },
  { 1469, 16, 8, 19, 1, -20 },
  { 1485, 10, 10, 16, 0, -9 },
  { 1498, 32, 43, 24, -3, -43 },
  { 1670, 28, 45, 30, 2, -44 },
  { 1828, 22, 43, 30, 6, -43 },
  { 1947, 32, 43, 30, -2, -43 },
  { 2119, 30, 44, 30, 0, -43 },
  { 2284, 31, 43, 30, -1, -43 },
  { 2451, 31, 44, 30, 0, -43 },
  { 2622, 30, 45, 30, 2, -44 },
  { 2791, 31, 43, 30, 2, -43 },
  { 2958, 30, 45, 30, 1, -44 },
  { 3127, 28, 45, 30, 2, -44 },
  { 3285, 16, 34, 16, 0, -33 },
  { 3353, 19, 41, 16, -3, -33 },
  { 3451, 27, 31, 32, 3, -37 },
  { 3556, 27, 18, 32, 3, -30 },
  { 3617, 27, 31, 32, 3, -37 },
  { 3722, 24, 44, 25, 3, -43 },
  { 3854, 44, 48, 47, 2, -43 },
  { 4118, 35, 43, 34, -4, -43 },
  { 4307, 33, 43, 34, 1, -43 },
  { 4485, 33, 45, 33, 3, -44 },
  { 4671, 35, 43, 37, 1, -43 },
  { 4860, 31, 43, 29, 1, -43 },
  { 5027, 31, 43, 29, 1, -43 },
  { 5194, 35, 45, 38, 3, -44 },
  { 5391, 38, 43, 38, 1, -43 },
  { 5596, 27, 43, 22, -2, -43 },
  { 5742, 28, 56, 18, -9, -43 },
  { 5938, 38, 43, 33, 1, -43 },
  { 6143, 23, 43, 28, 1, -43 },
  { 6267, 49, 43, 49, 1, -43 },
  { 6531, 41, 43, 41, 1, -43 },
  { 6752, 35, 45, 40, 3, -44 },
  { 6949, 33, 43, 33, 1, -43 },
  { 7127, 35, 54, 40, 3, -44 },
  { 7364, 32, 43, 34, 1, -43 },
  { 7536, 31, 44, 29, 0, -43 },
  { 7707, 28, 43, 29, 5, -43 },
  { 7858, 36, 44, 38, 3, -43 },
  { 8056, 33, 43, 33, 5, -43 },
  { 8234, 50, 43, 49, 5, -43 },
  { 8503, 40, 43, 33, -3, -43 },
  { 8718, 31, 43, 31, 5, -43 },
  { 8885, 34, 43, 29, -2, -43 },
  { 9068, 25, 52, 19, -2, -43 },
  { 9231, 14, 43, 24, 6, -43 },
  { 9307, 24, 52, 19, -4, -43 },
  { 9463, 29, 27, 30, 1, -43 },
  { 9561, 24, 4, 22, -6, 5 },
  { 9573, 12, 10, 19, 9, -46 },
  { 9588, 30, 34, 33, 2, -33 },
  { 9716, 31, 47, 33, 0, -46 },
  { 9899, 26, 34, 26, 2, -33 },
  { 10010, 33, 47, 33, 2, -46 },
  { 10204, 27, 34, 30, 2, -33 },
  { 10319, 34, 60, 20, -7, -46 },
  { 10574, 32, 47, 33, 0, -33 },
  { 10762, 30, 46, 33, 1, -46 },
  { 10935, 18, 46, 16, 0, -46 },
  { 11039, 26, 60, 16, -8, -46 },
  { 11234, 33, 46, 31, 1, -46 },
  { 11424, 19, 46, 16, 0, -46 },
  { 11534, 46, 33, 49, 1, -33 },
  { 11724, 30, 33, 33, 1, -33 },
  { 11848, 28, 34, 32, 2, -33 },
  { 11967, 34, 47, 33, -3, -33 },
  { 12167, 30, 47, 33, 2, -33 },
  { 12344, 26, 33, 23, 0, -33 },
  { 12452, 26, 34, 26, 0, -33 },
  { 12563, 20, 41, 22, 3, -40 },
  { 12666, 29, 34, 33, 3, -33 },
  { 12790, 29, 33, 28, 3, -33 },
  { 12910, 43, 33, 43, 4, -33 },
  { 13088, 35, 33, 29, -3, -33 },
  { 13233, 36, 47, 29, -4, -33 },
  { 13445, 28, 33, 25, -2, -33 },
  { 13561, 25, 52, 21, 0, -43 },
  { 13724, 7, 60, 29, 11, -46 },
  { 13777, 24, 52, 21, -3, -43 },
  { 13933, 27, 10, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC60PT7B_H_
