#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x07,
  0x83, 0xE0, 0xF8, 0x1E, 0x00, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xEF, 0x3D,
  0xE7, 0xB8, 0xE7, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x9C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9E, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0xF3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0x80, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E,
  0x62, 0x1E, 0x40, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xBC, 0x81, 0x3C, 0x63, 0x7C, 0x7F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x1F, 0x00, 0xF0, 0xFE, 0x07, 0x87, 0xFC, 0x1C, 0x1C, 0xF0, 0xE0,
  0xF3, 0xC7, 0x83, 0xCF, 0x1C, 0x0E, 0x3C, 0xE0, 0x38, 0xE7, 0x80, 0xE7,
  0x9C, 0x63, 0x9E, 0xE7, 0xEF, 0xF7, 0xBF, 0xBF, 0x9D, 0xEF, 0x7C, 0xE7,
  0x3C, 0x07, 0xBC, 0xF0, 0x1C, 0xF3, 0xC0, 0xE3, 0x8F, 0x07, 0x8E, 0x38,
  0x1C, 0x38, 0xE0, 0xE0, 0xE7, 0x87, 0x83, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0,
  0x1F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x0F, 0x9F, 0xE1, 0xE7, 0xFE, 0x7C, 0xF3, 0xEF, 0x3E,
  0x7F, 0xC7, 0x87, 0xF8, 0xF0, 0x7E, 0x1E, 0x0F, 0x83, 0xF7, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0x00, 0x7B, 0xDE, 0xEF, 0x7B, 0x9C,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x01, 0xE0, 0x78, 0x00, 0x02, 0x40, 0x1C, 0x00, 0xE0, 0x8F, 0x0F,
  0x70, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0x1F, 0xF9, 0xFC, 0x1E, 0xE1, 0xF7,
  0x83, 0x1E, 0x08, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0xDF, 0xDF, 0xE0, 0x33, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xE3, 0xE3, 0xC7, 0x87, 0xDF, 0x0F, 0xBE,
  0x1F, 0x78, 0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC1, 0xEF, 0x07, 0xDE, 0x0F,
  0xBC, 0x1E, 0x78, 0x7C, 0xF0, 0xF9, 0xE3, 0xE3, 0xEF, 0xC3, 0xFF, 0x07,
  0xFC, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xF7, 0xFD, 0xFF,
  0x9C, 0xF3, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xE0, 0x60, 0xF8, 0x20, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0x3F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x80, 0x7C, 0xF3, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0x3C,
  0x0E, 0x7C, 0x1E, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x70, 0x78, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x80, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x7E, 0x11, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7B, 0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xF3, 0xEF, 0x87, 0xDF, 0x0F,
  0xBE, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xF1, 0xF1, 0xF7, 0xC3, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F,
  0x1F, 0x1F, 0x0F, 0x3E, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x7C, 0x7C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0x78, 0x3C,
  0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xE1,
  0xFF, 0xCF, 0x9F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x7D,
  0xE1, 0xF7, 0xDF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x8C, 0x7E, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x0F,
  0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x78, 0xF8, 0xF8, 0xF8, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0xF8,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x7E, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x3F, 0xC7, 0xFE, 0x7F, 0xF7, 0x1F, 0x40, 0xF0, 0x0F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3C, 0x01, 0xE0, 0xF0,
  0x01, 0xC3, 0xC0, 0x03, 0xCF, 0x0F, 0xF3, 0x9C, 0x3F, 0xC7, 0x78, 0xF3,
  0x8E, 0xE3, 0x87, 0x1D, 0xC7, 0x1E, 0x3F, 0x9C, 0x38, 0xFE, 0x38, 0x71,
  0xDC, 0x70, 0xE3, 0xB8, 0xE3, 0xCF, 0x71, 0xCF, 0x9C, 0xE3, 0xFF, 0xF1,
  0xE7, 0xEF, 0xC1, 0xC3, 0x86, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x60, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0x81, 0xE3, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x01,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x1F, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0,
  0x7C, 0x3C, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFB, 0xC3,
  0xF0, 0x21, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F,
  0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8,
  0xF0, 0x3E, 0x3C, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xBC, 0x3F, 0x01, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xF3, 0xC3, 0xFC, 0xF0,
  0xFF, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xC0,
  0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF0,
  0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x83,
  0xC0, 0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0,
  0x78, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x9F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x02, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x07, 0x87, 0xC0, 0xF8,
  0xF8, 0x0F, 0x8F, 0x00, 0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x1F,
  0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0xFE, 0xFF, 0xE7, 0xFF, 0x7F, 0xF8, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3B, 0x83, 0xFC,
  0x1E, 0xE1, 0xEF, 0x07, 0xB8, 0x7B, 0xC1, 0xEE, 0x3D, 0xE0, 0x7B, 0x8F,
  0x78, 0x3C, 0xF7, 0x9E, 0x0F, 0x3D, 0xE7, 0x83, 0xCF, 0x73, 0xE0, 0xF3,
  0xFC, 0xF0, 0x3C, 0xFE, 0x3C, 0x1E, 0x3F, 0x8F, 0x07, 0x8F, 0xC3, 0xC1,
  0xE3, 0xF1, 0xE0, 0x78, 0x78, 0x78, 0x3E, 0x1E, 0x1E, 0x00, 0x07, 0xC0,
  0x3C, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x83, 0xF8, 0x1E, 0x0F, 0xE0, 0x78,
  0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x03, 0xBC, 0x3C, 0x1E, 0xF0, 0xF0, 0x79,
  0xE3, 0xC1, 0xE7, 0x9E, 0x07, 0x9E, 0x78, 0x3E, 0x3D, 0xE0, 0xF0, 0xF7,
  0x83, 0xC3, 0xDE, 0x0F, 0x0F, 0x70, 0x3C, 0x1F, 0xC1, 0xE0, 0x7F, 0x07,
  0x81, 0xFC, 0x1E, 0x07, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x7E, 0x3F, 0x0F, 0x8F, 0x81,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87,
  0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0xC3, 0xE1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x7E,
  0x3F, 0x0F, 0x8F, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x7C, 0xF0, 0x1F, 0x3E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xF7,
  0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x8F, 0x87, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xF7, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0xC7, 0x83,
  0xE7, 0xC0, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xDE, 0x1F,
  0x02, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0xC0, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x78,
  0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07,
  0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E, 0x1F, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC,
  0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x07, 0x3E, 0x03, 0xDE,
  0x01, 0xFF, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x07,
  0xFC, 0x1F, 0x03, 0xDE, 0x0F, 0x83, 0xEF, 0x07, 0xC1, 0xE7, 0x87, 0xE0,
  0xF3, 0xC3, 0xF0, 0xF9, 0xE3, 0xF8, 0x78, 0xF1, 0xDC, 0x7C, 0x79, 0xEE,
  0x3C, 0x3C, 0xF7, 0x1E, 0x1E, 0x73, 0x9E, 0x0F, 0x79, 0xCF, 0x07, 0xB8,
  0xEF, 0x83, 0xFC, 0x77, 0x81, 0xFE, 0x3B, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x07,
  0xC7, 0xC0, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF8, 0x7C, 0x07,
  0xC0, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF0, 0x79, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xF0, 0xE1, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x3C, 0x78,
  0xF1, 0xE3, 0xC0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xCE,
  0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x38, 0xF0, 0x71, 0xC0, 0xF7, 0x80, 0xFE,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF1, 0xE1, 0xE0, 0x07, 0xCF,
  0x0F, 0xEE, 0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x3E, 0x7C, 0x3E, 0x78, 0x3C,
  0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0x70, 0x3E, 0x70, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x7C,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x9F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x7E, 0x7C, 0x7F, 0xF8, 0x77, 0xF0, 0xF3, 0xE0, 0x07, 0xF8, 0x7F, 0xC7,
  0xFC, 0x7E, 0x63, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x82, 0x7E, 0x71, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87,
  0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C,
  0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xFF, 0xC1, 0xFD,
  0xC0, 0x7C, 0xE0, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x3C, 0x3D,
  0xF0, 0xF7, 0x87, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x02, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x17, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x03, 0xE7, 0x83, 0xFB, 0x83, 0xFF, 0xC3, 0xF7, 0xE1,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x0F, 0x87, 0x87, 0xC7, 0xC3, 0xE7, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x0C, 0x1F, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x7C, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xBF, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x78, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x70,
  0x00, 0x00, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x78,
  0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x00, 0x10, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC1, 0x3E, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x3F, 0x0F, 0x1F, 0x07, 0xC7, 0x81, 0xE3,
  0xC0, 0x79, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0x78, 0xF8, 0x1E,
  0x1E, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0x0E, 0x7C, 0x3E, 0x0E, 0xFE, 0xFF, 0x1F, 0xFE, 0xFF, 0x1F, 0xFF, 0xDF,
  0x1F, 0x1F, 0x8F, 0x1E, 0x1F, 0x0F, 0x3E, 0x1F, 0x0F, 0x3E, 0x1E, 0x1F,
  0x3C, 0x1E, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x3C, 0x1E, 0x7C, 0x3C, 0x1E,
  0x7C, 0x3C, 0x3E, 0x78, 0x3C, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x78, 0x3C,
  0xF8, 0x78, 0x7C, 0x0E, 0x7C, 0x0E, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8,
  0x78, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xDF, 0x7C, 0x3D, 0xF0, 0xF7,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0xFB,
  0xE7, 0xE7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0x3E, 0x03, 0xBF, 0x83,
  0xFF, 0xC1, 0xF9, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F,
  0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xFB,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7D, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0xCF,
  0x0F, 0xEE, 0x1F, 0xFE, 0x3F, 0x7E, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C,
  0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3E, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x0E, 0x78,
  0x77, 0xC7, 0xFE, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x7C, 0x63, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x61,
  0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x81,
  0xFE, 0xFF, 0xDF, 0xFD, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x21, 0xFC, 0x3F, 0x83, 0xF0, 0x1E,
  0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8,
  0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0x70, 0x3E, 0x70, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xBC, 0x3E, 0xF0, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C, 0xF8, 0xF3,
  0xC3, 0xDF, 0x07, 0x78, 0x1D, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0xF8, 0x3F, 0xC3, 0xE1, 0xEF, 0x1F, 0x87, 0xBC,
  0x7E, 0x3E, 0xF1, 0xF8, 0xF3, 0xCE, 0xE7, 0xCF, 0x3B, 0x9E, 0x3D, 0xEE,
  0x78, 0xF7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0xF3, 0xB8, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xE0, 0xF0, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80,
  0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0xC0, 0x3E, 0x78, 0x0F,
  0x8F, 0x01, 0xE1, 0xF0, 0xFC, 0x3E, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xF0,
  0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x1C,
  0xF8, 0x07, 0x3C, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x83, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x78, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xD0, 0x06,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 22, 8, 0, -22 },
  { 29, 11, 8, 13, 3, -22 },
  { 40, 19, 22, 18, 0, -22 },
  { 93, 16, 26, 16, 0, -24 },
  { 145, 22, 22, 25, 2, -22 },
  { 206, 19, 22, 20, 1, -22 },
  { 259, 5, 8, 8, 3, -22 },
  { 264, 11, 27, 10, 1, -22 },
  { 302, 11, 28, 10, -2, -23 },
  { 341, 13, 14, 15, 3, -24 },
  { 364, 15, 15, 16, 1, -18 },
  { 393, 8, 8, 8, -2, -4 },
  { 401, 9, 4, 10, 0, -10 },
  { 406, 5, 5, 8, 0, -5 },
  { 410, 16, 22, 13, -1, -22 },
  { 454, 15, 22, 16, 1, -22 },
  { 496, 11, 22, 16, 3, -22 },
  { 527, 17, 22, 16, -1, -22 },
  { 574, 16, 22, 16, 0, -22 },
  { 618, 16, 22, 16, 0, -22 },
  { 662, 16, 22, 16, 0, -22 },
  { 706, 15, 22, 16, 1, -22 },
  { 748, 16, 22, 16, 1, -22 },
  { 792, 16, 22, 16, 0, -22 },
  { 836, 14, 22, 16, 1, -22 },
  { 875, 8, 17, 8, 0, -17 },
  { 892, 10, 21, 8, -2, -17 },
  { 919, 15, 16, 16, 1, -19 },
  { 949, 15, 10, 16, 1, -16 },
  { 968, 15, 16, 16, 1, -19 },
  { 998, 12, 22, 13, 2, -22 },
  { 1031, 23, 25, 24, 1, -22 },
  { 1103, 18, 22, 18, -2, -22 },
  { 1153, 18, 22, 18, 0, -22 },
  { 1203, 17, 22, 17, 2, -22 },
  { 1250, 18, 22, 19, 0, -22 },
  { 1300, 16, 22, 15, 0, -22 },
  { 1344, 16, 22, 15, 0, -22 },
  { 1388, 18, 22, 20, 2, -22 },
  { 1438, 20, 22, 20, 0, -22 },
  { 1493, 14, 22, 11, -1, -22 },
  { 1532, 15, 29, 9, -5, -22 },
  { 1587, 20, 22, 17, 0, -22 },
  { 1642, 13, 22, 15, 0, -22 },
  { 1678, 26, 22, 25, 0, -22 },
  { 1750, 22, 22, 21, 0, -22 },
  { 1811, 18, 22, 21, 2, -22 },
  { 1861, 18, 22, 17, 0, -22 },
  { 1911, 18, 27, 21, 2, -22 },
  { 1972, 17, 22, 17, 0, -22 },
  { 2019, 16, 22, 15, 0, -22 },
  { 2063, 15, 22, 15, 2, -22 },
  { 2105, 18, 22, 19, 2, -22 },
  { 2155, 17, 22, 17, 3, -22 },
  { 2202, 25, 22, 26, 3, -22 },
  { 2271, 21, 22, 17, -2, -22 },
  { 2329, 16, 22, 16, 3, -22 },
  { 2373, 18, 22, 15, -1, -22 },
  { 2423, 13, 27, 10, -1, -22 },
  { 2467, 7, 22, 13, 3, -22 },
  { 2487, 13, 27, 10, -2, -22 },
  { 2531, 15, 14, 16, 0, -22 },
  { 2558, 12, 2, 12, -3, 3 },
  { 2561, 7, 5, 10, 4, -24 },
  { 2566, 16, 17, 17, 1, -17 },
  { 2600, 16, 24, 17, 0, -24 },
  { 2648, 13, 17, 14, 1, -17 },
  { 2676, 17, 24, 17, 1, -24 },
  { 2727, 14, 17, 16, 1, -17 },
  { 2757, 17, 31, 11, -3, -24 },
  { 2823, 17, 24, 17, 0, -17 },
  { 2874, 16, 24, 17, 0, -24 },
  { 2922, 9, 24, 8, 0, -24 },
  { 2949, 13, 31, 8, -4, -24 },
  { 3000, 18, 24, 16, 0, -24 },
  { 3054, 10, 24, 8, 0, -24 },
  { 3084, 24, 17, 25, 0, -17 },
  { 3135, 16, 17, 17, 0, -17 },
  { 3169, 14, 17, 17, 1, -17 },
  { 3199, 17, 24, 17, -1, -17 },
  { 3250, 16, 24, 17, 1, -17 },
  { 3298, 13, 17, 12, 0, -17 },
  { 3326, 13, 17, 13, 0, -17 },
  { 3354, 11, 21, 11, 1, -21 },
  { 3383, 16, 17, 17, 1, -17 },
  { 3417, 14, 17, 15, 2, -17 },
  { 3447, 22, 17, 22, 2, -17 },
  { 3494, 19, 17, 15, -2, -17 },
  { 3535, 18, 24, 15, -2, -17 },
  { 3589, 15, 17, 13, -1, -17 },
  { 3621, 13, 27, 11, 0, -22 },
  { 3665, 3, 31, 15, 6, -24 },
  { 3677, 13, 27, 11, -2, -22 },
  { 3721, 15, 6, 16, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC31PT7B_H_
