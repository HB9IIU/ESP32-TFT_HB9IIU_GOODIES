#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x07, 0x30, 0x6D, 0xB4, 0xB6, 0x09,
  0x05, 0x86, 0xCF, 0xF7, 0xF9, 0xB0, 0xD1, 0xFE, 0x2C, 0x36, 0x12, 0x00,
  0x04, 0x3F, 0x3E, 0x68, 0x38, 0x3C, 0x0E, 0x16, 0xDE, 0xFC, 0x10, 0x20,
  0x30, 0xCF, 0x33, 0x6C, 0x6D, 0x09, 0x69, 0xFB, 0x9A, 0xD8, 0xD2, 0x32,
  0x44, 0x59, 0x8E, 0x00, 0x0E, 0x0F, 0x8C, 0xC6, 0xC1, 0xE1, 0xCD, 0xB7,
  0xDE, 0xC7, 0x7F, 0x9E, 0xE0, 0x6D, 0x60, 0x0C, 0x63, 0x0C, 0x61, 0x86,
  0x10, 0xC3, 0x0C, 0x10, 0x60, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C,
  0xCC, 0x00, 0x18, 0xB3, 0xF9, 0xF7, 0x89, 0x80, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x00, 0x36, 0x6C, 0x7F, 0xF8, 0x03, 0x03, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1C, 0x3E, 0x36, 0x67, 0x66, 0x66,
  0xE6, 0xC6, 0xEE, 0x7C, 0x78, 0x0C, 0xF7, 0xBE, 0x18, 0x61, 0x8C, 0x30,
  0xC3, 0x00, 0x1C, 0x7E, 0x27, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFC,
  0xFC, 0x1C, 0x3E, 0x27, 0x06, 0x0E, 0x38, 0x0E, 0x06, 0x0E, 0xFC, 0xF8,
  0x07, 0x06, 0x0E, 0x1E, 0x36, 0x6C, 0x4C, 0xFE, 0xFE, 0x0C, 0x18, 0x1F,
  0x3E, 0x30, 0x30, 0x7C, 0x7E, 0x0E, 0x06, 0x0E, 0xFC, 0xF8, 0x1E, 0x7D,
  0x83, 0x0D, 0x9F, 0xB3, 0x66, 0xCD, 0xF3, 0xC0, 0x3F, 0x7F, 0x07, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70, 0xE0, 0x1E, 0x3E, 0x33, 0x37, 0x3E,
  0x3C, 0x7E, 0xE6, 0xC6, 0xEE, 0x7C, 0x1C, 0x7D, 0x9B, 0x36, 0x6F, 0xDF,
  0x83, 0x0D, 0xF3, 0xC0, 0x37, 0x00, 0x00, 0xEC, 0x19, 0xC0, 0x00, 0x01,
  0xCC, 0x66, 0x00, 0x06, 0x3D, 0xE6, 0x0F, 0x07, 0x81, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x81, 0xC0, 0xE0, 0x73, 0xDE, 0x30, 0x00, 0x7B, 0xF8,
  0xC7, 0x39, 0xC6, 0x10, 0x03, 0x0C, 0x00, 0x0F, 0x07, 0xF9, 0x81, 0x27,
  0xAD, 0xB7, 0x24, 0xAC, 0x95, 0xB6, 0xBF, 0x90, 0x03, 0x04, 0x3F, 0x00,
  0x07, 0x03, 0x83, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x7E, 0x63, 0x31, 0xF8,
  0x60, 0x3E, 0x3F, 0x33, 0x33, 0x37, 0x7C, 0x66, 0x63, 0x67, 0x7E, 0xFC,
  0x1E, 0x3F, 0x72, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x3E,
  0x1F, 0x8C, 0xE6, 0x33, 0x1B, 0x8D, 0x8E, 0xC6, 0x67, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x30, 0x30, 0x30, 0x7E, 0x60, 0x60, 0x60, 0x7C, 0xFC, 0x3F,
  0x3F, 0x30, 0x30, 0x30, 0x7E, 0x7C, 0x60, 0x60, 0x60, 0xE0, 0x0F, 0x9F,
  0x9C, 0x4C, 0x0C, 0x06, 0x7B, 0x3D, 0x8C, 0xC6, 0x7F, 0x1F, 0x80, 0x38,
  0xCC, 0x73, 0x18, 0xC6, 0x3F, 0x9F, 0xE6, 0x31, 0x8C, 0x63, 0x18, 0xCE,
  0x70, 0x1E, 0x7C, 0x30, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x73, 0xE0, 0x06,
  0x1C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x8F, 0x1C, 0x00,
  0x39, 0xCC, 0xE3, 0x30, 0xD8, 0x3C, 0x1F, 0x07, 0xC1, 0xB0, 0x6E, 0x19,
  0x8C, 0x70, 0x38, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0xFF, 0xC0, 0x38,
  0x73, 0x87, 0x38, 0xF3, 0x8F, 0x39, 0xB6, 0xDE, 0x6F, 0x66, 0xF6, 0x6E,
  0x64, 0xEC, 0xCC, 0xC0, 0x38, 0x67, 0x18, 0xF3, 0x1E, 0x62, 0xCC, 0xDB,
  0x19, 0xE3, 0x3C, 0x67, 0x88, 0xF3, 0x0C, 0x00, 0x1E, 0x1F, 0x9C, 0xCC,
  0x7C, 0x3E, 0x1B, 0x0D, 0x86, 0xC7, 0x7F, 0x1F, 0x00, 0x3E, 0x1F, 0x8C,
  0xE6, 0x73, 0x33, 0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x1E, 0x1F,
  0x9C, 0xCC, 0x7C, 0x3E, 0x1B, 0x0D, 0x86, 0xC6, 0x7F, 0x1F, 0x03, 0x80,
  0xC0, 0x70, 0x3C, 0x3F, 0x33, 0x33, 0x33, 0x7E, 0x7C, 0x6C, 0x66, 0x66,
  0xC7, 0x1F, 0x3E, 0x32, 0x70, 0x30, 0x3C, 0x1C, 0x0C, 0x8C, 0xFC, 0xF8,
  0x7F, 0xFC, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x80, 0x73, 0xB1,
  0x98, 0xCC, 0x66, 0x36, 0x3B, 0x19, 0x8C, 0xC6, 0x7E, 0x1E, 0x00, 0xC3,
  0xE1, 0xB1, 0x8C, 0xC6, 0xC3, 0x61, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x00,
  0xC6, 0x3E, 0x31, 0xB1, 0x8D, 0x9C, 0xCC, 0xE6, 0x6D, 0x73, 0x6B, 0x1A,
  0x58, 0xF3, 0x87, 0x1C, 0x38, 0xC0, 0x18, 0xC6, 0x71, 0x98, 0x3C, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x37, 0x18, 0xCE, 0x30, 0xE3, 0x66, 0x6E, 0x6C,
  0x78, 0x78, 0x30, 0x30, 0x70, 0x60, 0x60, 0x1F, 0x8F, 0xC8, 0xC0, 0xE0,
  0xE0, 0x60, 0x60, 0x70, 0x30, 0x3F, 0x3F, 0x80, 0x3C, 0xF3, 0x0C, 0x21,
  0x86, 0x18, 0x43, 0x0C, 0x30, 0xE0, 0x9B, 0x6D, 0xB2, 0x6D, 0x80, 0x1C,
  0xF0, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0xE0, 0x0C, 0x18, 0x71,
  0xA2, 0x6C, 0xF0, 0x80, 0xF8, 0xEC, 0x7F, 0xDF, 0x36, 0x6C, 0xD9, 0xBF,
  0x74, 0x38, 0x30, 0x30, 0x3E, 0x37, 0x63, 0x67, 0x66, 0x66, 0xFE, 0xDC,
  0x7D, 0xAC, 0x30, 0xC3, 0x0F, 0xBE, 0x07, 0x06, 0x06, 0x7E, 0x6E, 0xCC,
  0xCC, 0xCC, 0xCC, 0xFC, 0xE8, 0x7D, 0xBC, 0xFF, 0xF3, 0x0C, 0xBE, 0x07,
  0x87, 0x03, 0x03, 0xE0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x07, 0x81, 0x00, 0x3F, 0x37, 0x66, 0x66, 0x66, 0x66, 0x7E, 0x7C,
  0x0C, 0x8C, 0xF8, 0x60, 0x38, 0x30, 0x30, 0x3E, 0x37, 0x73, 0x66, 0x66,
  0x66, 0xE6, 0xCE, 0x39, 0x80, 0x63, 0x31, 0x8C, 0x67, 0x30, 0x0E, 0x18,
  0x00, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x1C, 0x30, 0x00,
  0x38, 0x30, 0x30, 0x33, 0x36, 0x6C, 0x78, 0x7C, 0x6C, 0xEC, 0xCE, 0x39,
  0x8C, 0x63, 0x31, 0x8C, 0x67, 0x30, 0x2E, 0xE3, 0x7F, 0x77, 0x36, 0x66,
  0x66, 0x66, 0x66, 0xE6, 0x6C, 0xCE, 0x2E, 0x37, 0x73, 0x66, 0x66, 0x66,
  0xE6, 0xCE, 0x7F, 0xBC, 0xF3, 0xCF, 0x3F, 0xBE, 0x17, 0x0D, 0xCC, 0x66,
  0x73, 0x31, 0x99, 0xFC, 0xDC, 0x60, 0x30, 0x18, 0x18, 0x00, 0x7E, 0xDF,
  0x36, 0x6C, 0xD9, 0xBF, 0x7C, 0x18, 0x30, 0x61, 0xC0, 0x3C, 0xF7, 0x18,
  0x61, 0x8E, 0x30, 0x3D, 0x96, 0x1E, 0x38, 0x7F, 0xBE, 0x23, 0x3E, 0xCE,
  0x63, 0x18, 0xE7, 0x00, 0x67, 0xCF, 0x3E, 0x6C, 0xD9, 0xBF, 0x74, 0xCF,
  0x9B, 0x76, 0xCD, 0x9E, 0x38, 0x70, 0xCC, 0xFB, 0x9B, 0x76, 0x6A, 0xCF,
  0x59, 0xCE, 0x39, 0xC7, 0x30, 0x3B, 0x8D, 0x87, 0x83, 0x81, 0xC1, 0xE1,
  0xD9, 0xCC, 0x33, 0x99, 0x8D, 0xC6, 0xC3, 0x61, 0xE0, 0x70, 0x30, 0x38,
  0x18, 0x38, 0x18, 0x00, 0x7E, 0x18, 0x61, 0xC3, 0x0C, 0x3E, 0x7C, 0x0C,
  0x71, 0x8C, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70, 0xFF, 0xFC, 0x10,
  0xE1, 0x86, 0x18, 0x61, 0xC7, 0x30, 0xC3, 0x18, 0xE0, 0x43, 0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 6, 4, 6, 1, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 8, 12, 8, 0, -11 },
  { 36, 11, 11, 12, 1, -11 },
  { 52, 9, 11, 10, 0, -11 },
  { 65, 3, 4, 4, 1, -11 },
  { 67, 6, 13, 5, 0, -11 },
  { 77, 5, 13, 5, -1, -11 },
  { 86, 7, 6, 7, 1, -11 },
  { 92, 7, 7, 8, 1, -9 },
  { 99, 4, 4, 4, -1, -2 },
  { 101, 4, 2, 5, 0, -5 },
  { 102, 3, 2, 4, 0, -2 },
  { 103, 8, 11, 6, -1, -11 },
  { 114, 8, 11, 8, 0, -11 },
  { 125, 6, 11, 8, 1, -11 },
  { 134, 8, 11, 8, 0, -11 },
  { 145, 8, 11, 8, 0, -11 },
  { 156, 8, 11, 8, 0, -11 },
  { 167, 8, 11, 8, 0, -11 },
  { 178, 7, 11, 8, 1, -11 },
  { 188, 8, 11, 8, 0, -11 },
  { 199, 8, 11, 8, 0, -11 },
  { 210, 7, 11, 8, 0, -11 },
  { 220, 4, 8, 4, 0, -8 },
  { 224, 5, 10, 4, -1, -8 },
  { 231, 7, 7, 8, 1, -9 },
  { 238, 7, 5, 8, 1, -8 },
  { 243, 7, 7, 8, 1, -9 },
  { 250, 6, 11, 6, 1, -11 },
  { 259, 11, 12, 12, 1, -11 },
  { 276, 9, 11, 9, -1, -11 },
  { 289, 8, 11, 9, 0, -11 },
  { 300, 8, 11, 8, 1, -11 },
  { 311, 9, 11, 9, 0, -11 },
  { 324, 8, 11, 7, 0, -11 },
  { 335, 8, 11, 7, 0, -11 },
  { 346, 9, 11, 9, 1, -11 },
  { 359, 10, 11, 10, 0, -11 },
  { 373, 7, 11, 5, -1, -11 },
  { 383, 7, 14, 5, -2, -11 },
  { 396, 10, 11, 8, 0, -11 },
  { 410, 6, 11, 7, 0, -11 },
  { 419, 12, 11, 12, 0, -11 },
  { 436, 11, 11, 10, 0, -11 },
  { 452, 9, 11, 10, 1, -11 },
  { 465, 9, 11, 8, 0, -11 },
  { 478, 9, 14, 10, 1, -11 },
  { 494, 8, 11, 8, 0, -11 },
  { 505, 8, 11, 7, 0, -11 },
  { 516, 7, 11, 7, 1, -11 },
  { 526, 9, 11, 9, 1, -11 },
  { 539, 9, 11, 8, 1, -11 },
  { 552, 13, 11, 12, 1, -11 },
  { 570, 10, 11, 8, -1, -11 },
  { 584, 8, 11, 8, 1, -11 },
  { 595, 9, 11, 7, -1, -11 },
  { 608, 6, 13, 5, 0, -11 },
  { 618, 3, 11, 6, 2, -11 },
  { 623, 6, 13, 5, -1, -11 },
  { 633, 7, 7, 8, 0, -11 },
  { 640, 5, 1, 6, -1, 1 },
  { 641, 3, 2, 5, 2, -11 },
  { 642, 7, 8, 8, 1, -8 },
  { 649, 8, 11, 8, 0, -11 },
  { 660, 6, 8, 7, 1, -8 },
  { 666, 8, 11, 8, 1, -11 },
  { 677, 6, 8, 8, 1, -8 },
  { 683, 9, 15, 5, -2, -11 },
  { 700, 8, 12, 8, 0, -8 },
  { 712, 8, 11, 8, 0, -11 },
  { 723, 5, 11, 4, 0, -11 },
  { 730, 7, 15, 4, -2, -11 },
  { 744, 8, 11, 8, 0, -11 },
  { 755, 5, 11, 4, 0, -11 },
  { 762, 12, 8, 12, 0, -8 },
  { 774, 8, 8, 8, 0, -8 },
  { 782, 6, 8, 8, 1, -8 },
  { 788, 9, 12, 8, -1, -8 },
  { 802, 7, 12, 8, 1, -8 },
  { 813, 6, 8, 6, 0, -8 },
  { 819, 6, 8, 6, 0, -8 },
  { 825, 5, 10, 6, 1, -10 },
  { 832, 7, 8, 8, 1, -8 },
  { 839, 7, 8, 7, 1, -8 },
  { 846, 11, 8, 11, 1, -8 },
  { 857, 9, 8, 7, -1, -8 },
  { 866, 9, 12, 7, -1, -8 },
  { 880, 7, 8, 6, 0, -8 },
  { 887, 6, 13, 5, 0, -11 },
  { 897, 1, 14, 7, 3, -11 },
  { 899, 6, 13, 5, -1, -11 },
  { 909, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC15PT7B_H_
