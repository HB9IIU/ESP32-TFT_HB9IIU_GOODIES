#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x37, 0xEF, 0xA0, 0x74, 0x6A, 0xE0, 0x6D, 0xBA,
  0x75, 0x80, 0x76, 0x5B, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80,
  0xDF, 0x00, 0x4F, 0x40, 0xC0, 0xC0, 0x80, 0x25, 0x48, 0x65, 0xAA, 0xE0,
  0x76, 0x80, 0x63, 0x24, 0xE0, 0x63, 0x62, 0xE0, 0x36, 0x6E, 0x20, 0x74,
  0x62, 0xE0, 0x74, 0xEA, 0xE0, 0x72, 0x24, 0xC0, 0x65, 0x6A, 0xE0, 0x77,
  0x9C, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0, 0x65, 0x0C,
  0x3B, 0xEF, 0xF8, 0x38, 0x26, 0x6E, 0x90, 0x75, 0x69, 0xE0, 0x74, 0x88,
  0x60, 0x75, 0x59, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68, 0x80, 0x74, 0xB9,
  0x70, 0x5A, 0x9D, 0x2B, 0x00, 0x69, 0x2C, 0x24, 0xA5, 0x80, 0x5B, 0x19,
  0x4B, 0x00, 0x49, 0x4E, 0x4D, 0xA7, 0xAE, 0xA8, 0x4B, 0x5D, 0x69, 0x00,
  0x75, 0x99, 0x60, 0x75, 0x78, 0x80, 0x75, 0x99, 0x63, 0x75, 0x6A, 0xB0,
  0x74, 0x62, 0xE0, 0xFA, 0x48, 0x5A, 0x95, 0x26, 0x00, 0xB7, 0x68, 0xAF,
  0x7D, 0x6A, 0x00, 0x56, 0x66, 0xA0, 0xBB, 0x48, 0x72, 0x4C, 0xE0, 0x69,
  0x49, 0x80, 0xF8, 0x55, 0xA0, 0x2E, 0x80, 0xE0, 0x80, 0x7E, 0xAE, 0x46,
  0x5A, 0xE0, 0x72, 0x70, 0x17, 0xAA, 0xE0, 0x77, 0x70, 0x37, 0x24, 0x44,
  0x80, 0x7E, 0xAE, 0x2C, 0x46, 0x5A, 0xA0, 0x56, 0x80, 0x24, 0xA4, 0xA0,
  0x45, 0x6E, 0xA0, 0x56, 0x80, 0x6A, 0xEB, 0x50, 0x65, 0xAA, 0x6B, 0xAE,
  0x65, 0xAE, 0x88, 0x7A, 0xAE, 0x22, 0x6A, 0x40, 0x79, 0xE0, 0x5D, 0x4C,
  0x55, 0xAE, 0x9A, 0xA4, 0xAD, 0x74, 0xA0, 0x76, 0x4A, 0x4A, 0x8C, 0x42,
  0x60, 0x69, 0x60, 0x69, 0x69, 0x80, 0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 5, 5, 6, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 2, 1, -5 },
  { 18, 3, 6, 2, 0, -5 },
  { 21, 3, 6, 2, -1, -5 },
  { 24, 3, 3, 3, 1, -5 },
  { 26, 4, 3, 4, 0, -4 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -2 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 2, 5, 4, 1, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 3, 5, 4, 0, -5 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 5, 2, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 3, 5, 3, 0, -5 },
  { 72, 5, 6, 5, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 3, 0, -5 },
  { 91, 4, 5, 3, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 5, 5, 4, 0, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 6, 2, -1, -5 },
  { 106, 5, 5, 4, 0, -5 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 6, 5, 6, 0, -5 },
  { 116, 5, 5, 5, 0, -5 },
  { 120, 4, 5, 5, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 6, 5, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 3, 0, -5 },
  { 135, 3, 5, 3, 1, -5 },
  { 137, 5, 5, 4, 0, -5 },
  { 141, 3, 5, 4, 1, -5 },
  { 143, 5, 5, 6, 1, -5 },
  { 147, 4, 5, 4, 0, -5 },
  { 150, 3, 5, 4, 1, -5 },
  { 152, 4, 5, 3, 0, -5 },
  { 155, 3, 6, 2, 0, -5 },
  { 158, 1, 5, 3, 1, -5 },
  { 159, 2, 6, 2, 0, -5 },
  { 161, 3, 3, 4, 0, -5 },
  { 163, 3, 1, 3, -1, 0 },
  { 164, 1, 1, 2, 1, -5 },
  { 165, 4, 4, 4, 0, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 4, 7, 2, -1, -5 },
  { 181, 4, 6, 4, 0, -4 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 2, 5, 2, 0, -5 },
  { 189, 3, 7, 2, -1, -5 },
  { 192, 4, 5, 4, 0, -5 },
  { 195, 2, 5, 2, 0, -5 },
  { 197, 5, 4, 6, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 6, 4, 0, -4 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 3, 4, 3, 0, -4 },
  { 214, 3, 5, 3, 0, -5 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 3, 0, -4 },
  { 220, 5, 4, 5, 0, -4 },
  { 223, 4, 4, 3, 0, -4 },
  { 225, 5, 6, 3, -1, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 3, 6, 2, 0, -5 },
  { 234, 1, 7, 3, 1, -5 },
  { 235, 2, 6, 2, 0, -5 },
  { 237, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC7PT7B_H_
