#ifndef _NOTOSANS_SEMICONDENSED_BOLDITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x31, 0x80, 0x07, 0x38, 0xDE, 0xE5, 0x20, 0x0D,
  0x82, 0x41, 0xB1, 0xFF, 0x12, 0x0C, 0x8F, 0xFB, 0xFE, 0x24, 0x1B, 0x06,
  0xC0, 0x04, 0x1F, 0x3F, 0x39, 0x38, 0x3C, 0x1E, 0x0E, 0x16, 0xFE, 0xFC,
  0x10, 0x10, 0x30, 0x0F, 0x1B, 0x66, 0x6C, 0x8D, 0xB1, 0xBD, 0xFD, 0x7A,
  0x79, 0x1B, 0x62, 0x6C, 0xCD, 0xB0, 0xE0, 0x04, 0x07, 0xC1, 0xB0, 0xEC,
  0x1F, 0x07, 0x83, 0xCD, 0xB6, 0xE7, 0xB9, 0xCF, 0xF1, 0xFE, 0xFA, 0x1C,
  0x63, 0x0C, 0x61, 0x86, 0x18, 0xC3, 0x06, 0x18, 0x61, 0x80, 0x18, 0x61,
  0x83, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x0C, 0x61, 0x8C, 0x00, 0x18, 0xB3,
  0xE9, 0xF3, 0x8D, 0x8B, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08,
  0x36, 0x6C, 0xFF, 0x80, 0xFC, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00, 0x0C, 0x1F, 0x3F, 0x73, 0x63,
  0x63, 0x67, 0xE7, 0xE6, 0xEE, 0x7C, 0x78, 0x1C, 0xFE, 0xD7, 0x18, 0x61,
  0x8E, 0x30, 0xC3, 0x00, 0x0C, 0x3F, 0x77, 0x23, 0x07, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xFE, 0xFE, 0x0C, 0x3F, 0x37, 0x03, 0x07, 0x1E, 0x3C, 0x06,
  0x06, 0x06, 0xFE, 0xF8, 0x07, 0x0F, 0x0E, 0x1E, 0x36, 0x66, 0xCE, 0xFF,
  0xFE, 0x0C, 0x1C, 0x1F, 0x3F, 0x30, 0x30, 0x7E, 0x7E, 0x06, 0x06, 0x8E,
  0xFC, 0xF8, 0x06, 0x3C, 0xC3, 0x0E, 0x1F, 0xBB, 0xE7, 0xCD, 0x9B, 0xF3,
  0xC0, 0x7F, 0xFE, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xC0,
  0x0C, 0x3F, 0x33, 0x33, 0x37, 0x3E, 0x3C, 0x66, 0xE6, 0xE6, 0xFE, 0x7C,
  0x0C, 0x3E, 0x37, 0x63, 0x63, 0x67, 0x7F, 0x3E, 0x06, 0x0C, 0xFC, 0xF8,
  0x37, 0x30, 0x00, 0x0E, 0xE0, 0x19, 0xC6, 0x00, 0x00, 0x0E, 0x63, 0x30,
  0x02, 0x1C, 0xF7, 0x8E, 0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x81, 0x81, 0xC0, 0xE0, 0xE7, 0xBC, 0x40, 0x13, 0xF4, 0xC3, 0x1C, 0xE7,
  0x18, 0x00, 0x0E, 0x30, 0x1F, 0xC6, 0x0D, 0x81, 0xA7, 0xDD, 0x93, 0x26,
  0x6C, 0xDD, 0x9A, 0x9F, 0xD8, 0x03, 0x84, 0x3F, 0x80, 0x07, 0x03, 0xC3,
  0x61, 0xB1, 0x98, 0xCC, 0xFE, 0x7F, 0x71, 0xB0, 0xF8, 0x60, 0x3F, 0x9D,
  0xCC, 0x66, 0x73, 0xF3, 0xF1, 0x8C, 0xC6, 0x67, 0x3F, 0xBF, 0x00, 0x06,
  0x1F, 0xCE, 0xCE, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x3F, 0x0F,
  0x80, 0x3F, 0x0F, 0xE3, 0x18, 0xC7, 0x31, 0x9C, 0x67, 0x19, 0x8E, 0x67,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x60,
  0x7C, 0xFC, 0x3F, 0x3F, 0x30, 0x30, 0x30, 0x7E, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0x06, 0x0F, 0xCE, 0x4E, 0x0E, 0x07, 0x03, 0x3D, 0x86, 0xC3, 0x73,
  0xBF, 0x8F, 0xC0, 0x38, 0xCE, 0x33, 0x0C, 0xC7, 0x3F, 0x9F, 0xE6, 0x19,
  0x8E, 0x63, 0x98, 0xCE, 0x30, 0x1F, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x38, 0x7C, 0xF8, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x78, 0xF0, 0x39, 0xCC, 0xE3, 0x30, 0xD8, 0x3E,
  0x1F, 0x07, 0xE1, 0x98, 0x66, 0x19, 0xCE, 0x70, 0x38, 0xE3, 0x0C, 0x31,
  0xC6, 0x18, 0x61, 0xFF, 0xC0, 0x3C, 0x39, 0xE3, 0xCF, 0x1E, 0x79, 0xE3,
  0xCF, 0x36, 0xD9, 0xB6, 0xCD, 0xEE, 0x6F, 0x63, 0x73, 0x33, 0x98, 0x38,
  0x67, 0x8C, 0xF3, 0x9E, 0x63, 0xEC, 0xCD, 0x99, 0xB3, 0x36, 0x63, 0x8C,
  0x73, 0x0E, 0x00, 0x0C, 0x1F, 0x9E, 0xEC, 0x3E, 0x1F, 0x0F, 0x07, 0x87,
  0xC3, 0x73, 0xBF, 0x8F, 0x80, 0x3F, 0x1F, 0xCC, 0x66, 0x33, 0x3B, 0xF9,
  0xF8, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x06, 0x1F, 0x9E, 0xEC, 0x3E, 0x1F,
  0x0F, 0x07, 0x87, 0xC3, 0x73, 0xBF, 0x8F, 0x80, 0xC0, 0x70, 0x18, 0x3F,
  0x1D, 0xCC, 0xE6, 0x73, 0x33, 0xF1, 0xF8, 0xCC, 0x66, 0x33, 0xB9, 0xC0,
  0x0C, 0x3F, 0x3B, 0x30, 0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8,
  0x7F, 0xFE, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x71,
  0xB0, 0xD8, 0xEC, 0x76, 0x37, 0x1B, 0x0D, 0x8E, 0xC6, 0x7F, 0x1F, 0x00,
  0xE3, 0xB1, 0x99, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78, 0x38, 0x1C,
  0x00, 0xE3, 0x1F, 0x9C, 0x6E, 0x73, 0x3B, 0xCC, 0xEF, 0x73, 0xED, 0x8D,
  0xB6, 0x16, 0xF0, 0x73, 0xC1, 0xCE, 0x06, 0x38, 0x00, 0x18, 0xE3, 0xB8,
  0x36, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF8, 0x33, 0x0E, 0x63, 0x8E,
  0x00, 0xE3, 0xB3, 0x1B, 0x8D, 0x87, 0xC1, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x00, 0x1F, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0,
  0x70, 0x1F, 0xCF, 0xE0, 0x3C, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x63, 0x0C,
  0x34, 0xE3, 0x80, 0xDB, 0x6D, 0x93, 0x6D, 0xB0, 0x1C, 0x30, 0xC3, 0x18,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0xF3, 0x80, 0x0C, 0x0C, 0x1E, 0x36, 0x22,
  0x63, 0xC3, 0xFF, 0xF0, 0xE7, 0x3B, 0x7E, 0xE6, 0xC6, 0xC6, 0xCC, 0xCC,
  0xFC, 0xEC, 0x18, 0x38, 0x30, 0x36, 0x3F, 0x33, 0x63, 0x63, 0x63, 0x66,
  0xFE, 0xDC, 0x3D, 0xFE, 0x30, 0xC3, 0x0C, 0x3E, 0x78, 0x03, 0x03, 0x03,
  0x3F, 0x7E, 0xE6, 0xC6, 0xC6, 0xCC, 0xCC, 0xFC, 0xFC, 0x3C, 0xFF, 0x9E,
  0x7F, 0xD8, 0x30, 0x7E, 0x78, 0x07, 0x83, 0xC3, 0x81, 0xE1, 0xF0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x83, 0xC1, 0xC0, 0x1D,
  0x9F, 0x9C, 0xCC, 0x66, 0x33, 0x31, 0x98, 0xFC, 0x76, 0x07, 0x23, 0x1F,
  0x8F, 0x00, 0x18, 0x38, 0x30, 0x36, 0x3F, 0x33, 0x73, 0x63, 0x67, 0x66,
  0xE6, 0xC6, 0x19, 0xC0, 0x63, 0x19, 0xCC, 0x63, 0x39, 0xC0, 0x06, 0x1C,
  0x00, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x3C, 0x70,
  0x18, 0x1C, 0x0C, 0x06, 0x73, 0x71, 0xB1, 0xB0, 0xF8, 0x7C, 0x36, 0x3B,
  0x98, 0xC0, 0x19, 0xCC, 0x63, 0x19, 0xCC, 0x63, 0x39, 0xC0, 0x36, 0x73,
  0xFF, 0x33, 0xB7, 0x33, 0x63, 0x36, 0x63, 0x66, 0x3E, 0x67, 0xC6, 0x60,
  0x36, 0x3F, 0x33, 0x73, 0x63, 0x67, 0x66, 0xE6, 0xC6, 0x3C, 0xFF, 0x9E,
  0x3C, 0x79, 0xF3, 0x7E, 0x78, 0x1B, 0x0F, 0xC6, 0x66, 0x33, 0x19, 0x8C,
  0xCC, 0xFE, 0x6E, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x3B, 0x7E, 0xE6, 0xC6,
  0xC6, 0xCC, 0xCC, 0xFC, 0xEC, 0x1C, 0x18, 0x18, 0x18, 0x36, 0x7C, 0xE3,
  0x86, 0x0C, 0x18, 0x70, 0xE0, 0x3C, 0xFD, 0x83, 0x83, 0x83, 0x83, 0x7E,
  0xF8, 0x31, 0x9F, 0xF6, 0x73, 0x18, 0xC7, 0xBC, 0x67, 0x66, 0xE6, 0xC6,
  0xC6, 0xCE, 0xCC, 0xFC, 0xEC, 0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x3C, 0x78,
  0x60, 0xCE, 0x79, 0xCF, 0x7B, 0x6F, 0x6D, 0x7D, 0xEF, 0x3D, 0xE7, 0x38,
  0xE7, 0x00, 0x39, 0xC6, 0xE1, 0xB0, 0x78, 0x0C, 0x07, 0x83, 0x61, 0xD8,
  0xE7, 0x00, 0x31, 0x98, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0x70, 0x38, 0x18,
  0x0C, 0x0C, 0x1E, 0x0C, 0x00, 0x3E, 0xFC, 0x30, 0xC3, 0x8E, 0x18, 0x7E,
  0xF8, 0x1E, 0x30, 0x60, 0xC3, 0x0E, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x78, 0x30, 0xC1, 0x83, 0x43,
  0x0E, 0x30, 0x60, 0xC3, 0x8E, 0x10, 0x00, 0xF3, 0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 7, 2, -11 },
  { 11, 10, 11, 9, 0, -11 },
  { 25, 8, 13, 8, 0, -12 },
  { 38, 11, 12, 13, 1, -12 },
  { 55, 10, 12, 10, 0, -12 },
  { 70, 2, 4, 4, 2, -11 },
  { 71, 6, 14, 5, 0, -11 },
  { 82, 6, 15, 5, -1, -12 },
  { 94, 7, 7, 8, 1, -12 },
  { 101, 7, 8, 9, 1, -10 },
  { 108, 4, 4, 4, -1, -2 },
  { 110, 5, 2, 5, 0, -5 },
  { 112, 3, 2, 4, 0, -2 },
  { 113, 9, 12, 6, -1, -12 },
  { 127, 8, 12, 8, 0, -12 },
  { 139, 6, 11, 8, 1, -11 },
  { 148, 8, 12, 8, 0, -12 },
  { 160, 8, 12, 8, 0, -12 },
  { 172, 8, 11, 8, 0, -11 },
  { 183, 8, 11, 8, 0, -11 },
  { 194, 7, 12, 8, 1, -12 },
  { 205, 8, 11, 8, 1, -11 },
  { 216, 8, 12, 8, 0, -12 },
  { 228, 8, 12, 8, 0, -12 },
  { 240, 4, 9, 4, 0, -9 },
  { 245, 5, 11, 4, -1, -9 },
  { 252, 7, 8, 9, 1, -10 },
  { 259, 7, 5, 9, 1, -8 },
  { 264, 7, 8, 9, 1, -10 },
  { 271, 6, 12, 7, 1, -12 },
  { 280, 11, 12, 12, 1, -11 },
  { 297, 9, 11, 9, -1, -11 },
  { 310, 9, 11, 9, 0, -11 },
  { 323, 9, 12, 9, 1, -12 },
  { 337, 10, 11, 10, 0, -11 },
  { 351, 8, 11, 8, 0, -11 },
  { 362, 8, 11, 8, 0, -11 },
  { 373, 9, 12, 10, 1, -12 },
  { 387, 10, 11, 10, 0, -11 },
  { 401, 8, 11, 6, -1, -11 },
  { 412, 8, 14, 5, -3, -11 },
  { 426, 10, 11, 9, 0, -11 },
  { 440, 6, 11, 8, 0, -11 },
  { 449, 13, 11, 13, 0, -11 },
  { 467, 11, 11, 11, 0, -11 },
  { 483, 9, 12, 11, 1, -12 },
  { 497, 9, 11, 9, 0, -11 },
  { 510, 9, 15, 11, 1, -12 },
  { 527, 9, 11, 9, 0, -11 },
  { 540, 8, 12, 8, 0, -12 },
  { 552, 8, 11, 8, 1, -11 },
  { 563, 9, 11, 10, 1, -11 },
  { 576, 9, 11, 9, 1, -11 },
  { 589, 14, 11, 13, 1, -11 },
  { 609, 11, 11, 9, -1, -11 },
  { 625, 9, 11, 8, 1, -11 },
  { 638, 10, 11, 8, -1, -11 },
  { 652, 6, 14, 5, 0, -11 },
  { 663, 3, 12, 7, 2, -12 },
  { 668, 6, 14, 5, -1, -11 },
  { 679, 8, 7, 8, 0, -11 },
  { 686, 6, 2, 6, -1, 1 },
  { 688, 4, 2, 5, 2, -12 },
  { 689, 8, 9, 9, 1, -9 },
  { 698, 8, 12, 9, 0, -12 },
  { 710, 6, 9, 7, 1, -9 },
  { 717, 8, 12, 9, 1, -12 },
  { 729, 7, 9, 8, 1, -9 },
  { 737, 9, 16, 5, -2, -12 },
  { 755, 9, 13, 9, 0, -9 },
  { 770, 8, 12, 9, 0, -12 },
  { 782, 5, 12, 4, 0, -12 },
  { 790, 7, 16, 4, -2, -12 },
  { 804, 9, 12, 8, 0, -12 },
  { 818, 5, 12, 4, 0, -12 },
  { 826, 12, 9, 13, 0, -9 },
  { 840, 8, 9, 9, 0, -9 },
  { 849, 7, 9, 9, 1, -9 },
  { 857, 9, 13, 9, -1, -9 },
  { 872, 8, 13, 9, 1, -9 },
  { 885, 7, 9, 6, 0, -9 },
  { 893, 7, 9, 7, 0, -9 },
  { 901, 5, 11, 6, 1, -11 },
  { 908, 8, 9, 9, 1, -9 },
  { 917, 7, 9, 8, 1, -9 },
  { 925, 11, 9, 12, 1, -9 },
  { 938, 10, 9, 8, -1, -9 },
  { 950, 9, 13, 8, -1, -9 },
  { 965, 7, 9, 7, 0, -9 },
  { 973, 7, 14, 6, 0, -11 },
  { 986, 2, 16, 8, 3, -12 },
  { 990, 7, 14, 6, -1, -11 },
  { 1003, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_BOLDITALIC16PT7B_H_
