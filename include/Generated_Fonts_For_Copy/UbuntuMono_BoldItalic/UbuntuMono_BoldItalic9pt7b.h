#ifndef _UBUNTUMONO_BOLDITALIC9PT7B_H_
#define _UBUNTUMONO_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x21, 0x80, 0xB7, 0x00, 0x2B, 0xD4, 0xAF, 0xB0, 0x11, 0xD0,
  0x61, 0x79, 0x00, 0x69, 0xC7, 0x0E, 0x6A, 0x40, 0x32, 0x8C, 0xD9, 0x38,
  0xE0, 0x16, 0x48, 0x8C, 0x40, 0x23, 0x11, 0x36, 0x40, 0xD6, 0x66, 0x44,
  0xF4, 0x40, 0x58, 0xE0, 0x50, 0x08, 0x84, 0x46, 0x22, 0x00, 0x69, 0xD9,
  0xAE, 0x3C, 0xA5, 0xC0, 0x30, 0x44, 0x44, 0x78, 0x30, 0x4C, 0x21, 0x78,
  0x19, 0x4C, 0xAF, 0x88, 0x39, 0x1C, 0x21, 0x78, 0x3C, 0xEB, 0xAE, 0xF3,
  0x24, 0x48, 0x79, 0x6A, 0xAE, 0x32, 0x52, 0xF1, 0x30, 0x6C, 0x24, 0x6C,
  0x25, 0x00, 0x3C, 0xC2, 0x78, 0x1C, 0x41, 0xCC, 0x80, 0x71, 0x24, 0x0C,
  0x3A, 0x5F, 0x5B, 0x21, 0xC0, 0x13, 0x35, 0x79, 0x3A, 0x5C, 0xB5, 0x78,
  0x7C, 0x88, 0x8E, 0x32, 0x52, 0xB5, 0x70, 0x3B, 0x1C, 0x84, 0x38, 0x74,
  0xE8, 0x88, 0x7C, 0x8A, 0xAE, 0x6A, 0x5E, 0xA5, 0x48, 0x38, 0x88, 0x42,
  0x78, 0x38, 0x44, 0x21, 0x70, 0x6A, 0x98, 0xC5, 0x68, 0x26, 0x44, 0x47,
  0x2B, 0xDE, 0xD9, 0x48, 0x6B, 0x5A, 0xE5, 0x48, 0x69, 0x99, 0xAE, 0x3A,
  0x52, 0xE4, 0x60, 0x69, 0x99, 0xAE, 0x46, 0x32, 0x56, 0xE5, 0x68, 0x3A,
  0x18, 0x61, 0x78, 0xF2, 0x44, 0x44, 0xD9, 0x9A, 0xAE, 0x94, 0xA9, 0x4A,
  0x60, 0x4A, 0x5A, 0xD5, 0x68, 0x29, 0xCC, 0x65, 0x68, 0x96, 0x98, 0x84,
  0x20, 0x38, 0x8C, 0x44, 0x78, 0x34, 0x44, 0xC8, 0xC0, 0xAA, 0xA4, 0x30,
  0x84, 0x22, 0x13, 0x80, 0x26, 0x90, 0xF0, 0x90, 0x7A, 0xAE, 0x23, 0x1C,
  0xB5, 0x78, 0x78, 0x8E, 0x11, 0x7A, 0xAE, 0x7B, 0xCE, 0x19, 0x1E, 0x42,
  0x33, 0x00, 0x3A, 0x94, 0xEE, 0x00, 0x26, 0x75, 0x55, 0x63, 0x24, 0xC0,
  0x10, 0x71, 0x32, 0xE0, 0x21, 0x16, 0xC7, 0x28, 0xE9, 0x24, 0xC0, 0x7B,
  0x5D, 0x20, 0x75, 0x55, 0x6B, 0xAE, 0x72, 0xD5, 0xE8, 0x00, 0x7A, 0xAE,
  0x20, 0x78, 0x88, 0x33, 0x05, 0xE0, 0x4F, 0x4C, 0x60, 0xBA, 0xAE, 0x9A,
  0xAC, 0x9D, 0xAA, 0x59, 0x8C, 0xA0, 0x4A, 0x94, 0x4C, 0x00, 0x78, 0x98,
  0xE0, 0x32, 0x48, 0x48, 0xE0, 0x25, 0x24, 0xA0, 0x31, 0x11, 0x22, 0xC0,
  0x6D, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 3, 3, 5, 2, -6 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 7, 5, 0, -6 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 1, 3, 5, 3, -6 },
  { 25, 4, 7, 5, 1, -6 },
  { 29, 4, 7, 5, 0, -6 },
  { 33, 4, 4, 5, 1, -6 },
  { 35, 4, 5, 5, 1, -4 },
  { 38, 2, 3, 5, 1, -2 },
  { 39, 3, 1, 5, 1, -3 },
  { 40, 2, 2, 5, 1, -2 },
  { 41, 5, 7, 5, 0, -6 },
  { 46, 4, 6, 5, 1, -6 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 4, 6, 5, 1, -6 },
  { 71, 4, 6, 5, 1, -6 },
  { 74, 4, 6, 5, 1, -6 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 3, 5, 5, 1, -5 },
  { 83, 3, 6, 5, 1, -5 },
  { 86, 4, 4, 5, 1, -4 },
  { 88, 5, 3, 5, 0, -4 },
  { 90, 5, 4, 5, 0, -4 },
  { 93, 4, 6, 5, 1, -6 },
  { 96, 5, 7, 5, 0, -6 },
  { 101, 4, 6, 5, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 4, 6, 5, 1, -6 },
  { 122, 4, 6, 5, 1, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 4, 6, 5, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 4, 6, 5, 1, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 8, 5, 1, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 4, 6, 5, 1, -6 },
  { 174, 4, 6, 5, 1, -6 },
  { 177, 5, 6, 5, 1, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 5, 6, 5, 1, -6 },
  { 193, 5, 6, 5, 0, -6 },
  { 197, 4, 7, 5, 1, -6 },
  { 201, 2, 7, 5, 2, -6 },
  { 203, 5, 7, 5, 0, -6 },
  { 208, 4, 3, 5, 1, -6 },
  { 210, 4, 1, 5, 0, 0 },
  { 211, 2, 2, 5, 2, -6 },
  { 212, 4, 4, 5, 1, -4 },
  { 214, 5, 6, 5, 0, -6 },
  { 218, 4, 4, 5, 1, -4 },
  { 220, 4, 6, 5, 1, -6 },
  { 223, 4, 4, 5, 1, -4 },
  { 225, 5, 7, 5, 0, -6 },
  { 230, 5, 5, 5, 0, -4 },
  { 234, 4, 6, 5, 0, -6 },
  { 237, 3, 6, 5, 1, -6 },
  { 240, 4, 7, 5, 0, -6 },
  { 244, 5, 6, 5, 0, -6 },
  { 248, 3, 6, 5, 1, -6 },
  { 251, 5, 4, 5, 0, -4 },
  { 254, 4, 4, 5, 0, -4 },
  { 256, 4, 4, 5, 1, -4 },
  { 258, 5, 5, 5, 0, -4 },
  { 262, 4, 5, 5, 1, -4 },
  { 265, 4, 4, 5, 1, -4 },
  { 267, 5, 4, 5, 0, -4 },
  { 270, 4, 5, 5, 1, -5 },
  { 273, 4, 4, 5, 1, -4 },
  { 275, 4, 4, 5, 1, -4 },
  { 277, 4, 4, 5, 1, -4 },
  { 279, 5, 4, 5, 0, -4 },
  { 282, 5, 5, 5, 0, -4 },
  { 286, 5, 4, 5, 0, -4 },
  { 289, 4, 7, 5, 1, -6 },
  { 293, 3, 7, 5, 1, -6 },
  { 296, 4, 7, 5, 0, -6 },
  { 300, 5, 2, 5, 0, -3 },
};

const GFXfont UbuntuMono_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic9pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _UBUNTUMONO_BOLDITALIC9PT7B_H_
