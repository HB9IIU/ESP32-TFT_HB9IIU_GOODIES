#ifndef _UBUNTUMONO_BOLDITALIC32PT7B_H_
#define _UBUNTUMONO_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3F, 0x0F, 0x00,
  0x79, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x18,
  0xE3, 0x80, 0x00, 0xE3, 0x80, 0xF3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x38,
  0xE1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0x3C, 0x07, 0x1C, 0x03,
  0x8E, 0x03, 0xCF, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x71, 0xC0,
  0x79, 0xC0, 0x38, 0xE0, 0x1C, 0xF0, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x86, 0x1F,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x30, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x7C, 0x1C, 0x0E, 0xC1, 0xC1, 0xCC, 0x38, 0x1C, 0xC7, 0x01,
  0xCC, 0xE0, 0x19, 0xDC, 0x01, 0xDB, 0x80, 0x1F, 0xB8, 0x00, 0xF7, 0x00,
  0x00, 0xEF, 0x00, 0x1D, 0xF0, 0x03, 0xBB, 0x80, 0x33, 0x38, 0x07, 0x73,
  0x80, 0xE7, 0x30, 0x1C, 0x73, 0x03, 0x87, 0x70, 0x70, 0x3E, 0x06, 0x03,
  0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x1C, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x38, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xC6, 0x1F, 0xCF, 0x3F,
  0xCE, 0x79, 0xEE, 0x70, 0xFC, 0x70, 0xFC, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xFC, 0x7F, 0xDC, 0x1F, 0x1C, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x38, 0xE3,
  0x00, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x18, 0x00, 0x00,
  0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1C, 0x00, 0x40, 0x00, 0x07, 0x00, 0x38,
  0x11, 0xC4, 0xEE, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xF0, 0x1F, 0xC1,
  0xEF, 0x1F, 0x7C, 0x71, 0xC0, 0x88, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x1F,
  0x3F, 0x3F, 0x3F, 0x1E, 0x0E, 0x1C, 0xF8, 0xF0, 0x80, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFE, 0x39, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0xF1, 0xE1, 0xE7, 0x83, 0xCE,
  0x07, 0xBC, 0x0F, 0x79, 0x9E, 0xE7, 0xBD, 0xCE, 0x7F, 0x80, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0xFF, 0xC0, 0xFF, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFC, 0x1F, 0xE3, 0xFF, 0x0F, 0x78,
  0x77, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x01,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x1F, 0x04, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x06, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x60,
  0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xEE, 0x01, 0xDE, 0x03, 0x9E, 0x07, 0x1E, 0x0E,
  0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFE, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x80, 0x78, 0x60, 0x78, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE,
  0x0F, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3B, 0xE0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x78, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0x78, 0x3C, 0x78, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF1, 0xE0, 0xE3, 0x81, 0xC7,
  0x87, 0x8F, 0x1E, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xE7, 0xC7, 0x87,
  0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xE7,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x3C, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFB, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xE1, 0xFF, 0x83,
  0xFC, 0x07, 0xC0, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x7C, 0xFC, 0xFC, 0xF8, 0x70, 0x03, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0x78, 0x0E, 0x07, 0x0F, 0x83, 0xC0, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1E, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x01, 0x00,
  0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x10, 0x00, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x7F, 0x0F, 0xF1, 0xFE, 0x0F,
  0xE0, 0x3C, 0x00, 0x80, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xF6, 0x1F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x1C, 0x07, 0x38, 0x07, 0x78,
  0x7F, 0x71, 0xFF, 0x73, 0xFE, 0xE3, 0xCE, 0xE7, 0x9E, 0xE7, 0x1E, 0xE7,
  0x1C, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0x3C, 0xE7, 0xF8, 0xE3, 0xF8, 0xE1,
  0xF8, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0, 0xF7,
  0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x70, 0xF1, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x7C, 0x7F,
  0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8,
  0x23, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x20, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3E, 0x78,
  0x3C, 0x78, 0x7C, 0x78, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x82, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x78, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xE0, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x3F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x70, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E,
  0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x81, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x03, 0x81, 0xC1,
  0xE0, 0xF0, 0x7C, 0x3C, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0x70, 0xFD,
  0xD8, 0x3B, 0x6E, 0x1C, 0xFB, 0x87, 0x3C, 0xE1, 0xCF, 0x78, 0xF3, 0x9C,
  0x3C, 0xE7, 0x0E, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1C,
  0x03, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF8,
  0x38, 0x3E, 0x1E, 0x1F, 0x87, 0x87, 0xF1, 0xC1, 0xFC, 0x70, 0x77, 0x3C,
  0x1D, 0xCF, 0x0F, 0x33, 0x83, 0xCE, 0xE0, 0xE3, 0xB8, 0x38, 0xFE, 0x1E,
  0x1F, 0x87, 0x87, 0xC1, 0xC1, 0xF0, 0x70, 0x7C, 0x3C, 0x1F, 0x0F, 0x03,
  0x83, 0x80, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0xF1, 0xE1,
  0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F,
  0x0F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0xF1, 0xE1, 0xE7, 0x83, 0xCF,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFC, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xC0, 0x07,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0xF0,
  0x3C, 0xF0, 0x3C, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x06, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x70,
  0x7C, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03,
  0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x70, 0xF0, 0x70, 0xE0,
  0x71, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0E, 0x01, 0xC3, 0x80,
  0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78,
  0xF3, 0x9C, 0x39, 0xE7, 0x0E, 0x79, 0xC3, 0xBE, 0x70, 0xED, 0xB8, 0x77,
  0x6E, 0x1D, 0x9B, 0x87, 0xE6, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x78, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x1E, 0x03,
  0xC1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0xE0, 0x3D, 0xE0, 0x7B, 0xC1,
  0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x3C, 0x1C, 0x78, 0x3D, 0xE0, 0x7F, 0x80,
  0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0xE3, 0x8F, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x8F, 0x3C, 0xF3, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xE7, 0x87, 0x8F, 0x1F,
  0x1E, 0x7C, 0x1E, 0xF0, 0x3C, 0xC0, 0x78, 0x00, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0xE3, 0xE3, 0xE3, 0xC1, 0x80, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF1, 0xF1, 0xE7, 0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F,
  0x8C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x78, 0xF8, 0xF0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x3C, 0xF0, 0x79,
  0xE3, 0xE3, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xFC,
  0x7F, 0xF1, 0xF8, 0x23, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x8F,
  0x0F, 0x87, 0x87, 0x83, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xF3, 0xC0,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0x9C,
  0x1F, 0x3F, 0xFC, 0xFF, 0xE1, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x87, 0xFF,
  0x07, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xC2, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x8F,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x60,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F,
  0xFC, 0x3F, 0xFC, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x07,
  0xF8, 0xFF, 0x1F, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x9F, 0xF1, 0xFE, 0x1F, 0x80, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x21, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x3C, 0xF8, 0x3D, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x7B, 0xC0, 0x79, 0xE0, 0x79, 0xE0,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xFF, 0x3F, 0xCF, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xFE, 0x7F, 0xCF, 0xE0,
  0x0F, 0x9E, 0x1F, 0xFF, 0x1F, 0xFF, 0x3C, 0xE7, 0x39, 0xE7, 0x39, 0xCF,
  0x39, 0xCE, 0x79, 0xCE, 0x73, 0xCE, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C,
  0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8,
  0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78,
  0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBE, 0x3C, 0x7F, 0xF1, 0xFF, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3C, 0x3E,
  0x3C, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9,
  0xF1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0xC7, 0x87, 0xFF, 0x0F, 0xFE, 0x07, 0xBC, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x03, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0x18, 0x3C, 0xFF, 0xF3,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x04, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x1C,
  0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0xC7, 0x87, 0xFF, 0x8F,
  0xFF, 0x0F, 0x9C, 0x00, 0xF0, 0x3F, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7,
  0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x38,
  0x03, 0x9C, 0x03, 0xCE, 0x39, 0xC7, 0x3C, 0xE3, 0x9E, 0x73, 0x9F, 0x71,
  0xCF, 0xB8, 0xEF, 0xDC, 0x76, 0xFC, 0x3F, 0x7E, 0x1F, 0x1E, 0x0F, 0x8F,
  0x07, 0x87, 0x83, 0x83, 0x80, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0x78, 0xF0,
  0x1E, 0x78, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7D, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0x9E,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x47, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x0F, 0x80, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x00, 0x1E, 0x0C, 0x7F, 0x3D, 0xFF,
  0xF7, 0xFF, 0xEE, 0x3F, 0x8C, 0x1E, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 20, 16, 5, -20 },
  { 24, 12, 9, 16, 6, -22 },
  { 38, 17, 20, 16, 1, -20 },
  { 81, 16, 25, 16, 1, -22 },
  { 131, 20, 20, 16, 0, -20 },
  { 181, 16, 20, 16, 1, -20 },
  { 221, 6, 10, 16, 9, -22 },
  { 229, 13, 28, 16, 4, -23 },
  { 275, 13, 28, 16, 1, -23 },
  { 321, 13, 13, 16, 4, -20 },
  { 343, 14, 15, 16, 2, -16 },
  { 370, 8, 11, 16, 3, -6 },
  { 381, 10, 4, 16, 4, -10 },
  { 386, 6, 6, 16, 5, -6 },
  { 391, 19, 27, 16, 0, -22 },
  { 456, 15, 20, 16, 2, -20 },
  { 494, 13, 20, 16, 2, -20 },
  { 527, 16, 20, 16, 1, -20 },
  { 567, 16, 20, 16, 1, -20 },
  { 607, 16, 20, 16, 1, -20 },
  { 647, 17, 20, 16, 1, -20 },
  { 690, 16, 20, 16, 2, -20 },
  { 730, 15, 20, 16, 4, -20 },
  { 768, 15, 20, 16, 2, -20 },
  { 806, 15, 20, 16, 2, -20 },
  { 844, 8, 16, 16, 5, -16 },
  { 860, 10, 21, 16, 3, -16 },
  { 887, 15, 13, 16, 2, -15 },
  { 912, 16, 9, 16, 1, -13 },
  { 930, 14, 13, 16, 2, -15 },
  { 953, 12, 20, 16, 5, -20 },
  { 983, 16, 24, 16, 2, -20 },
  { 1031, 15, 20, 16, 0, -20 },
  { 1069, 16, 20, 16, 1, -20 },
  { 1109, 15, 20, 16, 3, -20 },
  { 1147, 16, 20, 16, 1, -20 },
  { 1187, 16, 20, 16, 2, -20 },
  { 1227, 17, 20, 16, 2, -20 },
  { 1270, 16, 20, 16, 2, -20 },
  { 1310, 18, 20, 16, 1, -20 },
  { 1355, 17, 20, 16, 1, -20 },
  { 1398, 17, 20, 16, 1, -20 },
  { 1441, 18, 20, 16, 1, -20 },
  { 1486, 14, 20, 16, 1, -20 },
  { 1521, 18, 20, 16, 0, -20 },
  { 1566, 18, 20, 16, 1, -20 },
  { 1611, 15, 20, 16, 2, -20 },
  { 1649, 17, 20, 16, 1, -20 },
  { 1692, 15, 25, 16, 2, -20 },
  { 1739, 16, 20, 16, 1, -20 },
  { 1779, 16, 20, 16, 1, -20 },
  { 1819, 15, 20, 16, 4, -20 },
  { 1857, 17, 20, 16, 2, -20 },
  { 1900, 16, 20, 16, 4, -20 },
  { 1940, 18, 20, 16, 1, -20 },
  { 1985, 20, 20, 16, 0, -20 },
  { 2035, 15, 20, 16, 5, -20 },
  { 2073, 17, 20, 16, 1, -20 },
  { 2116, 15, 27, 16, 3, -22 },
  { 2167, 6, 27, 16, 7, -22 },
  { 2188, 16, 27, 16, 0, -22 },
  { 2242, 15, 12, 16, 2, -20 },
  { 2265, 15, 3, 16, -1, 2 },
  { 2271, 7, 6, 16, 8, -22 },
  { 2277, 15, 15, 16, 2, -15 },
  { 2306, 15, 22, 16, 1, -22 },
  { 2348, 15, 15, 16, 2, -15 },
  { 2377, 17, 22, 16, 2, -22 },
  { 2424, 15, 15, 16, 2, -15 },
  { 2453, 20, 27, 16, -1, -22 },
  { 2521, 17, 20, 16, 0, -15 },
  { 2564, 15, 22, 16, 1, -22 },
  { 2606, 11, 22, 16, 4, -22 },
  { 2637, 15, 27, 16, 0, -22 },
  { 2688, 16, 22, 16, 2, -22 },
  { 2732, 10, 22, 16, 5, -22 },
  { 2760, 16, 15, 16, 1, -15 },
  { 2790, 15, 15, 16, 1, -15 },
  { 2819, 14, 15, 16, 2, -15 },
  { 2846, 16, 20, 16, 0, -15 },
  { 2886, 15, 20, 16, 2, -15 },
  { 2924, 15, 15, 16, 2, -15 },
  { 2953, 14, 15, 16, 2, -15 },
  { 2980, 13, 19, 16, 4, -19 },
  { 3011, 15, 15, 16, 2, -15 },
  { 3040, 15, 15, 16, 3, -15 },
  { 3069, 17, 15, 16, 2, -15 },
  { 3101, 18, 15, 16, 0, -15 },
  { 3135, 19, 20, 16, -1, -15 },
  { 3183, 15, 15, 16, 2, -15 },
  { 3212, 16, 27, 16, 3, -22 },
  { 3266, 11, 27, 16, 4, -22 },
  { 3304, 15, 27, 16, 0, -22 },
  { 3355, 15, 6, 16, 2, -11 },
};

const GFXfont UbuntuMono_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic32pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUMONO_BOLDITALIC32PT7B_H_
