#ifndef _UBUNTUMONO_BOLDITALIC17PT7B_H_
#define _UBUNTUMONO_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0xE7, 0x31, 0x8C, 0x07, 0x30, 0x6D, 0xBC, 0xF2, 0xC8,
  0x09, 0x0D, 0x86, 0xCF, 0xF7, 0xF1, 0x23, 0xFD, 0xFC, 0xC8, 0x6C, 0x26,
  0x00, 0x06, 0x04, 0x1F, 0x3F, 0x70, 0x70, 0x3C, 0x1E, 0x06, 0x06, 0xFE,
  0x7C, 0x30, 0x30, 0x18, 0xCB, 0x22, 0x90, 0xAC, 0x36, 0x03, 0x00, 0xB8,
  0x5A, 0x34, 0x99, 0x4C, 0x70, 0x1E, 0x3E, 0x36, 0x26, 0x3C, 0x38, 0x7B,
  0xDE, 0xCE, 0xFE, 0x76, 0xFB, 0x68, 0x02, 0x18, 0x61, 0x83, 0x0C, 0x18,
  0x20, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x08, 0x00, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0xC1, 0x06, 0x0C, 0x18, 0x61, 0xC3, 0x1C, 0x20, 0x00, 0x18, 0x21,
  0x5F, 0xF3, 0x8D, 0x8A, 0x00, 0x0C, 0x08, 0x18, 0xFF, 0xFE, 0x10, 0x30,
  0x30, 0x77, 0x76, 0xC0, 0x7B, 0xE0, 0xFF, 0x00, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0x7B, 0xDB, 0xC3, 0xC6, 0xCE,
  0x7C, 0x78, 0x06, 0x3D, 0xF1, 0x60, 0xC1, 0x86, 0x0C, 0x19, 0xFF, 0xF8,
  0x1E, 0x3F, 0x23, 0x03, 0x06, 0x0E, 0x38, 0x70, 0x60, 0xFE, 0xFE, 0x1E,
  0x3F, 0x23, 0x07, 0x1E, 0x3C, 0x06, 0x06, 0x8E, 0xFC, 0xF8, 0x03, 0x07,
  0x0B, 0x16, 0x26, 0x46, 0xFF, 0xFF, 0x0C, 0x0C, 0x0C, 0x1F, 0x1F, 0x30,
  0x30, 0x38, 0x7E, 0x0E, 0x06, 0x06, 0xFC, 0xF8, 0x07, 0x1F, 0x38, 0x60,
  0x7E, 0xFE, 0xC7, 0xC3, 0xE6, 0x7E, 0x3C, 0x7F, 0xFF, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x1E, 0x3F, 0x33, 0x23, 0x36, 0x3C,
  0x66, 0xC6, 0xC6, 0xFE, 0x7C, 0x1E, 0x3F, 0x63, 0x63, 0x63, 0x7F, 0x3F,
  0x06, 0x1C, 0xF8, 0xF0, 0x77, 0x70, 0x0E, 0xEC, 0x39, 0xCE, 0x00, 0x39,
  0xCE, 0x66, 0x00, 0x01, 0x0F, 0x7E, 0x70, 0xF0, 0x7C, 0x1E, 0x04, 0x7F,
  0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x60, 0x78, 0x3E, 0x0F, 0x0E, 0x7E, 0xF0,
  0x80, 0x7B, 0xF8, 0xC3, 0x18, 0xC6, 0x18, 0x03, 0x0C, 0x00, 0x1F, 0x1F,
  0x9C, 0x6D, 0xED, 0xF6, 0xDB, 0x4D, 0xA4, 0xDE, 0x6F, 0x38, 0x0F, 0x83,
  0xC0, 0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x33, 0x33, 0x7F, 0x7F, 0x63, 0xC3,
  0x3E, 0x3F, 0x33, 0x63, 0x7E, 0x7E, 0x66, 0xC7, 0xC6, 0xFE, 0xF8, 0x0F,
  0x0F, 0x8C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x62, 0x3F, 0x0F, 0x00,
  0x3C, 0x3E, 0x73, 0x63, 0x63, 0x63, 0x67, 0xC6, 0xCE, 0xFC, 0xF8, 0x3F,
  0x9F, 0x8C, 0x06, 0x07, 0xE3, 0xF1, 0x80, 0xC0, 0xE0, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x60, 0x30,
  0x00, 0x0F, 0x1F, 0x8C, 0x0C, 0x06, 0x03, 0x1B, 0x19, 0x8C, 0xE6, 0x3F,
  0x0F, 0x80, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x3F, 0x8F, 0xE7, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x70, 0x3F, 0x9F, 0x83, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x38, 0x7F, 0x3F, 0x00, 0x1F, 0x1F, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x8C, 0xFC, 0x78, 0x31, 0x99, 0x9D, 0x8D, 0x87, 0xC3, 0xC1, 0xF1,
  0x98, 0xCC, 0x63, 0x31, 0x80, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0xC1, 0xFF, 0xF0, 0x18, 0xC6, 0x73, 0x98, 0xEA, 0x2B, 0x8B, 0x66, 0xD9,
  0x86, 0x61, 0x10, 0xCC, 0x30, 0x18, 0xC6, 0x33, 0x88, 0xF6, 0x3D, 0x8D,
  0x66, 0x51, 0x9C, 0x67, 0x19, 0xC4, 0x30, 0x1E, 0x3F, 0x73, 0x63, 0x63,
  0xC3, 0xC3, 0xC6, 0xCE, 0x7C, 0x78, 0x3E, 0x3F, 0x33, 0x63, 0x63, 0x7F,
  0x7C, 0xE0, 0xC0, 0xC0, 0xC0, 0x1E, 0x3F, 0x73, 0x63, 0x63, 0xC3, 0xC3,
  0xC6, 0xCE, 0x7C, 0x78, 0x30, 0x3C, 0x0C, 0x3E, 0x3F, 0x33, 0x63, 0x67,
  0x7E, 0x7C, 0xCC, 0xCC, 0xC6, 0xC6, 0x1F, 0x3F, 0x70, 0x60, 0x78, 0x3C,
  0x0E, 0x06, 0x86, 0xFC, 0xF8, 0xFF, 0xFF, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x60, 0x60, 0x31, 0x99, 0x98, 0xCC, 0x66, 0x33, 0x3B, 0x19,
  0x8C, 0xCE, 0x7E, 0x1E, 0x00, 0xC3, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xCC,
  0x58, 0x50, 0x70, 0x60, 0x21, 0xB0, 0xD8, 0x6C, 0x25, 0xB2, 0xDB, 0x6D,
  0xD4, 0xEE, 0x67, 0x33, 0x00, 0x18, 0xC6, 0x61, 0xF8, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x33, 0x18, 0xCE, 0x30, 0xE3, 0x33, 0x99, 0x8D, 0x86,
  0xC3, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x00, 0x1F, 0xC7, 0xE0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x1F, 0xC7, 0xE0, 0x1F, 0x1E,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xF8,
  0xF0, 0x66, 0x66, 0x66, 0x66, 0x66, 0x63, 0x33, 0x30, 0x0F, 0x07, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC3,
  0xC3, 0xE0, 0x0E, 0x1E, 0x3E, 0x37, 0x63, 0x42, 0x7F, 0xFF, 0x4E, 0x20,
  0x1F, 0x7F, 0x66, 0xC6, 0xC6, 0xC6, 0xFE, 0x76, 0x30, 0x30, 0x30, 0x30,
  0x7E, 0x7E, 0x67, 0x67, 0xE6, 0xCE, 0xFC, 0xF8, 0x1F, 0x3F, 0x70, 0xE0,
  0xC0, 0xE0, 0x7E, 0x3E, 0x01, 0x81, 0xC0, 0xC0, 0x61, 0xF3, 0xF9, 0x99,
  0x8C, 0xC6, 0x63, 0x3F, 0x8F, 0xC0, 0x1E, 0x3F, 0x63, 0xC6, 0xFC, 0xC0,
  0x7E, 0x3C, 0x01, 0xE0, 0x7C, 0x1C, 0x03, 0x01, 0xFC, 0x3F, 0x81, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x0F,
  0x8F, 0xCC, 0x66, 0x66, 0x33, 0x18, 0xFC, 0x7C, 0x06, 0x7E, 0x3E, 0x00,
  0x38, 0x60, 0xC1, 0x87, 0xEF, 0xD9, 0xB3, 0x67, 0x8F, 0x3E, 0x60, 0x18,
  0x60, 0x3C, 0xF0, 0xC3, 0x18, 0x61, 0xF3, 0xC0, 0x03, 0x03, 0x00, 0x1F,
  0x3F, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x8C, 0xFC, 0xF8, 0x18, 0x18,
  0x0C, 0x06, 0x03, 0x33, 0xB1, 0xB0, 0xF0, 0x7C, 0x76, 0x33, 0x98, 0xC0,
  0x79, 0xE1, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x87, 0xCF, 0x3F, 0x9F, 0xC9,
  0x6D, 0xB6, 0xD3, 0x09, 0x0D, 0x86, 0x3E, 0xFD, 0x9B, 0x36, 0x78, 0xF3,
  0xE6, 0x1E, 0x7E, 0x67, 0xC7, 0xC6, 0xC6, 0xFC, 0x78, 0x1F, 0x1F, 0x8C,
  0xE6, 0x33, 0x33, 0x39, 0xF8, 0xF8, 0x60, 0x60, 0x30, 0x00, 0x1F, 0x3F,
  0x63, 0xE6, 0xC6, 0xC6, 0xFE, 0x7C, 0x0C, 0x0C, 0x0C, 0x3F, 0x3F, 0x30,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0x1E, 0x3E, 0x60, 0x38, 0x1C, 0x06, 0xFC,
  0xF8, 0x30, 0x63, 0xFF, 0xF6, 0x0C, 0x18, 0x30, 0x7C, 0xF8, 0x63, 0x67,
  0x66, 0x66, 0xC6, 0xCE, 0xFE, 0x76, 0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x1C,
  0x30, 0x41, 0xA0, 0xB6, 0xDB, 0x6F, 0xA7, 0x73, 0xB1, 0x98, 0x31, 0x8D,
  0x87, 0x81, 0xC1, 0xC1, 0xF0, 0xD8, 0xC6, 0x18, 0xC6, 0x31, 0x98, 0x66,
  0x1B, 0x03, 0xC0, 0xE0, 0x38, 0x0C, 0x1E, 0x0F, 0x00, 0x3F, 0x3F, 0x0E,
  0x18, 0x30, 0x60, 0xFE, 0xFC, 0x0F, 0x1F, 0x18, 0x18, 0x18, 0x30, 0x30,
  0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x78, 0x78, 0x0C, 0x61, 0x86, 0x18,
  0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8C, 0x00, 0x1E, 0x1E, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x07, 0x0F, 0x0C, 0x1C, 0x18, 0x18, 0xF8, 0xF0, 0x73,
  0xFE, 0xCE,
};

const GFXglyph UbuntuMono_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 11, 9, 3, -11 },
  { 8, 6, 5, 9, 3, -12 },
  { 12, 9, 11, 9, 1, -11 },
  { 25, 8, 14, 9, 1, -12 },
  { 39, 10, 11, 9, 0, -11 },
  { 53, 8, 11, 9, 1, -11 },
  { 64, 3, 5, 9, 5, -12 },
  { 66, 7, 15, 9, 2, -12 },
  { 80, 7, 15, 9, 1, -12 },
  { 94, 7, 7, 9, 2, -11 },
  { 101, 8, 8, 9, 1, -8 },
  { 109, 4, 5, 9, 2, -3 },
  { 112, 6, 2, 9, 2, -5 },
  { 114, 3, 3, 9, 3, -3 },
  { 116, 10, 15, 9, 0, -12 },
  { 135, 8, 11, 9, 1, -11 },
  { 146, 7, 11, 9, 1, -11 },
  { 156, 8, 11, 9, 1, -11 },
  { 167, 8, 11, 9, 1, -11 },
  { 178, 8, 11, 9, 1, -11 },
  { 189, 8, 11, 9, 1, -11 },
  { 200, 8, 11, 9, 1, -11 },
  { 211, 8, 11, 9, 2, -11 },
  { 222, 8, 11, 9, 1, -11 },
  { 233, 8, 11, 9, 1, -11 },
  { 244, 4, 8, 9, 3, -8 },
  { 248, 5, 10, 9, 2, -8 },
  { 255, 8, 8, 9, 1, -8 },
  { 263, 8, 6, 9, 1, -7 },
  { 269, 8, 8, 9, 1, -8 },
  { 277, 6, 11, 9, 3, -11 },
  { 286, 9, 13, 9, 1, -11 },
  { 301, 8, 11, 9, 0, -11 },
  { 312, 8, 11, 9, 1, -11 },
  { 323, 9, 11, 9, 1, -11 },
  { 336, 8, 11, 9, 1, -11 },
  { 347, 9, 11, 9, 1, -11 },
  { 360, 9, 11, 9, 1, -11 },
  { 373, 9, 11, 9, 1, -11 },
  { 386, 10, 11, 9, 0, -11 },
  { 400, 9, 11, 9, 1, -11 },
  { 413, 8, 11, 9, 1, -11 },
  { 424, 9, 11, 9, 1, -11 },
  { 437, 7, 11, 9, 1, -11 },
  { 447, 10, 11, 9, 0, -11 },
  { 461, 10, 11, 9, 0, -11 },
  { 475, 8, 11, 9, 1, -11 },
  { 486, 8, 11, 9, 1, -11 },
  { 497, 8, 14, 9, 1, -11 },
  { 511, 8, 11, 9, 1, -11 },
  { 522, 8, 11, 9, 1, -11 },
  { 533, 8, 11, 9, 2, -11 },
  { 544, 9, 11, 9, 1, -11 },
  { 557, 8, 11, 9, 2, -11 },
  { 568, 9, 11, 9, 1, -11 },
  { 581, 10, 11, 9, 0, -11 },
  { 595, 9, 11, 9, 2, -11 },
  { 608, 10, 11, 9, 0, -11 },
  { 622, 8, 15, 9, 2, -12 },
  { 637, 4, 15, 9, 3, -12 },
  { 645, 9, 15, 9, 0, -12 },
  { 662, 8, 6, 9, 1, -11 },
  { 668, 8, 2, 9, -1, 1 },
  { 670, 4, 3, 9, 4, -12 },
  { 672, 8, 8, 9, 1, -8 },
  { 680, 8, 12, 9, 1, -12 },
  { 692, 8, 8, 9, 1, -8 },
  { 700, 9, 12, 9, 1, -12 },
  { 714, 8, 8, 9, 1, -8 },
  { 722, 11, 15, 9, -1, -12 },
  { 743, 9, 11, 9, 0, -8 },
  { 756, 7, 12, 9, 1, -12 },
  { 767, 6, 11, 9, 2, -11 },
  { 776, 8, 14, 9, 0, -11 },
  { 790, 9, 12, 9, 1, -12 },
  { 804, 6, 12, 9, 2, -12 },
  { 813, 9, 8, 9, 0, -8 },
  { 822, 7, 8, 9, 1, -8 },
  { 829, 8, 8, 9, 1, -8 },
  { 837, 9, 11, 9, 0, -8 },
  { 850, 8, 11, 9, 1, -8 },
  { 861, 8, 8, 9, 1, -8 },
  { 869, 8, 8, 9, 1, -8 },
  { 877, 7, 10, 9, 2, -10 },
  { 886, 8, 8, 9, 1, -8 },
  { 894, 7, 8, 9, 2, -8 },
  { 901, 9, 8, 9, 1, -8 },
  { 910, 9, 8, 9, 0, -8 },
  { 919, 10, 11, 9, -1, -8 },
  { 933, 8, 8, 9, 1, -8 },
  { 941, 8, 15, 9, 2, -12 },
  { 956, 6, 15, 9, 2, -12 },
  { 968, 8, 15, 9, 0, -12 },
  { 983, 8, 3, 9, 1, -6 },
};

const GFXfont UbuntuMono_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic17pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUMONO_BOLDITALIC17PT7B_H_
