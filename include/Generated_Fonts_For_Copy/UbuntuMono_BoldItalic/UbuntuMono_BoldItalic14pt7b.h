#ifndef _UBUNTUMONO_BOLDITALIC14PT7B_H_
#define _UBUNTUMONO_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x0E, 0xC0, 0xDE, 0xA5, 0x60, 0x0B, 0x1A, 0x7F,
  0x34, 0x34, 0x24, 0x7E, 0x48, 0x58, 0x08, 0x71, 0xF3, 0x07, 0x87, 0x03,
  0x7C, 0xF8, 0xC1, 0x80, 0x31, 0x35, 0x15, 0x87, 0x80, 0x80, 0xB0, 0xA8,
  0xD4, 0xCC, 0x00, 0x39, 0xB6, 0xDA, 0x73, 0xD9, 0xE6, 0xFC, 0xFE, 0x08,
  0x63, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x06, 0x10, 0x10, 0x86, 0x30, 0x84,
  0x63, 0x33, 0x31, 0x00, 0x25, 0x7E, 0xA5, 0x00, 0x10, 0x4F, 0xC8, 0x20,
  0x37, 0x72, 0xC0, 0xFF, 0x7F, 0x00, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x3C, 0xF9, 0x96, 0xAD, 0x59, 0xB3,
  0x7C, 0x70, 0x18, 0xE7, 0x86, 0x10, 0xC3, 0x3E, 0xF8, 0x3D, 0xF0, 0x43,
  0x18, 0xC4, 0x3E, 0xF8, 0x1E, 0x3C, 0x08, 0xF1, 0xC0, 0xC1, 0xBE, 0x78,
  0x0C, 0x38, 0xF1, 0x64, 0x9F, 0xBF, 0x0C, 0x18, 0x1F, 0x1F, 0x10, 0x38,
  0x3C, 0x06, 0x06, 0x7C, 0x78, 0x0E, 0x7D, 0x83, 0xCF, 0xD9, 0xB3, 0x7E,
  0x78, 0xFF, 0xF1, 0x84, 0x31, 0x84, 0x30, 0xC0, 0x3C, 0xF9, 0x9B, 0x63,
  0x99, 0xB3, 0x7E, 0x78, 0x39, 0xFC, 0x51, 0x7C, 0x31, 0xBE, 0xE0, 0x37,
  0x60, 0x6E, 0xC0, 0x19, 0xCC, 0x03, 0x39, 0xC4, 0xC0, 0x04, 0xFF, 0x38,
  0x38, 0x20, 0xFC, 0x0F, 0xC0, 0x41, 0xC1, 0xCF, 0xF2, 0x00, 0x78, 0x46,
  0x77, 0x30, 0x18, 0xC0, 0x1C, 0xED, 0x1E, 0xFB, 0x54, 0xA9, 0x5E, 0x9D,
  0x81, 0xE0, 0x0C, 0x18, 0x51, 0xA2, 0x67, 0xDF, 0xA3, 0xC6, 0x7C, 0xF9,
  0x93, 0xE7, 0xD9, 0xB3, 0x7E, 0xF0, 0x1E, 0x7D, 0x82, 0x0C, 0x18, 0x30,
  0x7C, 0x78, 0x3C, 0x7C, 0xD9, 0x16, 0x2C, 0xDB, 0xBE, 0x78, 0x3E, 0xFD,
  0x83, 0x07, 0xCF, 0x30, 0x7C, 0xF8, 0x3E, 0x7D, 0x83, 0x07, 0xCF, 0xB0,
  0x60, 0xC0, 0x1E, 0x7D, 0x82, 0x0C, 0xD9, 0xB3, 0x7C, 0x78, 0x33, 0x33,
  0x23, 0x3E, 0x7E, 0x66, 0x66, 0x44, 0xCC, 0x3F, 0x3F, 0x0C, 0x08, 0x18,
  0x18, 0x18, 0x7C, 0x7C, 0x3E, 0x78, 0x10, 0x60, 0xC1, 0xA6, 0x7C, 0xF0,
  0x33, 0x36, 0x34, 0x2C, 0x78, 0x68, 0x6C, 0x64, 0x46, 0x23, 0x18, 0xC4,
  0x63, 0x1F, 0xF8, 0x33, 0x33, 0x37, 0x37, 0x7A, 0x5A, 0x46, 0xC6, 0xC6,
  0x31, 0x33, 0x3B, 0x2A, 0x6A, 0x6E, 0x4E, 0x4C, 0xC4, 0x3C, 0xF9, 0x9E,
  0x3C, 0x59, 0xB3, 0x7C, 0x70, 0x3C, 0xFD, 0x9A, 0x37, 0xDF, 0x30, 0x60,
  0x80, 0x3C, 0xF9, 0x9E, 0x3C, 0x59, 0xB3, 0x7C, 0x70, 0xC0, 0xE0, 0x80,
  0x3E, 0x7C, 0xC9, 0x33, 0xEF, 0x1B, 0x32, 0x46, 0x1E, 0x3E, 0x30, 0x38,
  0x3C, 0x0E, 0x06, 0x7C, 0x78, 0xFF, 0xF3, 0x08, 0x61, 0x86, 0x10, 0xC0,
  0x66, 0xCD, 0x1A, 0x6C, 0xD9, 0xB3, 0x7C, 0x70, 0xC5, 0x9B, 0x36, 0xCD,
  0x9A, 0x3C, 0x70, 0xE0, 0x62, 0x42, 0x46, 0xD6, 0xF4, 0xB4, 0xD4, 0xD8,
  0x98, 0x33, 0x09, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0xC8, 0xC6, 0x00,
  0xC5, 0x9B, 0x62, 0x87, 0x0C, 0x18, 0x20, 0x40, 0x1F, 0x3F, 0x06, 0x0C,
  0x18, 0x10, 0x20, 0x7C, 0x7C, 0x1E, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30,
  0x60, 0xC1, 0x07, 0x80, 0xDB, 0x6D, 0xB2, 0x49, 0xB0, 0x1E, 0x0C, 0x10,
  0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x47, 0x80, 0x18, 0x78, 0xB3, 0x64,
  0x40, 0xFC, 0x4C, 0x80, 0x3D, 0xFC, 0xF3, 0xCB, 0xE7, 0xC0, 0x21, 0x86,
  0x1E, 0x7F, 0x3C, 0xF3, 0xFB, 0xC0, 0x3D, 0xFE, 0x30, 0xC3, 0xE7, 0x80,
  0x06, 0x0C, 0x19, 0xE7, 0xD9, 0xB3, 0x64, 0xF8, 0xF8, 0x3D, 0xFC, 0x7F,
  0xC3, 0xE7, 0x80, 0x07, 0x0F, 0x08, 0x3E, 0x3E, 0x18, 0x18, 0x10, 0x30,
  0x30, 0xF0, 0xE0, 0x1E, 0x7D, 0x9B, 0x37, 0xC7, 0x83, 0x7E, 0xF8, 0x30,
  0x86, 0x1E, 0x7D, 0x3C, 0xF2, 0xCA, 0x60, 0x33, 0x0E, 0xE6, 0x64, 0x77,
  0x06, 0x0C, 0x01, 0xF3, 0xC1, 0x83, 0x06, 0x09, 0x33, 0xE7, 0x80, 0x30,
  0x41, 0x83, 0x36, 0xCF, 0x1C, 0x6C, 0xD9, 0x90, 0xFF, 0x26, 0x66, 0x4C,
  0xF7, 0x3E, 0x7D, 0xAB, 0xD4, 0x68, 0xF1, 0x00, 0x79, 0xF4, 0xF3, 0xCB,
  0x29, 0x80, 0x39, 0xFC, 0xF3, 0xCF, 0xE7, 0x00, 0x3C, 0x7C, 0x9B, 0x36,
  0x6D, 0x9E, 0x60, 0xC0, 0x3D, 0xFC, 0xF3, 0xCB, 0xE7, 0x86, 0x18, 0x3D,
  0xF6, 0x18, 0x43, 0x0C, 0x00, 0x3D, 0x86, 0x1E, 0x18, 0x2F, 0x00, 0x23,
  0x3F, 0xF4, 0x63, 0x1E, 0x70, 0x65, 0x3C, 0xF3, 0xCB, 0xE7, 0xC0, 0x46,
  0x99, 0x32, 0xC7, 0x8E, 0x18, 0x00, 0xC7, 0xAE, 0xD5, 0xAF, 0xDB, 0x36,
  0x00, 0x32, 0x36, 0x1C, 0x18, 0x3C, 0x6C, 0x44, 0x11, 0x09, 0x86, 0xC3,
  0xC1, 0xC0, 0xE0, 0x60, 0xE0, 0xE0, 0x00, 0x7D, 0xF1, 0x8C, 0x63, 0xEF,
  0x80, 0x0E, 0x30, 0x40, 0x83, 0x08, 0x08, 0x10, 0x60, 0xC1, 0x81, 0xC0,
  0x13, 0x33, 0x26, 0x66, 0x4C, 0xCC, 0x1C, 0x18, 0x30, 0x60, 0x80, 0xC6,
  0x0C, 0x10, 0x20, 0xC7, 0x00, 0x67, 0xF9, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 9, 7, 2, -9 },
  { 6, 5, 4, 7, 3, -9 },
  { 9, 8, 9, 7, 0, -9 },
  { 18, 7, 11, 7, 1, -10 },
  { 28, 9, 9, 7, 0, -9 },
  { 39, 6, 9, 7, 1, -9 },
  { 46, 2, 4, 7, 4, -9 },
  { 47, 6, 12, 7, 2, -10 },
  { 56, 5, 12, 7, 1, -10 },
  { 64, 5, 5, 7, 2, -9 },
  { 68, 6, 5, 7, 1, -7 },
  { 72, 4, 5, 7, 1, -3 },
  { 75, 4, 2, 7, 2, -4 },
  { 76, 3, 3, 7, 2, -3 },
  { 78, 8, 12, 7, 0, -10 },
  { 90, 7, 9, 7, 1, -9 },
  { 98, 6, 9, 7, 1, -9 },
  { 105, 6, 9, 7, 1, -9 },
  { 112, 7, 9, 7, 0, -9 },
  { 120, 7, 9, 7, 1, -9 },
  { 128, 8, 9, 7, 0, -9 },
  { 137, 7, 9, 7, 1, -9 },
  { 145, 6, 9, 7, 2, -9 },
  { 152, 7, 9, 7, 1, -9 },
  { 160, 6, 9, 7, 1, -9 },
  { 167, 4, 7, 7, 2, -7 },
  { 171, 5, 9, 7, 1, -7 },
  { 177, 6, 6, 7, 1, -7 },
  { 182, 6, 3, 7, 1, -6 },
  { 185, 6, 6, 7, 1, -7 },
  { 190, 5, 9, 7, 2, -9 },
  { 196, 7, 11, 7, 1, -9 },
  { 206, 7, 9, 7, 0, -9 },
  { 214, 7, 9, 7, 1, -9 },
  { 222, 7, 9, 7, 1, -9 },
  { 230, 7, 9, 7, 0, -9 },
  { 238, 7, 9, 7, 1, -9 },
  { 246, 7, 9, 7, 1, -9 },
  { 254, 7, 9, 7, 1, -9 },
  { 262, 8, 9, 7, 0, -9 },
  { 271, 8, 9, 7, 0, -9 },
  { 280, 7, 9, 7, 1, -9 },
  { 288, 8, 9, 7, 0, -9 },
  { 297, 5, 9, 7, 1, -9 },
  { 303, 8, 9, 7, 0, -9 },
  { 312, 8, 9, 7, 0, -9 },
  { 321, 7, 9, 7, 1, -9 },
  { 329, 7, 9, 7, 1, -9 },
  { 337, 7, 12, 7, 1, -9 },
  { 348, 7, 9, 7, 0, -9 },
  { 356, 8, 9, 7, 0, -9 },
  { 365, 6, 9, 7, 2, -9 },
  { 372, 7, 9, 7, 1, -9 },
  { 380, 7, 9, 7, 2, -9 },
  { 388, 8, 9, 7, 1, -9 },
  { 397, 9, 9, 7, 0, -9 },
  { 408, 7, 9, 7, 2, -9 },
  { 416, 8, 9, 7, 0, -9 },
  { 425, 7, 12, 7, 1, -10 },
  { 436, 3, 12, 7, 3, -10 },
  { 441, 7, 12, 7, 0, -10 },
  { 452, 7, 5, 7, 1, -9 },
  { 457, 6, 1, 7, 0, 1 },
  { 458, 3, 3, 7, 3, -10 },
  { 460, 6, 7, 7, 1, -7 },
  { 466, 6, 10, 7, 1, -10 },
  { 474, 6, 7, 7, 1, -7 },
  { 480, 7, 10, 7, 1, -10 },
  { 489, 6, 7, 7, 1, -7 },
  { 495, 8, 12, 7, 0, -10 },
  { 507, 7, 9, 7, 0, -7 },
  { 515, 6, 10, 7, 1, -10 },
  { 523, 4, 10, 7, 2, -10 },
  { 528, 7, 12, 7, 0, -10 },
  { 539, 7, 10, 7, 1, -10 },
  { 548, 4, 10, 7, 2, -10 },
  { 553, 7, 7, 7, 0, -7 },
  { 560, 6, 7, 7, 1, -7 },
  { 566, 6, 7, 7, 1, -7 },
  { 572, 7, 9, 7, 0, -7 },
  { 580, 6, 9, 7, 1, -7 },
  { 587, 6, 7, 7, 1, -7 },
  { 593, 6, 7, 7, 1, -7 },
  { 599, 5, 9, 7, 2, -9 },
  { 605, 6, 7, 7, 1, -7 },
  { 611, 7, 7, 7, 1, -7 },
  { 618, 7, 7, 7, 1, -7 },
  { 625, 8, 7, 7, 0, -7 },
  { 632, 9, 9, 7, -1, -7 },
  { 643, 6, 7, 7, 1, -7 },
  { 649, 7, 12, 7, 1, -10 },
  { 660, 4, 12, 7, 2, -10 },
  { 666, 7, 12, 7, 0, -10 },
  { 677, 6, 3, 7, 1, -5 },
};

const GFXfont UbuntuMono_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic14pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUMONO_BOLDITALIC14PT7B_H_
