#ifndef _UBUNTUMONO_BOLDITALIC45PT7B_H_
#define _UBUNTUMONO_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0,
  0x00, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC,
  0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xE0,
  0x70, 0xE0, 0x70, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF1,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x00,
  0x78, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xC0, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x08, 0x00,
  0xF8, 0x38, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x39, 0xE0, 0x78, 0x07, 0x9E,
  0x07, 0x80, 0x71, 0xE0, 0xF0, 0x0F, 0x1E, 0x1E, 0x00, 0xF1, 0xC3, 0xC0,
  0x0F, 0x1C, 0x78, 0x00, 0xF3, 0xCF, 0x00, 0x0F, 0x38, 0xF0, 0x00, 0xFF,
  0x9E, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0xE0, 0x00,
  0x79, 0xFE, 0x00, 0x0F, 0x3C, 0xE0, 0x01, 0xE3, 0x8F, 0x00, 0x3C, 0x38,
  0xE0, 0x03, 0xC7, 0x8E, 0x00, 0x78, 0x78, 0xE0, 0x0F, 0x07, 0x1E, 0x01,
  0xE0, 0x71, 0xE0, 0x3C, 0x07, 0xBC, 0x07, 0x80, 0x7F, 0x80, 0x78, 0x03,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC7, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01,
  0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x87, 0xC3, 0xFE,
  0x1E, 0x1F, 0xF8, 0x78, 0xFD, 0xF3, 0xE7, 0xC7, 0xEF, 0x1F, 0x0F, 0xFC,
  0xF8, 0x1F, 0xE3, 0xE0, 0x7F, 0x8F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC,
  0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0xF8, 0x3F, 0xF1,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0xFD, 0xFB, 0xFF, 0xDF, 0xBF, 0x7C, 0xF9,
  0xE3, 0xC7, 0x8E, 0x00, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0x8F,
  0x86, 0x71, 0xE7, 0xBF, 0x7B, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x7E, 0x0F, 0xCF, 0xC3,
  0xE3, 0xE0, 0x38, 0x70, 0x04, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x03,
  0xC0, 0xF8, 0x7E, 0x7F, 0x8F, 0xE0, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x1E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x71, 0xF7, 0xE7, 0x8F, 0xBE, 0x7C, 0x7D, 0xF3,
  0xE7, 0xEF, 0x8E, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0xFD,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0x7E, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F,
  0x3F, 0x03, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x07,
  0xF0, 0x30, 0x0F, 0xC0, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0x83, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x08, 0x00, 0xFC, 0x38, 0x0F,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC,
  0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x01, 0xF8, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x38, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x07, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xF0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xC7, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xBF, 0x81, 0xF0, 0x7E, 0x1F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x9F, 0x81, 0xFC, 0xFE, 0x1F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xE1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xC1, 0xFC, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x3F, 0x87, 0xE0, 0xFC, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F,
  0x1F, 0x00, 0x1E, 0x3C, 0x0F, 0xFC, 0xF8, 0x3F, 0xF9, 0xE1, 0xFF, 0xF3,
  0xC3, 0xFF, 0xCF, 0x8F, 0xCF, 0x9E, 0x3E, 0x1F, 0x3C, 0x7C, 0x3E, 0x78,
  0xF0, 0x78, 0xF1, 0xE1, 0xF1, 0xE7, 0xC3, 0xE3, 0xCF, 0x87, 0xCF, 0x9F,
  0x0F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7F, 0xF8, 0x78, 0xFF,
  0xE0, 0xF0, 0xFF, 0xC1, 0xE0, 0x7F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x20, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xE0,
  0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x1F,
  0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x1F,
  0x03, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC1, 0xC0, 0xFC, 0x01, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x03,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7C, 0x3F, 0x80, 0xF8, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0,
  0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0x07, 0xF8,
  0x7E, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC1, 0xC1, 0xFC, 0x01, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0xF8,
  0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x08, 0x07, 0xF0,
  0x3C, 0x1F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xF8,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xDE, 0x03, 0xDC, 0xF7, 0x81, 0xF7, 0x3B,
  0xC0, 0x79, 0xDE, 0xF0, 0x1E, 0x77, 0x3C, 0x07, 0x9F, 0xCF, 0x03, 0xE7,
  0xE7, 0xC0, 0xF1, 0xF9, 0xE0, 0x3C, 0x7C, 0x78, 0x1F, 0x1F, 0x1E, 0x07,
  0xC7, 0x8F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7F, 0x01, 0xF0,
  0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF8, 0x3E,
  0x07, 0xFC, 0x3E, 0x03, 0xDE, 0x1F, 0x03, 0xEF, 0x8F, 0x81, 0xF3, 0xC7,
  0xC0, 0xF9, 0xE7, 0xC0, 0x7C, 0xF3, 0xE0, 0x7C, 0x79, 0xF0, 0x3E, 0x1E,
  0xF8, 0x1F, 0x0F, 0x78, 0x0F, 0x87, 0xFC, 0x0F, 0x83, 0xFE, 0x07, 0xC0,
  0xFF, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0xF8,
  0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F,
  0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0,
  0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF7,
  0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF1, 0xFC, 0x3F,
  0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80,
  0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFE, 0x3F,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0x87, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x87, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x07,
  0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x1C, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x30, 0x03, 0xF0, 0x3C, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0x8F, 0x8F, 0x83, 0xC7, 0xC7, 0x83, 0xE7, 0xE7, 0xC1, 0xF3, 0xF3,
  0xE0, 0xF3, 0xF9, 0xE0, 0x79, 0xDC, 0xF0, 0x3D, 0xEE, 0x78, 0x3E, 0xE7,
  0x7C, 0x1E, 0xF3, 0xBC, 0x0F, 0x71, 0xDE, 0x07, 0xF8, 0xEF, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF7, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFD, 0xF0,
  0x07, 0xE7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x1F,
  0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0xFC, 0x03,
  0xE3, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7E, 0xFC, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7E,
  0x03, 0xE7, 0xF0, 0x1F, 0xBF, 0x00, 0xFC, 0xF0, 0x03, 0xC1, 0x00, 0x10,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x20,
  0x1E, 0x07, 0xC3, 0xF8, 0xFF, 0x8F, 0xE0, 0xF8, 0x0C, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE1,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F,
  0x1F, 0x01, 0xF8, 0xFC, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0x3F, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E,
  0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xF8, 0x3F, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xF0, 0x10, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x0C,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xE1, 0xF8,
  0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFB, 0xE0, 0x0F, 0xC7,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFC, 0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7,
  0xC0, 0x7F, 0x7C, 0x7F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0,
  0xFF, 0x40, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x18, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x10, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x30, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xEF, 0x80, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F,
  0xC0, 0xF8, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC1, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x20, 0x3F,
  0x01, 0xC1, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF,
  0xCF, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x82, 0xFF, 0xF7, 0xFF, 0x9F, 0xFC, 0xFF, 0xE1, 0xFC, 0x01, 0xF8,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xE3, 0xC7, 0xC7, 0xC7, 0x8F, 0x8F, 0x8F, 0x1E, 0x1F, 0x3E, 0x3C,
  0x3C, 0x7C, 0x78, 0x78, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xE7, 0xC7, 0x87,
  0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0,
  0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xF8, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F,
  0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07,
  0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0,
  0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xE3, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3E, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0,
  0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0x87, 0xF0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xE0,
  0x10, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x30, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x20, 0x07, 0xC1, 0xC0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0xFC,
  0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x87, 0xC0,
  0xFC, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x7C, 0x07, 0xE3,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x7C, 0x3F, 0x07,
  0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC7, 0x87, 0xCF, 0x0F, 0x0F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF8, 0xF1, 0xF3, 0xF1, 0xE3, 0xC7,
  0xE7, 0x87, 0x9F, 0xCF, 0x0F, 0x7B, 0xDE, 0x1E, 0xF7, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x07,
  0xCF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x3F, 0xC1,
  0xF1, 0xFF, 0x8F, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xF1, 0xFF, 0x8F,
  0x83, 0xFC, 0x0C, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 13, 29, 23, 7, -28 },
  { 49, 16, 13, 23, 9, -30 },
  { 75, 25, 28, 23, 1, -28 },
  { 163, 22, 35, 23, 2, -31 },
  { 260, 28, 30, 23, 0, -29 },
  { 365, 22, 30, 23, 2, -29 },
  { 448, 7, 13, 23, 13, -30 },
  { 460, 18, 40, 23, 6, -32 },
  { 550, 18, 40, 23, 2, -32 },
  { 640, 18, 17, 23, 6, -28 },
  { 679, 20, 21, 23, 3, -22 },
  { 732, 11, 14, 23, 4, -7 },
  { 752, 14, 5, 23, 6, -14 },
  { 761, 8, 8, 23, 7, -7 },
  { 769, 27, 38, 23, -1, -31 },
  { 898, 21, 30, 23, 3, -29 },
  { 977, 18, 28, 23, 3, -28 },
  { 1040, 22, 29, 23, 2, -29 },
  { 1120, 22, 30, 23, 1, -29 },
  { 1203, 22, 28, 23, 2, -28 },
  { 1280, 24, 29, 23, 1, -28 },
  { 1367, 22, 29, 23, 3, -28 },
  { 1447, 22, 28, 23, 5, -28 },
  { 1524, 21, 30, 23, 3, -29 },
  { 1603, 22, 29, 23, 2, -29 },
  { 1683, 11, 22, 23, 7, -21 },
  { 1714, 14, 28, 23, 4, -21 },
  { 1763, 20, 20, 23, 4, -21 },
  { 1813, 22, 14, 23, 2, -19 },
  { 1852, 21, 20, 23, 2, -21 },
  { 1905, 17, 30, 23, 7, -29 },
  { 1969, 23, 35, 23, 2, -29 },
  { 2070, 21, 28, 23, 0, -28 },
  { 2144, 22, 29, 23, 2, -28 },
  { 2224, 22, 30, 23, 4, -29 },
  { 2307, 23, 30, 23, 1, -29 },
  { 2394, 24, 28, 23, 2, -28 },
  { 2478, 23, 28, 23, 3, -28 },
  { 2559, 22, 30, 23, 4, -29 },
  { 2642, 25, 28, 23, 1, -28 },
  { 2730, 24, 28, 23, 2, -28 },
  { 2814, 23, 29, 23, 2, -28 },
  { 2898, 26, 28, 23, 1, -28 },
  { 2989, 18, 28, 23, 2, -28 },
  { 3052, 26, 28, 23, 0, -28 },
  { 3143, 25, 28, 23, 1, -28 },
  { 3231, 21, 30, 23, 3, -29 },
  { 3310, 23, 28, 23, 2, -28 },
  { 3391, 21, 38, 23, 3, -29 },
  { 3491, 22, 28, 23, 2, -28 },
  { 3568, 24, 30, 23, 1, -29 },
  { 3658, 21, 28, 23, 6, -28 },
  { 3732, 23, 29, 23, 3, -28 },
  { 3816, 22, 28, 23, 6, -28 },
  { 3893, 25, 28, 23, 2, -28 },
  { 3981, 27, 28, 23, 0, -28 },
  { 4076, 22, 28, 23, 6, -28 },
  { 4153, 25, 28, 23, 1, -28 },
  { 4241, 22, 38, 23, 4, -31 },
  { 4346, 9, 38, 23, 9, -31 },
  { 4389, 22, 38, 23, 1, -31 },
  { 4494, 21, 16, 23, 3, -28 },
  { 4536, 22, 4, 23, -2, 3 },
  { 4547, 10, 8, 23, 11, -31 },
  { 4557, 21, 23, 23, 3, -22 },
  { 4618, 21, 33, 23, 2, -32 },
  { 4705, 21, 23, 23, 3, -22 },
  { 4766, 23, 33, 23, 3, -32 },
  { 4861, 20, 23, 23, 3, -22 },
  { 4919, 29, 40, 23, -2, -32 },
  { 5064, 24, 30, 23, 0, -22 },
  { 5154, 20, 32, 23, 2, -32 },
  { 5234, 16, 32, 23, 5, -31 },
  { 5298, 22, 39, 23, 0, -31 },
  { 5406, 24, 32, 23, 2, -32 },
  { 5502, 13, 32, 23, 7, -31 },
  { 5554, 23, 21, 23, 1, -21 },
  { 5615, 20, 22, 23, 2, -22 },
  { 5670, 20, 23, 23, 3, -22 },
  { 5728, 23, 29, 23, 0, -22 },
  { 5812, 21, 29, 23, 3, -22 },
  { 5889, 21, 22, 23, 3, -22 },
  { 5947, 21, 23, 23, 2, -22 },
  { 6008, 19, 28, 23, 5, -27 },
  { 6075, 21, 22, 23, 3, -21 },
  { 6133, 20, 21, 23, 5, -21 },
  { 6186, 23, 21, 23, 3, -21 },
  { 6247, 25, 21, 23, 0, -21 },
  { 6313, 27, 29, 23, -2, -21 },
  { 6411, 22, 21, 23, 2, -21 },
  { 6469, 22, 38, 23, 4, -31 },
  { 6574, 15, 38, 23, 6, -31 },
  { 6646, 22, 38, 23, 0, -31 },
  { 6751, 22, 8, 23, 2, -16 },
};

const GFXfont UbuntuMono_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic45pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _UBUNTUMONO_BOLDITALIC45PT7B_H_
