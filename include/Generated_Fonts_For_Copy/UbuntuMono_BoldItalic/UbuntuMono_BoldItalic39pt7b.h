#ifndef _UBUNTUMONO_BOLDITALIC39PT7B_H_
#define _UBUNTUMONO_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x81, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0x01, 0xC0, 0x7C, 0xFD,
  0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xC3, 0xCF, 0x1F, 0x3C, 0x78,
  0xE1, 0xE3, 0x87, 0x8C, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0x83, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x1C, 0x0F, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F,
  0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x0E, 0x03, 0xF0, 0x1E, 0x07, 0xF8, 0x3C, 0x07, 0x38, 0x78, 0x0E,
  0x38, 0x70, 0x0E, 0x38, 0xE0, 0x0E, 0x71, 0xC0, 0x0E, 0x73, 0xC0, 0x0E,
  0xF7, 0x80, 0x0F, 0xEF, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0xF7, 0xF0, 0x01, 0xEF, 0x70, 0x03,
  0xCE, 0x70, 0x03, 0x8E, 0x70, 0x07, 0x1C, 0x70, 0x0E, 0x1C, 0x70, 0x1E,
  0x1C, 0xE0, 0x3C, 0x1F, 0xE0, 0x78, 0x0F, 0xC0, 0x70, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xC7, 0x83, 0xE1,
  0xE0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x1E, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0x87, 0x1F, 0xE3, 0xCF, 0xFC, 0xF7, 0xCF, 0x3D, 0xE3, 0xFE, 0xF0,
  0x7F, 0x3C, 0x0F, 0xCF, 0x03, 0xE3, 0xE1, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFE, 0xF8, 0x7E, 0x3E, 0x7E, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E, 0x7C,
  0xF1, 0xE3, 0x87, 0x00, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6,
  0x7B, 0x9E, 0xFF, 0xBE, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0xF0,
  0x1E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x1C, 0x78, 0x0C, 0x20, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xF3, 0xF8, 0xFC, 0x3E, 0x0E, 0x1F, 0x7F,
  0x3F, 0x1E, 0x08, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE0,
  0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F,
  0x7C, 0x07, 0xDE, 0x39, 0xF7, 0x9E, 0x7F, 0xE7, 0x9F, 0xF9, 0xC7, 0xBC,
  0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x83,
  0xE3, 0xE1, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xFE,
  0x0F, 0xBE, 0x0F, 0x3C, 0x08, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x7E,
  0x0C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x38, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x38, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x0F,
  0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0x83, 0xC0,
  0xF0, 0xF0, 0x3E, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x60, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xBF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xF8, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9F, 0x01,
  0xE3, 0xE0, 0x7C, 0x3E, 0x1F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3,
  0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x3E, 0x7E, 0x0F, 0x07, 0xE3, 0xE0, 0x7C, 0x78,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x1F, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xE0, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x87, 0xE3, 0xF8, 0xFE,
  0x1F, 0x03, 0x80, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF8,
  0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x70, 0x1F, 0x0F, 0xE0,
  0xFC, 0x0F, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x80, 0x08, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3,
  0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xC1, 0xF0, 0xF8, 0x0F, 0x1E, 0x00, 0xF3, 0xE1, 0xFF, 0x3C, 0x3F, 0xF3,
  0x8F, 0xFE, 0x78, 0xFF, 0xE7, 0x9F, 0x1E, 0x71, 0xE3, 0xE7, 0x1E, 0x3C,
  0xF3, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0xC7, 0xCF, 0x3C, 0x78, 0xF3, 0xE7,
  0x8F, 0x3F, 0xF8, 0xF1, 0xFF, 0x8F, 0x0F, 0xF0, 0x78, 0x7E, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0,
  0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x07, 0x83,
  0xE0, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x1F, 0x0F, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xE0, 0x3E, 0x7C, 0x1F, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0x0C, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xC7, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x87, 0xC7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0x0C, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x70, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1F,
  0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xEE,
  0x07, 0x73, 0xB8, 0x3D, 0xDD, 0xE0, 0xF7, 0x77, 0x83, 0xDF, 0x9E, 0x1E,
  0x7E, 0xF0, 0x79, 0xF3, 0xC1, 0xE3, 0xCF, 0x07, 0x8E, 0x3C, 0x3C, 0x01,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x03, 0xE1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x1F,
  0x01, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0xF8, 0x3F, 0xC3,
  0xE0, 0xFF, 0x0F, 0x03, 0xDC, 0x3C, 0x0F, 0x70, 0xF0, 0x7D, 0xE7, 0xC1,
  0xF7, 0x9E, 0x07, 0x8E, 0x78, 0x1E, 0x39, 0xE0, 0x78, 0xEF, 0x83, 0xE3,
  0xFC, 0x0F, 0x0F, 0xF0, 0x3C, 0x1F, 0xC0, 0xF0, 0x7F, 0x07, 0xC1, 0xF8,
  0x1E, 0x07, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3C,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xC0, 0x3E, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0xFC, 0x1E, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xC0, 0x3E, 0xF0,
  0x1F, 0x3C, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC3, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x07,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE1, 0xE0, 0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80, 0x78, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xC0, 0xE0, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x20, 0x0F, 0x83, 0x81, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x78, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E,
  0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87,
  0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80,
  0x3C, 0x3C, 0x71, 0xE0, 0xF3, 0xC7, 0x83, 0xCF, 0x1E, 0x0F, 0x7E, 0x78,
  0x79, 0xFB, 0xC1, 0xEE, 0xEF, 0x07, 0xBB, 0xBC, 0x1F, 0xCE, 0xE0, 0x77,
  0x3B, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80,
  0x07, 0xC7, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0xFC, 0x03, 0xC0, 0xF0, 0x07, 0xFC,
  0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0x87,
  0xC1, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x1F,
  0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xF0, 0x1F, 0x78, 0x07, 0x84, 0x01,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0x1C,
  0x1F, 0x1F, 0xE3, 0xF8, 0x78, 0x08, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xCF, 0x81, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0x78, 0x1F, 0x1F,
  0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x03, 0xE3, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x07,
  0xCF, 0x87, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x81, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x81, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xC3, 0xC0, 0xF8, 0x1E, 0x0F, 0xC1, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0x78, 0x03, 0xE3, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF3, 0xF0, 0xFB, 0xE0, 0x3D, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x21, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x07,
  0xE0, 0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0xE0, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xEF, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x80, 0x00,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7E, 0x10, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x30, 0x7C, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x81, 0xF3, 0xF0,
  0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0xFF, 0xCF, 0xFC,
  0xFF, 0xCF, 0xFC, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x27, 0xFF, 0x7F, 0xF3, 0xFF,
  0x1F, 0xC0, 0x03, 0xE3, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1E, 0x78, 0xF1, 0xE7, 0x8E, 0x1E, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0x71,
  0xE3, 0xCF, 0x1C, 0x3C, 0xF3, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x03,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xE1,
  0xF3, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xC3, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x1F,
  0x07, 0xC1, 0xE1, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xDF, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0x81, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x1C, 0x0F, 0x87,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x81, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xC0, 0x1E, 0x07,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0x78, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x8C,
  0x00, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F,
  0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07,
  0xCF, 0x01, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x0F, 0x3E, 0x78, 0x7B, 0xF3, 0xC3, 0x9F, 0x9C, 0x1D, 0xFD, 0xE0, 0xEE,
  0xEF, 0x07, 0xF3, 0x70, 0x3F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x80,
  0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x1E, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x3E, 0x03, 0xE1, 0xF0,
  0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x81, 0x83, 0xF8, 0x3C, 0xFF,
  0x8F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xF3, 0xFF, 0x3C, 0x1F, 0xC1, 0x01,
  0xE0,
};

const GFXglyph UbuntuMono_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 24, 20, 6, -24 },
  { 34, 14, 11, 20, 8, -26 },
  { 54, 21, 24, 20, 1, -24 },
  { 117, 19, 31, 20, 2, -27 },
  { 191, 24, 24, 20, 0, -24 },
  { 263, 18, 24, 20, 2, -24 },
  { 317, 7, 12, 20, 11, -26 },
  { 328, 16, 34, 20, 5, -28 },
  { 396, 15, 34, 20, 2, -28 },
  { 460, 16, 15, 20, 5, -24 },
  { 490, 17, 18, 20, 3, -19 },
  { 529, 9, 13, 20, 4, -7 },
  { 544, 12, 5, 20, 5, -12 },
  { 552, 7, 7, 20, 6, -7 },
  { 559, 23, 33, 20, 0, -27 },
  { 654, 18, 24, 20, 3, -24 },
  { 708, 16, 24, 20, 2, -24 },
  { 756, 19, 24, 20, 2, -24 },
  { 813, 19, 24, 20, 1, -24 },
  { 870, 19, 24, 20, 2, -24 },
  { 927, 21, 24, 20, 1, -24 },
  { 990, 19, 24, 20, 3, -24 },
  { 1047, 18, 24, 20, 5, -24 },
  { 1101, 19, 24, 20, 2, -24 },
  { 1158, 19, 24, 20, 2, -24 },
  { 1215, 10, 19, 20, 6, -19 },
  { 1239, 12, 25, 20, 4, -19 },
  { 1277, 18, 17, 20, 3, -18 },
  { 1316, 19, 12, 20, 2, -16 },
  { 1345, 18, 17, 20, 2, -18 },
  { 1384, 15, 24, 20, 6, -24 },
  { 1429, 20, 29, 20, 2, -24 },
  { 1502, 19, 24, 20, 0, -24 },
  { 1559, 19, 24, 20, 2, -24 },
  { 1616, 19, 24, 20, 3, -24 },
  { 1673, 20, 24, 20, 1, -24 },
  { 1733, 20, 24, 20, 2, -24 },
  { 1793, 21, 24, 20, 2, -24 },
  { 1856, 19, 24, 20, 3, -24 },
  { 1913, 22, 24, 20, 1, -24 },
  { 1979, 21, 24, 20, 1, -24 },
  { 2042, 21, 24, 20, 1, -24 },
  { 2105, 23, 24, 20, 1, -24 },
  { 2174, 16, 24, 20, 2, -24 },
  { 2222, 22, 24, 20, 0, -24 },
  { 2288, 22, 24, 20, 1, -24 },
  { 2354, 18, 24, 20, 3, -24 },
  { 2408, 21, 24, 20, 1, -24 },
  { 2471, 18, 31, 20, 3, -24 },
  { 2541, 20, 24, 20, 1, -24 },
  { 2601, 20, 24, 20, 1, -24 },
  { 2661, 19, 24, 20, 5, -24 },
  { 2718, 20, 24, 20, 3, -24 },
  { 2778, 19, 24, 20, 5, -24 },
  { 2835, 22, 24, 20, 2, -24 },
  { 2901, 24, 24, 20, 0, -24 },
  { 2973, 18, 24, 20, 6, -24 },
  { 3027, 21, 24, 20, 1, -24 },
  { 3090, 19, 33, 20, 3, -27 },
  { 3169, 8, 33, 20, 8, -27 },
  { 3202, 19, 33, 20, 1, -27 },
  { 3281, 18, 14, 20, 3, -24 },
  { 3313, 18, 4, 20, -1, 2 },
  { 3322, 9, 7, 20, 9, -27 },
  { 3330, 18, 18, 20, 2, -18 },
  { 3371, 18, 27, 20, 2, -27 },
  { 3432, 18, 18, 20, 3, -18 },
  { 3473, 21, 27, 20, 2, -27 },
  { 3544, 17, 18, 20, 3, -18 },
  { 3583, 24, 33, 20, -1, -27 },
  { 3682, 21, 24, 20, 0, -18 },
  { 3745, 17, 27, 20, 2, -27 },
  { 3803, 14, 26, 20, 4, -26 },
  { 3849, 19, 32, 20, 0, -26 },
  { 3925, 20, 27, 20, 2, -27 },
  { 3993, 12, 27, 20, 6, -27 },
  { 4034, 20, 18, 20, 1, -18 },
  { 4079, 17, 18, 20, 2, -18 },
  { 4118, 17, 18, 20, 3, -18 },
  { 4157, 20, 24, 20, 0, -18 },
  { 4217, 18, 24, 20, 3, -18 },
  { 4271, 18, 18, 20, 3, -18 },
  { 4312, 18, 18, 20, 2, -18 },
  { 4353, 17, 23, 20, 4, -23 },
  { 4402, 17, 18, 20, 3, -18 },
  { 4441, 18, 18, 20, 4, -18 },
  { 4482, 21, 18, 20, 2, -18 },
  { 4530, 21, 18, 20, 0, -18 },
  { 4578, 23, 24, 20, -2, -18 },
  { 4647, 19, 18, 20, 2, -18 },
  { 4690, 19, 33, 20, 4, -27 },
  { 4769, 13, 33, 20, 5, -27 },
  { 4823, 19, 33, 20, 0, -27 },
  { 4902, 19, 8, 20, 2, -14 },
};

const GFXfont UbuntuMono_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic39pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _UBUNTUMONO_BOLDITALIC39PT7B_H_
