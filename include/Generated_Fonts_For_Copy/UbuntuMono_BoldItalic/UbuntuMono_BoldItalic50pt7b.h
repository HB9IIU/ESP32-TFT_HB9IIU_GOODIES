#ifndef _UBUNTUMONO_BOLDITALIC50PT7B_H_
#define _UBUNTUMONO_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x7F, 0x1F, 0xDF,
  0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0x80, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0x00, 0x1F, 0x81, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x07,
  0xFC, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x3C, 0xF0, 0x1F, 0x00, 0xF8,
  0xE0, 0x7C, 0x01, 0xE3, 0xC1, 0xF0, 0x03, 0xC7, 0x83, 0xC0, 0x07, 0x8F,
  0x0F, 0x00, 0x0E, 0x1E, 0x3C, 0x00, 0x1C, 0x78, 0xF8, 0x00, 0x3C, 0xF3,
  0xE0, 0x00, 0x7F, 0xEF, 0x80, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0xFE, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0xFE, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x03, 0xCF, 0xFC,
  0x00, 0x0F, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0xF0, 0x00, 0xF8, 0xF1, 0xE0,
  0x03, 0xE1, 0xE3, 0xC0, 0x07, 0x83, 0x87, 0x80, 0x1E, 0x0F, 0x0F, 0x00,
  0x78, 0x1E, 0x3C, 0x01, 0xF0, 0x3C, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x1F,
  0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x03,
  0xE3, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0x07, 0xFC, 0x1F, 0x1F, 0xFE, 0x1F, 0x1F, 0xBF, 0x3E, 0x3F,
  0x3F, 0x3E, 0x7E, 0x1F, 0xFC, 0x7C, 0x0F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFE, 0xFC, 0x1F, 0xF8, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0x0F, 0x82,
  0x3C, 0x7C, 0x71, 0xFB, 0xCF, 0xCF, 0xEE, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80,
  0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0x8F, 0xE0, 0x7C, 0x7C, 0x01, 0xC1,
  0xC0, 0x04, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07,
  0xE0, 0x3E, 0x07, 0xC1, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x1E,
  0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC7, 0x8F, 0xDF, 0x1F, 0x1F, 0x7E,
  0x3E, 0x3E, 0xFC, 0xFC, 0xFD, 0xF8, 0xF1, 0xFB, 0xF0, 0x03, 0xF7, 0xC0,
  0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0x83, 0xF8, 0x07, 0x00, 0xFC, 0x02, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0x83, 0xFC, 0x01, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x08, 0x00,
  0x7F, 0x07, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x08, 0x00, 0xFE, 0x07, 0x80,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF, 0xF0,
  0x3F, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFC, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x04,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x78, 0x3F, 0x88,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF,
  0xC0, 0xFF, 0xE7, 0xC1, 0xFF, 0xF3, 0xE1, 0xFF, 0xF3, 0xE1, 0xFF, 0xF9,
  0xF1, 0xFF, 0xFC, 0xF0, 0xFC, 0x7E, 0x78, 0xFC, 0x3E, 0x7C, 0x7C, 0x1F,
  0x3E, 0x3E, 0x0F, 0x9F, 0x1F, 0x0F, 0xCF, 0x8F, 0x87, 0xC7, 0x8F, 0x83,
  0xE3, 0xC7, 0xC1, 0xF1, 0xE3, 0xF1, 0xF8, 0xF0, 0xF8, 0xF8, 0x78, 0x7F,
  0xFC, 0x3E, 0x3F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0x07, 0xC0,
  0xFF, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xE0, 0x20, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xE0, 0x7F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x1F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFC,
  0x0E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x1F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFC,
  0x0E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0C, 0x01, 0xF8, 0x07, 0xC1, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x07,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF1,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3D, 0xC3, 0xFE, 0x01, 0xEE, 0x1F, 0xF0,
  0x1F, 0x71, 0xEF, 0x00, 0xFB, 0x8F, 0x78, 0x07, 0x9C, 0xF7, 0xC0, 0x7C,
  0xF7, 0xBE, 0x03, 0xE7, 0xF9, 0xF0, 0x1F, 0x3F, 0xCF, 0x00, 0xF9, 0xFC,
  0xF8, 0x0F, 0x8F, 0xC7, 0xC0, 0x7C, 0x7E, 0x3E, 0x03, 0xE3, 0xE1, 0xF0,
  0x3F, 0x1F, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xFC,
  0x03, 0xE0, 0x3F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7C,
  0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xF0, 0x7C, 0x07, 0xFF, 0x0F, 0xC0, 0x7C,
  0xF0, 0xFC, 0x07, 0xCF, 0x0F, 0x80, 0xFC, 0xF8, 0xF8, 0x0F, 0xCF, 0x9F,
  0x80, 0xF8, 0x79, 0xF8, 0x0F, 0x87, 0x9F, 0x00, 0xF8, 0x7D, 0xF0, 0x1F,
  0x87, 0xFF, 0x01, 0xF8, 0x3F, 0xF0, 0x1F, 0x03, 0xFE, 0x01, 0xF0, 0x3F,
  0xE0, 0x3F, 0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xE0, 0x3E, 0x01, 0xFC, 0x03,
  0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7C, 0x01,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFC,
  0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0x3F, 0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFE,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x70, 0x1F, 0xC0, 0x08, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0C, 0x00, 0xFE,
  0x0F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0xC1, 0xF8, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0xF8, 0x1F,
  0x3F, 0x9F, 0x01, 0xF3, 0xF9, 0xF0, 0x3E, 0x7F, 0x9F, 0x03, 0xE7, 0xF9,
  0xF0, 0x3E, 0xF7, 0x9E, 0x03, 0xCF, 0x7B, 0xE0, 0x3D, 0xE7, 0xBE, 0x07,
  0xDE, 0x7B, 0xC0, 0x7F, 0xC7, 0xBC, 0x07, 0xBC, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x3E, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xE0,
  0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0x3E,
  0x00, 0x7F, 0x3C, 0x00, 0x78, 0x10, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x10,
  0x07, 0x01, 0xF0, 0x3F, 0x8F, 0xF8, 0xFF, 0xC3, 0xF0, 0x1E, 0x00, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xF9, 0xF8,
  0x0F, 0xC3, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE7,
  0xF0, 0x3F, 0x8F, 0xC0, 0xFF, 0x1F, 0x83, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFE, 0x03, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0C, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0x80, 0x1F, 0x87, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0x87, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0x03, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x0C, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xF8, 0x7F,
  0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x82, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x20, 0x1F, 0x80, 0x78, 0x3F, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x1F,
  0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x03,
  0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0,
  0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x82, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xF8,
  0x00, 0xFC, 0x3E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7E, 0x7E, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x0F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7, 0xC7, 0xC3, 0xC3, 0xE3,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87,
  0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0,
  0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x7F, 0x01,
  0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xE1, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xBF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xF0, 0x0C, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x03, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xC0,
  0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x0C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0xFC, 0x7E,
  0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFD, 0xF8, 0x0F, 0xC3, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x1F, 0x07, 0x87, 0xC7, 0xC3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xCF,
  0xE3, 0xC1, 0xE3, 0xF9, 0xF0, 0x79, 0xEE, 0x7C, 0x1E, 0x7B, 0x9E, 0x07,
  0xBC, 0xE7, 0x83, 0xEF, 0x3B, 0xE0, 0xFF, 0x8E, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x43, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x0C, 0x03, 0xFC, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8,
  0x1F, 0xE0, 0x18, 0x03, 0xE0, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 14, 32, 25, 8, -31 },
  { 57, 18, 14, 25, 10, -34 },
  { 89, 26, 31, 25, 2, -31 },
  { 190, 25, 40, 25, 2, -35 },
  { 315, 31, 33, 25, 0, -32 },
  { 443, 24, 33, 25, 2, -32 },
  { 542, 9, 15, 25, 14, -34 },
  { 559, 20, 44, 25, 7, -35 },
  { 669, 20, 44, 25, 2, -35 },
  { 779, 21, 20, 25, 6, -31 },
  { 832, 23, 23, 25, 3, -24 },
  { 899, 12, 16, 25, 5, -8 },
  { 923, 15, 6, 25, 7, -16 },
  { 935, 9, 9, 25, 8, -8 },
  { 946, 30, 43, 25, -1, -35 },
  { 1108, 23, 33, 25, 4, -32 },
  { 1203, 20, 31, 25, 3, -31 },
  { 1281, 25, 32, 25, 2, -32 },
  { 1381, 25, 33, 25, 1, -32 },
  { 1485, 25, 31, 25, 2, -31 },
  { 1582, 26, 32, 25, 2, -31 },
  { 1686, 24, 32, 25, 4, -31 },
  { 1782, 24, 31, 25, 6, -31 },
  { 1875, 24, 33, 25, 3, -32 },
  { 1974, 24, 32, 25, 3, -32 },
  { 2070, 13, 24, 25, 8, -23 },
  { 2109, 16, 31, 25, 5, -23 },
  { 2171, 23, 21, 25, 4, -24 },
  { 2232, 25, 15, 25, 2, -21 },
  { 2279, 22, 21, 25, 3, -24 },
  { 2337, 19, 33, 25, 8, -32 },
  { 2416, 25, 39, 25, 3, -32 },
  { 2538, 24, 31, 25, 0, -31 },
  { 2631, 25, 32, 25, 2, -31 },
  { 2731, 24, 33, 25, 4, -32 },
  { 2830, 24, 33, 25, 2, -32 },
  { 2929, 25, 31, 25, 3, -31 },
  { 3026, 26, 31, 25, 3, -31 },
  { 3127, 24, 33, 25, 4, -32 },
  { 3226, 28, 31, 25, 1, -31 },
  { 3335, 27, 31, 25, 2, -31 },
  { 3440, 26, 32, 25, 2, -31 },
  { 3544, 28, 31, 25, 2, -31 },
  { 3653, 21, 31, 25, 2, -31 },
  { 3735, 29, 31, 25, 0, -31 },
  { 3848, 28, 31, 25, 1, -31 },
  { 3957, 24, 33, 25, 3, -32 },
  { 4056, 26, 31, 25, 2, -31 },
  { 4157, 24, 42, 25, 3, -32 },
  { 4283, 25, 31, 25, 2, -31 },
  { 4380, 25, 33, 25, 2, -32 },
  { 4484, 24, 31, 25, 6, -31 },
  { 4577, 26, 32, 25, 3, -31 },
  { 4681, 24, 31, 25, 7, -31 },
  { 4774, 28, 31, 25, 2, -31 },
  { 4883, 31, 31, 25, 0, -31 },
  { 5004, 24, 31, 25, 7, -31 },
  { 5097, 28, 31, 25, 1, -31 },
  { 5206, 25, 43, 25, 4, -35 },
  { 5341, 10, 43, 25, 10, -35 },
  { 5395, 24, 43, 25, 1, -35 },
  { 5524, 23, 18, 25, 4, -31 },
  { 5576, 24, 5, 25, -2, 3 },
  { 5591, 11, 9, 25, 12, -35 },
  { 5604, 23, 26, 25, 3, -25 },
  { 5679, 23, 36, 25, 2, -35 },
  { 5783, 23, 26, 25, 4, -25 },
  { 5858, 26, 36, 25, 3, -35 },
  { 5975, 22, 26, 25, 4, -25 },
  { 6047, 32, 44, 25, -2, -35 },
  { 6223, 27, 34, 25, 0, -25 },
  { 6338, 23, 35, 25, 2, -35 },
  { 6439, 17, 36, 25, 6, -35 },
  { 6516, 24, 44, 25, 0, -35 },
  { 6648, 25, 35, 25, 3, -35 },
  { 6758, 16, 35, 25, 7, -34 },
  { 6828, 25, 24, 25, 1, -24 },
  { 6903, 23, 25, 25, 2, -25 },
  { 6975, 22, 26, 25, 3, -25 },
  { 7047, 25, 33, 25, 0, -25 },
  { 7151, 23, 33, 25, 4, -25 },
  { 7246, 24, 25, 25, 3, -25 },
  { 7321, 23, 26, 25, 2, -25 },
  { 7396, 22, 32, 25, 5, -31 },
  { 7484, 22, 25, 25, 4, -24 },
  { 7553, 23, 24, 25, 5, -24 },
  { 7622, 26, 24, 25, 3, -24 },
  { 7700, 28, 24, 25, 0, -24 },
  { 7784, 29, 33, 25, -2, -24 },
  { 7904, 25, 24, 25, 2, -24 },
  { 7979, 24, 43, 25, 5, -35 },
  { 8108, 17, 43, 25, 6, -35 },
  { 8200, 24, 43, 25, 0, -35 },
  { 8329, 25, 9, 25, 2, -18 },
};

const GFXfont UbuntuMono_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic50pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUMONO_BOLDITALIC50PT7B_H_
