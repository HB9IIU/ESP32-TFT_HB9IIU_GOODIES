#ifndef _UBUNTUMONO_BOLDITALIC22PT7B_H_
#define _UBUNTUMONO_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x80, 0x00, 0xE3, 0x80,
  0x77, 0x77, 0x67, 0xE6, 0xC6, 0xC4, 0x06, 0x60, 0xCC, 0x33, 0x3F, 0xF7,
  0xFE, 0x33, 0x06, 0x61, 0xDC, 0x33, 0x1F, 0xFB, 0xFF, 0x33, 0x0E, 0xE1,
  0x98, 0x00, 0x03, 0x80, 0x60, 0x3F, 0x0F, 0xE3, 0x84, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0x70, 0x06, 0x00, 0xC4, 0x39, 0xFF, 0x1F, 0x80, 0xC0,
  0x18, 0x00, 0x0E, 0x18, 0xF1, 0x8C, 0x98, 0x6C, 0xC3, 0x6C, 0x1E, 0xC0,
  0x6C, 0x00, 0xDC, 0x07, 0xE0, 0x6D, 0x06, 0xC8, 0x66, 0xC6, 0x3E, 0x20,
  0xE0, 0x07, 0x83, 0xF0, 0x67, 0x0C, 0xC1, 0x98, 0x3E, 0x07, 0x81, 0xE6,
  0x6E, 0xDC, 0xF3, 0x0E, 0x73, 0xCF, 0xF8, 0xF3, 0x80, 0x77, 0x6E, 0xEC,
  0xC0, 0x01, 0x01, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x02, 0x00,
  0x04, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x08, 0x00, 0x1C,
  0x6C, 0xBF, 0xDF, 0xF1, 0xC3, 0xF1, 0xDC, 0x48, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x7F, 0xDF, 0xF0, 0xC0, 0x30, 0x1C, 0x06, 0x00, 0x39, 0xCE, 0x71,
  0xFB, 0x80, 0x7F, 0xFB, 0xF0, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0xC7, 0x61, 0xFB, 0x7C, 0xDF, 0x06,
  0xC1, 0xB0, 0xEC, 0x33, 0x1C, 0xFE, 0x1F, 0x00, 0x01, 0x83, 0xC7, 0xE7,
  0xE3, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC7, 0xFB, 0xFC,
  0x0F, 0x83, 0xF8, 0x43, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x30, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0x87, 0xF1, 0x1C,
  0x03, 0x00, 0xC0, 0x70, 0xF0, 0x7E, 0x03, 0x80, 0x70, 0x1A, 0x0E, 0xFF,
  0x1F, 0x80, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0x60, 0xDC, 0x3B, 0x8E, 0x73,
  0x8C, 0x61, 0x9F, 0xFB, 0xFF, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x0F, 0xE1,
  0xFC, 0x70, 0x0C, 0x01, 0x80, 0x7C, 0x0F, 0xE0, 0x3C, 0x01, 0x80, 0x30,
  0x06, 0x61, 0xCF, 0xF0, 0xFC, 0x00, 0x03, 0xC3, 0xF3, 0xC0, 0xC0, 0x70,
  0x3F, 0xCF, 0xFB, 0x0E, 0xC3, 0xB0, 0xEC, 0x3B, 0x8C, 0x7F, 0x0F, 0x00,
  0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x07, 0x83, 0xF8, 0x63, 0x9C, 0x73,
  0x8E, 0x33, 0x87, 0xE0, 0xF8, 0x73, 0x8C, 0x3B, 0x87, 0x71, 0xC7, 0xF8,
  0x7C, 0x00, 0x0F, 0x83, 0xF8, 0xE7, 0x18, 0x77, 0x0E, 0xE1, 0xDC, 0x39,
  0xFE, 0x1F, 0xC0, 0x38, 0x0E, 0x07, 0x8F, 0xE1, 0xF0, 0x00, 0x3B, 0xDE,
  0x60, 0x00, 0x1C, 0xE7, 0x38, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x1C,
  0x38, 0x70, 0xE0, 0xCF, 0x1C, 0x00, 0x00, 0xC0, 0xF1, 0xF3, 0xF0, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x1F, 0x01, 0xC3, 0xF3, 0xE3,
  0xC0, 0xC0, 0x00, 0x3E, 0x3F, 0x90, 0xE0, 0x70, 0x70, 0x78, 0x78, 0x78,
  0x38, 0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x07, 0xC1, 0xFC, 0x71, 0x98,
  0x37, 0x3E, 0xCF, 0xDB, 0xBB, 0x67, 0xCC, 0xD9, 0x9B, 0x37, 0x67, 0xEC,
  0x78, 0xC0, 0x1C, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x1B,
  0x0E, 0xC3, 0x31, 0xCC, 0x63, 0x3F, 0xCF, 0xF7, 0x0D, 0x83, 0x60, 0xF8,
  0x30, 0x1F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0x8F, 0xE3, 0xFC,
  0x71, 0xCE, 0x39, 0x87, 0x71, 0xEF, 0xF9, 0xFC, 0x00, 0x07, 0xC3, 0xF8,
  0xE1, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x87, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xF8, 0xE7, 0x1C, 0x73, 0x8E,
  0x61, 0xDC, 0x3B, 0x86, 0x71, 0xCC, 0x3B, 0x8E, 0x73, 0xCF, 0xF1, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x18, 0x01, 0x80, 0x38, 0x03, 0xF8, 0x3F, 0x83,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1,
  0xFE, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0x83, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC3, 0xF8, 0xE1, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x1C, 0xC3, 0x98, 0x73, 0x8C, 0x71, 0x87,
  0xF0, 0x7C, 0x00, 0x18, 0x73, 0x87, 0x38, 0x63, 0x8E, 0x38, 0xE3, 0x0E,
  0x7F, 0xC7, 0xFC, 0x71, 0xC6, 0x1C, 0xE1, 0x8E, 0x18, 0xE3, 0x8C, 0x38,
  0x1F, 0xF1, 0xFE, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xE1, 0xFC,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x23, 0x8F, 0xF0, 0xF8, 0x00, 0x1C, 0x71, 0x8E, 0x39, 0xC3, 0xBC, 0x3B,
  0x83, 0x70, 0x7E, 0x07, 0xE0, 0x77, 0x06, 0x70, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0x0C, 0x38, 0x73, 0x87, 0x9C, 0x3D,
  0xE1, 0xEF, 0x1F, 0xD8, 0xDF, 0xC6, 0xEC, 0x37, 0x63, 0x83, 0x18, 0x18,
  0xC1, 0xC6, 0x0C, 0x70, 0x60, 0x18, 0x73, 0xC7, 0x3C, 0x63, 0xC6, 0x3C,
  0xE3, 0x6E, 0x76, 0xC6, 0x6C, 0x66, 0xC6, 0x3C, 0xE3, 0x8E, 0x38, 0xC3,
  0x8C, 0x38, 0x07, 0x83, 0xF8, 0x63, 0x9C, 0x77, 0x0E, 0xE1, 0xDC, 0x3B,
  0x06, 0x60, 0xDC, 0x39, 0x86, 0x39, 0xC7, 0xF0, 0x7C, 0x00, 0x1F, 0x83,
  0xFC, 0x63, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x73, 0xFE, 0x7F, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x83, 0xF8, 0x63, 0x9C, 0x73,
  0x0E, 0xE1, 0xDC, 0x3B, 0x06, 0x60, 0xCC, 0x39, 0x86, 0x39, 0xC7, 0xF0,
  0x7C, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x1F, 0x83, 0xF8, 0xE3, 0x9C,
  0x73, 0x8E, 0x61, 0x8C, 0x73, 0xFC, 0x7E, 0x0E, 0xE1, 0x8C, 0x71, 0xCE,
  0x39, 0xC3, 0x00, 0x0F, 0xC3, 0xFC, 0xE1, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0x80, 0x30, 0x06, 0x21, 0xCF, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x00, 0x18, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x30,
  0xE7, 0x0C, 0x70, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x86, 0x38, 0x7F,
  0x03, 0xE0, 0xE0, 0xDC, 0x3B, 0x86, 0x71, 0xCE, 0x39, 0xCE, 0x39, 0xC7,
  0x30, 0xEE, 0x1D, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x33,
  0x83, 0x30, 0x73, 0x06, 0x70, 0x67, 0x66, 0x6E, 0xE6, 0xEC, 0x7A, 0xC7,
  0xAC, 0xF2, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0x1C, 0x38, 0x71, 0x83, 0x9C,
  0x0D, 0xC0, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xEC, 0x07,
  0x70, 0x73, 0x87, 0x0C, 0x78, 0x60, 0xE1, 0xDC, 0x39, 0x8E, 0x31, 0x86,
  0x70, 0xFC, 0x1F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xFF, 0x8F, 0xF8, 0x0F,
  0xE1, 0xF8, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1F, 0x83,
  0xF0, 0x00, 0xCC, 0xCC, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x67, 0x77, 0x70,
  0x07, 0xE0, 0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x0F,
  0xC3, 0xF8, 0x00, 0x07, 0x03, 0xC1, 0xF0, 0xEE, 0x73, 0x9C, 0x6E, 0x1D,
  0x06, 0x7F, 0xFF, 0xFB, 0xFF, 0x00, 0x43, 0x9E, 0x20, 0x0F, 0xC3, 0xF8,
  0xE7, 0x38, 0xE6, 0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x7F, 0x87, 0xB0, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0F, 0xE3, 0xFC, 0xC7, 0x71, 0xDC, 0x77,
  0x1D, 0x86, 0xE3, 0xBF, 0xCF, 0xC0, 0x0F, 0xCF, 0xE7, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x80, 0xFF, 0x0F, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0xFC, 0x1F, 0xC3, 0x9C, 0x71, 0xC6, 0x18, 0xE1, 0x8E,
  0x38, 0x63, 0x87, 0xF8, 0x3D, 0x80, 0x1F, 0x1F, 0xDC, 0x7C, 0x3C, 0x7F,
  0xF3, 0x01, 0xC0, 0xFF, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xFF, 0x1C, 0x63, 0x8E, 0x38, 0xE3,
  0x0E, 0x30, 0xC3, 0x9C, 0x3F, 0xC1, 0xFC, 0x01, 0x80, 0x38, 0xFF, 0x07,
  0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0F, 0xE3, 0xFC, 0xC7, 0x31,
  0xDC, 0x77, 0x19, 0xCE, 0x63, 0xB8, 0xEE, 0x30, 0x0E, 0x0E, 0x0E, 0x00,
  0x7C, 0x7C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0x00, 0xC0,
  0x3C, 0x07, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC2, 0x30, 0xFE, 0x0F, 0x80, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x71, 0xCE, 0x71, 0xDC, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3B, 0x87, 0x30, 0xC7, 0x38, 0xE0, 0x7D, 0xF8, 0x70, 0xC3,
  0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xCF, 0x80, 0x1E, 0xE1,
  0xFF, 0x3B, 0x73, 0x36, 0x37, 0x63, 0x66, 0x70, 0xE6, 0x0C, 0x60, 0xC6,
  0x0C, 0x1F, 0x8F, 0xF3, 0x9C, 0xC7, 0x71, 0xDC, 0x67, 0x39, 0x8E, 0xE3,
  0xB8, 0xC0, 0x0F, 0x8F, 0xF3, 0x9D, 0xC7, 0x61, 0xF8, 0x7E, 0x1D, 0x8E,
  0x7F, 0x0F, 0x80, 0x0F, 0xC3, 0xFC, 0x63, 0x8C, 0x73, 0x8E, 0x71, 0xCC,
  0x39, 0x8E, 0x7F, 0x8F, 0xC1, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x1F,
  0x8F, 0xF7, 0x1B, 0x8E, 0xE3, 0xB0, 0xEC, 0x33, 0x9C, 0xFF, 0x1F, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xCF, 0xE7, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x0F, 0xC7, 0xF3, 0x80, 0xE0, 0x3E,
  0x03, 0xE0, 0x39, 0x0E, 0xFF, 0x1F, 0x80, 0x0C, 0x07, 0x01, 0xC1, 0xFF,
  0x7F, 0x8E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x00, 0xFC, 0x1F, 0x00,
  0x71, 0x9C, 0xE6, 0x3B, 0x8E, 0xE3, 0x39, 0xCC, 0x73, 0x9C, 0xFF, 0x1E,
  0xC0, 0xE1, 0xF8, 0x76, 0x39, 0x8E, 0x67, 0x1D, 0x87, 0xE1, 0xF0, 0x78,
  0x0E, 0x00, 0x60, 0x76, 0x06, 0x66, 0x66, 0xEE, 0x6E, 0xC7, 0xEC, 0x5F,
  0x8F, 0x38, 0xE3, 0x8E, 0x30, 0x18, 0x71, 0xCE, 0x0D, 0xC0, 0xF8, 0x07,
  0x00, 0xF0, 0x1F, 0x81, 0xB8, 0x39, 0xC7, 0x1C, 0x0C, 0x38, 0x61, 0x83,
  0x1C, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xE7, 0xF8, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0x9F, 0xE0, 0x03, 0xE0, 0xF8,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x78, 0x1E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x07, 0xC0, 0xF8, 0x00,
  0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E,
  0x1C, 0x30, 0xE1, 0xC3, 0x80, 0x0F, 0x81, 0xF0, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x1F, 0x83, 0xE0, 0x00, 0x38, 0x4F, 0x9B, 0xFF,
  0x67, 0xC0, 0x30,
};

const GFXglyph UbuntuMono_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 14, 11, 4, -14 },
  { 12, 8, 6, 11, 4, -15 },
  { 18, 11, 14, 11, 1, -14 },
  { 38, 11, 17, 11, 1, -15 },
  { 62, 13, 14, 11, 0, -14 },
  { 85, 11, 14, 11, 1, -14 },
  { 105, 4, 7, 11, 6, -15 },
  { 109, 9, 20, 11, 3, -16 },
  { 132, 9, 20, 11, 1, -16 },
  { 155, 9, 8, 11, 3, -14 },
  { 164, 10, 10, 11, 1, -11 },
  { 177, 5, 7, 11, 2, -4 },
  { 182, 7, 3, 11, 3, -7 },
  { 185, 3, 4, 11, 4, -4 },
  { 187, 13, 19, 11, 0, -15 },
  { 218, 10, 14, 11, 2, -14 },
  { 236, 9, 14, 11, 1, -14 },
  { 252, 11, 14, 11, 1, -14 },
  { 272, 10, 14, 11, 1, -14 },
  { 290, 11, 14, 11, 1, -14 },
  { 310, 11, 14, 11, 1, -14 },
  { 330, 10, 14, 11, 2, -14 },
  { 348, 10, 14, 11, 3, -14 },
  { 366, 11, 14, 11, 1, -14 },
  { 386, 11, 14, 11, 1, -14 },
  { 406, 5, 11, 11, 4, -11 },
  { 413, 7, 14, 11, 2, -11 },
  { 426, 10, 9, 11, 2, -10 },
  { 438, 11, 6, 11, 1, -9 },
  { 447, 10, 9, 11, 1, -10 },
  { 459, 9, 14, 11, 3, -14 },
  { 475, 11, 17, 11, 1, -14 },
  { 499, 10, 14, 11, 0, -14 },
  { 517, 11, 14, 11, 1, -14 },
  { 537, 11, 14, 11, 2, -14 },
  { 557, 11, 14, 11, 1, -14 },
  { 577, 12, 14, 11, 1, -14 },
  { 598, 12, 14, 11, 1, -14 },
  { 619, 11, 14, 11, 2, -14 },
  { 639, 12, 14, 11, 1, -14 },
  { 660, 12, 14, 11, 1, -14 },
  { 681, 11, 14, 11, 1, -14 },
  { 701, 12, 14, 11, 1, -14 },
  { 722, 9, 14, 11, 1, -14 },
  { 738, 13, 14, 11, 0, -14 },
  { 761, 12, 14, 11, 1, -14 },
  { 782, 11, 14, 11, 1, -14 },
  { 802, 11, 14, 11, 1, -14 },
  { 822, 11, 18, 11, 1, -14 },
  { 847, 11, 14, 11, 1, -14 },
  { 867, 11, 14, 11, 1, -14 },
  { 887, 10, 14, 11, 3, -14 },
  { 905, 12, 14, 11, 1, -14 },
  { 926, 11, 14, 11, 3, -14 },
  { 946, 12, 14, 11, 1, -14 },
  { 967, 13, 14, 11, 0, -14 },
  { 990, 11, 14, 11, 3, -14 },
  { 1010, 12, 14, 11, 1, -14 },
  { 1031, 11, 19, 11, 2, -15 },
  { 1058, 4, 19, 11, 5, -15 },
  { 1068, 11, 19, 11, 0, -15 },
  { 1095, 10, 8, 11, 2, -14 },
  { 1105, 11, 3, 11, -1, 1 },
  { 1110, 5, 4, 11, 5, -15 },
  { 1113, 11, 10, 11, 1, -10 },
  { 1127, 10, 15, 11, 1, -15 },
  { 1146, 10, 10, 11, 2, -10 },
  { 1159, 12, 15, 11, 1, -15 },
  { 1182, 9, 10, 11, 2, -10 },
  { 1194, 14, 19, 11, -1, -15 },
  { 1228, 12, 14, 11, 0, -10 },
  { 1249, 10, 15, 11, 1, -15 },
  { 1268, 8, 14, 11, 2, -14 },
  { 1282, 11, 18, 11, 0, -14 },
  { 1307, 11, 15, 11, 1, -15 },
  { 1328, 7, 15, 11, 3, -15 },
  { 1342, 12, 10, 11, 0, -10 },
  { 1357, 10, 10, 11, 1, -10 },
  { 1370, 10, 10, 11, 1, -10 },
  { 1383, 11, 14, 11, 0, -10 },
  { 1403, 10, 14, 11, 2, -10 },
  { 1421, 10, 10, 11, 2, -10 },
  { 1434, 10, 10, 11, 1, -10 },
  { 1447, 10, 13, 11, 2, -13 },
  { 1464, 10, 10, 11, 2, -10 },
  { 1477, 10, 10, 11, 2, -10 },
  { 1490, 12, 10, 11, 1, -10 },
  { 1505, 12, 10, 11, 0, -10 },
  { 1520, 13, 14, 11, -1, -10 },
  { 1543, 11, 10, 11, 1, -10 },
  { 1557, 11, 19, 11, 2, -15 },
  { 1584, 7, 19, 11, 3, -15 },
  { 1601, 11, 19, 11, 0, -15 },
  { 1628, 11, 5, 11, 1, -8 },
};

const GFXfont UbuntuMono_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic22pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUMONO_BOLDITALIC22PT7B_H_
