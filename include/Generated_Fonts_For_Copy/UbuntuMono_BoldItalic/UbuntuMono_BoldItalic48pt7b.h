#ifndef _UBUNTUMONO_BOLDITALIC48PT7B_H_
#define _UBUNTUMONO_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x01, 0xE0, 0x00, 0x3F, 0x1F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x3F, 0x9F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0x1C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x30, 0x03, 0xF8, 0x3C, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xC0, 0x7F, 0x80, 0x3C, 0x07, 0xFE, 0x03, 0xC0, 0x3C, 0xF0, 0x3C, 0x03,
  0xC7, 0x83, 0xE0, 0x1E, 0x3C, 0x3E, 0x00, 0xE1, 0xC1, 0xE0, 0x07, 0x1E,
  0x1E, 0x00, 0x78, 0xF1, 0xE0, 0x03, 0xCF, 0x9E, 0x00, 0x0F, 0xF9, 0xF0,
  0x00, 0x7F, 0x8F, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07,
  0x9F, 0xC0, 0x00, 0x79, 0xFF, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x78, 0xF3,
  0xC0, 0x07, 0xC7, 0x1E, 0x00, 0x7C, 0x78, 0xF0, 0x03, 0xC3, 0xC7, 0x80,
  0x3C, 0x1E, 0x3C, 0x03, 0xC0, 0xE3, 0xC0, 0x3C, 0x07, 0x9E, 0x03, 0xE0,
  0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0x07,
  0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x7F, 0xF8, 0xF1, 0xF1, 0xFB, 0xE7, 0xC3,
  0xFF, 0x8F, 0x83, 0xFF, 0x3F, 0x03, 0xFC, 0x7C, 0x07, 0xF8, 0xF8, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xBF, 0x0F, 0xFE, 0x3E, 0x07, 0xF0, 0x00, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x21, 0xF0, 0x47, 0x8F, 0x1C, 0x7C, 0xF7, 0xE7, 0xFE, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xBF, 0x01, 0xF9, 0xF8, 0x3F, 0x9F, 0xC1, 0xF1, 0xF0,
  0x0F, 0x0E, 0x00, 0x20, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x0F, 0xC0, 0x78, 0x1F, 0x0F, 0xCF, 0xF1, 0xFC, 0x3E, 0x07,
  0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83,
  0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE1, 0xC7, 0xE7, 0xCF, 0x8F, 0x9F, 0x9F,
  0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x78, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03,
  0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xDF, 0x80,
  0xF3, 0xF0, 0x10, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7C, 0x1F, 0xC0, 0xE0, 0x1F, 0x80, 0x80,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xE0, 0x7F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x20,
  0x03, 0xF8, 0x3C, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3E,
  0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3C, 0x07, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0x3F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x3F,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0x87, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xE0, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x03, 0xC0, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC7, 0x07, 0xF1, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x07, 0xFF, 0x3E, 0x0F, 0xFF, 0x3C, 0x3F,
  0xFE, 0x7C, 0x3F, 0xFE, 0x78, 0x7F, 0xFE, 0x78, 0xFE, 0x3E, 0xF8, 0xF8,
  0x7C, 0xF8, 0xF8, 0x7C, 0xF1, 0xF0, 0x7C, 0xF1, 0xF0, 0x7C, 0xF1, 0xF0,
  0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF9,
  0xF8, 0xF1, 0xFF, 0xF0, 0xF0, 0xFF, 0xF0, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F,
  0xF0, 0xF8, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x07,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x03, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x03, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x30,
  0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01,
  0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x9F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFE, 0x03, 0xFE, 0x3B, 0xC0, 0x3D, 0xE7, 0xBC, 0x03, 0xDE, 0x73, 0xC0,
  0x7D, 0xEF, 0x7C, 0x07, 0xDE, 0xE7, 0xC0, 0x78, 0xFE, 0x78, 0x07, 0x8F,
  0xC7, 0x80, 0xF8, 0xFC, 0xF8, 0x0F, 0x8F, 0x8F, 0x80, 0xF8, 0xF8, 0xF8,
  0x1F, 0x0F, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07,
  0xF8, 0x0F, 0x80, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xFE, 0x0F,
  0x80, 0xFB, 0xC1, 0xF0, 0x1F, 0x78, 0x7E, 0x03, 0xEF, 0x8F, 0x80, 0xFC,
  0xF1, 0xF0, 0x1F, 0x1E, 0x3E, 0x03, 0xE3, 0xCF, 0xC0, 0x7C, 0x7D, 0xF0,
  0x1F, 0x8F, 0xBE, 0x03, 0xE0, 0xF7, 0xC0, 0x7C, 0x1F, 0xF8, 0x0F, 0x83,
  0xFE, 0x03, 0xF0, 0x7F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01,
  0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0x83, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83,
  0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xC0, 0x70, 0x0F, 0xC0, 0x08, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x08, 0x00, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7,
  0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x8F, 0x8F, 0x81, 0xF1,
  0xF1, 0xF0, 0x3C, 0x7E, 0x3E, 0x0F, 0x8F, 0xC7, 0x81, 0xF3, 0xF9, 0xF0,
  0x3E, 0x7F, 0x3E, 0x07, 0x9E, 0xE7, 0x80, 0xF3, 0x9C, 0xF0, 0x3E, 0xF3,
  0xBE, 0x07, 0xFC, 0x77, 0xC0, 0xF7, 0x8E, 0xF0, 0x1F, 0xE1, 0xDE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD, 0xF8, 0x07,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0x7E, 0x7F, 0x01,
  0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x3C, 0x18, 0x00, 0xC0,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x10, 0x07, 0x00, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0xC3,
  0xF0, 0x1E, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xE1, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFC, 0xFC, 0x0F, 0xC3,
  0x80, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC,
  0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x7F, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x18, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFD, 0xF8, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xE1, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFD, 0xF3, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x03, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x7C, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x04,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x02, 0x01, 0xF8, 0x0F, 0x0F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x6F, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x7C, 0x07, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x8F, 0x9F, 0x0F, 0x8F, 0x0F, 0x0F, 0x8F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E,
  0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E,
  0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x7E, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x87, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x3E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8,
  0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xDF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x01, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xC0, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC2, 0x00, 0x7F, 0x0F, 0x03, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x18, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0x9F, 0x03, 0xF0, 0xE0, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x03,
  0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x7E, 0x3E, 0x1E, 0x3F, 0x9E, 0x0F,
  0x3F, 0xCF, 0x0F, 0x9F, 0xEF, 0x87, 0xDE, 0xF7, 0x83, 0xEF, 0x7B, 0xC1,
  0xEF, 0x3F, 0xE0, 0xF7, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3C,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x21,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x18, 0x1F, 0xF0, 0x3C, 0x7F,
  0xF0, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0x1F,
  0xFE, 0x7C, 0x0F, 0xF0, 0x18, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 13, 31, 24, 8, -30 },
  { 52, 18, 13, 24, 9, -32 },
  { 82, 25, 30, 24, 2, -30 },
  { 176, 24, 39, 24, 2, -34 },
  { 293, 29, 32, 24, 0, -31 },
  { 409, 23, 32, 24, 2, -31 },
  { 501, 9, 14, 24, 13, -32 },
  { 517, 19, 43, 24, 7, -34 },
  { 620, 19, 43, 24, 2, -34 },
  { 723, 20, 20, 24, 6, -30 },
  { 773, 22, 21, 24, 3, -23 },
  { 831, 11, 16, 24, 5, -8 },
  { 853, 14, 6, 24, 7, -15 },
  { 864, 8, 9, 24, 8, -8 },
  { 873, 29, 42, 24, -1, -34 },
  { 1026, 23, 32, 24, 3, -31 },
  { 1118, 19, 30, 24, 3, -30 },
  { 1190, 23, 31, 24, 2, -31 },
  { 1280, 24, 32, 24, 1, -31 },
  { 1376, 24, 30, 24, 2, -30 },
  { 1466, 25, 31, 24, 2, -30 },
  { 1563, 23, 31, 24, 4, -30 },
  { 1653, 23, 30, 24, 6, -30 },
  { 1740, 23, 32, 24, 3, -31 },
  { 1832, 23, 31, 24, 3, -31 },
  { 1922, 12, 24, 24, 8, -23 },
  { 1958, 15, 31, 24, 5, -23 },
  { 2017, 22, 21, 24, 4, -23 },
  { 2075, 24, 14, 24, 2, -20 },
  { 2117, 21, 21, 24, 3, -23 },
  { 2173, 18, 32, 24, 7, -31 },
  { 2245, 24, 37, 24, 3, -31 },
  { 2356, 23, 30, 24, 0, -30 },
  { 2443, 24, 31, 24, 2, -30 },
  { 2536, 23, 32, 24, 4, -31 },
  { 2628, 24, 32, 24, 1, -31 },
  { 2724, 24, 30, 24, 3, -30 },
  { 2814, 25, 30, 24, 3, -30 },
  { 2908, 23, 32, 24, 4, -31 },
  { 3000, 27, 30, 24, 1, -30 },
  { 3102, 26, 30, 24, 2, -30 },
  { 3200, 25, 31, 24, 2, -30 },
  { 3297, 28, 30, 24, 1, -30 },
  { 3402, 20, 30, 24, 2, -30 },
  { 3477, 28, 30, 24, 0, -30 },
  { 3582, 27, 30, 24, 1, -30 },
  { 3684, 23, 32, 24, 3, -31 },
  { 3776, 25, 30, 24, 2, -30 },
  { 3870, 23, 40, 24, 3, -31 },
  { 3985, 24, 30, 24, 2, -30 },
  { 4075, 25, 32, 24, 1, -31 },
  { 4175, 23, 30, 24, 6, -30 },
  { 4262, 25, 31, 24, 3, -30 },
  { 4359, 23, 30, 24, 7, -30 },
  { 4446, 27, 30, 24, 2, -30 },
  { 4548, 29, 30, 24, 0, -30 },
  { 4657, 23, 30, 24, 7, -30 },
  { 4744, 26, 30, 24, 1, -30 },
  { 4842, 24, 42, 24, 4, -34 },
  { 4968, 9, 42, 24, 10, -34 },
  { 5016, 23, 42, 24, 1, -34 },
  { 5137, 22, 17, 24, 4, -30 },
  { 5184, 23, 5, 24, -2, 3 },
  { 5199, 11, 9, 24, 11, -33 },
  { 5212, 22, 25, 24, 3, -24 },
  { 5281, 22, 35, 24, 2, -34 },
  { 5378, 21, 25, 24, 4, -24 },
  { 5444, 25, 35, 24, 3, -34 },
  { 5554, 21, 25, 24, 4, -24 },
  { 5620, 30, 43, 24, -2, -34 },
  { 5782, 26, 33, 24, 0, -24 },
  { 5890, 22, 34, 24, 2, -34 },
  { 5984, 17, 35, 24, 5, -34 },
  { 6059, 23, 43, 24, 0, -34 },
  { 6183, 24, 34, 24, 3, -34 },
  { 6285, 15, 34, 24, 7, -33 },
  { 6349, 24, 23, 24, 1, -23 },
  { 6418, 22, 24, 24, 2, -24 },
  { 6484, 21, 25, 24, 3, -24 },
  { 6550, 24, 32, 24, 0, -24 },
  { 6646, 23, 32, 24, 3, -24 },
  { 6738, 23, 24, 24, 3, -24 },
  { 6807, 22, 25, 24, 2, -24 },
  { 6876, 20, 31, 24, 5, -30 },
  { 6954, 21, 24, 24, 4, -23 },
  { 7017, 22, 23, 24, 5, -23 },
  { 7081, 25, 23, 24, 3, -23 },
  { 7153, 26, 23, 24, 0, -23 },
  { 7228, 28, 32, 24, -2, -23 },
  { 7340, 23, 23, 24, 2, -23 },
  { 7407, 23, 42, 24, 5, -34 },
  { 7528, 16, 42, 24, 6, -34 },
  { 7612, 23, 42, 24, 0, -34 },
  { 7733, 23, 9, 24, 2, -17 },
};

const GFXfont UbuntuMono_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic48pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUMONO_BOLDITALIC48PT7B_H_
