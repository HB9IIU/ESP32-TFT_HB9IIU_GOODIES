#ifndef _UBUNTUMONO_BOLDITALIC61PT7B_H_
#define _UBUNTUMONO_BOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F,
  0x87, 0xF9, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F,
  0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x01,
  0xF0, 0x0F, 0xF0, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0x80, 0x07, 0xF8, 0x0F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0xFF, 0x00, 0x7C, 0x00, 0xFC, 0xF8, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x7E,
  0x00, 0x7C, 0x3E, 0x07, 0xE0, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x1F, 0x0F,
  0x83, 0xE0, 0x00, 0xF0, 0x78, 0x3E, 0x00, 0x07, 0x87, 0xC3, 0xF0, 0x00,
  0x3C, 0x3E, 0x3F, 0x00, 0x01, 0xF3, 0xE3, 0xF0, 0x00, 0x0F, 0xFF, 0x1F,
  0x00, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0x00, 0x00, 0x0F,
  0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x0F,
  0x8F, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0xFE, 0x00,
  0x00, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xC7, 0xC7, 0xC0, 0x00, 0x7C, 0x3E,
  0x3E, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x7C, 0x00, 0x7E, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0x3C, 0x3E,
  0x00, 0x3E, 0x01, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0x00,
  0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xF8, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0xF8,
  0x1F, 0x83, 0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0x0F, 0xC3, 0xFB, 0xFC, 0x7E,
  0x3F, 0x8F, 0xF7, 0xE3, 0xF8, 0x3F, 0xBF, 0x1F, 0x81, 0xFF, 0xF1, 0xFC,
  0x07, 0xFF, 0x8F, 0xE0, 0x1F, 0xF8, 0x7E, 0x00, 0xFF, 0x83, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFD, 0xFC, 0x1F,
  0xFF, 0xCF, 0xE0, 0x7F, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0xFF, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x0F,
  0xC0, 0xC3, 0xC3, 0xF0, 0xF0, 0xFC, 0xFC, 0xFC, 0x7F, 0x9E, 0x7F, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xE1, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x1C, 0x0E, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0xFE, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xF0, 0x06, 0x00,
  0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x0F, 0x07, 0xF9, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0xF0, 0x7F, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC,
  0xFE, 0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xF0,
  0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF3, 0xFC, 0x03, 0xC3,
  0xF8, 0x03, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0x00, 0x60,
  0x01, 0xFC, 0x01, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0xFF, 0xC0, 0x0C, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0x7F, 0xC0, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x7F,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xCF, 0xFC, 0x03, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xC0, 0xFF, 0x8E, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xC7, 0xE0,
  0x7F, 0xFF, 0x8F, 0x81, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFC, 0x7E, 0x1F,
  0xFF, 0xF8, 0xF8, 0x3F, 0xC7, 0xF3, 0xF0, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8,
  0x1F, 0x8F, 0xC3, 0xF0, 0x3F, 0x1F, 0x0F, 0xE0, 0xFE, 0x3E, 0x1F, 0x81,
  0xF8, 0x7C, 0x3F, 0x03, 0xF1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x1F,
  0xC7, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0xC0,
  0xF8, 0x3F, 0xFF, 0x81, 0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0x3F, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x04, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0x00,
  0xFF, 0x80, 0x08, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x04,
  0x00, 0xFF, 0xC0, 0x78, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0x00, 0xFF, 0x80, 0x08,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0xFF, 0x00, 0x1C,
  0x01, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0x8F, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7D, 0xF1, 0xF7, 0xC0, 0x1F, 0xBE,
  0x3E, 0xF8, 0x03, 0xF7, 0xCF, 0xBF, 0x00, 0x7E, 0xF9, 0xF7, 0xE0, 0x0F,
  0x8F, 0x7C, 0xFC, 0x03, 0xF1, 0xEF, 0x9F, 0x80, 0x7E, 0x3F, 0xE7, 0xE0,
  0x0F, 0xC7, 0xFC, 0xFC, 0x03, 0xF8, 0xFF, 0x1F, 0x80, 0x7E, 0x1F, 0xE3,
  0xF0, 0x0F, 0xC3, 0xF8, 0xFC, 0x01, 0xF8, 0x7F, 0x1F, 0x80, 0x7F, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0x07, 0xFE,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x3F,
  0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0x03, 0xF8, 0x03, 0xF7, 0xE0, 0xFE, 0x01,
  0xFD, 0xF8, 0x3F, 0x00, 0x7F, 0x3E, 0x0F, 0xC0, 0x1F, 0xCF, 0x87, 0xF0,
  0x07, 0xE3, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x1F,
  0x80, 0x3F, 0x87, 0xCF, 0xE0, 0x0F, 0xC1, 0xF3, 0xF8, 0x07, 0xF0, 0x7E,
  0xFE, 0x01, 0xFC, 0x0F, 0xBF, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x07,
  0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x08, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0xC0, 0x7E, 0x01, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC3,
  0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF8, 0x7E, 0x01, 0xF8, 0xFF, 0x1F, 0x80, 0x3F, 0x1F, 0xE3, 0xF0,
  0x0F, 0xC7, 0xFC, 0x7E, 0x01, 0xF8, 0xFF, 0x8F, 0xC0, 0x3F, 0x3F, 0xF3,
  0xF0, 0x07, 0xE7, 0xBE, 0x7E, 0x00, 0xF9, 0xF3, 0xCF, 0xC0, 0x3F, 0x3C,
  0x79, 0xF0, 0x07, 0xEF, 0x8F, 0x7E, 0x00, 0xFD, 0xE1, 0xEF, 0xC0, 0x1F,
  0x7C, 0x3D, 0xF8, 0x03, 0xEF, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xE7, 0xF8,
  0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x1F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0xFE, 0x1C,
  0x00, 0x0F, 0x00, 0x40, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x01, 0xC0, 0x0F,
  0x80, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF0, 0x0F,
  0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFC, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0x7F, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xF8, 0x03,
  0xF8, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0x83, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x60, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x1C, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x38, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x07, 0xFD, 0xFC, 0x03, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1C,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x7F, 0x80, 0x0F, 0x80,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x8F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x10, 0x03, 0xFC, 0x00, 0xF0, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0x03, 0xF8, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x0C, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x03, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFC,
  0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0,
  0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x81,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xC0, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x0F, 0xF0, 0x3E, 0x01, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x70, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8,
  0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xCF, 0xF0, 0x1F, 0xE0,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x03,
  0xF8, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x8F,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x1F, 0xC1, 0xF0, 0x7E, 0x3F,
  0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x87, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF1, 0xFE, 0x1F, 0x07, 0xC3, 0xFC, 0x7E, 0x0F, 0x8F,
  0xF8, 0xFC, 0x1F, 0x1F, 0xF1, 0xF0, 0x7E, 0x7D, 0xE7, 0xE0, 0xFC, 0xFB,
  0xCF, 0xC1, 0xFB, 0xE7, 0x9F, 0x03, 0xF7, 0xCF, 0x3E, 0x07, 0xDF, 0x1F,
  0xFC, 0x0F, 0xBE, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x1F, 0xF0, 0x0F, 0xC3, 0xFF, 0xE0,
  0x7E, 0x3F, 0xFF, 0x87, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xC3, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0x87, 0xE0,
  0x1F, 0xF8, 0x06, 0x00, 0x3F, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 17, 39, 31, 10, -38 },
  { 84, 22, 17, 31, 12, -41 },
  { 131, 33, 38, 31, 2, -38 },
  { 288, 30, 49, 31, 3, -43 },
  { 472, 37, 40, 31, 0, -39 },
  { 657, 29, 40, 31, 3, -39 },
  { 802, 11, 18, 31, 17, -41 },
  { 827, 25, 54, 31, 8, -43 },
  { 996, 24, 54, 31, 3, -43 },
  { 1158, 26, 24, 31, 7, -38 },
  { 1236, 27, 28, 31, 4, -30 },
  { 1331, 15, 20, 31, 6, -10 },
  { 1369, 19, 7, 31, 8, -19 },
  { 1386, 11, 11, 31, 10, -10 },
  { 1402, 36, 53, 31, -1, -43 },
  { 1641, 29, 40, 31, 4, -39 },
  { 1786, 24, 38, 31, 4, -38 },
  { 1900, 30, 39, 31, 2, -39 },
  { 2047, 30, 40, 31, 2, -39 },
  { 2197, 31, 38, 31, 2, -38 },
  { 2345, 32, 39, 31, 2, -38 },
  { 2501, 29, 39, 31, 5, -38 },
  { 2643, 29, 38, 31, 7, -38 },
  { 2781, 29, 40, 31, 4, -39 },
  { 2926, 30, 39, 31, 3, -39 },
  { 3073, 15, 29, 31, 10, -28 },
  { 3128, 19, 38, 31, 6, -28 },
  { 3219, 28, 27, 31, 5, -29 },
  { 3314, 30, 18, 31, 3, -25 },
  { 3382, 28, 27, 31, 3, -29 },
  { 3477, 23, 40, 31, 9, -39 },
  { 3592, 31, 47, 31, 3, -39 },
  { 3775, 29, 38, 31, 0, -38 },
  { 3913, 31, 39, 31, 2, -38 },
  { 4065, 30, 40, 31, 5, -39 },
  { 4215, 30, 40, 31, 2, -39 },
  { 4365, 32, 38, 31, 3, -38 },
  { 4517, 33, 38, 31, 3, -38 },
  { 4674, 30, 40, 31, 5, -39 },
  { 4824, 34, 38, 31, 2, -38 },
  { 4986, 33, 38, 31, 2, -38 },
  { 5143, 32, 39, 31, 2, -38 },
  { 5299, 35, 38, 31, 2, -38 },
  { 5466, 25, 38, 31, 3, -38 },
  { 5585, 35, 38, 31, 0, -38 },
  { 5752, 34, 38, 31, 2, -38 },
  { 5914, 29, 40, 31, 4, -39 },
  { 6059, 32, 38, 31, 2, -38 },
  { 6211, 29, 50, 31, 4, -39 },
  { 6393, 31, 38, 31, 2, -38 },
  { 6541, 31, 40, 31, 2, -39 },
  { 6696, 29, 38, 31, 8, -38 },
  { 6834, 31, 39, 31, 4, -38 },
  { 6986, 30, 38, 31, 8, -38 },
  { 7129, 35, 38, 31, 2, -38 },
  { 7296, 37, 38, 31, 0, -38 },
  { 7472, 29, 38, 31, 9, -38 },
  { 7610, 33, 38, 31, 2, -38 },
  { 7767, 30, 53, 31, 5, -43 },
  { 7966, 12, 53, 31, 13, -43 },
  { 8046, 30, 53, 31, 1, -43 },
  { 8245, 28, 22, 31, 5, -38 },
  { 8322, 29, 7, 31, -2, 3 },
  { 8348, 13, 11, 31, 15, -42 },
  { 8366, 28, 31, 31, 4, -30 },
  { 8475, 29, 44, 31, 2, -43 },
  { 8635, 27, 31, 31, 5, -30 },
  { 8740, 32, 44, 31, 4, -43 },
  { 8916, 27, 31, 31, 5, -30 },
  { 9021, 38, 54, 31, -2, -43 },
  { 9278, 33, 41, 31, 0, -30 },
  { 9448, 27, 43, 31, 3, -43 },
  { 9594, 21, 43, 31, 7, -42 },
  { 9707, 29, 53, 31, 0, -42 },
  { 9900, 32, 43, 31, 3, -43 },
  { 10072, 19, 43, 31, 9, -42 },
  { 10175, 31, 29, 31, 1, -29 },
  { 10288, 27, 30, 31, 3, -30 },
  { 10390, 27, 31, 31, 4, -30 },
  { 10495, 31, 40, 31, 0, -30 },
  { 10650, 29, 40, 31, 4, -30 },
  { 10795, 29, 30, 31, 4, -30 },
  { 10904, 28, 31, 31, 3, -30 },
  { 11013, 25, 38, 31, 7, -37 },
  { 11132, 27, 30, 31, 5, -29 },
  { 11234, 28, 29, 31, 6, -29 },
  { 11336, 31, 29, 31, 4, -29 },
  { 11449, 33, 29, 31, 1, -29 },
  { 11569, 36, 40, 31, -3, -29 },
  { 11749, 29, 29, 31, 3, -29 },
  { 11855, 29, 53, 31, 6, -43 },
  { 12048, 20, 53, 31, 8, -43 },
  { 12181, 29, 53, 31, 0, -43 },
  { 12374, 29, 11, 31, 3, -22 },
};

const GFXfont UbuntuMono_BoldItalic61pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic61pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic61pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UBUNTUMONO_BOLDITALIC61PT7B_H_
