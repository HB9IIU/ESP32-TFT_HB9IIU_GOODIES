#ifndef _UBUNTUMONO_BOLDITALIC34PT7B_H_
#define _UBUNTUMONO_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x3E, 0x1F, 0x0F,
  0x00, 0x79, 0xFF, 0x9F, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xE3, 0xCE,
  0x3C, 0xE3, 0x8C, 0x38, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x1E, 0x38, 0x07,
  0x9E, 0x01, 0xC7, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x1E,
  0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0x38, 0xF0, 0x0E, 0x38, 0x07, 0x9E, 0x01, 0xC7,
  0x00, 0xF1, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x01, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x60, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x70, 0x3F, 0x07, 0x83, 0xF8, 0x38, 0x1D, 0xC3, 0x81, 0xCE, 0x38, 0x0E,
  0x73, 0x80, 0x73, 0xB8, 0x03, 0xFB, 0xC0, 0x1F, 0x9C, 0x00, 0x79, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x1C, 0xF8, 0x01, 0xCF, 0xE0, 0x0E,
  0xE7, 0x00, 0xE7, 0x38, 0x0E, 0x31, 0x80, 0xE1, 0x9C, 0x0E, 0x0F, 0xE0,
  0xE0, 0x7E, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x1E, 0x3C, 0x0E, 0x78, 0x0E, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC6, 0x3F, 0x8F, 0x7F, 0xCE, 0xF1, 0xFE, 0xF1, 0xFC,
  0xE0, 0xFC, 0xE0, 0x78, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xBC, 0x3E, 0x1C,
  0x7B, 0xFF, 0xFF, 0x7B, 0x9C, 0xE6, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x04, 0x00, 0x00, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x07, 0x80, 0x1E, 0x06, 0x78, 0x9C, 0xEE, 0x7F, 0x7F, 0xFF, 0xF3,
  0xFF, 0x01, 0xE0, 0x0F, 0xE0, 0x7B, 0xC3, 0xCF, 0x87, 0x1C, 0x08, 0x40,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x1F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0xF8,
  0x3C, 0x3C, 0xFC, 0x7C, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFE, 0x7B,
  0xEF, 0xFE, 0xF9, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x79,
  0xCF, 0x79, 0xCF, 0x79, 0xCF, 0x78, 0x0F, 0x70, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0x78, 0x7C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xEF, 0x02, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC1, 0xE1, 0xF0, 0x40,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x30,
  0x3E, 0x1F, 0xFF, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x1E, 0xF0,
  0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x1E, 0x1F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x1C, 0x1F,
  0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xFF,
  0x07, 0xFF, 0x0F, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x7B, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF8, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0xFF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1F, 0x1E,
  0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x78, 0x3C, 0x78, 0x3C,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3E, 0x1F, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xDE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x0E, 0x1F, 0x3F, 0x3F,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xFC, 0xF8, 0xF8, 0x70,
  0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x0F, 0x03,
  0xC3, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x03, 0xF8, 0x1F,
  0xF1, 0xFF, 0xDF, 0xFC, 0x3F, 0xC0, 0x7C, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x01, 0xFE, 0x1F, 0xFD, 0xFF,
  0xC7, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xF3, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0xC1, 0xF0, 0xF1, 0xE0, 0x39, 0xE0, 0x1C, 0xE1, 0xFE, 0xF1,
  0xFF, 0x71, 0xFF, 0xB9, 0xE3, 0x9C, 0xE3, 0xDC, 0xF1, 0xEE, 0x78, 0xF7,
  0x3C, 0x73, 0x9E, 0x79, 0xCF, 0x3C, 0xE7, 0x9E, 0x71, 0xFE, 0x38, 0xFF,
  0x1C, 0x1F, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFF, 0x01, 0xEF, 0x01, 0xEF, 0x03, 0xCF, 0x03, 0xCF, 0x07, 0x8F,
  0x07, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x03, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x3E, 0x0F, 0x1E, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xC3,
  0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x1F, 0x3C, 0x1F,
  0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0x86, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x10, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE3, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xE7, 0xC1, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0xF8, 0x7C, 0x78,
  0x3C, 0x3C, 0x7E, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x0F,
  0xFF, 0x1F, 0x86, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xC0, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1F, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x20, 0x7C, 0x1C, 0x3E, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x0F, 0x87,
  0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3D,
  0xF0, 0x03, 0xCF, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x00, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC1, 0xF0,
  0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E,
  0x0E, 0xCE, 0xE0, 0xEC, 0xFC, 0x0E, 0xFD, 0xC1, 0xEF, 0xDC, 0x1E, 0xFB,
  0xC1, 0xCF, 0xBC, 0x1C, 0xF3, 0x83, 0xCF, 0x38, 0x3C, 0x07, 0x83, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x07, 0xE1, 0xE0,
  0xFC, 0x3C, 0x1F, 0x87, 0x87, 0xF0, 0xE0, 0xF7, 0x3C, 0x1E, 0xE7, 0x83,
  0x9C, 0xF0, 0xF3, 0x9C, 0x1E, 0x3F, 0x83, 0xC7, 0xF0, 0x70, 0xFE, 0x1E,
  0x1F, 0x83, 0xC3, 0xF0, 0x78, 0x3E, 0x0E, 0x07, 0xC3, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x1F,
  0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF8, 0x7C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1E, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0x83, 0xE1, 0xE1, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0x78, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0x0F, 0x87,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xCF, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0x0C, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x1C, 0x1F, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC7, 0xC1,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x3E, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF8, 0x78, 0x3E, 0x3E,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF3, 0x80,
  0xF7, 0x80, 0xF7, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x03, 0xC1, 0xC7, 0x3C, 0x3C, 0xF3,
  0x83, 0xCF, 0x38, 0x39, 0xF7, 0x83, 0xBF, 0x78, 0x3B, 0xF7, 0x07, 0xF7,
  0x70, 0x77, 0x77, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x0F,
  0x80, 0xF0, 0x78, 0x07, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x78, 0x01, 0xF3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F,
  0x80, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0x78,
  0x78, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xF1, 0xE3, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x81, 0xEF, 0x87, 0x8F, 0x1F, 0x1E, 0x7C, 0x3F, 0xF0, 0x3F, 0xC0,
  0x79, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x20,
  0x70, 0x7C, 0x7E, 0x1E, 0x04, 0x01, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x3F,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF8, 0x78, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x1F,
  0x38, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x78, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x3E, 0x78, 0x7C, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x01,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0x27, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0x83,
  0xE3, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xF3, 0xC0, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF1, 0xF1, 0xF7, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0x7F, 0xFC,
  0xFF, 0xF1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0x0F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7C, 0x20, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x78,
  0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7D, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x06, 0x0F, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1F, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x03, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x01, 0xE1, 0x1F, 0xF1, 0xFF, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x61, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x1F, 0x1F,
  0x0F, 0x1F, 0x07, 0x9F, 0x03, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F,
  0x87, 0x87, 0x83, 0xE3, 0xC1, 0xF0, 0x7F, 0xBF, 0xEF, 0xF8, 0x3E, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7F, 0xCF, 0xF1, 0xF8, 0x07,
  0xCF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0x9E, 0xF1, 0xCE, 0x79, 0xE7, 0x3C,
  0xE3, 0x9C, 0x73, 0xCE, 0x39, 0xC7, 0x3C, 0xE7, 0x9C, 0x03, 0xCE, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x38, 0x03, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x78, 0x01, 0xF0, 0x0F, 0xF8, 0x7F, 0xF1, 0xF1,
  0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xF7, 0xC3, 0xEF, 0x8F, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x01,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC7, 0xC3,
  0xE3, 0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1E, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0x78, 0x7C, 0x78, 0x78,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x1E, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0xF0, 0x21, 0xE0, 0x03,
  0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03,
  0xC6, 0x0F, 0x9F, 0xFF, 0x3F, 0xFC, 0x1F, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xF0, 0x43, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x3C, 0x1E, 0x78,
  0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0xBE, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1F, 0xFE, 0x3F,
  0xFE, 0x1F, 0x38, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x07,
  0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF9, 0xE0, 0xF7, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xDE,
  0x00, 0xE7, 0x80, 0x79, 0xC7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xC7, 0x3C,
  0xE1, 0xDF, 0x38, 0xF7, 0xCE, 0x3B, 0xB7, 0x0E, 0xEF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x0F, 0x03, 0xC1,
  0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xDE, 0x01, 0xF3, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF8, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x3D, 0xF0,
  0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x47, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0x06, 0x3F, 0x8F, 0x7F, 0xFE, 0xFF, 0xFE, 0xF3,
  0xFC, 0x60, 0xF0,
};

const GFXglyph UbuntuMono_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 21, 17, 6, -21 },
  { 25, 12, 10, 17, 7, -23 },
  { 40, 18, 21, 17, 1, -21 },
  { 88, 16, 27, 17, 2, -24 },
  { 142, 21, 21, 17, 0, -21 },
  { 198, 16, 21, 17, 2, -21 },
  { 240, 5, 10, 17, 10, -23 },
  { 247, 13, 30, 17, 5, -24 },
  { 296, 14, 30, 17, 1, -24 },
  { 349, 14, 13, 17, 4, -21 },
  { 372, 15, 15, 17, 2, -17 },
  { 401, 9, 11, 17, 3, -6 },
  { 414, 10, 4, 17, 5, -11 },
  { 419, 6, 6, 17, 6, -6 },
  { 424, 20, 30, 17, 0, -24 },
  { 499, 16, 21, 17, 2, -21 },
  { 541, 14, 21, 17, 2, -21 },
  { 578, 17, 21, 17, 1, -21 },
  { 623, 17, 21, 17, 1, -21 },
  { 668, 18, 21, 17, 1, -21 },
  { 716, 18, 21, 17, 1, -21 },
  { 764, 16, 21, 17, 3, -21 },
  { 806, 16, 21, 17, 4, -21 },
  { 848, 16, 21, 17, 2, -21 },
  { 890, 16, 21, 17, 2, -21 },
  { 932, 8, 16, 17, 6, -16 },
  { 948, 11, 21, 17, 3, -16 },
  { 977, 15, 15, 17, 3, -16 },
  { 1006, 16, 9, 17, 2, -14 },
  { 1024, 15, 15, 17, 2, -16 },
  { 1053, 13, 21, 17, 5, -21 },
  { 1088, 17, 26, 17, 2, -21 },
  { 1144, 16, 21, 17, 0, -21 },
  { 1186, 17, 21, 17, 1, -21 },
  { 1231, 16, 21, 17, 3, -21 },
  { 1273, 17, 21, 17, 1, -21 },
  { 1318, 17, 21, 17, 2, -21 },
  { 1363, 18, 21, 17, 2, -21 },
  { 1411, 16, 21, 17, 3, -21 },
  { 1453, 19, 21, 17, 1, -21 },
  { 1503, 19, 21, 17, 1, -21 },
  { 1553, 18, 21, 17, 1, -21 },
  { 1601, 20, 21, 17, 1, -21 },
  { 1654, 13, 21, 17, 2, -21 },
  { 1689, 20, 21, 17, 0, -21 },
  { 1742, 19, 21, 17, 1, -21 },
  { 1792, 16, 21, 17, 2, -21 },
  { 1834, 18, 21, 17, 1, -21 },
  { 1882, 16, 26, 17, 2, -21 },
  { 1934, 17, 21, 17, 1, -21 },
  { 1979, 18, 21, 17, 1, -21 },
  { 2027, 17, 21, 17, 4, -21 },
  { 2072, 18, 21, 17, 2, -21 },
  { 2120, 16, 21, 17, 5, -21 },
  { 2162, 20, 21, 17, 1, -21 },
  { 2215, 21, 21, 17, 0, -21 },
  { 2271, 16, 21, 17, 5, -21 },
  { 2313, 18, 21, 17, 1, -21 },
  { 2361, 17, 30, 17, 3, -24 },
  { 2425, 7, 30, 17, 7, -24 },
  { 2452, 16, 30, 17, 1, -24 },
  { 2512, 15, 12, 17, 3, -21 },
  { 2535, 16, 4, 17, -1, 2 },
  { 2543, 8, 6, 17, 8, -23 },
  { 2549, 16, 16, 17, 2, -16 },
  { 2581, 16, 23, 17, 1, -23 },
  { 2627, 15, 16, 17, 3, -16 },
  { 2657, 18, 23, 17, 2, -23 },
  { 2709, 15, 16, 17, 3, -16 },
  { 2739, 21, 29, 17, -1, -23 },
  { 2816, 18, 22, 17, 0, -16 },
  { 2866, 16, 23, 17, 1, -23 },
  { 2912, 12, 23, 17, 4, -23 },
  { 2947, 16, 29, 17, 0, -23 },
  { 3005, 17, 23, 17, 2, -23 },
  { 3054, 10, 23, 17, 5, -23 },
  { 3083, 17, 16, 17, 1, -16 },
  { 3117, 16, 16, 17, 1, -16 },
  { 3149, 15, 16, 17, 2, -16 },
  { 3179, 17, 22, 17, 0, -16 },
  { 3226, 16, 22, 17, 2, -16 },
  { 3270, 16, 16, 17, 2, -16 },
  { 3302, 15, 16, 17, 2, -16 },
  { 3332, 14, 21, 17, 4, -21 },
  { 3369, 15, 16, 17, 3, -16 },
  { 3399, 15, 16, 17, 4, -16 },
  { 3429, 18, 16, 17, 2, -16 },
  { 3465, 19, 16, 17, 0, -16 },
  { 3503, 20, 22, 17, -1, -16 },
  { 3558, 16, 16, 17, 2, -16 },
  { 3590, 17, 30, 17, 3, -24 },
  { 3654, 12, 30, 17, 4, -24 },
  { 3699, 16, 30, 17, 0, -24 },
  { 3759, 16, 6, 17, 2, -12 },
};

const GFXfont UbuntuMono_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic34pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUMONO_BOLDITALIC34PT7B_H_
