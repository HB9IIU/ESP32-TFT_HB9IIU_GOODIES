#ifndef _UBUNTUMONO_BOLDITALIC35PT7B_H_
#define _UBUNTUMONO_BOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x78, 0xF7, 0x8F, 0xF9, 0xFF, 0x9F, 0xF1,
  0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCC, 0x18, 0x00, 0x71, 0xE0, 0x1E,
  0x38, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8E,
  0x00, 0xE3, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x1E, 0x01, 0xE3, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFC, 0x3E, 0x04, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x18, 0x0F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0,
  0x7F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x3F, 0x03, 0x83, 0xF8, 0x38, 0x1C, 0xC3, 0xC0, 0xC6, 0x1C,
  0x0E, 0x31, 0xC0, 0x73, 0x9C, 0x03, 0x9D, 0xC0, 0x1F, 0xDC, 0x00, 0x7F,
  0xE0, 0x01, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x0E, 0xFC, 0x00, 0xEF, 0xE0,
  0x0E, 0x73, 0x00, 0xF7, 0x18, 0x07, 0x39, 0xC0, 0x71, 0xCE, 0x07, 0x0E,
  0x70, 0x70, 0x7F, 0x07, 0x81, 0xF0, 0x38, 0x0F, 0x00, 0x00, 0xF8, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E,
  0x3C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xC7, 0x1F, 0xC7, 0x3F, 0xCF, 0x79,
  0xEE, 0xF1, 0xFE, 0xE0, 0xFC, 0xE0, 0x7C, 0xF0, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFC, 0x7F, 0x9E, 0x3F, 0x1E, 0x7D, 0xE7, 0xBE, 0xFB, 0xCF, 0x38, 0xE3,
  0x80, 0x00, 0x10, 0x00, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x40, 0x01, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x0E,
  0x03, 0x1C, 0x67, 0xB9, 0xCF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFC, 0x07, 0xC0,
  0x1D, 0xC0, 0x7B, 0xC1, 0xF7, 0xC1, 0xC7, 0x01, 0x04, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x78, 0x1C, 0x3C, 0xFE, 0x7C, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x78,
  0x0F, 0x3C, 0xC7, 0xBC, 0xF3, 0xDE, 0x73, 0xCF, 0x39, 0xE7, 0x80, 0xF3,
  0xC0, 0x7B, 0xE0, 0x79, 0xE0, 0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x1F, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F,
  0xC1, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x82, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x07, 0xC1, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x80,
  0x00, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x30, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x30, 0x3F, 0x1F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xE1, 0xF0,
  0x70, 0x78, 0x38, 0x1E, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x18, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7B, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0xF8, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x1E, 0x0F, 0x1F, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xE7, 0xC3, 0xC1, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x7C, 0x3F,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xE0, 0x7C, 0xF0, 0x3E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xC7, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3E, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x0E, 0x1F, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC, 0xF8,
  0x70, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x00, 0xE0, 0x78, 0x7F, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x1F,
  0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x10, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFE,
  0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x30, 0xFC, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x00, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E,
  0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0xFE, 0x78, 0xFF, 0x9C,
  0x7F, 0xE7, 0x1E, 0x7B, 0xCF, 0x1C, 0xF3, 0x87, 0x39, 0xE3, 0xCE, 0x78,
  0xF3, 0x9E, 0x3C, 0xE7, 0x8E, 0x39, 0xE7, 0x8E, 0x3F, 0xE3, 0xCF, 0xF8,
  0xF0, 0xFC, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xC7, 0x01,
  0xE3, 0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x7F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x9E, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x1F, 0x0F, 0x03, 0xE3, 0xC0,
  0xF8, 0xF0, 0x3E, 0x3C, 0x0F, 0x1E, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xF8, 0x31, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x0C, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3,
  0xC0, 0xF0, 0xF0, 0x7C, 0x7C, 0x3E, 0x1E, 0x3F, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x31, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0x9E, 0x07, 0xCF,
  0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C,
  0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x20,
  0x3C, 0x06, 0x0F, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0x87, 0xC0, 0xF8, 0x78,
  0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xCF,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xE0, 0x78,
  0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xEE, 0xEE, 0x0E, 0xEE, 0xE0, 0xEF,
  0xDE, 0x1E, 0xF9, 0xC1, 0xEF, 0x9C, 0x1C, 0x71, 0xC3, 0xC7, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0xF0, 0x3C,
  0x3F, 0x07, 0x87, 0xE0, 0xF0, 0xFC, 0x1C, 0x1F, 0x87, 0x83, 0xF8, 0xF0,
  0xF7, 0x1E, 0x1E, 0xE3, 0x83, 0xDC, 0xF0, 0x73, 0xDE, 0x1E, 0x3B, 0xC3,
  0xC7, 0x78, 0x78, 0xFE, 0x0F, 0x1F, 0xC3, 0xC1, 0xF8, 0x78, 0x3F, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0xF8, 0xF0,
  0x7C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xEF,
  0x01, 0xE7, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E,
  0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x87, 0xC3, 0xE0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xE1, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0xF8,
  0xF0, 0x7C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0xF8,
  0x3E, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0C,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x8F,
  0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x87, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xC7, 0x80, 0xF1,
  0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x3E, 0x07, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE,
  0x0F, 0x83, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x1C, 0x0F, 0x87, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7,
  0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xE0,
  0xF0, 0xF8, 0x3C, 0x3E, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xF0, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xCF,
  0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1C, 0x1C, 0xF3,
  0xC3, 0xCF, 0x3C, 0x3D, 0xF3, 0x83, 0xDF, 0x38, 0x3B, 0xB3, 0x83, 0xBB,
  0x78, 0x7F, 0x37, 0x07, 0xF3, 0x70, 0x7E, 0x37, 0x07, 0xE3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0xF8,
  0x1E, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xFB,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C,
  0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x78, 0x0F, 0xBC,
  0x07, 0x9F, 0x07, 0xC7, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F,
  0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xBC, 0x1F, 0x3C,
  0x3E, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0x70, 0x1E, 0x00, 0x08,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x78, 0x7C, 0x7F,
  0x1F, 0x06, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x18, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xF0, 0xF0, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07,
  0x9F, 0x07, 0xCF, 0x8F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0x80, 0x01, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x08, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x0F, 0x0F, 0x83, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7C, 0x70, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xE1,
  0xEF, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0xFF, 0xF9, 0xFF, 0x83, 0xC0, 0x07,
  0xC0, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x0F, 0x87, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xF7, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x0C, 0x0F, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3,
  0xE3, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x3E, 0xF8, 0x79, 0xE0,
  0xF3, 0xC1, 0xEF, 0x87, 0xDF, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0x01, 0xC0,
  0x3C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x30, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0x87, 0xC3,
  0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0x78,
  0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0x7F, 0xCF, 0xF3, 0xFE,
  0x7F, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x17,
  0xFE, 0xFF, 0xCF, 0xF8, 0xFC, 0x07, 0xCF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1C, 0xF3, 0x8F, 0x38, 0xE3, 0xCE, 0x38, 0xF3, 0x9E, 0x39,
  0xE7, 0x1E, 0x79, 0xC7, 0x80, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x3C, 0x03,
  0x8F, 0x00, 0xE3, 0x80, 0x78, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF3, 0xE3, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x3E, 0xF8, 0x79,
  0xE0, 0xF3, 0xC1, 0xEF, 0x87, 0xDF, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0x01,
  0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x7C, 0x1F, 0x78,
  0x1F, 0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C,
  0x1F, 0x1F, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0x78, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x1E, 0x78, 0x3E, 0xF8, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF0, 0x3E, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0x04, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x60, 0x7C, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x10, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x80, 0xFE, 0x00, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0xFB, 0xE1, 0xF7, 0x83,
  0xCF, 0x07, 0xBE, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7,
  0x8F, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0x38, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x07, 0x9E, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8,
  0x79, 0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x39, 0xE3, 0x8E,
  0x71, 0xE7, 0x9C, 0x79, 0xC7, 0x3E, 0x71, 0xCF, 0xBC, 0x77, 0xEE, 0x3D,
  0xBB, 0x8E, 0xEF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x1E, 0x0F, 0x87,
  0x83, 0xC1, 0xC0, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x1E, 0x01, 0xE7,
  0xC0, 0x3D, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3C, 0x3C,
  0x0F, 0x07, 0xC3, 0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80,
  0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x06, 0x1F, 0xE3, 0x9F, 0xFF,
  0xDF, 0xFF, 0xCF, 0x1F, 0xC3, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 10, 22, 18, 6, -22 },
  { 29, 12, 10, 18, 7, -24 },
  { 44, 19, 22, 18, 1, -22 },
  { 97, 17, 27, 18, 2, -24 },
  { 155, 21, 22, 18, 0, -22 },
  { 213, 16, 22, 18, 2, -22 },
  { 257, 6, 10, 18, 10, -24 },
  { 265, 14, 31, 18, 5, -25 },
  { 320, 15, 31, 18, 1, -25 },
  { 379, 15, 14, 18, 4, -22 },
  { 406, 16, 16, 18, 2, -17 },
  { 438, 9, 11, 18, 3, -6 },
  { 451, 10, 4, 18, 5, -11 },
  { 456, 6, 6, 18, 6, -6 },
  { 461, 20, 30, 18, 0, -24 },
  { 536, 17, 22, 18, 2, -22 },
  { 583, 14, 22, 18, 2, -22 },
  { 622, 18, 22, 18, 1, -22 },
  { 672, 17, 22, 18, 1, -22 },
  { 719, 18, 22, 18, 1, -22 },
  { 769, 18, 22, 18, 1, -22 },
  { 819, 16, 22, 18, 3, -22 },
  { 863, 17, 22, 18, 4, -22 },
  { 910, 17, 22, 18, 2, -22 },
  { 957, 17, 22, 18, 2, -22 },
  { 1004, 8, 17, 18, 6, -17 },
  { 1021, 11, 22, 18, 3, -17 },
  { 1052, 16, 16, 18, 3, -16 },
  { 1084, 17, 11, 18, 2, -14 },
  { 1108, 16, 16, 18, 2, -16 },
  { 1140, 14, 22, 18, 5, -22 },
  { 1179, 18, 27, 18, 2, -22 },
  { 1240, 17, 22, 18, 0, -22 },
  { 1287, 18, 22, 18, 1, -22 },
  { 1337, 17, 22, 18, 3, -22 },
  { 1384, 18, 22, 18, 1, -22 },
  { 1434, 18, 22, 18, 2, -22 },
  { 1484, 18, 22, 18, 2, -22 },
  { 1534, 17, 22, 18, 3, -22 },
  { 1581, 20, 22, 18, 1, -22 },
  { 1636, 19, 22, 18, 1, -22 },
  { 1689, 19, 22, 18, 1, -22 },
  { 1742, 20, 22, 18, 1, -22 },
  { 1797, 14, 22, 18, 2, -22 },
  { 1836, 20, 22, 18, 0, -22 },
  { 1891, 19, 22, 18, 1, -22 },
  { 1944, 17, 22, 18, 2, -22 },
  { 1991, 18, 22, 18, 1, -22 },
  { 2041, 17, 28, 18, 2, -22 },
  { 2101, 18, 22, 18, 1, -22 },
  { 2151, 18, 22, 18, 1, -22 },
  { 2201, 16, 22, 18, 5, -22 },
  { 2245, 18, 22, 18, 2, -22 },
  { 2295, 17, 22, 18, 5, -22 },
  { 2342, 20, 22, 18, 1, -22 },
  { 2397, 21, 22, 18, 0, -22 },
  { 2455, 17, 22, 18, 5, -22 },
  { 2502, 19, 22, 18, 1, -22 },
  { 2555, 17, 30, 18, 3, -24 },
  { 2619, 7, 30, 18, 7, -24 },
  { 2646, 17, 30, 18, 1, -24 },
  { 2710, 16, 13, 18, 3, -22 },
  { 2736, 16, 4, 18, -1, 2 },
  { 2744, 8, 6, 18, 8, -24 },
  { 2750, 16, 16, 18, 2, -16 },
  { 2782, 17, 24, 18, 1, -24 },
  { 2833, 16, 16, 18, 3, -16 },
  { 2865, 18, 24, 18, 2, -24 },
  { 2919, 15, 16, 18, 3, -16 },
  { 2949, 22, 30, 18, -1, -24 },
  { 3032, 19, 22, 18, 0, -16 },
  { 3085, 15, 24, 18, 2, -24 },
  { 3130, 12, 24, 18, 4, -24 },
  { 3166, 17, 30, 18, 0, -24 },
  { 3230, 18, 24, 18, 2, -24 },
  { 3284, 11, 24, 18, 5, -24 },
  { 3317, 18, 16, 18, 1, -16 },
  { 3353, 15, 16, 18, 2, -16 },
  { 3383, 16, 16, 18, 2, -16 },
  { 3415, 18, 22, 18, 0, -16 },
  { 3465, 16, 22, 18, 3, -16 },
  { 3509, 17, 16, 18, 2, -16 },
  { 3543, 16, 16, 18, 2, -16 },
  { 3575, 15, 21, 18, 4, -21 },
  { 3615, 15, 16, 18, 3, -16 },
  { 3645, 15, 16, 18, 4, -16 },
  { 3675, 18, 16, 18, 2, -16 },
  { 3711, 19, 16, 18, 0, -16 },
  { 3749, 21, 22, 18, -2, -16 },
  { 3807, 17, 16, 18, 2, -16 },
  { 3841, 17, 30, 18, 3, -24 },
  { 3905, 12, 30, 18, 4, -24 },
  { 3950, 17, 30, 18, 0, -24 },
  { 4014, 17, 6, 18, 2, -12 },
};

const GFXfont UbuntuMono_BoldItalic35pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic35pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic35pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUMONO_BOLDITALIC35PT7B_H_
