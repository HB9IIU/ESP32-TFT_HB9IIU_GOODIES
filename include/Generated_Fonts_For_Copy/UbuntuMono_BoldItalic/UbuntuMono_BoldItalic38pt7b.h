#ifndef _UBUNTUMONO_BOLDITALIC38PT7B_H_
#define _UBUNTUMONO_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x3E, 0x7D,
  0xF1, 0xF7, 0xC7, 0xDF, 0x3E, 0x78, 0xF9, 0xE3, 0xE7, 0x8F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x71, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xE1, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xC1, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0x03,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x07, 0xE0,
  0x38, 0x1F, 0xC0, 0xE0, 0x7B, 0x83, 0x80, 0xE3, 0x0F, 0x01, 0xCE, 0x3C,
  0x03, 0x9C, 0xF0, 0x06, 0x39, 0xC0, 0x1E, 0xE7, 0x00, 0x1F, 0xDC, 0x00,
  0x3F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xFC, 0x00,
  0x3B, 0xFC, 0x00, 0xF7, 0x38, 0x03, 0xDE, 0x70, 0x0F, 0x38, 0xE0, 0x1C,
  0x71, 0xC0, 0x70, 0xE7, 0x01, 0xC1, 0xCE, 0x07, 0x83, 0xF8, 0x1E, 0x03,
  0xF0, 0x38, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x8E, 0x1F, 0xE3, 0xCF, 0xF8, 0xE7,
  0x9F, 0x79, 0xE3, 0xFE, 0xF0, 0x7F, 0x3C, 0x1F, 0x8F, 0x03, 0xE3, 0xE1,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFC, 0xF0, 0x7C, 0x3C, 0x7D, 0xF7,
  0xFE, 0xFB, 0xEF, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x04, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x40, 0x01,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x40, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x03, 0x1C, 0x27, 0x39, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF7, 0xC3, 0xC7, 0x83,
  0x8E, 0x02, 0x08, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C,
  0x1E, 0x1E, 0x7F, 0x3E, 0x1E, 0x00, 0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE,
  0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF1, 0xF8, 0xF9, 0xF0, 0x3C, 0xF8, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBC,
  0x63, 0xDE, 0x79, 0xFF, 0x7C, 0xFF, 0x1C, 0xFF, 0x80, 0x7F, 0xC0, 0x3D,
  0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F, 0x9F, 0x1F, 0x8F, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0xFE, 0x01, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x0E, 0x7C, 0x08,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x07, 0xC1, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x38,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x38, 0x1F,
  0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x3F, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0x03, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x7E, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF,
  0x81, 0xF3, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x1E, 0x07,
  0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x87, 0xC1, 0xF9, 0xF0, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x7E, 0x1F, 0x87, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x0F, 0xC7, 0x81, 0xF3, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x3C, 0xFC, 0x1F, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFF, 0x78, 0x1F, 0xBE, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x07,
  0x80, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x00, 0xF0, 0x1E, 0x0F, 0xE0, 0xF8, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x08, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x03, 0xF8,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFF, 0x30, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x1E,
  0x3E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0xFF, 0x3C, 0x7F, 0xEF, 0x1F, 0xFD,
  0xE3, 0xFF, 0xB8, 0xF9, 0xE7, 0x1E, 0x3D, 0xE7, 0x87, 0xBC, 0xF0, 0xF7,
  0x9E, 0x3C, 0xF3, 0xC7, 0x9E, 0x78, 0xF3, 0xCF, 0x1E, 0x79, 0xFF, 0x8F,
  0x1F, 0xF1, 0xE3, 0xFE, 0x1E, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0x78, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F,
  0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x0F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7C, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x07,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3C, 0x1F,
  0x87, 0x81, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3F,
  0x3E, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x18,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x06, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x7C, 0x0F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x0F, 0xC7, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x3F, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x18, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xCF, 0x80,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x01, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E,
  0x0F, 0x03, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x20, 0x1F, 0x03, 0x87, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0xFC,
  0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x1E,
  0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03,
  0xE1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x3B, 0x81, 0xDC, 0xFE, 0x0F, 0x77,
  0x78, 0x3D, 0xDD, 0xC0, 0xF7, 0xE7, 0x03, 0x9F, 0xBC, 0x1E, 0x7C, 0xF0,
  0x79, 0xF3, 0xC1, 0xE7, 0x8E, 0x07, 0x1E, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1,
  0xF0, 0x1E, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83,
  0xC1, 0xFE, 0x3C, 0x0F, 0x71, 0xE0, 0xFB, 0x8F, 0x07, 0x9C, 0x78, 0x3C,
  0xF7, 0xC1, 0xE3, 0xBC, 0x1F, 0x1D, 0xE0, 0xF0, 0xEF, 0x07, 0x87, 0xF8,
  0x3C, 0x3F, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x07, 0x81,
  0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xE3, 0xE0,
  0x79, 0xF0, 0x1F, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C,
  0x0F, 0x8F, 0x83, 0xE3, 0xE3, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1,
  0xF8, 0xF9, 0xF0, 0x3C, 0xF8, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xE0,
  0x3E, 0xF0, 0x1F, 0x78, 0x1F, 0x3E, 0x0F, 0x9F, 0x1F, 0x8F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x0F, 0x07, 0xC3,
  0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x3F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xF1, 0xE0, 0x3E,
  0x3E, 0x07, 0x87, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC0, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x20, 0x0F, 0x83, 0x81, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF8, 0xF8, 0x1E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x38, 0xF0, 0x79, 0xE3, 0xC1, 0xE7, 0x9E, 0x07, 0x3E, 0x78,
  0x3C, 0xF9, 0xE0, 0xF7, 0xE7, 0x83, 0xDD, 0x9C, 0x0E, 0xE6, 0xF0, 0x3B,
  0x9B, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0x80,
  0xF9, 0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xC0, 0xF1, 0xF0,
  0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF1, 0xE3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x9F, 0x3E,
  0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC7, 0x8F, 0x1E, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3E, 0x7C, 0x3E, 0x3E, 0x3F,
  0x1F, 0x1F, 0x07, 0xDF, 0x03, 0xFF, 0x01, 0xF3, 0x00, 0x78, 0x80, 0x20,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x20, 0x70, 0x7C,
  0xFE, 0x3F, 0x0F, 0x02, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0x8F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x1F,
  0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x1F, 0x1F, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xE3, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0xBE, 0x07, 0xDF,
  0x03, 0xEF, 0x83, 0xE7, 0x83, 0xF7, 0xC3, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xE3, 0xF8, 0x13, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x21, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0,
  0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x1E,
  0x07, 0xC7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8,
  0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0, 0xFB,
  0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x61, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x40, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xE1,
  0xE0, 0xF8, 0x1E, 0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xE0,
  0x3C, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x07,
  0x03, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xF1, 0xF1, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F,
  0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE3, 0xFE,
  0x1F, 0xF1, 0xFF, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x81, 0x83, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E,
  0x07, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xFF, 0xDF, 0xFB, 0xFE,
  0x7F, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF8, 0x5F, 0xFB, 0xFF, 0x3F, 0xE3, 0xF8, 0x07, 0xE7, 0xC1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0x1C,
  0x79, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x9E, 0x78, 0xE3, 0xCF, 0x3C, 0x01,
  0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F,
  0x1E, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1,
  0xF1, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3C, 0x78, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0x78,
  0x0F, 0xBC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xE7, 0x81, 0xF3, 0xE3, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xE1, 0xE0, 0xFC, 0x7C, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF3, 0xF0, 0xF3, 0xF0, 0x79, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1E, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xF0, 0x10, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x30, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x03, 0xE3, 0x81, 0xF1, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x08, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x07,
  0xF0, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0x83, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F,
  0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0x8C, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x83, 0xE7, 0xC1, 0xF1, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0xF8, 0x3C,
  0x7C, 0x1F, 0x7C, 0x0F, 0xBC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x1F,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xF3,
  0xC7, 0x9F, 0x3C, 0x73, 0xF3, 0x87, 0x3F, 0x78, 0x77, 0x77, 0x07, 0x77,
  0x70, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8,
  0x3C, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xDF, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x01, 0x8F, 0xF0, 0xF7, 0xFE, 0x3D, 0xFF, 0xFE, 0xF1,
  0xFF, 0x18, 0x3F, 0x80, 0x03, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 11, 24, 19, 6, -24 },
  { 34, 14, 11, 19, 7, -26 },
  { 54, 21, 24, 19, 1, -24 },
  { 117, 18, 31, 19, 2, -27 },
  { 187, 23, 24, 19, 0, -24 },
  { 256, 18, 24, 19, 2, -24 },
  { 310, 6, 11, 19, 11, -26 },
  { 319, 15, 33, 19, 5, -27 },
  { 381, 15, 33, 19, 2, -27 },
  { 443, 15, 15, 19, 5, -24 },
  { 472, 16, 18, 19, 3, -19 },
  { 508, 9, 12, 19, 4, -7 },
  { 522, 12, 5, 19, 5, -12 },
  { 530, 7, 7, 19, 6, -7 },
  { 537, 22, 33, 19, 0, -27 },
  { 628, 17, 24, 19, 3, -24 },
  { 679, 16, 24, 19, 2, -24 },
  { 727, 18, 24, 19, 2, -24 },
  { 781, 19, 24, 19, 1, -24 },
  { 838, 19, 24, 19, 2, -24 },
  { 895, 20, 24, 19, 1, -24 },
  { 955, 18, 24, 19, 3, -24 },
  { 1009, 19, 24, 19, 4, -24 },
  { 1066, 19, 24, 19, 2, -24 },
  { 1123, 18, 24, 19, 2, -24 },
  { 1177, 10, 19, 19, 6, -19 },
  { 1201, 12, 24, 19, 4, -19 },
  { 1237, 17, 17, 19, 3, -18 },
  { 1274, 18, 12, 19, 2, -16 },
  { 1301, 17, 17, 19, 2, -18 },
  { 1338, 14, 24, 19, 6, -24 },
  { 1380, 19, 29, 19, 2, -24 },
  { 1449, 18, 24, 19, 0, -24 },
  { 1503, 19, 24, 19, 1, -24 },
  { 1560, 19, 24, 19, 3, -24 },
  { 1617, 19, 24, 19, 1, -24 },
  { 1674, 20, 24, 19, 2, -24 },
  { 1734, 20, 24, 19, 2, -24 },
  { 1794, 19, 24, 19, 3, -24 },
  { 1851, 21, 24, 19, 1, -24 },
  { 1914, 21, 24, 19, 1, -24 },
  { 1977, 20, 24, 19, 1, -24 },
  { 2037, 22, 24, 19, 1, -24 },
  { 2103, 15, 24, 19, 2, -24 },
  { 2148, 22, 24, 19, 0, -24 },
  { 2214, 21, 24, 19, 1, -24 },
  { 2277, 18, 24, 19, 3, -24 },
  { 2331, 20, 24, 19, 1, -24 },
  { 2391, 17, 31, 19, 3, -24 },
  { 2457, 19, 24, 19, 1, -24 },
  { 2514, 20, 24, 19, 1, -24 },
  { 2574, 18, 24, 19, 5, -24 },
  { 2628, 19, 24, 19, 3, -24 },
  { 2685, 18, 24, 19, 5, -24 },
  { 2739, 22, 24, 19, 1, -24 },
  { 2805, 23, 24, 19, 0, -24 },
  { 2874, 18, 24, 19, 5, -24 },
  { 2928, 21, 24, 19, 1, -24 },
  { 2991, 19, 33, 19, 3, -27 },
  { 3070, 7, 33, 19, 8, -27 },
  { 3099, 18, 33, 19, 1, -27 },
  { 3174, 17, 14, 19, 3, -24 },
  { 3204, 18, 4, 19, -1, 2 },
  { 3213, 8, 7, 19, 9, -26 },
  { 3220, 18, 18, 19, 2, -18 },
  { 3261, 17, 26, 19, 2, -26 },
  { 3317, 17, 18, 19, 3, -18 },
  { 3356, 20, 26, 19, 2, -26 },
  { 3421, 17, 18, 19, 3, -18 },
  { 3460, 23, 32, 19, -1, -26 },
  { 3552, 20, 24, 19, 0, -18 },
  { 3612, 17, 26, 19, 2, -26 },
  { 3668, 13, 26, 19, 4, -26 },
  { 3711, 18, 32, 19, 0, -26 },
  { 3783, 20, 26, 19, 2, -26 },
  { 3848, 11, 26, 19, 6, -26 },
  { 3884, 19, 18, 19, 1, -18 },
  { 3927, 17, 18, 19, 2, -18 },
  { 3966, 17, 18, 19, 2, -18 },
  { 4005, 19, 24, 19, 0, -18 },
  { 4062, 17, 24, 19, 3, -18 },
  { 4113, 17, 18, 19, 3, -18 },
  { 4152, 17, 18, 19, 2, -18 },
  { 4191, 16, 23, 19, 4, -23 },
  { 4237, 17, 18, 19, 3, -18 },
  { 4276, 17, 18, 19, 4, -18 },
  { 4315, 20, 18, 19, 2, -18 },
  { 4360, 21, 18, 19, 0, -18 },
  { 4408, 23, 24, 19, -2, -18 },
  { 4477, 18, 18, 19, 2, -18 },
  { 4518, 18, 33, 19, 4, -27 },
  { 4593, 12, 33, 19, 5, -27 },
  { 4643, 18, 33, 19, 0, -27 },
  { 4718, 18, 7, 19, 2, -14 },
};

const GFXfont UbuntuMono_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic38pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUMONO_BOLDITALIC38PT7B_H_
