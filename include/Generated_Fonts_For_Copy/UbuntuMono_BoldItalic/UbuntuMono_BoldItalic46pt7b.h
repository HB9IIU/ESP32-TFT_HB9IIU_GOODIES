#ifndef _UBUNTUMONO_BOLDITALIC46PT7B_H_
#define _UBUNTUMONO_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x3F, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xE7, 0xE1, 0xF3, 0xF1, 0xF9,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80,
  0x0F, 0x87, 0x80, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xF8, 0x78, 0x00, 0x78, 0x7C,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x70, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x20, 0x03, 0xF0, 0x78, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x03, 0xFE, 0x01, 0xE0,
  0x3F, 0xE0, 0x3C, 0x07, 0x9E, 0x07, 0x80, 0x78, 0xE0, 0xF0, 0x07, 0x1E,
  0x1E, 0x00, 0xF1, 0xE3, 0xE0, 0x0F, 0x1C, 0x3C, 0x00, 0xF3, 0xC7, 0x80,
  0x0F, 0xFC, 0xF0, 0x00, 0x7F, 0x9E, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xCF, 0xE0, 0x00, 0x79, 0xFF, 0x00, 0x0F, 0x1F, 0xF0, 0x01,
  0xF3, 0xCF, 0x00, 0x1E, 0x3C, 0x70, 0x03, 0xC3, 0x8F, 0x00, 0x78, 0x78,
  0xF0, 0x0F, 0x07, 0x8E, 0x01, 0xE0, 0x79, 0xE0, 0x3C, 0x07, 0xFE, 0x07,
  0xC0, 0x3F, 0xC0, 0x78, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xC7, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC3, 0xC1, 0xFE, 0x1F, 0x1F, 0xFC, 0x7C, 0xFD, 0xF1, 0xE3,
  0xE7, 0xEF, 0x9F, 0x0F, 0xFC, 0x78, 0x1F, 0xF3, 0xE0, 0x7F, 0x8F, 0x80,
  0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7C, 0x3F, 0xF1, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x30, 0xF0, 0x47,
  0x9E, 0x39, 0xFB, 0xDF, 0xBF, 0xBF, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xC7, 0xC0, 0x70, 0xE0, 0x04, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x1F, 0x8F, 0xF0, 0x7E, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFB, 0xFF,
  0xE0, 0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xF9, 0xF8, 0x78, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0x8E, 0x3F, 0x7E, 0x7C, 0xF9, 0xF1, 0xF3, 0xE7, 0xCF, 0x8F, 0x9F,
  0x1C, 0x3E, 0x7C, 0x01, 0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x7E, 0x0F,
  0x9F, 0x03, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0x83,
  0xF0, 0x38, 0x07, 0xC0, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1C, 0x1F, 0xC0, 0x20, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x10, 0x01,
  0xFC, 0x38, 0x0F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x3F, 0x01, 0xE0, 0x7E, 0x07,
  0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x70, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x07, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x0F,
  0x80, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xF8,
  0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0,
  0x1F, 0x9F, 0xC0, 0xF8, 0x3F, 0x87, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0xFE, 0x1F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F,
  0x3F, 0x00, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xE7, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x81, 0xFE, 0x01, 0xF8, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xE0, 0xFC, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x07,
  0xC1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0x78, 0x0F, 0xF8, 0xF0, 0x7F, 0xF3, 0xE1, 0xFF, 0xE7, 0x87, 0xFF, 0xCF,
  0x1F, 0x8F, 0xBE, 0x3E, 0x1E, 0x78, 0xF8, 0x7C, 0xF1, 0xF0, 0xF9, 0xE3,
  0xC1, 0xF3, 0xC7, 0x83, 0xC7, 0x8F, 0x0F, 0x8F, 0x1E, 0x1F, 0x1E, 0x3C,
  0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xFF, 0xF0, 0xF0, 0xFF, 0xE1, 0xE0, 0xFF,
  0xC3, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x81,
  0xF8, 0x3E, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0xFE, 0x3E, 0x07, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xC0,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x20, 0x7F, 0x03, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7E, 0x1F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0,
  0xFE, 0x1F, 0x03, 0xF8, 0x3E, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xC0, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x30, 0x0F, 0xC0, 0x78, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xC0, 0xFE, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0x7F, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x7F, 0x80, 0xFF, 0x0E, 0xF0, 0x1E, 0xE3, 0xFC, 0x03, 0xDC, 0x77, 0x80,
  0x7B, 0x9E, 0xF0, 0x1F, 0x73, 0xBE, 0x03, 0xCE, 0xF7, 0xC0, 0x79, 0xDC,
  0xF0, 0x1F, 0x3F, 0x9E, 0x03, 0xE7, 0xE7, 0xC0, 0x78, 0xFC, 0xF8, 0x1F,
  0x1F, 0x1F, 0x03, 0xE3, 0xE3, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F,
  0x80, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0xFF, 0x03, 0xE0,
  0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0x87,
  0xC0, 0xF9, 0xE3, 0xE0, 0x3E, 0x78, 0xF8, 0x0F, 0x9E, 0x3E, 0x03, 0xE7,
  0xCF, 0x81, 0xF8, 0xF7, 0xC0, 0x7C, 0x3D, 0xF0, 0x1F, 0x0F, 0x7C, 0x07,
  0xC3, 0xDF, 0x03, 0xF0, 0x7F, 0x80, 0xF8, 0x1F, 0xE0, 0x3E, 0x07, 0xF8,
  0x0F, 0x81, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0xFE, 0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F,
  0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xE1, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFC,
  0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1C, 0x03, 0xE0,
  0x04, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x10, 0x03, 0xF0, 0x3C, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x3F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xF1, 0xE3, 0xE0, 0x78,
  0xF8, 0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x9F, 0x8F, 0x03, 0xE7, 0xE7, 0xC0,
  0xF3, 0xF9, 0xF0, 0x3C, 0xEE, 0x78, 0x1F, 0x7B, 0x9E, 0x07, 0xFC, 0xE7,
  0x81, 0xEF, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE1,
  0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F,
  0x80, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE0,
  0xF8, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xF9, 0xE0, 0x07, 0xE7,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x20, 0x0E, 0x07, 0xC3, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFC, 0x1E, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xE0, 0xF8, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xDF, 0x81, 0xF8, 0x60, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xF8, 0x7F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x3E, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFC, 0x1F, 0xC7,
  0xC1, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFE, 0x06, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x01, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xC1, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF7, 0xE0, 0x0F, 0xC3, 0x80, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x1F, 0x3E, 0x01, 0xFB, 0xF0, 0x1F,
  0x9F, 0x03, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x60,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x10, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0xC3, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0E, 0x07, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7C,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC1, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x02, 0x03, 0xF0, 0x1C,
  0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x07, 0xC3,
  0xF8, 0x07, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0x7F, 0xFD, 0xFF, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xE0, 0x01, 0xF8, 0x78, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF3, 0xE7, 0xC3, 0xC7,
  0xC7, 0x8F, 0x8F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x78, 0x78, 0xF8,
  0xF1, 0xF1, 0xE3, 0xE3, 0xE3, 0xC7, 0xC7, 0xC7, 0x8F, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE1,
  0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC,
  0x7F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7E, 0x1F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F,
  0x07, 0xF0, 0x7E, 0x3F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xE1, 0xF8, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x00, 0x40, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xF0, 0x30, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE1, 0x00, 0x3F, 0x0E, 0x03, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x18, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0x3F, 0x1C, 0x00, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01,
  0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xFC, 0x78, 0x78, 0xFC, 0xF8,
  0x79, 0xFC, 0xF0, 0xF9, 0xFC, 0xF0, 0xFB, 0xFC, 0xF0, 0xF3, 0xFD, 0xE0,
  0xF7, 0x9D, 0xE0, 0xF7, 0x9D, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x04, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x30, 0x3F, 0xC0, 0xF1, 0xFF,
  0xC7, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF1, 0xFF, 0xCF, 0x81, 0xFE,
  0x0C, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 12, 29, 23, 8, -28 },
  { 45, 17, 13, 23, 9, -31 },
  { 73, 25, 28, 23, 1, -28 },
  { 161, 23, 36, 23, 2, -32 },
  { 265, 28, 30, 23, 0, -29 },
  { 370, 22, 30, 23, 2, -29 },
  { 453, 8, 14, 23, 13, -31 },
  { 467, 19, 42, 23, 6, -33 },
  { 567, 18, 42, 23, 2, -33 },
  { 662, 19, 17, 23, 6, -28 },
  { 703, 21, 21, 23, 3, -22 },
  { 759, 12, 15, 23, 4, -7 },
  { 782, 14, 6, 23, 6, -15 },
  { 793, 9, 8, 23, 7, -7 },
  { 802, 28, 40, 23, -1, -32 },
  { 942, 22, 30, 23, 3, -29 },
  { 1025, 18, 28, 23, 3, -28 },
  { 1088, 22, 29, 23, 2, -29 },
  { 1168, 23, 30, 23, 1, -29 },
  { 1255, 23, 28, 23, 2, -28 },
  { 1336, 25, 29, 23, 1, -28 },
  { 1427, 23, 29, 23, 3, -28 },
  { 1511, 22, 28, 23, 5, -28 },
  { 1588, 22, 30, 23, 3, -29 },
  { 1671, 22, 29, 23, 3, -29 },
  { 1751, 12, 22, 23, 7, -21 },
  { 1784, 15, 29, 23, 4, -21 },
  { 1839, 21, 20, 23, 4, -22 },
  { 1892, 23, 14, 23, 2, -19 },
  { 1933, 21, 20, 23, 2, -22 },
  { 1986, 17, 30, 23, 7, -29 },
  { 2050, 23, 35, 23, 3, -29 },
  { 2151, 22, 28, 23, 0, -28 },
  { 2228, 23, 29, 23, 2, -28 },
  { 2312, 22, 30, 23, 4, -29 },
  { 2395, 23, 30, 23, 1, -29 },
  { 2482, 24, 28, 23, 2, -28 },
  { 2566, 24, 28, 23, 3, -28 },
  { 2650, 22, 30, 23, 4, -29 },
  { 2733, 26, 28, 23, 1, -28 },
  { 2824, 25, 28, 23, 2, -28 },
  { 2912, 24, 29, 23, 2, -28 },
  { 2999, 27, 28, 23, 1, -28 },
  { 3094, 19, 28, 23, 2, -28 },
  { 3161, 27, 28, 23, 0, -28 },
  { 3256, 26, 28, 23, 1, -28 },
  { 3347, 22, 30, 23, 3, -29 },
  { 3430, 24, 28, 23, 2, -28 },
  { 3514, 22, 38, 23, 3, -29 },
  { 3619, 23, 28, 23, 2, -28 },
  { 3700, 24, 30, 23, 1, -29 },
  { 3790, 22, 28, 23, 6, -28 },
  { 3867, 24, 29, 23, 3, -28 },
  { 3954, 22, 28, 23, 6, -28 },
  { 4031, 26, 28, 23, 2, -28 },
  { 4122, 28, 28, 23, 0, -28 },
  { 4220, 21, 28, 23, 7, -28 },
  { 4294, 25, 28, 23, 1, -28 },
  { 4382, 22, 40, 23, 4, -32 },
  { 4492, 10, 40, 23, 9, -32 },
  { 4542, 22, 40, 23, 1, -32 },
  { 4652, 21, 17, 23, 4, -28 },
  { 4697, 22, 5, 23, -2, 3 },
  { 4711, 10, 9, 23, 11, -32 },
  { 4723, 21, 24, 23, 3, -23 },
  { 4786, 21, 34, 23, 2, -33 },
  { 4876, 20, 24, 23, 4, -23 },
  { 4936, 24, 34, 23, 3, -33 },
  { 5038, 21, 24, 23, 3, -23 },
  { 5101, 29, 42, 23, -2, -33 },
  { 5254, 25, 32, 23, 0, -23 },
  { 5354, 21, 33, 23, 2, -33 },
  { 5441, 16, 33, 23, 5, -32 },
  { 5507, 22, 41, 23, 0, -32 },
  { 5620, 24, 33, 23, 2, -33 },
  { 5719, 14, 33, 23, 7, -32 },
  { 5777, 23, 22, 23, 1, -22 },
  { 5841, 21, 23, 23, 2, -23 },
  { 5902, 20, 24, 23, 3, -23 },
  { 5962, 23, 31, 23, 0, -23 },
  { 6052, 22, 31, 23, 3, -23 },
  { 6138, 22, 23, 23, 3, -23 },
  { 6202, 21, 24, 23, 2, -23 },
  { 6265, 19, 29, 23, 5, -28 },
  { 6334, 21, 23, 23, 3, -22 },
  { 6395, 21, 22, 23, 5, -22 },
  { 6453, 24, 22, 23, 3, -22 },
  { 6519, 25, 22, 23, 0, -22 },
  { 6588, 27, 31, 23, -2, -22 },
  { 6693, 22, 22, 23, 2, -22 },
  { 6754, 22, 40, 23, 5, -32 },
  { 6864, 15, 40, 23, 6, -32 },
  { 6939, 22, 40, 23, 0, -32 },
  { 7049, 22, 8, 23, 2, -16 },
};

const GFXfont UbuntuMono_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic46pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUMONO_BOLDITALIC46PT7B_H_
