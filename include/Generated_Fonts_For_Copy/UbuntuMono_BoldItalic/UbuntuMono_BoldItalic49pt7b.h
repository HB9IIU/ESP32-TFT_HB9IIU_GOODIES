#ifndef _UBUNTUMONO_BOLDITALIC49PT7B_H_
#define _UBUNTUMONO_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF1, 0xFD, 0xFC, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9,
  0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF8,
  0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0x1E, 0x07, 0xE0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x30, 0x01, 0xF8, 0x3C, 0x07, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x1F,
  0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x03, 0xCF, 0x01, 0xE0, 0x1E, 0x3C,
  0x0F, 0x00, 0x78, 0xF0, 0x78, 0x01, 0xE3, 0xC3, 0xC0, 0x07, 0x0F, 0x1F,
  0x00, 0x1C, 0x78, 0xF8, 0x00, 0x71, 0xE3, 0xC0, 0x01, 0xFF, 0x1E, 0x00,
  0x07, 0xFC, 0xF0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE7, 0xF8, 0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x78, 0xFF, 0x80, 0x03, 0xE7,
  0xCF, 0x00, 0x1F, 0x1E, 0x3C, 0x00, 0x78, 0x70, 0xF0, 0x03, 0xC3, 0xC3,
  0x80, 0x1E, 0x0F, 0x1E, 0x00, 0xF0, 0x3C, 0x78, 0x07, 0xC0, 0xF3, 0xC0,
  0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0,
  0x03, 0xE3, 0xE0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0x07, 0xFC, 0x1E, 0x0F, 0xFE, 0x3E, 0x1F, 0xFE, 0x3E,
  0x3E, 0x3F, 0x7C, 0x7E, 0x1F, 0xFC, 0x7C, 0x1F, 0xF8, 0xFC, 0x0F, 0xF8,
  0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xF8, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x20, 0xF8, 0x67, 0x8F, 0x1E, 0x7E, 0xF3, 0xE7, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x3F, 0x9F, 0xC1,
  0xF0, 0xF8, 0x07, 0x0F, 0x00, 0x20, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFE, 0x07,
  0xE0, 0x3C, 0x07, 0xC1, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0E, 0x00, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x00, 0x1E,
  0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF1, 0xC3, 0xE7, 0xC7, 0xCF, 0xDF,
  0x9F, 0x9F, 0xBF, 0x3E, 0x3F, 0x7E, 0x38, 0x7E, 0xF8, 0x00, 0xF9, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xEF, 0xC0, 0x79, 0xF8, 0x06, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x7F,
  0x03, 0x80, 0x3F, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0x83, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x10, 0x00, 0xFE,
  0x0F, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3C,
  0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0x07, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x07,
  0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x3F, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87,
  0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF,
  0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x04,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xCE, 0x0F, 0xF2, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xF8, 0x3F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x0F, 0x1F, 0x80, 0x1F,
  0x1F, 0x03, 0xFF, 0x3E, 0x0F, 0xFF, 0x3E, 0x1F, 0xFF, 0x7C, 0x3F, 0xFF,
  0x7C, 0x7F, 0xFF, 0x7C, 0x7E, 0x3E, 0x78, 0xFC, 0x3E, 0xF8, 0xF8, 0x3E,
  0xF8, 0xF8, 0x7E, 0xF8, 0xF8, 0x7C, 0xF1, 0xF0, 0x7C, 0xF1, 0xF0, 0x7C,
  0xF1, 0xF0, 0xFC, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF8, 0xF8,
  0xF0, 0xFF, 0xF8, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xF0, 0xF8, 0x3F, 0xF0,
  0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x7F,
  0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x7E, 0x0F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x81, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x07, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x1C, 0x07, 0xF0, 0x04,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x7E, 0x0F, 0xF0, 0x7E, 0x1F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x04,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x30, 0x0F, 0xE0, 0x3E, 0x0F, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xDE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE3, 0xBE, 0x03, 0xCE, 0x7B, 0xE0, 0x7C, 0xE7, 0x3C, 0x07, 0xCE, 0xF7,
  0xC0, 0x7C, 0xFE, 0x7C, 0x07, 0x8F, 0xE7, 0xC0, 0xF8, 0xFC, 0x7C, 0x0F,
  0x8F, 0xCF, 0x80, 0xF8, 0xF8, 0xF8, 0x1F, 0x8F, 0x8F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F,
  0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7C, 0x03, 0xFE, 0x07,
  0xC0, 0x3F, 0xE0, 0x7C, 0x07, 0xFE, 0x0F, 0xC0, 0x7F, 0xE0, 0xF8, 0x07,
  0xDF, 0x0F, 0x80, 0x7C, 0xF0, 0xF8, 0x0F, 0xCF, 0x1F, 0x80, 0xFC, 0xF1,
  0xF0, 0x0F, 0x8F, 0x9F, 0x00, 0xF8, 0x79, 0xF0, 0x0F, 0x87, 0xBF, 0x01,
  0xF8, 0x7B, 0xE0, 0x1F, 0x07, 0xFE, 0x01, 0xF0, 0x7F, 0xE0, 0x1F, 0x03,
  0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0,
  0x3E, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xFC,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8,
  0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x10, 0x01,
  0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF1, 0xF0, 0xF8,
  0x1F, 0x1F, 0x1F, 0x01, 0xF3, 0xF1, 0xF0, 0x1E, 0x3F, 0x1F, 0x03, 0xE7,
  0xF1, 0xF0, 0x3E, 0x7F, 0x3E, 0x03, 0xEF, 0x73, 0xE0, 0x3C, 0xF7, 0xBE,
  0x03, 0xDE, 0x7B, 0xC0, 0x7D, 0xC7, 0xBC, 0x07, 0xFC, 0x7F, 0xC0, 0x7B,
  0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x7C, 0x3F,
  0x00, 0xF8, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0xFC, 0x07, 0xF3, 0xF0, 0x3F,
  0x8F, 0xC1, 0xFC, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x18, 0x00, 0xF0, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x20, 0x0E, 0x07, 0xC3, 0xF8, 0xFF, 0x9F, 0xF1, 0xFC,
  0x1E, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8,
  0x07, 0xE1, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0xC0, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xC0, 0x43, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x30, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE1, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xBF, 0x00, 0x1F, 0x87, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x0F,
  0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0xBF,
  0x7F, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x70,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xC1, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x07,
  0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xE0, 0x3F, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFD, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE3,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x04, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x20, 0x1F, 0x80,
  0x78, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x3E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E,
  0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x0F, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7,
  0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xE1, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xF1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x7E,
  0x1F, 0xC7, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7F, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0x87, 0xE3, 0xF8, 0x1F, 0x9F, 0xC0, 0x7E, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x01, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFE, 0x07, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x80, 0x0F, 0xC1, 0xE0, 0x3F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x0C, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87,
  0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE3, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x7E, 0x07,
  0xF0, 0xC0, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x00, 0xF9, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE1, 0xF0,
  0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7E, 0x3C, 0x3C, 0x7F,
  0x1E, 0x1E, 0x3F, 0x9F, 0x0F, 0x3F, 0xCF, 0x07, 0x9F, 0xE7, 0x87, 0xDE,
  0xF7, 0xC3, 0xEF, 0x7B, 0xC1, 0xFF, 0x3D, 0xE0, 0xF7, 0x8F, 0xF0, 0x7F,
  0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0,
  0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x7F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x0C, 0x0F, 0xF8, 0x1F, 0x1F, 0xFE, 0x3E, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7C, 0x3F, 0xF8, 0x78, 0x1F, 0xF0,
  0x18, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 14, 31, 25, 8, -30 },
  { 56, 18, 14, 25, 9, -33 },
  { 88, 26, 30, 25, 2, -30 },
  { 186, 24, 39, 25, 2, -34 },
  { 303, 30, 32, 25, 0, -31 },
  { 423, 24, 32, 25, 2, -31 },
  { 519, 8, 15, 25, 14, -33 },
  { 534, 19, 44, 25, 7, -35 },
  { 639, 20, 44, 25, 2, -35 },
  { 749, 20, 20, 25, 6, -30 },
  { 799, 22, 23, 25, 3, -24 },
  { 863, 12, 16, 25, 5, -8 },
  { 887, 15, 6, 25, 7, -16 },
  { 899, 9, 9, 25, 8, -8 },
  { 910, 29, 42, 25, -1, -34 },
  { 1063, 23, 32, 25, 3, -31 },
  { 1155, 20, 30, 25, 3, -30 },
  { 1230, 24, 31, 25, 2, -31 },
  { 1323, 25, 32, 25, 1, -31 },
  { 1423, 25, 30, 25, 2, -30 },
  { 1517, 25, 31, 25, 2, -30 },
  { 1614, 23, 31, 25, 4, -30 },
  { 1704, 23, 30, 25, 6, -30 },
  { 1791, 23, 32, 25, 3, -31 },
  { 1883, 23, 31, 25, 3, -31 },
  { 1973, 12, 24, 25, 8, -23 },
  { 2009, 15, 31, 25, 5, -23 },
  { 2068, 22, 21, 25, 4, -23 },
  { 2126, 24, 15, 25, 2, -20 },
  { 2171, 22, 21, 25, 3, -23 },
  { 2229, 18, 32, 25, 8, -31 },
  { 2301, 24, 38, 25, 3, -31 },
  { 2415, 23, 30, 25, 0, -30 },
  { 2502, 24, 31, 25, 2, -30 },
  { 2595, 24, 32, 25, 4, -31 },
  { 2691, 24, 32, 25, 2, -31 },
  { 2787, 25, 30, 25, 3, -30 },
  { 2881, 26, 30, 25, 3, -30 },
  { 2979, 24, 32, 25, 4, -31 },
  { 3075, 28, 30, 25, 1, -30 },
  { 3180, 26, 30, 25, 2, -30 },
  { 3278, 25, 31, 25, 2, -30 },
  { 3375, 28, 30, 25, 2, -30 },
  { 3480, 20, 30, 25, 2, -30 },
  { 3555, 28, 30, 25, 0, -30 },
  { 3660, 28, 30, 25, 1, -30 },
  { 3765, 23, 32, 25, 3, -31 },
  { 3857, 25, 30, 25, 2, -30 },
  { 3951, 23, 40, 25, 3, -31 },
  { 4066, 24, 30, 25, 2, -30 },
  { 4156, 25, 32, 25, 2, -31 },
  { 4256, 24, 30, 25, 6, -30 },
  { 4346, 25, 31, 25, 3, -30 },
  { 4443, 23, 30, 25, 7, -30 },
  { 4530, 28, 30, 25, 2, -30 },
  { 4635, 30, 30, 25, 0, -30 },
  { 4748, 23, 30, 25, 7, -30 },
  { 4835, 27, 30, 25, 1, -30 },
  { 4937, 24, 42, 25, 4, -34 },
  { 5063, 10, 42, 25, 10, -34 },
  { 5116, 24, 42, 25, 1, -34 },
  { 5242, 22, 18, 25, 4, -30 },
  { 5292, 24, 5, 25, -2, 3 },
  { 5307, 10, 9, 25, 12, -34 },
  { 5319, 23, 25, 25, 3, -24 },
  { 5391, 23, 36, 25, 2, -35 },
  { 5495, 22, 25, 25, 4, -24 },
  { 5564, 26, 36, 25, 3, -35 },
  { 5681, 22, 25, 25, 4, -24 },
  { 5750, 31, 44, 25, -2, -35 },
  { 5921, 26, 33, 25, 0, -24 },
  { 6029, 22, 35, 25, 2, -35 },
  { 6126, 17, 35, 25, 5, -34 },
  { 6201, 24, 43, 25, 0, -34 },
  { 6330, 25, 35, 25, 3, -35 },
  { 6440, 15, 35, 25, 7, -34 },
  { 6506, 25, 23, 25, 1, -23 },
  { 6578, 22, 24, 25, 2, -24 },
  { 6644, 22, 25, 25, 3, -24 },
  { 6713, 25, 32, 25, 0, -24 },
  { 6813, 22, 32, 25, 4, -24 },
  { 6901, 23, 24, 25, 3, -24 },
  { 6970, 23, 25, 25, 2, -24 },
  { 7042, 21, 31, 25, 5, -30 },
  { 7124, 22, 24, 25, 4, -23 },
  { 7190, 22, 23, 25, 5, -23 },
  { 7254, 25, 23, 25, 3, -23 },
  { 7326, 27, 23, 25, 0, -23 },
  { 7404, 29, 32, 25, -2, -23 },
  { 7520, 24, 23, 25, 2, -23 },
  { 7589, 23, 42, 25, 5, -34 },
  { 7710, 16, 42, 25, 6, -34 },
  { 7794, 24, 42, 25, 0, -34 },
  { 7920, 24, 9, 25, 2, -17 },
};

const GFXfont UbuntuMono_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic49pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUMONO_BOLDITALIC49PT7B_H_
