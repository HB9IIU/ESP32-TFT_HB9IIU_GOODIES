#ifndef _UBUNTUMONO_BOLDITALIC72PT7B_H_
#define _UBUNTUMONO_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xCF,
  0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF,
  0x9F, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0x80, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x80, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x07, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x00,
  0x1F, 0x83, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x07,
  0xE1, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x3F, 0x80, 0x00, 0x1F, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xC0,
  0x00, 0x01, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xF1, 0xF0, 0xFC,
  0x00, 0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0xC0,
  0x7C, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x82, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x03, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0x07, 0xFD, 0xFE, 0x1F, 0xE1, 0xFF, 0x3F, 0xE3, 0xF8,
  0x7F, 0x83, 0xFE, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0x07, 0xFF,
  0xF8, 0x7F, 0x80, 0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x83, 0xFC, 0x00,
  0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF7,
  0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x7F,
  0x00, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x8F, 0xCF,
  0xF1, 0xFF, 0xBE, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x10, 0x04, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x0F, 0x83, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F,
  0xE3, 0xFE, 0x0F, 0x07, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7F, 0x9F, 0xF1, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x1F,
  0xC3, 0xFE, 0x7F, 0x83, 0xC0, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0x7F, 0xC0, 0x3F, 0xCF, 0xF8, 0x03, 0xF0, 0xFF, 0x80, 0x1C, 0x0F, 0xF8,
  0x01, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0x00,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0x00, 0x00, 0x7F, 0xE0, 0x1C, 0x00, 0x0F, 0xFE, 0x03,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7E, 0x07, 0xFF,
  0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF7, 0xF0, 0xFE, 0x01, 0xFF, 0xFF,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0x80, 0xFF,
  0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0xE3, 0xF0,
  0x3F, 0xE1, 0xFE, 0x7F, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x81, 0xFC,
  0x7F, 0x0F, 0xF0, 0x3F, 0xC7, 0xE0, 0xFE, 0x03, 0xFC, 0x7E, 0x0F, 0xE0,
  0x3F, 0x8F, 0xE1, 0xFE, 0x03, 0xF8, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xE1,
  0xFC, 0x07, 0xF8, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF,
  0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x20, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x30, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFC,
  0x03, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x20,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x03, 0xEF, 0xC0, 0x07,
  0xEF, 0x83, 0xFF, 0xE0, 0x07, 0xF7, 0xC1, 0xF7, 0xF0, 0x03, 0xFB, 0xE1,
  0xFB, 0xF0, 0x01, 0xFD, 0xF0, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0xFD, 0xFC,
  0x00, 0xFE, 0x7C, 0x7C, 0xFE, 0x00, 0x7F, 0x3E, 0x7E, 0x7F, 0x00, 0x3F,
  0x9F, 0x3E, 0x3F, 0x80, 0x3F, 0x8F, 0xBF, 0x3F, 0x80, 0x1F, 0xC7, 0xDF,
  0x1F, 0xC0, 0x0F, 0xE3, 0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xFF, 0x87, 0xF0,
  0x07, 0xF0, 0xFF, 0xC7, 0xF8, 0x03, 0xF8, 0x3F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7E, 0x0F, 0xF0, 0x03,
  0xFC, 0x7E, 0x0F, 0xF0, 0x03, 0xFC, 0x7E, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x9F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xBF, 0xC0, 0x0F, 0xF0, 0x1F, 0xBF, 0xC0, 0x0F, 0xF0, 0x1F, 0xBF,
  0xC0, 0x0F, 0xF0, 0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x02, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x3F, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0xFE, 0x00,
  0x7F, 0x1F, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xFC, 0x3F, 0x80, 0x3F, 0x8F,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xFF, 0x1F, 0xC0, 0x0F, 0xE7, 0xEF, 0x8F,
  0xE0, 0x07, 0xF3, 0xF7, 0xC7, 0xF0, 0x03, 0xF3, 0xF3, 0xE7, 0xF0, 0x03,
  0xF9, 0xF1, 0xF3, 0xF8, 0x01, 0xFD, 0xF8, 0xF9, 0xFC, 0x00, 0xFE, 0xF8,
  0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFE,
  0x3E, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x08,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xE1,
  0xFE, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x9F, 0xC0, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x38, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xFC,
  0x7F, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x04, 0x03, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x06, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0x03, 0xFF, 0x00, 0x0F,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xF8, 0xFF, 0x03, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x30,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x1F, 0xF0, 0x3F,
  0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x80, 0x7F, 0xF0, 0x1E, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xF8,
  0x07, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x3F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x83,
  0xF0, 0x3F, 0x87, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xFF, 0x0F, 0xC0, 0xFE, 0x3F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xC7, 0xF0,
  0x3F, 0x9F, 0xBE, 0x3F, 0x01, 0xFC, 0xFD, 0xF1, 0xF8, 0x0F, 0xCF, 0xCF,
  0x9F, 0xC0, 0x7E, 0x7E, 0x7E, 0xFC, 0x03, 0xF7, 0xE3, 0xF7, 0xE0, 0x1F,
  0xBF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0xFC,
  0x01, 0xFC, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0x0F, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x81,
  0xF0, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0x1F, 0x80, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 20, 46, 36, 12, -45 },
  { 116, 26, 20, 36, 14, -49 },
  { 181, 39, 45, 36, 2, -45 },
  { 401, 36, 57, 36, 3, -50 },
  { 658, 44, 47, 36, 0, -46 },
  { 917, 35, 47, 36, 3, -46 },
  { 1123, 13, 22, 36, 20, -49 },
  { 1159, 29, 64, 36, 10, -51 },
  { 1391, 29, 64, 36, 3, -51 },
  { 1623, 30, 28, 36, 9, -45 },
  { 1728, 32, 33, 36, 5, -35 },
  { 1860, 17, 23, 36, 7, -12 },
  { 1909, 22, 9, 36, 10, -23 },
  { 1934, 12, 13, 36, 12, -12 },
  { 1954, 43, 62, 36, -1, -50 },
  { 2288, 34, 47, 36, 5, -46 },
  { 2488, 28, 45, 36, 5, -45 },
  { 2646, 35, 46, 36, 3, -46 },
  { 2848, 36, 47, 36, 2, -46 },
  { 3060, 36, 45, 36, 3, -45 },
  { 3263, 38, 46, 36, 2, -45 },
  { 3482, 35, 46, 36, 5, -45 },
  { 3684, 35, 45, 36, 8, -45 },
  { 3881, 35, 47, 36, 4, -46 },
  { 4087, 35, 46, 36, 4, -46 },
  { 4289, 18, 35, 36, 12, -34 },
  { 4368, 23, 45, 36, 7, -34 },
  { 4498, 32, 31, 36, 6, -34 },
  { 4622, 36, 21, 36, 3, -30 },
  { 4717, 33, 31, 36, 4, -34 },
  { 4845, 27, 47, 36, 11, -46 },
  { 5004, 36, 56, 36, 4, -46 },
  { 5256, 34, 45, 36, 0, -45 },
  { 5448, 36, 46, 36, 3, -45 },
  { 5655, 35, 47, 36, 6, -46 },
  { 5861, 36, 47, 36, 2, -46 },
  { 6073, 37, 45, 36, 4, -45 },
  { 6282, 38, 45, 36, 4, -45 },
  { 6496, 35, 47, 36, 6, -46 },
  { 6702, 40, 45, 36, 2, -45 },
  { 6927, 38, 45, 36, 3, -45 },
  { 7141, 37, 46, 36, 3, -45 },
  { 7354, 41, 45, 36, 2, -45 },
  { 7585, 30, 45, 36, 3, -45 },
  { 7754, 41, 45, 36, 0, -45 },
  { 7985, 40, 45, 36, 2, -45 },
  { 8210, 34, 47, 36, 5, -46 },
  { 8410, 37, 45, 36, 3, -45 },
  { 8619, 34, 59, 36, 5, -46 },
  { 8870, 36, 45, 36, 2, -45 },
  { 9073, 37, 47, 36, 2, -46 },
  { 9291, 34, 45, 36, 9, -45 },
  { 9483, 37, 46, 36, 5, -45 },
  { 9696, 34, 45, 36, 10, -45 },
  { 9888, 41, 45, 36, 3, -45 },
  { 10119, 44, 45, 36, 0, -45 },
  { 10367, 35, 45, 36, 10, -45 },
  { 10564, 39, 45, 36, 2, -45 },
  { 10784, 35, 62, 36, 6, -50 },
  { 11056, 14, 62, 36, 15, -50 },
  { 11165, 35, 62, 36, 1, -50 },
  { 11437, 33, 26, 36, 6, -45 },
  { 11545, 34, 8, 36, -2, 4 },
  { 11579, 16, 13, 36, 17, -50 },
  { 11605, 33, 36, 36, 5, -35 },
  { 11754, 33, 52, 36, 3, -51 },
  { 11969, 32, 36, 36, 6, -35 },
  { 12113, 37, 52, 36, 5, -51 },
  { 12354, 33, 36, 36, 5, -35 },
  { 12503, 46, 64, 36, -3, -51 },
  { 12871, 38, 48, 36, 0, -35 },
  { 13099, 33, 51, 36, 3, -51 },
  { 13310, 25, 50, 36, 8, -49 },
  { 13467, 35, 62, 36, 0, -49 },
  { 13739, 37, 51, 36, 4, -51 },
  { 13975, 23, 51, 36, 10, -50 },
  { 14122, 36, 34, 36, 2, -34 },
  { 14275, 33, 35, 36, 3, -35 },
  { 14420, 31, 36, 36, 5, -35 },
  { 14560, 36, 47, 36, 0, -35 },
  { 14772, 33, 47, 36, 5, -35 },
  { 14966, 34, 35, 36, 5, -35 },
  { 15115, 32, 36, 36, 4, -35 },
  { 15259, 30, 45, 36, 8, -44 },
  { 15428, 33, 35, 36, 5, -34 },
  { 15573, 32, 34, 36, 8, -34 },
  { 15709, 37, 34, 36, 5, -34 },
  { 15867, 39, 34, 36, 1, -34 },
  { 16033, 43, 47, 36, -3, -34 },
  { 16286, 34, 34, 36, 4, -34 },
  { 16431, 35, 62, 36, 7, -50 },
  { 16703, 24, 62, 36, 9, -50 },
  { 16889, 35, 62, 36, 0, -50 },
  { 17161, 34, 13, 36, 4, -26 },
};

const GFXfont UbuntuMono_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic72pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _UBUNTUMONO_BOLDITALIC72PT7B_H_
