#ifndef _UBUNTUMONO_BOLDITALIC41PT7B_H_
#define _UBUNTUMONO_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00,
  0x7E, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xEF, 0xC7, 0xDF, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC3, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x1F, 0x87, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x81, 0xFC,
  0x07, 0x81, 0xFE, 0x07, 0x80, 0xE7, 0x07, 0x80, 0xF3, 0x83, 0x80, 0x71,
  0xC3, 0x80, 0x38, 0xE3, 0xC0, 0x1C, 0x73, 0xC0, 0x0E, 0x73, 0xC0, 0x07,
  0xFB, 0xC0, 0x03, 0xFB, 0xC0, 0x00, 0xF9, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0xE0, 0x01, 0xEF, 0xF0, 0x01, 0xE7, 0x38,
  0x00, 0xE7, 0x9C, 0x00, 0xE3, 0x8E, 0x00, 0xF1, 0xC7, 0x00, 0xF0, 0xE3,
  0x80, 0xF0, 0x73, 0x80, 0xF0, 0x3F, 0xC0, 0xF0, 0x1F, 0xC0, 0x70, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xC7, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F,
  0x80, 0x79, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0xE1, 0xFF,
  0x1E, 0x3F, 0xF1, 0xE7, 0xCF, 0xBE, 0x78, 0x7F, 0xCF, 0x87, 0xF8, 0xF0,
  0x3F, 0x8F, 0x01, 0xF0, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFE, 0x78, 0x1F, 0x87, 0xC0, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x0C,
  0x78, 0x67, 0x9C, 0xF3, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x03, 0xBC, 0x07, 0xDF, 0x07, 0xEF, 0xC3, 0xE3, 0xE0, 0xF1, 0xC0, 0x10,
  0x40, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x87, 0xE1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF0, 0xF8, 0x1E, 0x0F, 0x1F, 0xCF, 0xE3, 0xE0, 0xE0, 0x00, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFC, 0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF,
  0x80, 0x7D, 0xF3, 0xCF, 0xBC, 0xF9, 0xFF, 0x9F, 0x3D, 0xF1, 0xCF, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x8F, 0xC7, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x7C, 0x0C, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0x83, 0xF0, 0x60, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x78, 0x1F, 0xC7,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xFB, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07,
  0x87, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x8F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x30, 0x1F, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xC0, 0xF8, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8,
  0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xF0,
  0xF8, 0x3F, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0x9F,
  0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F,
  0xCF, 0xC3, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0x87, 0xE1, 0xF0, 0x3F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF1, 0xF8, 0x3F, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x0F,
  0x00, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x02, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0C, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x38, 0x3F, 0x20,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7E, 0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3E, 0x0F, 0xF9, 0xE1, 0xFF, 0xCF, 0x1F, 0xFC, 0xF1, 0xFF, 0xE7, 0x8F,
  0x8F, 0x3C, 0xF8, 0xF9, 0xC7, 0x87, 0x9E, 0x3C, 0x3C, 0xF1, 0xE1, 0xE7,
  0x8F, 0x1F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFC, 0x78, 0xFF,
  0xE3, 0xC3, 0xFE, 0x0F, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xE0,
  0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3E, 0x0F, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0x0C, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0,
  0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x87,
  0xC3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xE0, 0x60, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x40, 0x7E, 0x07,
  0x07, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xE1,
  0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF,
  0xC0, 0x0F, 0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xB8, 0xFE, 0x07, 0xB9, 0xDC, 0x07, 0xBB,
  0xFC, 0x07, 0xBB, 0xBC, 0x0F, 0x3F, 0xBC, 0x0F, 0x3F, 0x3C, 0x0F, 0x3F,
  0x7C, 0x1F, 0x3E, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x3F, 0x81,
  0xE0, 0x7F, 0x07, 0xC0, 0xFE, 0x0F, 0x81, 0xFC, 0x1E, 0x07, 0xFC, 0x3C,
  0x0F, 0xF8, 0xF8, 0x1E, 0xF1, 0xF0, 0x3C, 0xE3, 0xC0, 0xF9, 0xE7, 0x81,
  0xF3, 0xCF, 0x03, 0xC7, 0xBE, 0x07, 0x87, 0x78, 0x1F, 0x0F, 0xF0, 0x3E,
  0x1F, 0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x3F, 0x83, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC,
  0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F,
  0x8F, 0xC7, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7C, 0x3F, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0xC7, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x78, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x07, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x40, 0x0F, 0x83, 0xC0, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x7C, 0xF1,
  0xE0, 0xF1, 0xE3, 0xC1, 0xE7, 0xC7, 0x83, 0xCF, 0x9F, 0x0F, 0xBF, 0x3C,
  0x1E, 0x7E, 0x78, 0x3D, 0xDC, 0xF0, 0x7B, 0x9F, 0xC0, 0xFE, 0x3F, 0x81,
  0xDC, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF7,
  0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07,
  0xC7, 0x81, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0xFC,
  0x07, 0x9F, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C,
  0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0x3E,
  0x70, 0x07, 0x80, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x20, 0x38, 0x1E, 0x1F, 0xC7, 0xF0, 0xF8,
  0x3C, 0x04, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xF8, 0x7C, 0xFC, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F,
  0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x7E, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF7, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF1,
  0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x3F, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x1F, 0x1F, 0x07, 0xE7, 0xE1, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x08, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xC3, 0xE1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x87, 0xCF, 0x80, 0xF7, 0xC0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0x80, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x21, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x81, 0xC0, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x47,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x06, 0x0F, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0xFC, 0x03,
  0xEF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x7F, 0xE3,
  0xFF, 0x3F, 0xF9, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC2, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x1F, 0xC0, 0x03, 0xF1, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF3, 0xCF, 0x8F, 0x1E, 0x7C,
  0x78, 0xF3, 0xC3, 0xCF, 0x1E, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x78, 0x79, 0xE3, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE0, 0x01, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x83, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0x0F, 0x9F, 0x83, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x07,
  0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x83,
  0xF0, 0x7C, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F,
  0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3F, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x18, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x1C, 0x0F, 0xC3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x1F,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFB, 0xE0, 0x7C, 0x30, 0x00, 0xFC,
  0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF3,
  0xF0, 0x1E, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0xFB,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x8F, 0x1E, 0x7C, 0x78,
  0xF3, 0xC7, 0xC7, 0x9E, 0x3E, 0x78, 0xF3, 0xF3, 0xC7, 0x9F, 0x9C, 0x3D,
  0xDD, 0xE1, 0xEE, 0xEF, 0x0E, 0xE7, 0x70, 0x7F, 0x3F, 0x83, 0xF1, 0xFC,
  0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x00, 0x07,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0xC1, 0xFE, 0x0F,
  0x3F, 0xF1, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0x8F, 0xFC, 0xF0, 0x7F,
  0x83, 0x01, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 11, 25, 21, 7, -25 },
  { 36, 15, 12, 21, 8, -28 },
  { 59, 22, 25, 21, 1, -25 },
  { 128, 20, 33, 21, 2, -29 },
  { 211, 25, 25, 21, 0, -25 },
  { 290, 20, 25, 21, 2, -25 },
  { 353, 8, 12, 21, 11, -28 },
  { 365, 16, 36, 21, 6, -29 },
  { 437, 16, 36, 21, 2, -29 },
  { 509, 17, 15, 21, 5, -25 },
  { 541, 18, 18, 21, 3, -20 },
  { 582, 10, 13, 21, 4, -7 },
  { 599, 12, 5, 21, 6, -13 },
  { 607, 7, 7, 21, 7, -7 },
  { 614, 24, 36, 21, 0, -29 },
  { 722, 19, 25, 21, 3, -25 },
  { 782, 16, 25, 21, 3, -25 },
  { 832, 20, 25, 21, 2, -25 },
  { 895, 20, 25, 21, 1, -25 },
  { 958, 20, 25, 21, 2, -25 },
  { 1021, 22, 25, 21, 1, -25 },
  { 1090, 20, 25, 21, 3, -25 },
  { 1153, 19, 25, 21, 5, -25 },
  { 1213, 19, 25, 21, 3, -25 },
  { 1273, 20, 25, 21, 2, -25 },
  { 1336, 10, 19, 21, 7, -19 },
  { 1360, 13, 25, 21, 4, -19 },
  { 1401, 19, 17, 21, 3, -19 },
  { 1442, 20, 12, 21, 2, -17 },
  { 1472, 19, 17, 21, 2, -19 },
  { 1513, 16, 25, 21, 6, -25 },
  { 1563, 21, 31, 21, 2, -25 },
  { 1645, 20, 25, 21, 0, -25 },
  { 1708, 20, 25, 21, 2, -25 },
  { 1771, 19, 25, 21, 4, -25 },
  { 1831, 21, 25, 21, 1, -25 },
  { 1897, 21, 25, 21, 2, -25 },
  { 1963, 22, 25, 21, 2, -25 },
  { 2032, 20, 25, 21, 3, -25 },
  { 2095, 23, 25, 21, 1, -25 },
  { 2167, 23, 25, 21, 1, -25 },
  { 2239, 21, 25, 21, 2, -25 },
  { 2305, 24, 25, 21, 1, -25 },
  { 2380, 17, 25, 21, 2, -25 },
  { 2434, 24, 25, 21, 0, -25 },
  { 2509, 23, 25, 21, 1, -25 },
  { 2581, 19, 25, 21, 3, -25 },
  { 2641, 21, 25, 21, 2, -25 },
  { 2707, 19, 32, 21, 3, -25 },
  { 2783, 21, 25, 21, 1, -25 },
  { 2849, 21, 25, 21, 1, -25 },
  { 2915, 20, 25, 21, 5, -25 },
  { 2978, 21, 25, 21, 3, -25 },
  { 3044, 19, 25, 21, 6, -25 },
  { 3104, 23, 25, 21, 2, -25 },
  { 3176, 25, 25, 21, 0, -25 },
  { 3255, 19, 25, 21, 6, -25 },
  { 3315, 22, 25, 21, 1, -25 },
  { 3384, 20, 36, 21, 4, -29 },
  { 3474, 9, 36, 21, 8, -29 },
  { 3515, 20, 36, 21, 1, -29 },
  { 3605, 19, 15, 21, 3, -25 },
  { 3641, 19, 5, 21, -1, 2 },
  { 3653, 9, 8, 21, 10, -28 },
  { 3662, 19, 19, 21, 3, -19 },
  { 3708, 19, 28, 21, 2, -28 },
  { 3775, 19, 19, 21, 3, -19 },
  { 3821, 21, 28, 21, 3, -28 },
  { 3895, 18, 19, 21, 3, -19 },
  { 3938, 25, 35, 21, -1, -28 },
  { 4048, 22, 26, 21, 0, -19 },
  { 4120, 18, 28, 21, 2, -28 },
  { 4183, 14, 27, 21, 5, -27 },
  { 4231, 20, 34, 21, 0, -27 },
  { 4316, 21, 28, 21, 2, -28 },
  { 4390, 13, 28, 21, 6, -28 },
  { 4436, 21, 19, 21, 1, -19 },
  { 4486, 18, 19, 21, 2, -19 },
  { 4529, 18, 19, 21, 3, -19 },
  { 4572, 21, 26, 21, 0, -19 },
  { 4641, 19, 26, 21, 3, -19 },
  { 4703, 19, 19, 21, 3, -19 },
  { 4749, 19, 19, 21, 2, -19 },
  { 4795, 17, 25, 21, 5, -25 },
  { 4849, 19, 19, 21, 3, -19 },
  { 4895, 19, 19, 21, 4, -19 },
  { 4941, 21, 19, 21, 3, -19 },
  { 4991, 23, 19, 21, 0, -19 },
  { 5046, 25, 26, 21, -2, -19 },
  { 5128, 20, 19, 21, 2, -19 },
  { 5176, 20, 36, 21, 4, -29 },
  { 5266, 14, 36, 21, 5, -29 },
  { 5329, 20, 36, 21, 0, -29 },
  { 5419, 20, 8, 21, 2, -15 },
};

const GFXfont UbuntuMono_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic41pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUMONO_BOLDITALIC41PT7B_H_
