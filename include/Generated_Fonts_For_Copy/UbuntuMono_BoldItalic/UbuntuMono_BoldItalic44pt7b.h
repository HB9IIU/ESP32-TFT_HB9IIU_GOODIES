#ifndef _UBUNTUMONO_BOLDITALIC44PT7B_H_
#define _UBUNTUMONO_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x70, 0x00, 0x3F,
  0x1F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x70, 0x00,
  0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x78, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1E,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xE0, 0x70, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x20, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x38, 0x0F, 0xF0, 0x0F, 0x03, 0xCE, 0x03, 0xC0, 0x71,
  0xC0, 0xF0, 0x0E, 0x38, 0x3C, 0x03, 0xC7, 0x0F, 0x00, 0x78, 0xE3, 0xC0,
  0x0E, 0x3C, 0x78, 0x01, 0xC7, 0x1E, 0x00, 0x3D, 0xE7, 0x80, 0x07, 0xF9,
  0xE0, 0x00, 0x7F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x3F, 0xC0, 0x03, 0xCF,
  0x78, 0x00, 0xF1, 0xC7, 0x00, 0x3C, 0x78, 0xE0, 0x07, 0x8E, 0x1C, 0x01,
  0xE1, 0xC7, 0x80, 0x78, 0x38, 0xE0, 0x1E, 0x07, 0x1C, 0x07, 0x80, 0xE7,
  0x81, 0xE0, 0x1F, 0xE0, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3E, 0x3E,
  0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x3E,
  0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE1, 0xE1, 0xFE, 0x0F, 0x1F, 0xF8, 0xF1, 0xF7, 0xE7, 0x9F, 0x1F,
  0xFC, 0xF0, 0x7F, 0xCF, 0x83, 0xFC, 0x7C, 0x0F, 0xE3, 0xE0, 0x3E, 0x1F,
  0x03, 0xF8, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFE, 0xF8, 0x7F, 0xE7,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0x1E, 0x18, 0xF9, 0xCF, 0x1F, 0xBF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xDF,
  0x01, 0xFB, 0xF0, 0x3E, 0x7E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x02, 0x08,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0xFE, 0x7F, 0x8F, 0xC1, 0xE0, 0x00, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xC3, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0xF8, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0xDF,
  0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x7C,
  0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0x3E, 0x06, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7C, 0x1F,
  0x81, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x08, 0x01, 0xF8, 0x38, 0x0F, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x0C, 0x01, 0xF8, 0x1E, 0x07, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x9F, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F,
  0x9F, 0x80, 0xFC, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xE3, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x3F, 0x07,
  0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01,
  0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xC1, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x83, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8,
  0x07, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x40, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x38, 0x3F,
  0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07,
  0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x07, 0xFC,
  0x3C, 0x3F, 0xF8, 0xF0, 0xFF, 0xF1, 0xE3, 0xFF, 0xE3, 0xC7, 0xC7, 0xCF,
  0x1F, 0x0F, 0x1E, 0x3C, 0x3E, 0x3C, 0x78, 0x7C, 0x79, 0xF0, 0xF8, 0xF3,
  0xE1, 0xE1, 0xE7, 0xC3, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E,
  0x3C, 0x3E, 0x3F, 0xF8, 0x7C, 0x7F, 0xF0, 0x78, 0x7F, 0xE0, 0xF0, 0x3F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xC1,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x07, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE1, 0xF8, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E,
  0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x38, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0,
  0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7F,
  0x0F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x08,
  0x07, 0xE0, 0x3C, 0x1F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xF7,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x07,
  0xFC, 0xEF, 0x03, 0xDE, 0xF7, 0x81, 0xEF, 0x77, 0xC0, 0xF3, 0xFB, 0xC0,
  0xF9, 0xF9, 0xE0, 0x78, 0xFC, 0xF0, 0x3C, 0x7C, 0xF8, 0x3E, 0x3C, 0x7C,
  0x1F, 0x1E, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x81, 0xF0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0xF8, 0x0F, 0xF8, 0x7C,
  0x07, 0xBC, 0x3E, 0x07, 0xDE, 0x1E, 0x03, 0xEF, 0x1F, 0x01, 0xF3, 0xCF,
  0x80, 0xF1, 0xE7, 0xC0, 0xF8, 0xF3, 0xC0, 0x7C, 0x7B, 0xE0, 0x3E, 0x1D,
  0xF0, 0x1E, 0x0F, 0xF8, 0x1F, 0x07, 0xFC, 0x0F, 0x83, 0xFC, 0x07, 0xC1,
  0xFE, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7E,
  0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00,
  0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x3E,
  0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xC1, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x07,
  0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7,
  0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF,
  0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F,
  0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x7E,
  0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0,
  0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x80,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x03,
  0x80, 0x7C, 0x01, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x18, 0x01, 0xF0, 0x3C, 0x0F, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C,
  0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x07,
  0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0,
  0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x8F, 0x1F, 0x07,
  0xCF, 0x8F, 0x83, 0xE7, 0xC7, 0x81, 0xE7, 0xE3, 0xC0, 0xF3, 0xFB, 0xE0,
  0x7B, 0xFD, 0xF0, 0x7D, 0xDE, 0xF0, 0x3D, 0xEF, 0x78, 0x1E, 0xE3, 0xBC,
  0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x7E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E,
  0x07, 0xE1, 0xF0, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0,
  0x0F, 0x9F, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xF8, 0x7C,
  0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xF1, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x07,
  0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xFC, 0xE0, 0x07,
  0x81, 0x00, 0x10, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x10, 0x0E, 0x03, 0xE1, 0xFC, 0x7F, 0x87, 0xF0, 0x78, 0x04,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC3,
  0xE3, 0xF0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0,
  0x7C, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFE, 0x7C, 0x0F, 0x86, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7D, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0x83, 0xF1,
  0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F,
  0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07,
  0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xCF, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x21, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x01, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xC3, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0,
  0x7E, 0x7C, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x01, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF0, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC,
  0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xE1,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xE0, 0x7F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7D, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0,
  0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7C,
  0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x1F, 0x80,
  0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x10, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0x01, 0xF0, 0x1C, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF8, 0x3E, 0x0F, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x03,
  0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0xBF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF,
  0x80, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF8,
  0x00, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0xF0, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78,
  0xF1, 0xF1, 0xE3, 0xC7, 0xCF, 0x9F, 0x1E, 0x3C, 0x7C, 0x78, 0xF1, 0xE3,
  0xE3, 0xC7, 0x8F, 0x9F, 0x3E, 0x3C, 0x78, 0xF8, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x3E, 0x00, 0x78, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x87, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x7E,
  0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F,
  0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0x81,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8,
  0xFE, 0x7E, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xF7, 0xC0, 0x7E, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xF8, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF1, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0xC3, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xBF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFC, 0x02, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xC0, 0x60, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x38, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x18, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1,
  0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C,
  0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xE3,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x81, 0xF8, 0x60, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF8,
  0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF1,
  0xF8, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1E,
  0x78, 0x78, 0x79, 0xE1, 0xE3, 0xE7, 0x8F, 0x8F, 0x1E, 0x3E, 0x3C, 0xF9,
  0xF9, 0xF3, 0xC7, 0xE7, 0x8F, 0x3F, 0x9E, 0x3C, 0xEE, 0x78, 0xF7, 0xBB,
  0xC3, 0xDC, 0xEF, 0x0F, 0xF3, 0xB8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x3E, 0x00, 0x07,
  0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x01,
  0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xC0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x61, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x60, 0x7F, 0x83, 0xC7, 0xFE,
  0x3E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3C, 0x7F, 0xF3, 0xE0, 0xFF, 0x06,
  0x01, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 13, 28, 22, 7, -27 },
  { 47, 16, 12, 22, 8, -30 },
  { 71, 24, 27, 22, 1, -27 },
  { 152, 22, 35, 22, 2, -31 },
  { 249, 27, 29, 22, 0, -28 },
  { 347, 21, 29, 22, 2, -28 },
  { 424, 8, 13, 22, 12, -30 },
  { 437, 18, 39, 22, 6, -31 },
  { 525, 17, 39, 22, 2, -31 },
  { 608, 19, 17, 22, 5, -27 },
  { 649, 20, 20, 22, 3, -21 },
  { 699, 11, 14, 22, 4, -7 },
  { 719, 13, 5, 22, 6, -14 },
  { 728, 8, 8, 22, 7, -7 },
  { 736, 26, 38, 22, 0, -31 },
  { 860, 21, 29, 22, 3, -28 },
  { 937, 17, 27, 22, 3, -27 },
  { 995, 21, 28, 22, 2, -28 },
  { 1069, 22, 29, 22, 1, -28 },
  { 1149, 22, 27, 22, 2, -27 },
  { 1224, 23, 28, 22, 1, -27 },
  { 1305, 21, 28, 22, 3, -27 },
  { 1379, 21, 27, 22, 5, -27 },
  { 1450, 21, 29, 22, 3, -28 },
  { 1527, 22, 28, 22, 2, -28 },
  { 1604, 11, 21, 22, 7, -20 },
  { 1633, 14, 27, 22, 4, -20 },
  { 1681, 21, 19, 22, 3, -21 },
  { 1731, 22, 12, 22, 2, -18 },
  { 1764, 20, 19, 22, 2, -21 },
  { 1812, 16, 29, 22, 7, -28 },
  { 1870, 23, 34, 22, 2, -28 },
  { 1968, 21, 27, 22, 0, -27 },
  { 2039, 22, 28, 22, 2, -27 },
  { 2116, 21, 29, 22, 4, -28 },
  { 2193, 22, 29, 22, 1, -28 },
  { 2273, 23, 27, 22, 2, -27 },
  { 2351, 23, 27, 22, 3, -27 },
  { 2429, 22, 29, 22, 3, -28 },
  { 2509, 25, 27, 22, 1, -27 },
  { 2594, 23, 27, 22, 2, -27 },
  { 2672, 23, 28, 22, 2, -27 },
  { 2753, 26, 27, 22, 1, -27 },
  { 2841, 18, 27, 22, 2, -27 },
  { 2902, 25, 27, 22, 0, -27 },
  { 2987, 25, 27, 22, 1, -27 },
  { 3072, 21, 29, 22, 3, -28 },
  { 3149, 22, 27, 22, 2, -27 },
  { 3224, 21, 36, 22, 3, -28 },
  { 3319, 22, 27, 22, 1, -27 },
  { 3394, 23, 29, 22, 1, -28 },
  { 3478, 21, 27, 22, 6, -27 },
  { 3549, 22, 28, 22, 3, -27 },
  { 3626, 21, 27, 22, 6, -27 },
  { 3697, 25, 27, 22, 2, -27 },
  { 3782, 27, 27, 22, 0, -27 },
  { 3874, 21, 27, 22, 6, -27 },
  { 3945, 24, 27, 22, 1, -27 },
  { 4026, 21, 38, 22, 4, -31 },
  { 4126, 9, 38, 22, 9, -31 },
  { 4169, 21, 38, 22, 1, -31 },
  { 4269, 21, 16, 22, 3, -27 },
  { 4311, 21, 4, 22, -2, 3 },
  { 4322, 10, 8, 22, 10, -30 },
  { 4332, 20, 23, 22, 3, -22 },
  { 4390, 20, 32, 22, 2, -31 },
  { 4470, 20, 23, 22, 3, -22 },
  { 4528, 23, 32, 22, 3, -31 },
  { 4620, 20, 23, 22, 3, -22 },
  { 4678, 28, 39, 22, -2, -31 },
  { 4815, 23, 30, 22, 0, -22 },
  { 4902, 20, 31, 22, 2, -31 },
  { 4980, 15, 32, 22, 5, -31 },
  { 5040, 21, 39, 22, 0, -31 },
  { 5143, 23, 31, 22, 2, -31 },
  { 5233, 14, 31, 22, 6, -30 },
  { 5288, 22, 21, 22, 1, -21 },
  { 5346, 20, 22, 22, 2, -22 },
  { 5401, 19, 23, 22, 3, -22 },
  { 5456, 22, 29, 22, 0, -22 },
  { 5536, 20, 29, 22, 3, -22 },
  { 5609, 21, 22, 22, 3, -22 },
  { 5667, 20, 23, 22, 2, -22 },
  { 5725, 18, 28, 22, 5, -27 },
  { 5788, 20, 22, 22, 3, -21 },
  { 5843, 19, 21, 22, 5, -21 },
  { 5893, 22, 21, 22, 3, -21 },
  { 5951, 24, 21, 22, 0, -21 },
  { 6014, 26, 29, 22, -2, -21 },
  { 6109, 21, 21, 22, 2, -21 },
  { 6165, 21, 38, 22, 4, -31 },
  { 6265, 15, 38, 22, 5, -31 },
  { 6337, 21, 38, 22, 0, -31 },
  { 6437, 21, 8, 22, 2, -16 },
};

const GFXfont UbuntuMono_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic44pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUMONO_BOLDITALIC44PT7B_H_
