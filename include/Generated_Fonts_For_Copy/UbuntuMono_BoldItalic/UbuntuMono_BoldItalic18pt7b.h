#ifndef _UBUNTUMONO_BOLDITALIC18PT7B_H_
#define _UBUNTUMONO_BOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x07, 0x38, 0x66, 0xDD, 0xB2, 0x6C,
  0xC0, 0x0D, 0x84, 0xC6, 0xCF, 0xF7, 0xF9, 0xB3, 0xFD, 0xFE, 0xCC, 0x6C,
  0x36, 0x00, 0x06, 0x03, 0x07, 0xC7, 0xE3, 0x03, 0x80, 0xC0, 0x78, 0x1E,
  0x03, 0x81, 0x9F, 0xC7, 0xC1, 0x80, 0xC0, 0x1C, 0x64, 0x98, 0xB6, 0x15,
  0x83, 0xA0, 0x08, 0x02, 0xE0, 0xD4, 0x36, 0x8C, 0xD1, 0x0C, 0x00, 0x1E,
  0x3F, 0x33, 0x32, 0x36, 0x3C, 0x7B, 0xCF, 0xC6, 0xFE, 0x7B, 0x7F, 0x6C,
  0x02, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x60,
  0x60, 0x60, 0x30, 0x10, 0x08, 0x38, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x18, 0x70, 0xC3, 0x8E, 0x38, 0x40, 0x18, 0x18, 0x5E, 0xFF, 0x38, 0x7E,
  0x24, 0x0C, 0x0C, 0x0C, 0x7F, 0xFF, 0x18, 0x18, 0x30, 0x77, 0x73, 0xE8,
  0x7D, 0xF0, 0xFF, 0x80, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00,
  0x0E, 0x1F, 0x8C, 0xEC, 0x36, 0xDB, 0x5B, 0x0D, 0x86, 0xE6, 0x3F, 0x0E,
  0x00, 0x06, 0x3C, 0xF9, 0x70, 0xC1, 0x83, 0x0E, 0x19, 0xFF, 0xF8, 0x1E,
  0x1F, 0x88, 0xE0, 0x60, 0x70, 0x70, 0x70, 0xE0, 0x60, 0x7F, 0x3F, 0x80,
  0x1E, 0x3F, 0x03, 0x03, 0x1E, 0x1E, 0x06, 0x07, 0x86, 0xFE, 0xFC, 0x03,
  0x83, 0x83, 0xC3, 0x63, 0x33, 0x33, 0xFD, 0xFE, 0x06, 0x06, 0x03, 0x00,
  0x1F, 0x8F, 0xCC, 0x06, 0x03, 0xC3, 0xF0, 0x18, 0x0E, 0x06, 0x7F, 0x3F,
  0x00, 0x07, 0x8F, 0xCE, 0x0E, 0x07, 0xE3, 0xFB, 0x8D, 0x86, 0xE7, 0x3F,
  0x0F, 0x00, 0x7F, 0xBF, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x38, 0x00, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0xF1, 0xE1, 0x99, 0x86,
  0xC7, 0x7F, 0x1F, 0x00, 0x1E, 0x1F, 0x98, 0xCC, 0x76, 0x3B, 0xF8, 0xEC,
  0x0E, 0x0E, 0x7E, 0x3C, 0x00, 0x37, 0x70, 0x0E, 0xEE, 0x19, 0xCE, 0x00,
  0x39, 0xCE, 0x37, 0x20, 0x01, 0x03, 0xCF, 0x8E, 0x07, 0x01, 0xE0, 0x38,
  0x04, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x20, 0x78, 0x3E, 0x0F,
  0x0F, 0x7E, 0xF0, 0x80, 0x7C, 0xF8, 0x38, 0x61, 0xC7, 0x1C, 0x30, 0x01,
  0xC3, 0x00, 0x0F, 0x1F, 0xCC, 0x6C, 0xF4, 0xFE, 0xCB, 0x6D, 0xB6, 0xDF,
  0x67, 0x38, 0x0F, 0x83, 0xC0, 0x07, 0x03, 0x83, 0xC1, 0xE1, 0xB0, 0xD8,
  0xCC, 0x7F, 0x7F, 0xB1, 0xF0, 0xE0, 0x3F, 0x1F, 0x8C, 0xEE, 0x67, 0xE3,
  0xF1, 0x8D, 0xC6, 0xC7, 0x7F, 0x3F, 0x00, 0x1F, 0x3F, 0x70, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x3E, 0x1F, 0x8C, 0xCE, 0x76, 0x33,
  0x19, 0x8D, 0xCE, 0xCE, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0xCC, 0x06, 0x03,
  0xF3, 0xF1, 0x80, 0xC0, 0x60, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE3, 0x00,
  0xC0, 0x30, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0C, 0x00, 0x0F, 0x8F,
  0xCE, 0x0E, 0x06, 0x03, 0x1B, 0x8D, 0xCE, 0x66, 0x3F, 0x0F, 0x80, 0x18,
  0xC3, 0x18, 0x63, 0x18, 0xE3, 0xF8, 0x7F, 0x0C, 0x63, 0x9C, 0x63, 0x0C,
  0x61, 0x8C, 0x00, 0x3F, 0x9F, 0xC3, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x7E, 0x1E, 0x00, 0x31, 0x8C, 0xE3, 0x71, 0xF8, 0x7C, 0x1E,
  0x07, 0xC3, 0xB0, 0xC6, 0x31, 0x8C, 0x70, 0x38, 0x60, 0xC1, 0x87, 0x0C,
  0x18, 0x30, 0xE1, 0xFF, 0xF8, 0x18, 0xC6, 0x31, 0x9C, 0xFF, 0x3E, 0xCB,
  0xA6, 0xD9, 0x86, 0x61, 0x90, 0x6C, 0x30, 0x18, 0xC3, 0x18, 0x73, 0x1E,
  0x63, 0x58, 0x6F, 0x0D, 0xE3, 0x3C, 0x63, 0x0C, 0x61, 0x8C, 0x00, 0x0E,
  0x1F, 0x8C, 0xEC, 0x76, 0x3F, 0x1B, 0x0D, 0x86, 0xE6, 0x3F, 0x1E, 0x00,
  0x3F, 0x1F, 0xCC, 0x66, 0x36, 0x3B, 0xF9, 0xF0, 0xC0, 0xC0, 0x60, 0x30,
  0x00, 0x0E, 0x1F, 0x8C, 0xEC, 0x76, 0x3F, 0x1B, 0x0D, 0x86, 0xE6, 0x3F,
  0x1E, 0x06, 0x01, 0xC0, 0x60, 0x3E, 0x1F, 0x8C, 0xEE, 0x76, 0x33, 0xF9,
  0xF1, 0xD8, 0xC6, 0x63, 0x31, 0x80, 0x1F, 0x1F, 0x8C, 0x0E, 0x03, 0x81,
  0xF0, 0x38, 0x0E, 0x86, 0x7F, 0x3F, 0x00, 0x7F, 0xFF, 0xC6, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x00, 0x31, 0x98, 0xDC, 0x6C,
  0x76, 0x33, 0x1B, 0x8D, 0x8E, 0xE6, 0x7F, 0x1F, 0x00, 0xE1, 0xF1, 0xB8,
  0xDC, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x30, 0xD8,
  0x36, 0x19, 0x86, 0x6D, 0x97, 0x4D, 0xF3, 0xDC, 0xE7, 0x39, 0x8C, 0x60,
  0x18, 0xE3, 0x98, 0x36, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xD8, 0x33,
  0x0E, 0x63, 0x8C, 0x00, 0xC7, 0xC6, 0xCE, 0xCC, 0xD8, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0xC0, 0x1F, 0xC7, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x1F, 0xC7, 0xF0, 0x1F, 0x1F, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xF8, 0xF8, 0xDB, 0x6D, 0xB6,
  0xED, 0xB6, 0xDB, 0x0F, 0x87, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x61, 0xF1, 0xF0, 0x0E, 0x07, 0x07,
  0xC6, 0x67, 0x37, 0x18, 0x7F, 0xBF, 0xC0, 0x4F, 0x30, 0x1F, 0x3F, 0x63,
  0xE7, 0xC6, 0xC6, 0xFE, 0x7E, 0x38, 0x38, 0x30, 0x30, 0x7E, 0x7F, 0x63,
  0x63, 0xE3, 0xC6, 0xFE, 0xF8, 0x1F, 0x9F, 0x9C, 0x0C, 0x0E, 0x07, 0x01,
  0xF8, 0x7C, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x1F, 0x0F, 0xC6, 0x33, 0x9C,
  0xC6, 0x31, 0x8F, 0xE1, 0xF8, 0x1F, 0x3F, 0x63, 0x67, 0xFC, 0xE0, 0x7E,
  0x3E, 0x01, 0xF0, 0x3E, 0x03, 0x00, 0x70, 0x0F, 0xE1, 0xFC, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0xC7, 0xE3, 0x98, 0xC6, 0x73, 0x9C, 0xC3, 0xF0, 0xFC, 0x06, 0x3F,
  0x8F, 0xC0, 0x18, 0x38, 0x30, 0x30, 0x3E, 0x7F, 0x63, 0x63, 0x67, 0xE6,
  0xC6, 0xC6, 0x18, 0x60, 0x3E, 0xF8, 0xC3, 0x0C, 0x71, 0xF3, 0xC0, 0x03,
  0x81, 0x80, 0x03, 0xE1, 0xF0, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x91,
  0x8F, 0xC3, 0xC0, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x39, 0xB9, 0xF0, 0xF0,
  0x6C, 0x36, 0x39, 0x98, 0xC0, 0xF7, 0x8C, 0x66, 0x31, 0x8C, 0xC6, 0x3E,
  0xF0, 0x3F, 0x8F, 0xF3, 0x68, 0x96, 0x6D, 0x98, 0x66, 0x11, 0x0C, 0x3E,
  0x7F, 0x73, 0x63, 0x67, 0xE6, 0xC6, 0xC6, 0x1E, 0x3F, 0x63, 0xE3, 0xC3,
  0xE6, 0xFE, 0x78, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x1B, 0x19, 0xFC, 0xF8,
  0x60, 0x70, 0x30, 0x00, 0x1F, 0x1F, 0x9C, 0xCC, 0x6C, 0x77, 0x31, 0xF8,
  0xFC, 0x0E, 0x06, 0x03, 0x00, 0x1F, 0x9F, 0x8C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0x1F, 0x3F, 0x70, 0x38, 0x0E, 0x06, 0xFE, 0x7C, 0x18, 0x30,
  0xFE, 0xFE, 0x30, 0x60, 0x60, 0x60, 0x7C, 0x3C, 0x73, 0x63, 0x63, 0x67,
  0xE6, 0xE6, 0xFE, 0x7E, 0xC7, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x70, 0x70,
  0x61, 0xA0, 0xF3, 0x7B, 0xED, 0xF7, 0x73, 0xB9, 0x98, 0x39, 0xC6, 0xE1,
  0xF0, 0x38, 0x1E, 0x07, 0x83, 0x31, 0x8C, 0x18, 0xE3, 0x18, 0x63, 0x0E,
  0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x70, 0x0C, 0x0F, 0x03, 0xC0, 0x00, 0x3F,
  0x1F, 0x81, 0x81, 0x83, 0x83, 0x83, 0xF9, 0xFC, 0x0F, 0x0F, 0x18, 0x18,
  0x18, 0x18, 0x30, 0xF0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x78, 0x78,
  0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38,
  0x1E, 0x0F, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0F, 0x07, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC3, 0xE1, 0xE0, 0x79, 0xFF, 0xB3, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 11, 9, 3, -11 },
  { 8, 7, 5, 9, 3, -12 },
  { 13, 9, 11, 9, 1, -11 },
  { 26, 9, 15, 9, 1, -13 },
  { 43, 11, 11, 9, 0, -11 },
  { 59, 8, 11, 9, 1, -11 },
  { 70, 3, 5, 9, 5, -12 },
  { 72, 8, 16, 9, 2, -13 },
  { 88, 7, 16, 9, 1, -13 },
  { 102, 8, 7, 9, 2, -11 },
  { 109, 8, 8, 9, 1, -9 },
  { 117, 4, 6, 9, 2, -3 },
  { 120, 6, 2, 9, 2, -6 },
  { 122, 3, 3, 9, 3, -3 },
  { 124, 10, 16, 9, 0, -13 },
  { 144, 9, 11, 9, 1, -11 },
  { 157, 7, 11, 9, 1, -11 },
  { 167, 9, 11, 9, 1, -11 },
  { 180, 8, 11, 9, 1, -11 },
  { 191, 9, 11, 9, 1, -11 },
  { 204, 9, 11, 9, 1, -11 },
  { 217, 9, 11, 9, 1, -11 },
  { 230, 9, 11, 9, 2, -11 },
  { 243, 9, 11, 9, 1, -11 },
  { 256, 9, 11, 9, 1, -11 },
  { 269, 4, 8, 9, 3, -8 },
  { 273, 5, 11, 9, 2, -8 },
  { 280, 9, 8, 9, 1, -8 },
  { 289, 9, 6, 9, 1, -7 },
  { 296, 8, 8, 9, 1, -8 },
  { 304, 7, 11, 9, 3, -11 },
  { 314, 9, 13, 9, 1, -11 },
  { 329, 9, 11, 9, 0, -11 },
  { 342, 9, 11, 9, 1, -11 },
  { 355, 8, 11, 9, 2, -11 },
  { 366, 9, 11, 9, 1, -11 },
  { 379, 9, 11, 9, 1, -11 },
  { 392, 10, 11, 9, 1, -11 },
  { 406, 9, 11, 9, 1, -11 },
  { 419, 11, 11, 9, 0, -11 },
  { 435, 9, 11, 9, 1, -11 },
  { 448, 9, 11, 9, 1, -11 },
  { 461, 10, 11, 9, 1, -11 },
  { 475, 7, 11, 9, 1, -11 },
  { 485, 10, 11, 9, 0, -11 },
  { 499, 11, 11, 9, 0, -11 },
  { 515, 9, 11, 9, 1, -11 },
  { 528, 9, 11, 9, 1, -11 },
  { 541, 9, 14, 9, 1, -11 },
  { 557, 9, 11, 9, 1, -11 },
  { 570, 9, 11, 9, 1, -11 },
  { 583, 9, 11, 9, 2, -11 },
  { 596, 9, 11, 9, 1, -11 },
  { 609, 9, 11, 9, 2, -11 },
  { 622, 10, 11, 9, 1, -11 },
  { 636, 11, 11, 9, 0, -11 },
  { 652, 8, 11, 9, 3, -11 },
  { 663, 10, 11, 9, 0, -11 },
  { 677, 8, 16, 9, 2, -13 },
  { 693, 3, 16, 9, 4, -13 },
  { 699, 9, 16, 9, 0, -13 },
  { 717, 9, 6, 9, 1, -11 },
  { 724, 9, 2, 9, -1, 1 },
  { 727, 4, 3, 9, 4, -12 },
  { 729, 8, 8, 9, 1, -8 },
  { 737, 8, 12, 9, 1, -12 },
  { 749, 9, 8, 9, 1, -8 },
  { 758, 10, 12, 9, 1, -12 },
  { 773, 8, 8, 9, 1, -8 },
  { 781, 12, 15, 9, -1, -12 },
  { 804, 10, 11, 9, 0, -8 },
  { 818, 8, 12, 9, 1, -12 },
  { 830, 6, 11, 9, 2, -11 },
  { 839, 9, 14, 9, 0, -11 },
  { 855, 9, 12, 9, 1, -12 },
  { 869, 5, 12, 9, 3, -12 },
  { 877, 10, 8, 9, 0, -8 },
  { 887, 8, 8, 9, 1, -8 },
  { 895, 8, 8, 9, 1, -8 },
  { 903, 9, 11, 9, 0, -8 },
  { 916, 9, 11, 9, 1, -8 },
  { 929, 9, 8, 9, 1, -8 },
  { 938, 8, 8, 9, 1, -8 },
  { 946, 8, 10, 9, 2, -10 },
  { 956, 8, 8, 9, 1, -8 },
  { 964, 8, 8, 9, 2, -8 },
  { 972, 9, 8, 9, 1, -8 },
  { 981, 10, 8, 9, 0, -8 },
  { 991, 11, 11, 9, -1, -8 },
  { 1007, 9, 8, 9, 1, -8 },
  { 1016, 8, 16, 9, 2, -13 },
  { 1032, 6, 16, 9, 2, -13 },
  { 1044, 9, 16, 9, 0, -13 },
  { 1062, 9, 3, 9, 1, -6 },
};

const GFXfont UbuntuMono_BoldItalic18pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic18pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic18pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUMONO_BOLDITALIC18PT7B_H_
