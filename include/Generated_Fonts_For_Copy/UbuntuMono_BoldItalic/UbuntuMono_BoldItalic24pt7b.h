#ifndef _UBUNTUMONO_BOLDITALIC24PT7B_H_
#define _UBUNTUMONO_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x61, 0xC0, 0x00,
  0x1E, 0x38, 0x00, 0xE7, 0xE7, 0xE7, 0xE6, 0xCE, 0xCE, 0xCC, 0x03, 0x30,
  0x39, 0x81, 0x9C, 0x1C, 0xC7, 0xFF, 0x3F, 0xF8, 0x73, 0x03, 0x38, 0x39,
  0x87, 0xFF, 0x3F, 0xF8, 0xCE, 0x06, 0x70, 0x73, 0x03, 0x38, 0x00, 0x01,
  0xC0, 0x18, 0x07, 0xE1, 0xFF, 0x1C, 0x23, 0x80, 0x38, 0x01, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC4, 0x1C, 0x7F, 0x87, 0xF0, 0x1C,
  0x01, 0xC0, 0x18, 0x00, 0x0E, 0x0C, 0x3E, 0x30, 0x6C, 0xE1, 0x99, 0x83,
  0x66, 0x07, 0xD8, 0x07, 0x60, 0x01, 0x80, 0x07, 0x70, 0x0D, 0xE0, 0x36,
  0x60, 0xCC, 0x83, 0x1B, 0x0E, 0x3E, 0x18, 0x38, 0x00, 0x07, 0x80, 0xFC,
  0x1C, 0xE1, 0x8E, 0x18, 0xC1, 0x9C, 0x1F, 0x81, 0xF4, 0x3E, 0x67, 0x76,
  0xE3, 0xCE, 0x3C, 0xE3, 0xCF, 0xFC, 0x7C, 0xE0, 0x7F, 0xEE, 0xEC, 0xC0,
  0x00, 0x80, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x10, 0x00, 0x02, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x0F, 0x07, 0x83, 0x80, 0x40, 0x00, 0x1C, 0x03, 0x04, 0xCB, 0xFE, 0xFF,
  0xC7, 0x83, 0xF1, 0xCE, 0x32, 0x00, 0x06, 0x01, 0x80, 0xE0, 0x38, 0xFF,
  0xFF, 0xF1, 0xC0, 0x70, 0x18, 0x06, 0x00, 0x1C, 0xF3, 0xCF, 0x1D, 0xEF,
  0x00, 0x7E, 0x7E, 0xFE, 0x7F, 0xFE, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8,
  0x77, 0x0E, 0xC1, 0xFB, 0xBF, 0x67, 0xE0, 0xD8, 0x3B, 0x07, 0x71, 0xCE,
  0x78, 0xFE, 0x0F, 0x00, 0x03, 0x83, 0xC7, 0xEF, 0xE3, 0xF1, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC7, 0xFF, 0xFE, 0x07, 0xC1, 0xFE,
  0x18, 0xF0, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xC1, 0xFE, 0x08,
  0xE0, 0x06, 0x00, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0xC3, 0xCF, 0xF8, 0x7E, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xE0,
  0x7E, 0x0E, 0xE1, 0xCE, 0x38, 0xE3, 0x1C, 0x71, 0xCF, 0xFE, 0xFF, 0xE0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x1F, 0x03, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x43, 0xCF, 0xF8, 0x7E, 0x00, 0x01, 0xE1, 0xFC, 0x78, 0x1C, 0x07, 0x00,
  0xDE, 0x3F, 0xE7, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEF, 0x38, 0xFE,
  0x0F, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0xC0, 0xFE, 0x1C, 0x71, 0x87, 0x18, 0x71, 0xCE, 0x1F, 0xC1, 0xF8, 0x3B,
  0xC7, 0x0E, 0x60, 0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x81,
  0xFE, 0x38, 0xE3, 0x87, 0x30, 0x73, 0x07, 0x38, 0x73, 0xFF, 0x1F, 0xE0,
  0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x18, 0xF3, 0xCE,
  0x00, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x3C, 0x3C, 0x3C, 0x1C, 0x78, 0xF0, 0x00, 0x60, 0x3C, 0x3F,
  0xBF, 0xCF, 0x81, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0x80, 0x30, 0x3F, 0xF7,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x10, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x07, 0xCF, 0xF7, 0xF0, 0xF0, 0x18, 0x00, 0x3E, 0x3F, 0x9F,
  0xE8, 0xF0, 0x38, 0x38, 0x3C, 0x3C, 0x38, 0x38, 0x1C, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x03, 0xE0, 0xFF, 0x1C, 0x33, 0x83, 0x31, 0xF7, 0x3F, 0x67,
  0x76, 0xE7, 0xEE, 0x6E, 0xC6, 0xEC, 0xEE, 0xEE, 0xE7, 0xCE, 0x7C, 0x60,
  0x07, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0x76,
  0x1C, 0xC3, 0x98, 0xE3, 0x1C, 0x67, 0xFC, 0xFF, 0xB8, 0x37, 0x06, 0xC1,
  0xF8, 0x38, 0x1F, 0xC1, 0xFE, 0x1C, 0x71, 0x87, 0x38, 0x73, 0x8E, 0x3F,
  0xC3, 0xFC, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE1, 0xCF, 0xF8, 0xFE,
  0x00, 0x07, 0xE0, 0xFE, 0x1C, 0x23, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x87, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xFC, 0x1C, 0xE3, 0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x0F,
  0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0xE3, 0x8F, 0xF0, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF8,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xC7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0x87,
  0xF8, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0xFE, 0x3C, 0x23, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0xF3, 0x87, 0xF8, 0x3F, 0x00,
  0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xCF,
  0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x43, 0x8F, 0xF0, 0x3E,
  0x00, 0x1C, 0x38, 0xE3, 0x87, 0x3C, 0x73, 0xC3, 0xBC, 0x1D, 0xC0, 0xFC,
  0x07, 0xC0, 0x77, 0x03, 0xBC, 0x1C, 0xE0, 0xE7, 0x0E, 0x1C, 0x70, 0xE3,
  0x87, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xFF, 0xF8, 0x0E, 0x1C, 0x38,
  0xF0, 0xE3, 0x87, 0x9E, 0x1A, 0x78, 0x6B, 0x63, 0xAF, 0x8E, 0xEE, 0x33,
  0xB0, 0xCC, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0x8E, 0x0E, 0x00,
  0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x7C, 0x63, 0xE7, 0x1B, 0x38, 0xD9, 0xCE,
  0x6C, 0x73, 0xE3, 0x9F, 0x18, 0xF9, 0xC7, 0x8E, 0x1C, 0x70, 0xE3, 0x07,
  0x00, 0x0F, 0x83, 0xF8, 0xE7, 0xB8, 0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xCE, 0x79, 0xFE, 0x0F, 0x00, 0x1F, 0xC1,
  0xFE, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x7F, 0xC7,
  0xF0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xF8,
  0xE7, 0xB8, 0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xDC, 0x3B, 0x87,
  0x71, 0xCE, 0x79, 0xFE, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x18, 0x00,
  0x1F, 0xC1, 0xFE, 0x1C, 0xF1, 0x87, 0x38, 0x73, 0x8F, 0x38, 0xE3, 0xFC,
  0x7F, 0x87, 0x30, 0x73, 0x87, 0x18, 0xE1, 0xCE, 0x1C, 0xE1, 0xC0, 0x07,
  0xE1, 0xFF, 0x1C, 0x23, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x41, 0xCF, 0xF8, 0x7F, 0x00, 0x7F, 0xFF,
  0xFC, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x38, 0x73, 0x87, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E,
  0x38, 0xE7, 0x8F, 0xF0, 0x7C, 0x00, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x06, 0x60, 0x6E, 0x06, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x00, 0x18, 0x18, 0xE0, 0x63, 0x83, 0x8E, 0x0E,
  0x30, 0x30, 0xCC, 0xC7, 0x77, 0x1D, 0xDC, 0x6F, 0x61, 0xBD, 0x87, 0xB6,
  0x3C, 0xF0, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x0E, 0x1C, 0x1C, 0x38,
  0x18, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x3B, 0x00, 0xE7, 0x03, 0x8E, 0x0F, 0x1C, 0x3C, 0x38,
  0x00, 0xE0, 0xF6, 0x0E, 0x71, 0xC7, 0x1C, 0x73, 0x87, 0x70, 0x37, 0x03,
  0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x07, 0xF0, 0x7E, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xE0, 0xFE, 0x00, 0xE7, 0x39, 0xCE,
  0x71, 0x8C, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x73, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x0E,
  0xC3, 0x9C, 0xF3, 0xBC, 0x77, 0x07, 0x00, 0x80, 0x7F, 0xEF, 0xFE, 0xFF,
  0xE0, 0x47, 0x3E, 0x20, 0x0F, 0xC7, 0xF9, 0xC7, 0x70, 0xEE, 0x1D, 0xC7,
  0x30, 0xE7, 0x1C, 0xE7, 0x9F, 0xF1, 0xE6, 0x00, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0xE1, 0xFE, 0x38, 0xE7, 0x1D, 0xC3, 0xB8,
  0x77, 0x0E, 0xE3, 0xB8, 0xF7, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xF9, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x8F, 0xF0, 0xFE, 0x00,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xC3, 0xFC,
  0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0xC3, 0x8E, 0x38, 0xE7, 0x8F, 0xF8,
  0x79, 0x80, 0x0F, 0x87, 0xF9, 0xE7, 0x30, 0x6E, 0x1D, 0xFF, 0x3F, 0x87,
  0x00, 0xE0, 0x8F, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x7F, 0xC7, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x3F,
  0xE0, 0xF7, 0x00, 0x70, 0x03, 0x84, 0x38, 0x7F, 0xC1, 0xF8, 0x00, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xF1, 0xFF, 0x38, 0xE7,
  0x1C, 0xE3, 0xB8, 0x77, 0x1C, 0xE3, 0x9C, 0x77, 0x0E, 0xE3, 0x80, 0x0E,
  0x1E, 0x1E, 0x0C, 0x00, 0xFC, 0xFC, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3F, 0x1F, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x04, 0x70, 0xFE, 0x07, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x71, 0xC7, 0x9C, 0x39, 0xC1,
  0xDC, 0x0F, 0x80, 0x7E, 0x07, 0x70, 0x39, 0xC1, 0xCE, 0x0E, 0x38, 0xE1,
  0xC0, 0x7E, 0x7E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x3F, 0x3F, 0x1F, 0x70, 0xFF, 0xC6, 0xEE, 0x77,
  0x73, 0xB3, 0x19, 0x98, 0xCD, 0xCE, 0x0E, 0x70, 0x63, 0x03, 0x18, 0x38,
  0x1F, 0xC7, 0xFC, 0xE3, 0x9C, 0x73, 0x8E, 0xE1, 0xDC, 0x73, 0x8E, 0x71,
  0xDC, 0x3B, 0x8E, 0x00, 0x0F, 0x0F, 0xE7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8E, 0xE7, 0xBF, 0xC7, 0xC0, 0x0F, 0xC1, 0xFE, 0x1C, 0x71, 0xC7,
  0x18, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x39, 0xE7, 0xFC, 0x7F, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC7, 0xFD, 0xE7, 0x38, 0xEE, 0x1D,
  0xC3, 0xB8, 0xE7, 0x1C, 0xE3, 0x9F, 0xF1, 0xFC, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x0F, 0xE7, 0xF8, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0xE3, 0xFC, 0xE0, 0x1C, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x0E, 0x41, 0xCF, 0xF1, 0xFC, 0x00, 0x1C, 0x07,
  0x01, 0xC3, 0xFF, 0xFF, 0x8E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x7F, 0x0F, 0xC0, 0x70, 0xCE, 0x39, 0xC7, 0x38, 0xEE, 0x19, 0xC7,
  0x38, 0xE7, 0x1C, 0xE7, 0x9F, 0xF1, 0xEE, 0x00, 0xE1, 0xF8, 0x7E, 0x3B,
  0x8E, 0xE7, 0x39, 0xCE, 0xE3, 0xF0, 0x7C, 0x1E, 0x07, 0x00, 0xE0, 0x7E,
  0x06, 0xE6, 0x6C, 0xEE, 0xCE, 0xCD, 0xEC, 0xDF, 0xCF, 0x78, 0xE7, 0x8E,
  0x70, 0xC7, 0x00, 0x1C, 0x38, 0xE3, 0x83, 0xB8, 0x1F, 0xC0, 0x7C, 0x03,
  0xC0, 0x3E, 0x03, 0xF8, 0x1D, 0xC1, 0xC7, 0x1C, 0x38, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x01, 0xB8, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0xF1, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xF0, 0x3E, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xF0, 0x1E,
  0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x07, 0x80,
  0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x0F, 0xC0, 0xF8, 0x00, 0x1C, 0x63, 0xE6, 0x7F, 0xEE, 0x7C,
  0x43, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 15, 12, 4, -15 },
  { 15, 8, 7, 12, 5, -16 },
  { 22, 13, 15, 12, 1, -15 },
  { 47, 12, 19, 12, 1, -17 },
  { 76, 15, 15, 12, 0, -15 },
  { 105, 12, 15, 12, 1, -15 },
  { 128, 4, 7, 12, 7, -16 },
  { 132, 10, 21, 12, 3, -17 },
  { 159, 10, 21, 12, 1, -17 },
  { 186, 10, 9, 12, 3, -15 },
  { 198, 10, 10, 12, 2, -12 },
  { 211, 6, 7, 12, 2, -4 },
  { 217, 8, 3, 12, 3, -8 },
  { 220, 4, 4, 12, 4, -4 },
  { 222, 14, 21, 12, 0, -17 },
  { 259, 11, 15, 12, 2, -15 },
  { 280, 9, 15, 12, 2, -15 },
  { 297, 12, 15, 12, 1, -15 },
  { 320, 12, 15, 12, 1, -15 },
  { 343, 12, 15, 12, 1, -15 },
  { 366, 12, 15, 12, 1, -15 },
  { 389, 11, 15, 12, 2, -15 },
  { 410, 11, 15, 12, 3, -15 },
  { 431, 12, 15, 12, 1, -15 },
  { 454, 12, 15, 12, 1, -15 },
  { 477, 6, 11, 12, 4, -11 },
  { 486, 8, 14, 12, 2, -11 },
  { 500, 11, 10, 12, 2, -11 },
  { 514, 12, 6, 12, 1, -10 },
  { 523, 11, 10, 12, 1, -11 },
  { 537, 9, 15, 12, 4, -15 },
  { 554, 12, 18, 12, 1, -15 },
  { 581, 11, 15, 12, 0, -15 },
  { 602, 12, 15, 12, 1, -15 },
  { 625, 12, 15, 12, 2, -15 },
  { 648, 12, 15, 12, 1, -15 },
  { 671, 13, 15, 12, 1, -15 },
  { 696, 13, 15, 12, 1, -15 },
  { 721, 12, 15, 12, 2, -15 },
  { 744, 13, 15, 12, 1, -15 },
  { 769, 13, 15, 12, 1, -15 },
  { 794, 12, 15, 12, 1, -15 },
  { 817, 13, 15, 12, 1, -15 },
  { 842, 10, 15, 12, 1, -15 },
  { 861, 14, 15, 12, 0, -15 },
  { 888, 13, 15, 12, 1, -15 },
  { 913, 11, 15, 12, 2, -15 },
  { 934, 12, 15, 12, 1, -15 },
  { 957, 11, 19, 12, 2, -15 },
  { 984, 12, 15, 12, 1, -15 },
  { 1007, 12, 15, 12, 1, -15 },
  { 1030, 11, 15, 12, 3, -15 },
  { 1051, 12, 15, 12, 2, -15 },
  { 1074, 12, 15, 12, 3, -15 },
  { 1097, 14, 15, 12, 1, -15 },
  { 1124, 15, 15, 12, 0, -15 },
  { 1153, 12, 15, 12, 3, -15 },
  { 1176, 13, 15, 12, 1, -15 },
  { 1201, 12, 21, 12, 2, -17 },
  { 1233, 5, 21, 12, 5, -17 },
  { 1247, 12, 21, 12, 0, -17 },
  { 1279, 11, 9, 12, 2, -15 },
  { 1292, 12, 3, 12, -1, 1 },
  { 1297, 5, 4, 12, 6, -17 },
  { 1300, 11, 11, 12, 2, -11 },
  { 1316, 11, 17, 12, 1, -17 },
  { 1340, 11, 11, 12, 2, -11 },
  { 1356, 12, 17, 12, 2, -17 },
  { 1382, 11, 11, 12, 2, -11 },
  { 1398, 15, 21, 12, -1, -17 },
  { 1438, 13, 15, 12, 0, -11 },
  { 1463, 11, 17, 12, 1, -17 },
  { 1487, 8, 16, 12, 3, -16 },
  { 1503, 12, 20, 12, 0, -16 },
  { 1533, 13, 17, 12, 1, -17 },
  { 1561, 8, 17, 12, 3, -17 },
  { 1578, 13, 11, 12, 0, -11 },
  { 1596, 11, 11, 12, 1, -11 },
  { 1612, 10, 11, 12, 2, -11 },
  { 1626, 12, 15, 12, 0, -11 },
  { 1649, 11, 15, 12, 2, -11 },
  { 1670, 11, 11, 12, 2, -11 },
  { 1686, 11, 11, 12, 1, -11 },
  { 1702, 10, 14, 12, 3, -14 },
  { 1720, 11, 11, 12, 2, -11 },
  { 1736, 10, 11, 12, 3, -11 },
  { 1750, 12, 11, 12, 2, -11 },
  { 1767, 13, 11, 12, 0, -11 },
  { 1785, 14, 15, 12, -1, -11 },
  { 1812, 12, 11, 12, 1, -11 },
  { 1829, 12, 21, 12, 2, -17 },
  { 1861, 8, 21, 12, 3, -17 },
  { 1882, 12, 21, 12, 0, -17 },
  { 1914, 12, 5, 12, 1, -9 },
};

const GFXfont UbuntuMono_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic24pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUMONO_BOLDITALIC24PT7B_H_
