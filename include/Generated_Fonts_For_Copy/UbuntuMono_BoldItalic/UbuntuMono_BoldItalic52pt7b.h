#ifndef _UBUNTUMONO_BOLDITALIC52PT7B_H_
#define _UBUNTUMONO_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x78, 0x00, 0x3F,
  0x8F, 0xE7, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC,
  0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xF0,
  0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0xF8, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x1F, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xF0, 0x0F,
  0xC0, 0x04, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x10, 0x00, 0xFC, 0x0F, 0x80, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0x00,
  0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE7, 0x80, 0xF8, 0x03, 0xC7, 0x81,
  0xF0, 0x07, 0xC7, 0x83, 0xE0, 0x07, 0x87, 0x83, 0xC0, 0x07, 0x87, 0x87,
  0x80, 0x07, 0x8F, 0x0F, 0x80, 0x07, 0x8F, 0x1F, 0x00, 0x07, 0x9F, 0x3E,
  0x00, 0x07, 0xFE, 0x7C, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x03, 0xF8, 0xF0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x1E, 0x3F,
  0xE0, 0x00, 0x3E, 0x7F, 0xE0, 0x00, 0x7C, 0xF9, 0xE0, 0x00, 0xF8, 0xF1,
  0xE0, 0x01, 0xF0, 0xF1, 0xE0, 0x01, 0xE1, 0xE1, 0xE0, 0x03, 0xC1, 0xE1,
  0xE0, 0x07, 0xC1, 0xE1, 0xE0, 0x0F, 0x81, 0xE3, 0xC0, 0x1F, 0x01, 0xE7,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0x78, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE3, 0xF0,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0x83, 0xFF,
  0x07, 0xC3, 0xFF, 0xC3, 0xE3, 0xFF, 0xE3, 0xE3, 0xF1, 0xF9, 0xF1, 0xF0,
  0xFF, 0xF9, 0xF8, 0x3F, 0xF8, 0xF8, 0x0F, 0xF8, 0x7C, 0x07, 0xFC, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x9F, 0xCF, 0xE7, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x30, 0x7C, 0x10, 0xF1, 0xE3, 0xC7, 0xE7,
  0x9F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x07,
  0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3E, 0x1F, 0x00, 0x78, 0x38, 0x00, 0x40,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x3F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x8F, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0x00,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0x1F, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xF9, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x1C,
  0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x7E, 0x7E, 0xFC, 0x7C, 0x7E, 0xFC, 0x78,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0x3F, 0x01, 0xE3, 0xF8, 0x04, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x1C, 0x01, 0xFC,
  0x06, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0x83, 0xFC, 0x02, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x04, 0x00, 0x3F, 0x87, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x80, 0x07, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF3, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFE,
  0x0F, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC7, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFD, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03,
  0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0xC1,
  0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F,
  0xEF, 0xC0, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xC1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC,
  0x1F, 0xE0, 0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xC0, 0xFF,
  0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x1F, 0xFC, 0xFC, 0x1F,
  0xFF, 0x3E, 0x0F, 0xFF, 0xCF, 0x87, 0xFF, 0xE7, 0xC3, 0xFF, 0xF9, 0xF0,
  0xFC, 0x7E, 0x7C, 0x7E, 0x1F, 0x9E, 0x1F, 0x07, 0xCF, 0x8F, 0xC1, 0xF3,
  0xE3, 0xE0, 0xFC, 0xF8, 0xF8, 0x3F, 0x3E, 0x3E, 0x0F, 0x8F, 0x8F, 0x83,
  0xE3, 0xE3, 0xE1, 0xF8, 0xF8, 0xF8, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F,
  0xFF, 0xC3, 0xE1, 0xFF, 0xF0, 0xF8, 0x7F, 0xFC, 0x3E, 0x0F, 0xFE, 0x0F,
  0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x02, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF8,
  0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x70, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xC0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x83, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xE0, 0x1F, 0xC0,
  0x3E, 0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x01, 0xF9, 0xFE,
  0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xBC, 0x7B, 0xC0, 0x3E,
  0xF1, 0xEF, 0x00, 0xFB, 0xCF, 0x7C, 0x03, 0xEF, 0x3D, 0xF0, 0x1F, 0xBD,
  0xE7, 0xC0, 0x7C, 0xF7, 0x9F, 0x01, 0xF1, 0xFC, 0xF8, 0x07, 0xC7, 0xF3,
  0xE0, 0x3F, 0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x3E, 0x03, 0xE1, 0xF1, 0xF8,
  0x1F, 0x87, 0xC7, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xFC, 0x03, 0xF0,
  0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xE0, 0x7E, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0x78, 0x3F, 0x00, 0xFB, 0xE1,
  0xF8, 0x0F, 0xDF, 0x0F, 0xC0, 0x7E, 0xF8, 0x7C, 0x03, 0xE3, 0xC3, 0xE0,
  0x1F, 0x1F, 0x3F, 0x01, 0xF8, 0xF9, 0xF8, 0x0F, 0xC7, 0xCF, 0x80, 0x7E,
  0x1E, 0x7C, 0x03, 0xE0, 0xF7, 0xE0, 0x3F, 0x07, 0xFF, 0x01, 0xF8, 0x3F,
  0xF0, 0x0F, 0xC1, 0xFF, 0x80, 0x7C, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xE0,
  0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0,
  0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x7F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFC,
  0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0x03, 0xC0, 0x3F, 0x00, 0x10, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0xC0, 0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7E, 0x03, 0xE1, 0xE1, 0xF8, 0x1F, 0x8F, 0x87, 0xC0, 0x7E, 0x3E, 0x1F,
  0x01, 0xF1, 0xF8, 0xFC, 0x07, 0xCF, 0xE3, 0xE0, 0x1F, 0x3F, 0x8F, 0x80,
  0xFD, 0xFE, 0x3E, 0x03, 0xE7, 0xBC, 0xF8, 0x0F, 0xBC, 0xF7, 0xC0, 0x3E,
  0xF3, 0xDF, 0x00, 0xF7, 0x8F, 0x7C, 0x07, 0xDE, 0x3D, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80,
  0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF9, 0xF8, 0x07, 0xF1,
  0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x10,
  0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x87, 0xFE, 0x1F, 0xF0, 0x7E, 0x01,
  0xC0, 0x04, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x7E, 0x1F, 0xE0, 0x7E, 0x1F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7E,
  0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFD, 0xFC, 0x07, 0xE0, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0C, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x60, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF,
  0xC0, 0x0F, 0xE1, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0,
  0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x07,
  0xF7, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x0E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x30, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x20, 0x03, 0xF8, 0x03, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x04, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x80, 0x7F, 0x00, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x8F, 0x8F, 0xC3, 0xF1, 0xF1,
  0xF0, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7E,
  0x3E, 0x3F, 0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x0F, 0xC7, 0xC7, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC3, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0x0C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x03, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0x00,
  0x1F, 0x87, 0x80, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x1C, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF9, 0xF8, 0x0F, 0xC1, 0x80, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xFC, 0xFC, 0x3E, 0x1F, 0x1F, 0x87, 0xC3, 0xE3, 0xE1, 0xF8, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0x8F, 0xE3, 0xE1, 0xF1, 0xFC, 0x78, 0x3E, 0x7F, 0x9F,
  0x07, 0xCF, 0xF3, 0xE0, 0xF3, 0xDE, 0x78, 0x1E, 0x7B, 0xDF, 0x03, 0xDE,
  0x7B, 0xE0, 0x7B, 0xCF, 0x78, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0xC0,
  0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x0C, 0x07,
  0xF8, 0x0F, 0xC7, 0xFF, 0x07, 0xC7, 0xFF, 0xC7, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF3, 0xF1, 0xFF, 0xF1, 0xF0, 0x3F, 0xF0, 0x30, 0x0F, 0xF0,
  0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 14, 33, 26, 9, -32 },
  { 59, 19, 15, 26, 10, -35 },
  { 95, 27, 32, 26, 2, -32 },
  { 203, 26, 41, 26, 2, -36 },
  { 337, 32, 34, 26, 0, -33 },
  { 473, 25, 34, 26, 2, -33 },
  { 580, 9, 16, 26, 15, -35 },
  { 598, 21, 47, 26, 7, -37 },
  { 722, 21, 47, 26, 2, -37 },
  { 846, 22, 20, 26, 6, -32 },
  { 901, 24, 23, 26, 3, -25 },
  { 970, 13, 16, 26, 5, -8 },
  { 996, 16, 6, 26, 7, -16 },
  { 1008, 10, 9, 26, 8, -8 },
  { 1020, 31, 45, 26, -1, -36 },
  { 1195, 24, 34, 26, 4, -33 },
  { 1297, 21, 32, 26, 3, -32 },
  { 1381, 26, 33, 26, 2, -33 },
  { 1489, 25, 34, 26, 2, -33 },
  { 1596, 26, 32, 26, 2, -32 },
  { 1700, 27, 33, 26, 2, -32 },
  { 1812, 25, 33, 26, 4, -32 },
  { 1916, 25, 32, 26, 6, -32 },
  { 2016, 25, 34, 26, 3, -33 },
  { 2123, 25, 33, 26, 3, -33 },
  { 2227, 13, 25, 26, 8, -24 },
  { 2268, 16, 32, 26, 5, -24 },
  { 2332, 24, 23, 26, 4, -24 },
  { 2401, 26, 15, 26, 2, -21 },
  { 2450, 23, 23, 26, 3, -24 },
  { 2517, 20, 34, 26, 8, -33 },
  { 2602, 26, 40, 26, 3, -33 },
  { 2732, 25, 32, 26, 0, -32 },
  { 2832, 26, 33, 26, 2, -32 },
  { 2940, 25, 34, 26, 5, -33 },
  { 3047, 26, 34, 26, 2, -33 },
  { 3158, 27, 32, 26, 3, -32 },
  { 3266, 27, 32, 26, 3, -32 },
  { 3374, 26, 34, 26, 4, -33 },
  { 3485, 29, 32, 26, 1, -32 },
  { 3601, 28, 32, 26, 2, -32 },
  { 3713, 27, 33, 26, 2, -32 },
  { 3825, 29, 32, 26, 2, -32 },
  { 3941, 22, 32, 26, 2, -32 },
  { 4029, 30, 32, 26, 0, -32 },
  { 4149, 29, 32, 26, 1, -32 },
  { 4265, 25, 34, 26, 3, -33 },
  { 4372, 27, 32, 26, 2, -32 },
  { 4480, 24, 43, 26, 4, -33 },
  { 4609, 26, 32, 26, 2, -32 },
  { 4713, 26, 34, 26, 2, -33 },
  { 4824, 24, 32, 26, 7, -32 },
  { 4920, 27, 33, 26, 3, -32 },
  { 5032, 25, 32, 26, 7, -32 },
  { 5132, 30, 32, 26, 2, -32 },
  { 5252, 32, 32, 26, 0, -32 },
  { 5380, 25, 32, 26, 7, -32 },
  { 5480, 29, 32, 26, 1, -32 },
  { 5596, 25, 45, 26, 5, -36 },
  { 5737, 10, 45, 26, 11, -36 },
  { 5794, 25, 45, 26, 1, -36 },
  { 5935, 24, 19, 26, 4, -32 },
  { 5992, 25, 6, 26, -2, 3 },
  { 6011, 12, 10, 26, 12, -36 },
  { 6026, 24, 26, 26, 3, -25 },
  { 6104, 24, 38, 26, 2, -37 },
  { 6218, 24, 26, 26, 4, -25 },
  { 6296, 27, 38, 26, 3, -37 },
  { 6425, 23, 26, 26, 4, -25 },
  { 6500, 33, 47, 26, -2, -37 },
  { 6694, 28, 35, 26, 0, -25 },
  { 6817, 24, 37, 26, 2, -37 },
  { 6928, 18, 36, 26, 6, -35 },
  { 7009, 25, 45, 26, 0, -35 },
  { 7150, 26, 37, 26, 3, -37 },
  { 7271, 16, 37, 26, 8, -36 },
  { 7345, 27, 24, 26, 1, -24 },
  { 7426, 24, 25, 26, 2, -25 },
  { 7501, 23, 26, 26, 3, -25 },
  { 7576, 26, 34, 26, 0, -25 },
  { 7687, 24, 34, 26, 4, -25 },
  { 7789, 24, 25, 26, 4, -25 },
  { 7864, 23, 26, 26, 3, -25 },
  { 7939, 22, 32, 26, 6, -31 },
  { 8027, 23, 25, 26, 4, -24 },
  { 8099, 23, 24, 26, 6, -24 },
  { 8168, 27, 24, 26, 3, -24 },
  { 8249, 28, 24, 26, 1, -24 },
  { 8333, 31, 34, 26, -2, -24 },
  { 8465, 25, 24, 26, 3, -24 },
  { 8540, 25, 45, 26, 5, -36 },
  { 8681, 18, 45, 26, 6, -36 },
  { 8783, 25, 45, 26, 0, -36 },
  { 8924, 25, 10, 26, 3, -19 },
};

const GFXfont UbuntuMono_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic52pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUMONO_BOLDITALIC52PT7B_H_
