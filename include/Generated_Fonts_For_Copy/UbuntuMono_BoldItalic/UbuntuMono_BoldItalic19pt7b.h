#ifndef _UBUNTUMONO_BOLDITALIC19PT7B_H_
#define _UBUNTUMONO_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x98, 0xCE, 0x60, 0x39, 0xC0, 0xED, 0x9B, 0x36,
  0x49, 0x80, 0x0C, 0xC3, 0x61, 0x99, 0xFF, 0x7F, 0x8C, 0xC3, 0x63, 0xFE,
  0xFF, 0x13, 0x0C, 0xC3, 0x60, 0x06, 0x03, 0x07, 0xE7, 0xF3, 0x01, 0x80,
  0xE0, 0x78, 0x1F, 0x03, 0x80, 0xDF, 0xE7, 0xC1, 0x80, 0xC0, 0x1C, 0x23,
  0x44, 0x24, 0xC2, 0x58, 0x2F, 0x03, 0xE0, 0x05, 0x80, 0xAC, 0x1A, 0xC3,
  0x6C, 0x62, 0x8C, 0x38, 0x0E, 0x0F, 0x8C, 0xC6, 0x63, 0x60, 0xE1, 0xE7,
  0x9E, 0xCF, 0x63, 0x3F, 0xCF, 0x60, 0x66, 0x6E, 0xCC, 0x06, 0x1C, 0x71,
  0xC7, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x10, 0x08,
  0x18, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0xE3, 0x8E, 0x38,
  0x60, 0x18, 0x18, 0x6B, 0xFF, 0x1C, 0x76, 0x24, 0x0C, 0x06, 0x03, 0x0F,
  0xFF, 0xF0, 0xC0, 0x60, 0x30, 0x37, 0x73, 0xE8, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x0F, 0x0F,
  0xCC, 0x6E, 0x36, 0x1B, 0x6D, 0xB7, 0xC7, 0xE3, 0x73, 0x9F, 0x87, 0x80,
  0x07, 0x0E, 0x3E, 0x36, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x7F, 0xFE,
  0x1F, 0x1F, 0xCC, 0x60, 0x30, 0x38, 0x38, 0x38, 0x78, 0x70, 0x30, 0x3F,
  0xDF, 0xE0, 0x1F, 0x1F, 0xC0, 0xE0, 0x30, 0x30, 0xF0, 0x78, 0x0E, 0x03,
  0x43, 0xBF, 0x9F, 0x80, 0x03, 0x83, 0xC3, 0xE3, 0xE3, 0xB1, 0x99, 0x8D,
  0xFF, 0xFF, 0x83, 0x01, 0x81, 0xC0, 0x1F, 0x87, 0xE1, 0x80, 0xC0, 0x3C,
  0x0F, 0x80, 0x70, 0x0C, 0x03, 0x21, 0xCF, 0xE3, 0xF0, 0x03, 0x83, 0xE3,
  0xC0, 0xC0, 0x7E, 0x1F, 0xC6, 0x3B, 0x8E, 0xE3, 0x18, 0xC7, 0xF0, 0xF0,
  0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x00, 0x0F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0xF8, 0xF8, 0xCE, 0xC3,
  0x71, 0xBF, 0xCF, 0x80, 0x1E, 0x1F, 0x9C, 0xEC, 0x36, 0x1B, 0x8D, 0xFE,
  0x7E, 0x07, 0x07, 0x3F, 0x1E, 0x00, 0x3B, 0xCC, 0x00, 0x01, 0x9C, 0xE0,
  0x1C, 0xF1, 0x80, 0x00, 0x03, 0x1C, 0x70, 0xCE, 0x20, 0x00, 0x83, 0xCF,
  0xCF, 0x07, 0x01, 0xF0, 0x3C, 0x04, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7,
  0xF8, 0x20, 0x3C, 0x0F, 0x80, 0xF0, 0xF3, 0xF3, 0xC1, 0x00, 0x7C, 0xFC,
  0x38, 0x30, 0xE3, 0x8E, 0x38, 0x60, 0x03, 0x87, 0x00, 0x0F, 0x07, 0xE3,
  0x9D, 0x83, 0x67, 0x93, 0xED, 0xDB, 0x66, 0xD9, 0xB6, 0xCD, 0xF3, 0x3C,
  0x60, 0x1F, 0x83, 0xE0, 0x03, 0x03, 0xC3, 0xE1, 0xB1, 0x98, 0xCC, 0xE6,
  0x7F, 0x7F, 0xB0, 0xD8, 0x78, 0x30, 0x3F, 0x1F, 0xCC, 0x66, 0x37, 0x3B,
  0xF9, 0xFC, 0xC6, 0xE3, 0xF1, 0xBF, 0xDF, 0x80, 0x0F, 0x1F, 0xDC, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x71, 0x3F, 0x8F, 0x80, 0x3E, 0x1F,
  0x8C, 0xE6, 0x37, 0x1B, 0x0D, 0x8E, 0xC7, 0xE3, 0x63, 0xBF, 0x9F, 0x00,
  0x1F, 0xCF, 0xE3, 0x80, 0xC0, 0x30, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18,
  0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF3, 0x80, 0xC0, 0x30, 0x0F, 0xC7, 0xF1,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x07, 0x87, 0xF3, 0x80, 0xC0, 0x60,
  0x18, 0x06, 0x3B, 0x8C, 0x63, 0x18, 0xC7, 0xF0, 0xF8, 0x1C, 0x63, 0x1C,
  0x63, 0x8C, 0x63, 0x8C, 0x7F, 0x8F, 0xF1, 0x8C, 0x71, 0x8C, 0x31, 0x8E,
  0x31, 0x80, 0x3F, 0xCF, 0xF0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x8F, 0xE1, 0xE0, 0x39, 0xCC, 0x63, 0x38,
  0xDC, 0x7E, 0x1F, 0x07, 0xC1, 0xB8, 0xEE, 0x39, 0x8C, 0x73, 0x0C, 0x18,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xFE, 0xFE, 0x1C,
  0x63, 0x9C, 0x73, 0x9E, 0xE3, 0x5C, 0x6F, 0x8D, 0xB3, 0x36, 0x61, 0x8C,
  0x31, 0x86, 0x60, 0xC0, 0x18, 0x63, 0x8C, 0x73, 0x9E, 0x63, 0x6C, 0x6D,
  0x8D, 0xB1, 0x9C, 0x63, 0x8C, 0x71, 0x8E, 0x31, 0x80, 0x0F, 0x0F, 0xCC,
  0x6E, 0x36, 0x1B, 0x0F, 0x87, 0xC7, 0xE3, 0x73, 0x9F, 0x87, 0x80, 0x3F,
  0x0F, 0xE3, 0x18, 0xC7, 0x31, 0x9C, 0xE7, 0xF1, 0xF8, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0x0F, 0x0F, 0xCC, 0x6E, 0x36, 0x1B, 0x0F, 0x87, 0xC7, 0xE3,
  0x73, 0x9F, 0x87, 0x83, 0x80, 0xF0, 0x30, 0x3F, 0x1F, 0xCC, 0xE6, 0x37,
  0x1B, 0x99, 0xFC, 0xF8, 0xEE, 0x73, 0x31, 0xD8, 0x60, 0x0F, 0x9F, 0xCC,
  0x06, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x03, 0x43, 0xBF, 0x8F, 0x80, 0x7F,
  0xBF, 0xC7, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x00, 0x30, 0xCC, 0x73, 0x19, 0xC6, 0x71, 0x98, 0xE6, 0x33, 0x8C, 0xE3,
  0x39, 0xC7, 0xE1, 0xF0, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0x63, 0x31,
  0xB0, 0xD8, 0x78, 0x3C, 0x1C, 0x00, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x66,
  0xD8, 0xDB, 0x17, 0x66, 0xAC, 0xF5, 0x1C, 0xE3, 0x9C, 0x63, 0x00, 0x18,
  0x61, 0xCE, 0x0D, 0xC0, 0xF8, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3B,
  0x03, 0xB8, 0x73, 0x8E, 0x18, 0xC3, 0x63, 0xB1, 0x9D, 0x87, 0xC3, 0xC1,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x3F, 0xCF, 0xE0, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0F, 0xF3, 0xF8, 0x0F, 0x8F,
  0xC6, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0xE1, 0xF0, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x77,
  0x0F, 0x83, 0xE0, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x07, 0xC3, 0xF0, 0x06, 0x07, 0x87, 0xC7,
  0x67, 0x3B, 0x0C, 0x04, 0x7F, 0xBF, 0xC0, 0x8C, 0x72, 0x1F, 0x9F, 0xDC,
  0xCC, 0x6E, 0x37, 0x3B, 0x9C, 0xFE, 0x7B, 0x00, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0xE3, 0xF9, 0xCC, 0xC7, 0x63, 0x71, 0xB9, 0xDF, 0xCF, 0x80, 0x0F,
  0x9F, 0xDC, 0x0C, 0x06, 0x07, 0x01, 0x80, 0xFE, 0x3E, 0x00, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x1F, 0x8F, 0xE7, 0x31, 0x8C, 0xE3, 0x39, 0xCE, 0x71,
  0xFC, 0x7B, 0x00, 0x0F, 0x1F, 0xDC, 0x6C, 0x7F, 0xF7, 0xC1, 0x80, 0xFC,
  0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x30, 0x0F, 0xE1, 0xFE, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x78,
  0x0F, 0x00, 0x0F, 0xC7, 0xF3, 0x9C, 0xC6, 0x71, 0x9C, 0xE3, 0xF8, 0xFC,
  0x03, 0x01, 0xCF, 0xE1, 0xF0, 0x18, 0x18, 0x38, 0x30, 0x3F, 0x3F, 0x73,
  0x63, 0x63, 0x63, 0xE7, 0xE6, 0xC6, 0x1C, 0x38, 0x07, 0xCF, 0x87, 0x0E,
  0x18, 0x30, 0x60, 0xF9, 0xF0, 0x03, 0x81, 0xC0, 0x03, 0xF1, 0xF8, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC8, 0xE7, 0xE1, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x31, 0x8C, 0xC3, 0x61, 0xF0, 0x7C, 0x1B, 0x06, 0xE3,
  0x98, 0xC7, 0x00, 0xFB, 0xE3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x8E, 0x3F,
  0x78, 0x3D, 0xCF, 0xF3, 0x6C, 0xDB, 0x64, 0xDB, 0x66, 0x19, 0x86, 0x41,
  0x80, 0x3F, 0x3F, 0x73, 0x73, 0x63, 0x63, 0xE7, 0xE6, 0xC6, 0x1E, 0x1F,
  0x9C, 0xEC, 0x7E, 0x37, 0x1B, 0x9C, 0xFC, 0x7C, 0x00, 0x1F, 0x07, 0xE3,
  0x9C, 0xC7, 0x31, 0x8C, 0x67, 0x39, 0xFC, 0x7E, 0x18, 0x0E, 0x03, 0x00,
  0x0F, 0x9F, 0xDC, 0xEC, 0x6E, 0x37, 0x1B, 0x9C, 0xFC, 0x7E, 0x03, 0x03,
  0x81, 0x80, 0x1F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x00, 0x1F, 0x1F, 0x8C, 0x07, 0x03, 0xE0, 0x38, 0x1D, 0xFC, 0x7C, 0x00,
  0x18, 0x18, 0x38, 0xFF, 0xFF, 0x30, 0x70, 0x70, 0x60, 0x60, 0x7E, 0x3E,
  0x31, 0xB9, 0xDC, 0xCC, 0x66, 0x37, 0x3B, 0x9C, 0xFE, 0x7B, 0x00, 0xC3,
  0x73, 0xB9, 0x9C, 0xCE, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x00, 0x60, 0xD8,
  0x24, 0xD9, 0x36, 0xDD, 0x35, 0xCF, 0x73, 0x98, 0xC6, 0x00, 0x38, 0xC6,
  0x61, 0xF8, 0x3C, 0x0E, 0x07, 0x83, 0xF0, 0xCC, 0x63, 0x80, 0x1C, 0x63,
  0x9C, 0x73, 0x0E, 0x60, 0xDC, 0x1B, 0x03, 0xE0, 0x78, 0x0E, 0x01, 0x81,
  0xE0, 0x78, 0x00, 0x3F, 0x9F, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFC,
  0xFE, 0x00, 0x07, 0x87, 0xC3, 0x03, 0x81, 0x80, 0xC0, 0xE1, 0xE0, 0xE0,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0xF0, 0x70, 0x0E, 0x18, 0x30, 0xE1,
  0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0x0E, 0x0F,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x07, 0x07, 0x87, 0x03, 0x01, 0x80,
  0xC0, 0xC3, 0xE1, 0xE0, 0x39, 0xBF, 0xB3, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 7, 5, 10, 4, -13 },
  { 14, 10, 12, 10, 1, -12 },
  { 29, 9, 15, 10, 1, -13 },
  { 46, 12, 12, 10, 0, -12 },
  { 64, 9, 12, 10, 1, -12 },
  { 78, 4, 6, 10, 5, -13 },
  { 81, 7, 16, 10, 3, -13 },
  { 95, 7, 16, 10, 1, -13 },
  { 109, 8, 7, 10, 2, -12 },
  { 116, 9, 8, 10, 1, -9 },
  { 125, 4, 6, 10, 2, -3 },
  { 128, 5, 2, 10, 3, -6 },
  { 130, 3, 3, 10, 3, -3 },
  { 132, 11, 16, 10, 0, -13 },
  { 154, 9, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 9, 12, 10, 1, -12 },
  { 194, 9, 12, 10, 1, -12 },
  { 208, 9, 12, 10, 1, -12 },
  { 222, 10, 12, 10, 1, -12 },
  { 237, 10, 12, 10, 1, -12 },
  { 252, 9, 12, 10, 2, -12 },
  { 266, 9, 12, 10, 1, -12 },
  { 280, 9, 12, 10, 1, -12 },
  { 294, 5, 9, 10, 3, -9 },
  { 300, 6, 12, 10, 2, -9 },
  { 309, 9, 8, 10, 1, -9 },
  { 318, 9, 6, 10, 1, -8 },
  { 325, 9, 8, 10, 1, -9 },
  { 334, 7, 12, 10, 3, -12 },
  { 345, 10, 15, 10, 1, -12 },
  { 364, 9, 12, 10, 0, -12 },
  { 378, 9, 12, 10, 1, -12 },
  { 392, 9, 12, 10, 2, -12 },
  { 406, 9, 12, 10, 1, -12 },
  { 420, 10, 12, 10, 1, -12 },
  { 435, 10, 12, 10, 1, -12 },
  { 450, 10, 12, 10, 1, -12 },
  { 465, 11, 12, 10, 0, -12 },
  { 482, 10, 12, 10, 1, -12 },
  { 497, 10, 12, 10, 1, -12 },
  { 512, 10, 12, 10, 1, -12 },
  { 527, 8, 12, 10, 1, -12 },
  { 539, 11, 12, 10, 0, -12 },
  { 556, 11, 12, 10, 0, -12 },
  { 573, 9, 12, 10, 1, -12 },
  { 587, 10, 12, 10, 1, -12 },
  { 602, 9, 15, 10, 1, -12 },
  { 619, 9, 12, 10, 1, -12 },
  { 633, 9, 12, 10, 1, -12 },
  { 647, 9, 12, 10, 2, -12 },
  { 661, 10, 12, 10, 1, -12 },
  { 676, 9, 12, 10, 3, -12 },
  { 690, 11, 12, 10, 1, -12 },
  { 707, 12, 12, 10, 0, -12 },
  { 725, 9, 12, 10, 3, -12 },
  { 739, 10, 12, 10, 1, -12 },
  { 754, 9, 16, 10, 2, -13 },
  { 772, 4, 16, 10, 4, -13 },
  { 780, 10, 16, 10, 0, -13 },
  { 800, 9, 7, 10, 1, -12 },
  { 808, 9, 2, 10, -1, 1 },
  { 811, 4, 4, 10, 5, -13 },
  { 813, 9, 9, 10, 1, -9 },
  { 824, 9, 13, 10, 1, -13 },
  { 839, 9, 9, 10, 1, -9 },
  { 850, 10, 13, 10, 1, -13 },
  { 867, 9, 9, 10, 1, -9 },
  { 878, 12, 16, 10, -1, -13 },
  { 902, 10, 12, 10, 0, -9 },
  { 917, 8, 13, 10, 1, -13 },
  { 930, 7, 12, 10, 2, -12 },
  { 941, 9, 15, 10, 0, -12 },
  { 958, 10, 13, 10, 1, -13 },
  { 975, 6, 13, 10, 3, -13 },
  { 985, 10, 9, 10, 0, -9 },
  { 997, 8, 9, 10, 1, -9 },
  { 1006, 9, 9, 10, 1, -9 },
  { 1017, 10, 12, 10, 0, -9 },
  { 1032, 9, 12, 10, 1, -9 },
  { 1046, 9, 9, 10, 1, -9 },
  { 1057, 9, 9, 10, 1, -9 },
  { 1068, 8, 12, 10, 2, -12 },
  { 1080, 9, 9, 10, 1, -9 },
  { 1091, 9, 9, 10, 2, -9 },
  { 1102, 10, 9, 10, 1, -9 },
  { 1114, 10, 9, 10, 0, -9 },
  { 1126, 11, 12, 10, -1, -9 },
  { 1143, 9, 9, 10, 1, -9 },
  { 1154, 9, 16, 10, 2, -13 },
  { 1172, 7, 16, 10, 2, -13 },
  { 1186, 9, 16, 10, 0, -13 },
  { 1204, 9, 3, 10, 1, -7 },
};

const GFXfont UbuntuMono_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic19pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUMONO_BOLDITALIC19PT7B_H_
