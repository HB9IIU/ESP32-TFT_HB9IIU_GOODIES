#ifndef _UBUNTUMONO_BOLDITALIC7PT7B_H_
#define _UBUNTUMONO_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x52, 0x34, 0x56, 0xFA, 0x25, 0x42, 0xE4, 0xF6, 0x7A, 0x76, 0xAE,
  0xC0, 0x2A, 0x49, 0x00, 0x24, 0x95, 0x80, 0xE8, 0x2E, 0x40, 0xC0, 0xC0,
  0x80, 0x12, 0x24, 0x48, 0x77, 0x96, 0x64, 0xB0, 0x72, 0x4E, 0x32, 0x2E,
  0x36, 0xF2, 0x66, 0x2E, 0xFA, 0xE0, 0xEA, 0x40, 0x76, 0xA6, 0x75, 0x2E,
  0x48, 0x4A, 0x71, 0x00, 0x7E, 0x66, 0x80, 0xE8, 0x40, 0x7B, 0xDA, 0x60,
  0x2D, 0xD0, 0x76, 0x5E, 0xD2, 0x60, 0x75, 0x9E, 0x66, 0x4E, 0x76, 0x48,
  0xD3, 0x60, 0x57, 0xAA, 0x32, 0x4E, 0x31, 0x2E, 0x56, 0xAA, 0x49, 0x70,
  0x57, 0x9A, 0x55, 0xAA, 0x75, 0x96, 0x75, 0x68, 0x75, 0x96, 0x40, 0x75,
  0x6A, 0x66, 0x2E, 0xEA, 0x40, 0x55, 0xA6, 0xB7, 0x40, 0x57, 0x6A, 0x52,
  0x6A, 0xBA, 0x40, 0x32, 0x4E, 0x6A, 0x49, 0x80, 0xA5, 0x50, 0x62, 0x22,
  0x2C, 0x54, 0xE0, 0x80, 0x7A, 0x60, 0x44, 0x65, 0xE0, 0xD3, 0x00, 0x11,
  0x7A, 0x60, 0xFB, 0x00, 0x32, 0x44, 0x4C, 0x7A, 0x6E, 0x49, 0xBA, 0x4E,
  0xC0, 0x21, 0x93, 0x80, 0x44, 0x66, 0xA0, 0xDA, 0xC0, 0x79, 0xA0, 0x6E,
  0x80, 0x79, 0x60, 0x75, 0xE8, 0x7A, 0x62, 0x64, 0x40, 0x66, 0xE0, 0x52,
  0x60, 0xBB, 0x00, 0xBA, 0x00, 0xB6, 0xA0, 0x66, 0xA0, 0x56, 0x4C, 0x34,
  0xE0, 0x69, 0x49, 0x80, 0x56, 0xA0, 0x64, 0x95, 0x80, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 3, 2, 4, 1, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 2, -5 },
  { 13, 3, 6, 4, 1, -5 },
  { 16, 3, 6, 4, 0, -5 },
  { 19, 3, 2, 4, 1, -4 },
  { 20, 4, 3, 4, 0, -3 },
  { 22, 1, 2, 4, 1, -1 },
  { 23, 2, 1, 4, 1, -2 },
  { 24, 1, 1, 4, 1, -1 },
  { 25, 4, 6, 4, 0, -5 },
  { 28, 4, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 4, 4, 4, 0, -4 },
  { 34, 4, 4, 4, 0, -4 },
  { 36, 4, 4, 4, 0, -4 },
  { 38, 4, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 1, -4 },
  { 42, 3, 4, 4, 1, -4 },
  { 44, 4, 4, 4, 0, -4 },
  { 46, 4, 4, 4, 0, -4 },
  { 48, 2, 3, 4, 1, -3 },
  { 49, 2, 4, 4, 1, -3 },
  { 50, 3, 3, 4, 1, -3 },
  { 52, 4, 2, 4, 0, -3 },
  { 53, 4, 3, 4, 0, -3 },
  { 55, 3, 4, 4, 1, -4 },
  { 57, 4, 5, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 1, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 1, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 4, 4, 4, 0, -4 },
  { 92, 4, 5, 4, 0, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 4, 4, 4, 0, -4 },
  { 99, 3, 4, 4, 1, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 3, 4, 4, 1, -4 },
  { 105, 4, 4, 4, 0, -4 },
  { 107, 4, 4, 4, 0, -4 },
  { 109, 3, 4, 4, 1, -4 },
  { 111, 4, 4, 4, 0, -4 },
  { 113, 3, 6, 4, 1, -5 },
  { 116, 2, 6, 4, 1, -5 },
  { 118, 4, 6, 4, 0, -5 },
  { 121, 3, 2, 4, 1, -4 },
  { 122, 3, 1, 4, 0, 0 },
  { 123, 1, 1, 4, 2, -5 },
  { 124, 4, 3, 4, 0, -3 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 3, 3, 4, 1, -3 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 3, 3, 4, 1, -3 },
  { 136, 4, 6, 4, 0, -5 },
  { 139, 4, 4, 4, 0, -3 },
  { 141, 3, 5, 4, 0, -5 },
  { 143, 2, 5, 4, 1, -5 },
  { 145, 3, 6, 4, 0, -5 },
  { 148, 4, 5, 4, 0, -5 },
  { 151, 2, 5, 4, 1, -5 },
  { 153, 4, 3, 4, 0, -3 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 4, 3, 4, 0, -3 },
  { 159, 4, 4, 4, 0, -3 },
  { 161, 4, 4, 4, 0, -3 },
  { 163, 4, 3, 4, 0, -3 },
  { 165, 4, 3, 4, 0, -3 },
  { 167, 3, 4, 4, 1, -4 },
  { 169, 3, 3, 4, 1, -3 },
  { 171, 3, 3, 4, 1, -3 },
  { 173, 4, 3, 4, 0, -3 },
  { 175, 4, 3, 4, 0, -3 },
  { 177, 4, 4, 4, 0, -3 },
  { 179, 4, 3, 4, 0, -3 },
  { 181, 3, 6, 4, 1, -5 },
  { 184, 2, 6, 4, 1, -5 },
  { 186, 3, 6, 4, 0, -5 },
  { 189, 4, 1, 4, 0, -2 },
};

const GFXfont UbuntuMono_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic7pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUMONO_BOLDITALIC7PT7B_H_
