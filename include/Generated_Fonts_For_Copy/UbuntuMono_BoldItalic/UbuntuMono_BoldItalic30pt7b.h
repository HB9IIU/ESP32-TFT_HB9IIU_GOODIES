#ifndef _UBUNTUMONO_BOLDITALIC30PT7B_H_
#define _UBUNTUMONO_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0x79, 0xFE, 0x7B, 0xCF,
  0x79, 0xEE, 0x39, 0xC7, 0x38, 0xE6, 0x18, 0x01, 0xC7, 0x01, 0xCE, 0x01,
  0xCE, 0x03, 0x8E, 0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x0E,
  0x38, 0x0E, 0x70, 0x1C, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x39,
  0xC0, 0x71, 0xC0, 0x73, 0x80, 0xF3, 0x80, 0xE3, 0x80, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0x87, 0xC3, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0xC0, 0xF1, 0xFF, 0xE7, 0xFF, 0x81, 0xFC,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x81, 0xC3, 0xF0, 0xE0, 0xDC,
  0x30, 0x77, 0x18, 0x19, 0xCE, 0x06, 0x67, 0x01, 0x9B, 0x80, 0x7C, 0xC0,
  0x0E, 0x60, 0x00, 0x38, 0x00, 0x1D, 0xE0, 0x0E, 0xF8, 0x07, 0x77, 0x01,
  0x99, 0xC0, 0xE6, 0x70, 0x71, 0x98, 0x38, 0x6E, 0x1C, 0x1F, 0x06, 0x03,
  0x80, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x9E, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0x10, 0xFE, 0x3B, 0xDE, 0xE7,
  0x1D, 0xDE, 0x1F, 0x3C, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0xFF, 0x70, 0xFC,
  0xE0, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x38, 0xE0, 0x00, 0x20, 0x0E, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0x01,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x70,
  0x06, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x04, 0x66, 0xF6, 0xEF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x3F, 0x87, 0x9C, 0x39, 0xC1, 0x08, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xE1, 0x8F,
  0x7C, 0xE0, 0x7F, 0xBF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF,
  0x87, 0x8F, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xDE, 0xE7, 0x73, 0xBF, 0xCC,
  0xFF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x78, 0x7F,
  0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x07, 0xE1, 0xFE, 0x3F,
  0xE1, 0xDE, 0x11, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x0F, 0xF8, 0x7F, 0xF8, 0x70, 0xF0, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x21, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x03,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x30, 0x7C, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7B, 0x81, 0xEF, 0x07,
  0x9E, 0x0E, 0x38, 0x38, 0x70, 0xE1, 0xE3, 0xC3, 0xC7, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x60, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0x80,
  0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x3D, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xCF, 0x03,
  0x9E, 0x0F, 0x3C, 0x1E, 0x3C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00,
  0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C, 0x1C, 0xF0, 0x71, 0xC3, 0x87, 0xFE,
  0x0F, 0xE0, 0x7F, 0x83, 0x9F, 0x1C, 0x3C, 0xF0, 0x7B, 0x81, 0xEE, 0x07,
  0x3C, 0x3C, 0xFF, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x1F, 0x38, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3C,
  0xFF, 0xF3, 0xFF, 0x83, 0xDE, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x7C, 0xF9, 0xF1, 0xC0, 0x00,
  0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x8E, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x30,
  0x78, 0xF8, 0x70, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xF8, 0x07, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3C, 0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF8, 0x30, 0x01, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xE0, 0x7F, 0x0F, 0xF3, 0xFC,
  0x3F, 0x01, 0xE0, 0x08, 0x00, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0xB0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDC, 0x3F, 0xB9, 0xFE,
  0xE3, 0xFD, 0xCF, 0x3B, 0x9C, 0x77, 0x71, 0xCE, 0xE3, 0x99, 0xC7, 0x33,
  0xCE, 0x73, 0xF8, 0xE7, 0xF1, 0xC7, 0xE3, 0xC0, 0x03, 0xC0, 0x07, 0xFC,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0x1C, 0x3C, 0x70, 0xE1,
  0xC7, 0x87, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xDE, 0x07, 0x78, 0x1F, 0xC0,
  0x7F, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE0,
  0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1,
  0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x7F, 0xF9, 0xFF,
  0xE1, 0xFE, 0x00, 0x01, 0xF0, 0x1F, 0xF1, 0xFF, 0xCF, 0x82, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x10, 0x7F, 0xE1, 0xFF, 0x81, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xC1, 0xE7,
  0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x38, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF8, 0xF8, 0x21, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x73, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x3C, 0x78, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x00, 0x0F, 0x07, 0x07, 0x83, 0x83, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x3C, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x61, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x00,
  0x0F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xC7, 0x81, 0xE7, 0xC0, 0xF3,
  0xC0, 0x7B, 0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0x3C, 0x07, 0x9E, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE0, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC,
  0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0xD8, 0x36, 0x7C, 0x3B, 0x6E, 0x1D, 0xF7, 0x0E, 0xF3, 0x8E, 0x7B, 0xC7,
  0x39, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x3C, 0x70, 0x1C,
  0x38, 0x0E, 0x3C, 0x07, 0x00, 0x0F, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC3,
  0xE1, 0xE1, 0xF8, 0xF0, 0xFC, 0x70, 0x7E, 0x38, 0x7B, 0x1C, 0x3D, 0xDE,
  0x1C, 0xEE, 0x0E, 0x77, 0x07, 0x1B, 0x87, 0x8F, 0xC3, 0x87, 0xC1, 0xC3,
  0xE0, 0xE1, 0xF0, 0xF0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x03, 0xE0,
  0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x3C, 0x78, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0E, 0x1E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E,
  0x1C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xC0, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x3C, 0x78, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x70, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x71, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x3C, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x03, 0x9E, 0x0F, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0x70, 0x79,
  0xE0, 0xF3, 0xC1, 0xE0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x78, 0x61,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x30, 0x7C, 0xFF, 0xF1,
  0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x0E, 0x38, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xC7,
  0x87, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9C,
  0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0xE0, 0x3C, 0x73, 0x9C, 0x39, 0xCE, 0x1D, 0xE7, 0x1C,
  0xF3, 0x0E, 0xDB, 0x87, 0x6D, 0xC3, 0xE6, 0xE1, 0xB3, 0xE0, 0xF1, 0xF0,
  0xF8, 0xF8, 0x78, 0x38, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0x0E, 0x3C, 0x03, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x03, 0xDE, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F,
  0x81, 0xC0, 0xF0, 0x3D, 0xE0, 0x79, 0xC1, 0xE3, 0x83, 0x87, 0x0F, 0x0F,
  0x3C, 0x1E, 0x78, 0x1D, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x00, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x79,
  0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3, 0xCF, 0x3C, 0xF0, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0x70, 0x79, 0xE3, 0xE7, 0x8F,
  0x0E, 0x78, 0x3D, 0xC0, 0xF0, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x20, 0xE3, 0xE3, 0xE1, 0xC0, 0x80, 0x03, 0xF0, 0x3F, 0xF3, 0xFF,
  0x8F, 0x1E, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x1F, 0x3F, 0xFC, 0x7F, 0xF0, 0xF9, 0xC0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xF8,
  0x7F, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xDE, 0x0F,
  0x78, 0x79, 0xE3, 0xE7, 0xFF, 0x3F, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0xF1, 0xFF, 0x8F, 0x82, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0x78,
  0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3E, 0x70, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x78,
  0x3D, 0xC1, 0xEF, 0xFF, 0xBF, 0xF8, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x78, 0x00,
  0x70, 0x40, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x3C, 0xF0, 0xF0, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x1F, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0x7F,
  0x8F, 0xF0, 0xFC, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x84, 0x3C, 0x3F, 0xF0, 0xFF, 0x81, 0xF8,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x1F, 0x3C, 0x7C, 0x78, 0xF0, 0xF7, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0xC3, 0xC7,
  0x87, 0x87, 0x8E, 0x0F, 0x00, 0x7F, 0x9F, 0xCF, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0xFC, 0xFF, 0x1F, 0x80, 0x0F, 0xBC, 0x3F, 0xFC,
  0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0x9E, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x00, 0x07,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0xF3, 0xC3, 0xC0,
  0x07, 0xE0, 0x7F, 0x8F, 0xFE, 0x78, 0xF7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x7D, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8E, 0x0F, 0x1C, 0x1E, 0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F,
  0xF8, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x0E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC,
  0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x7F,
  0xF1, 0xFF, 0x87, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0xF0, 0xFF, 0x87, 0x82, 0x1E, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xF0, 0x01, 0xE2, 0x0F, 0x1F, 0xFC, 0x7F, 0xE0, 0xFE, 0x00, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xC3, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x87,
  0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x3C, 0x3C, 0xF0, 0xE3, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xE1, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E,
  0x3F, 0xFC, 0x7F, 0xF0, 0xF9, 0x80, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC,
  0x3C, 0x70, 0xF1, 0xC7, 0x87, 0x1E, 0x1E, 0xF0, 0x7B, 0x81, 0xFE, 0x07,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x7B, 0x9C, 0xEE, 0x39, 0xDC, 0xF3, 0xB9, 0xEE, 0x77, 0xDC, 0xED, 0xB1,
  0xFB, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1C, 0x38, 0x00, 0x0E, 0x0F,
  0x07, 0x87, 0x01, 0xC7, 0x80, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC3, 0xC3, 0xC1, 0xE0, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE1,
  0xE0, 0x70, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0xBC, 0x03,
  0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x7E, 0x03, 0xC0,
  0x0F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x1F,
  0xC0, 0xFF, 0x03, 0xF0, 0x00, 0x1E, 0x0C, 0x7F, 0x3D, 0xFF, 0xF3, 0x9F,
  0xC6, 0x0F, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 19, 15, 5, -19 },
  { 20, 11, 8, 15, 6, -20 },
  { 31, 16, 19, 15, 1, -19 },
  { 69, 15, 24, 15, 1, -21 },
  { 114, 18, 19, 15, 0, -19 },
  { 157, 15, 19, 15, 1, -19 },
  { 193, 6, 9, 15, 8, -20 },
  { 200, 12, 26, 15, 4, -21 },
  { 239, 12, 26, 15, 1, -21 },
  { 278, 12, 12, 15, 4, -19 },
  { 296, 13, 13, 15, 2, -15 },
  { 318, 7, 9, 15, 3, -5 },
  { 326, 9, 4, 15, 4, -10 },
  { 331, 5, 5, 15, 5, -5 },
  { 335, 17, 26, 15, 0, -21 },
  { 391, 14, 19, 15, 2, -19 },
  { 425, 12, 19, 15, 2, -19 },
  { 454, 15, 19, 15, 1, -19 },
  { 490, 15, 19, 15, 1, -19 },
  { 526, 15, 19, 15, 1, -19 },
  { 562, 16, 19, 15, 1, -19 },
  { 600, 15, 19, 15, 2, -19 },
  { 636, 14, 19, 15, 4, -19 },
  { 670, 14, 19, 15, 2, -19 },
  { 704, 14, 19, 15, 2, -19 },
  { 738, 7, 14, 15, 5, -14 },
  { 751, 9, 18, 15, 3, -14 },
  { 772, 14, 13, 15, 2, -14 },
  { 795, 15, 9, 15, 1, -12 },
  { 812, 13, 13, 15, 2, -14 },
  { 834, 11, 19, 15, 5, -19 },
  { 861, 15, 23, 15, 2, -19 },
  { 905, 14, 19, 15, 0, -19 },
  { 939, 15, 19, 15, 1, -19 },
  { 975, 14, 19, 15, 3, -19 },
  { 1009, 15, 19, 15, 1, -19 },
  { 1045, 15, 19, 15, 2, -19 },
  { 1081, 16, 19, 15, 2, -19 },
  { 1119, 15, 19, 15, 2, -19 },
  { 1155, 17, 19, 15, 1, -19 },
  { 1196, 16, 19, 15, 1, -19 },
  { 1234, 16, 19, 15, 1, -19 },
  { 1272, 17, 19, 15, 1, -19 },
  { 1313, 13, 19, 15, 1, -19 },
  { 1344, 17, 19, 15, 0, -19 },
  { 1385, 17, 19, 15, 1, -19 },
  { 1426, 14, 19, 15, 2, -19 },
  { 1460, 16, 19, 15, 1, -19 },
  { 1498, 14, 24, 15, 2, -19 },
  { 1540, 15, 19, 15, 1, -19 },
  { 1576, 15, 19, 15, 1, -19 },
  { 1612, 14, 19, 15, 4, -19 },
  { 1646, 15, 19, 15, 2, -19 },
  { 1682, 15, 19, 15, 4, -19 },
  { 1718, 17, 19, 15, 1, -19 },
  { 1759, 18, 19, 15, 0, -19 },
  { 1802, 15, 19, 15, 4, -19 },
  { 1838, 16, 19, 15, 1, -19 },
  { 1876, 14, 26, 15, 3, -21 },
  { 1922, 6, 26, 15, 6, -21 },
  { 1942, 15, 26, 15, 0, -21 },
  { 1991, 14, 11, 15, 2, -19 },
  { 2011, 14, 3, 15, -1, 2 },
  { 2017, 7, 6, 15, 7, -21 },
  { 2023, 14, 14, 15, 2, -14 },
  { 2048, 14, 21, 15, 1, -21 },
  { 2085, 14, 14, 15, 2, -14 },
  { 2110, 16, 21, 15, 2, -21 },
  { 2152, 14, 14, 15, 2, -14 },
  { 2177, 19, 26, 15, -1, -21 },
  { 2239, 16, 19, 15, 0, -14 },
  { 2277, 14, 21, 15, 1, -21 },
  { 2314, 11, 21, 15, 3, -21 },
  { 2343, 14, 26, 15, 0, -21 },
  { 2389, 15, 21, 15, 2, -21 },
  { 2429, 10, 21, 15, 4, -21 },
  { 2456, 15, 14, 15, 1, -14 },
  { 2483, 14, 14, 15, 1, -14 },
  { 2508, 13, 14, 15, 2, -14 },
  { 2531, 15, 19, 15, 0, -14 },
  { 2567, 14, 19, 15, 2, -14 },
  { 2601, 14, 14, 15, 2, -14 },
  { 2626, 14, 14, 15, 1, -14 },
  { 2651, 13, 18, 15, 3, -18 },
  { 2681, 14, 14, 15, 2, -14 },
  { 2706, 14, 14, 15, 3, -14 },
  { 2731, 15, 14, 15, 2, -14 },
  { 2758, 17, 14, 15, 0, -14 },
  { 2788, 17, 19, 15, -1, -14 },
  { 2829, 15, 14, 15, 1, -14 },
  { 2856, 14, 26, 15, 3, -21 },
  { 2902, 10, 26, 15, 4, -21 },
  { 2935, 14, 26, 15, 0, -21 },
  { 2981, 15, 5, 15, 1, -11 },
};

const GFXfont UbuntuMono_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic30pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUMONO_BOLDITALIC30PT7B_H_
