#ifndef _UBUNTUMONO_BOLDITALIC47PT7B_H_
#define _UBUNTUMONO_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x3C, 0x00, 0x3F, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xE3,
  0xF3, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C,
  0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3,
  0xE0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x78, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xC1, 0xE0,
  0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0x80, 0x7F, 0x80, 0x78, 0x07, 0xFC, 0x07, 0xC0, 0x7C, 0xE0,
  0x3C, 0x03, 0xC7, 0x03, 0xC0, 0x1C, 0x38, 0x3C, 0x00, 0xE1, 0xC3, 0xC0,
  0x0F, 0x1E, 0x3C, 0x00, 0x78, 0xF3, 0xE0, 0x03, 0xCF, 0x1E, 0x00, 0x1F,
  0xF9, 0xE0, 0x00, 0x7F, 0x9E, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xF8,
  0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF3, 0xFE, 0x00, 0x0F, 0x1E, 0x78, 0x00,
  0xF9, 0xE3, 0xC0, 0x0F, 0x8F, 0x1C, 0x00, 0x78, 0x70, 0xE0, 0x07, 0x83,
  0x8F, 0x00, 0x78, 0x1C, 0x78, 0x07, 0x80, 0xE7, 0x80, 0x7C, 0x07, 0xFC,
  0x07, 0xC0, 0x3F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0x0F, 0xF8,
  0x3C, 0x3F, 0xF8, 0xF8, 0xFD, 0xF9, 0xF3, 0xF1, 0xFF, 0xC7, 0xC3, 0xFF,
  0x9F, 0x83, 0xFE, 0x3E, 0x03, 0xF8, 0x7C, 0x07, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0x07,
  0xFF, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x30,
  0xF8, 0x67, 0x9F, 0x3C, 0xF9, 0xCF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3F,
  0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x0E, 0x0E, 0x00, 0xC1, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x07, 0xC0, 0xF0, 0xFE, 0x7F, 0x8F,
  0xE1, 0xF0, 0x20, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xC0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C,
  0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x3C, 0x7D, 0xF9,
  0xF1, 0xF7, 0xE7, 0xCF, 0xDF, 0x1F, 0x3F, 0x7C, 0x78, 0xF9, 0xF0, 0x03,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x9F, 0x81, 0xE3,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7C, 0x1F, 0xC0, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1C, 0x1F, 0xC0, 0x20, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x20, 0x03,
  0xF8, 0x78, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3C, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x7D, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFE, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F,
  0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F,
  0x01, 0xF8, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E,
  0x07, 0xF3, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7E, 0x7F, 0x03, 0xF0, 0xFE, 0x1F, 0x80, 0xFC, 0x7C, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xFC, 0x07, 0xE3,
  0xF8, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F,
  0x07, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00,
  0x1E, 0x7C, 0x0F, 0xFC, 0xF0, 0x7F, 0xFB, 0xE1, 0xFF, 0xF7, 0x87, 0xFF,
  0xCF, 0x0F, 0xFF, 0xBE, 0x3F, 0x1F, 0x7C, 0x7C, 0x3E, 0xF1, 0xF0, 0x7D,
  0xE3, 0xE1, 0xF3, 0xC7, 0xC3, 0xE7, 0x8F, 0x87, 0xCF, 0x1F, 0x0F, 0x9E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF1, 0xFF, 0xF1, 0xE1,
  0xFF, 0xC3, 0xC1, 0xFF, 0x87, 0xC1, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xF7, 0x80, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF0, 0x07,
  0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xC0,
  0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3E, 0x07, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC,
  0x7E, 0x07, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x07, 0x03,
  0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x03, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8,
  0x3F, 0x07, 0xF0, 0x3E, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0x07, 0x03, 0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFE,
  0x1F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x30,
  0x0F, 0xC0, 0x78, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x07,
  0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xEF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xDC,
  0x7B, 0xC0, 0x7B, 0x8F, 0xF8, 0x1F, 0x7B, 0xDE, 0x03, 0xEF, 0x7B, 0xC0,
  0x79, 0xFE, 0x78, 0x0F, 0x3F, 0x9F, 0x03, 0xE7, 0xF3, 0xE0, 0x7C, 0xFC,
  0x78, 0x0F, 0x9F, 0x8F, 0x03, 0xE1, 0xE3, 0xE0, 0x7C, 0x3C, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x3F,
  0x80, 0xF8, 0x07, 0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C,
  0x07, 0xFE, 0x1F, 0x00, 0xFB, 0xC3, 0xE0, 0x1F, 0x78, 0x7C, 0x07, 0xEF,
  0x0F, 0x80, 0xF9, 0xF3, 0xF0, 0x1F, 0x1E, 0x7C, 0x03, 0xE3, 0xCF, 0x80,
  0xFC, 0x79, 0xF0, 0x1F, 0x0F, 0x7E, 0x03, 0xE0, 0xFF, 0x80, 0x7C, 0x1F,
  0xF0, 0x1F, 0x83, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF0, 0x0F,
  0x80, 0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0x7C,
  0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x03,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0x83, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC7,
  0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF8,
  0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03,
  0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x10, 0x01, 0xF8, 0x1F, 0x03,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x78, 0x7C, 0x0F, 0x8F, 0x0F, 0x01,
  0xE3, 0xE3, 0xE0, 0x7C, 0x7C, 0x7C, 0x0F, 0x9F, 0xCF, 0x81, 0xF3, 0xF9,
  0xE0, 0x3C, 0xFF, 0x3C, 0x07, 0x9D, 0xEF, 0x81, 0xF7, 0xBD, 0xF0, 0x3F,
  0xE7, 0xBC, 0x07, 0xBC, 0xF7, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE7,
  0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0xFE, 0xFC, 0x0F, 0xE7, 0xE0, 0xFE, 0x1F, 0x07,
  0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x1F, 0x7F, 0x00, 0xFF, 0xF0, 0x07,
  0xE7, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x10, 0x0E, 0x07,
  0xC1, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x0E, 0x01, 0x80, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0x87, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xE1,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0x3E,
  0x03, 0xF0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xF8, 0xFE, 0x0F,
  0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x1F, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xF0, 0x10, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x60, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xE1, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x0F, 0xC3, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xE1, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x1F,
  0xBE, 0x07, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x60,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x40,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xCF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0E, 0x07, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x80,
  0xFC, 0x03, 0x83, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F,
  0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xF9,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC3, 0x7F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x7C, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0x9F, 0x1F, 0x0F, 0x8F, 0x1F, 0x0F, 0x1F, 0x1E, 0x1F, 0x1F, 0x1E, 0x1F,
  0x1E, 0x3E, 0x1F, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E,
  0x3C, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7C, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE7,
  0xE0, 0x7F, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0x83, 0xFC,
  0x1F, 0x87, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x40, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0x80, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x80, 0x1F, 0x83, 0x80,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x10, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F,
  0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xF7, 0xE0, 0x7E, 0x18, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x0F,
  0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x78, 0x7C, 0x7C, 0x78, 0xFC, 0x78, 0x78, 0xFC, 0x78, 0x79, 0xFC, 0xF8,
  0xF9, 0xFC, 0xF0, 0xFB, 0xDC, 0xF0, 0xF3, 0x9D, 0xF0, 0xF7, 0x9D, 0xE0,
  0xF7, 0x1D, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x02, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x18, 0x1F, 0xE0, 0x7C, 0x7F, 0xF1, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x8F, 0x8F, 0xFE, 0x3E, 0x07, 0xF8, 0x1C, 0x07, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 13, 30, 24, 8, -29 },
  { 50, 17, 13, 24, 9, -32 },
  { 78, 26, 29, 24, 1, -29 },
  { 173, 23, 38, 24, 2, -33 },
  { 283, 29, 31, 24, 0, -30 },
  { 396, 23, 31, 24, 2, -30 },
  { 486, 8, 14, 24, 13, -32 },
  { 500, 19, 42, 24, 6, -33 },
  { 600, 19, 42, 24, 2, -33 },
  { 700, 19, 18, 24, 6, -29 },
  { 743, 21, 21, 24, 3, -23 },
  { 799, 11, 15, 24, 5, -7 },
  { 820, 14, 6, 24, 7, -15 },
  { 831, 8, 8, 24, 8, -7 },
  { 839, 28, 41, 24, -1, -33 },
  { 983, 22, 31, 24, 3, -30 },
  { 1069, 19, 29, 24, 3, -29 },
  { 1138, 23, 30, 24, 2, -30 },
  { 1225, 23, 31, 24, 1, -30 },
  { 1315, 24, 29, 24, 2, -29 },
  { 1402, 25, 30, 24, 1, -29 },
  { 1496, 22, 30, 24, 4, -29 },
  { 1579, 22, 29, 24, 6, -29 },
  { 1659, 22, 31, 24, 3, -30 },
  { 1745, 22, 30, 24, 3, -30 },
  { 1828, 11, 22, 24, 8, -21 },
  { 1859, 14, 29, 24, 5, -21 },
  { 1910, 21, 21, 24, 4, -22 },
  { 1966, 23, 14, 24, 2, -19 },
  { 2007, 22, 21, 24, 2, -22 },
  { 2065, 18, 31, 24, 7, -30 },
  { 2135, 23, 36, 24, 3, -30 },
  { 2239, 22, 29, 24, 0, -29 },
  { 2319, 23, 30, 24, 2, -29 },
  { 2406, 23, 31, 24, 4, -30 },
  { 2496, 24, 31, 24, 1, -30 },
  { 2589, 25, 29, 24, 2, -29 },
  { 2680, 25, 29, 24, 3, -29 },
  { 2771, 23, 31, 24, 4, -30 },
  { 2861, 27, 29, 24, 1, -29 },
  { 2959, 25, 29, 24, 2, -29 },
  { 3050, 24, 30, 24, 2, -29 },
  { 3140, 27, 29, 24, 1, -29 },
  { 3238, 19, 29, 24, 2, -29 },
  { 3307, 27, 29, 24, 0, -29 },
  { 3405, 27, 29, 24, 1, -29 },
  { 3503, 22, 31, 24, 3, -30 },
  { 3589, 24, 29, 24, 2, -29 },
  { 3676, 22, 39, 24, 3, -30 },
  { 3784, 23, 29, 24, 2, -29 },
  { 3868, 25, 31, 24, 1, -30 },
  { 3965, 22, 29, 24, 6, -29 },
  { 4045, 24, 30, 24, 3, -29 },
  { 4135, 23, 29, 24, 6, -29 },
  { 4219, 27, 29, 24, 2, -29 },
  { 4317, 29, 29, 24, 0, -29 },
  { 4423, 22, 29, 24, 7, -29 },
  { 4503, 26, 29, 24, 1, -29 },
  { 4598, 23, 41, 24, 4, -33 },
  { 4716, 9, 41, 24, 10, -33 },
  { 4763, 23, 41, 24, 1, -33 },
  { 4881, 21, 17, 24, 4, -29 },
  { 4926, 23, 5, 24, -2, 3 },
  { 4941, 10, 9, 24, 11, -32 },
  { 4953, 22, 24, 24, 3, -23 },
  { 5019, 22, 34, 24, 2, -33 },
  { 5113, 21, 24, 24, 4, -23 },
  { 5176, 24, 34, 24, 3, -33 },
  { 5278, 21, 24, 24, 4, -23 },
  { 5341, 30, 42, 24, -2, -33 },
  { 5499, 25, 32, 24, 0, -23 },
  { 5599, 21, 33, 24, 2, -33 },
  { 5686, 17, 33, 24, 5, -32 },
  { 5757, 23, 41, 24, 0, -32 },
  { 5875, 24, 33, 24, 3, -33 },
  { 5974, 14, 33, 24, 7, -32 },
  { 6032, 24, 22, 24, 1, -22 },
  { 6098, 21, 23, 24, 2, -23 },
  { 6159, 21, 24, 24, 3, -23 },
  { 6222, 24, 31, 24, 0, -23 },
  { 6315, 22, 31, 24, 3, -23 },
  { 6401, 22, 23, 24, 3, -23 },
  { 6465, 22, 24, 24, 2, -23 },
  { 6531, 20, 29, 24, 5, -28 },
  { 6604, 21, 23, 24, 4, -22 },
  { 6665, 21, 22, 24, 5, -22 },
  { 6723, 24, 22, 24, 3, -22 },
  { 6789, 26, 22, 24, 0, -22 },
  { 6861, 28, 31, 24, -2, -22 },
  { 6970, 23, 22, 24, 2, -22 },
  { 7034, 22, 41, 24, 5, -33 },
  { 7147, 15, 41, 24, 6, -33 },
  { 7224, 23, 41, 24, 0, -33 },
  { 7342, 23, 8, 24, 2, -17 },
};

const GFXfont UbuntuMono_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic47pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUMONO_BOLDITALIC47PT7B_H_
