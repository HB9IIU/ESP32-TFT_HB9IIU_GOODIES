#ifndef _UBUNTUMONO_BOLDITALIC11PT7B_H_
#define _UBUNTUMONO_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x21, 0xA0, 0xDF, 0xA0, 0x14, 0x57, 0xCA, 0xFD, 0x45, 0x00,
  0x13, 0xD0, 0x87, 0x08, 0x5E, 0x40, 0x34, 0xA9, 0xA0, 0x82, 0xCA, 0xA6,
  0x00, 0x38, 0xA2, 0x8C, 0x5F, 0x67, 0x80, 0xF8, 0x09, 0x88, 0xC4, 0x21,
  0x08, 0x41, 0x00, 0x10, 0x86, 0x10, 0x8C, 0x46, 0x62, 0x00, 0x23, 0x5C,
  0xE5, 0x00, 0x21, 0x3C, 0xC4, 0x00, 0x6D, 0x40, 0xE0, 0xF0, 0x04, 0x30,
  0x86, 0x10, 0xC2, 0x18, 0x43, 0x00, 0x72, 0x63, 0x79, 0x4B, 0x80, 0x3F,
  0x32, 0x22, 0xF0, 0x38, 0x30, 0xC6, 0x31, 0x07, 0x80, 0x38, 0x30, 0x8C,
  0x08, 0x2F, 0x00, 0x0C, 0x72, 0x92, 0x7C, 0x61, 0x00, 0x3C, 0x82, 0x0E,
  0x08, 0x2F, 0x00, 0x3B, 0x31, 0xE9, 0xC9, 0xC0, 0x78, 0x63, 0x08, 0x61,
  0x0C, 0x00, 0x72, 0x56, 0xE9, 0x4B, 0xC0, 0x76, 0xE2, 0xF1, 0x1B, 0x00,
  0x48, 0x6C, 0x22, 0x06, 0x64, 0x80, 0x1B, 0x38, 0x20, 0x7C, 0x07, 0x80,
  0xC1, 0x9D, 0x00, 0xE3, 0x36, 0xC0, 0x80, 0x3A, 0x6F, 0xDD, 0x5A, 0x0E,
  0x18, 0xCA, 0x57, 0xA6, 0x20, 0x38, 0x96, 0xDE, 0x4D, 0x2F, 0x80, 0x3A,
  0x31, 0x08, 0x61, 0xC0, 0x38, 0xB6, 0xDB, 0x49, 0x6F, 0x00, 0x7A, 0x11,
  0xEC, 0x43, 0xC0, 0x7A, 0x11, 0xEC, 0x42, 0x00, 0x3A, 0x31, 0x39, 0x4B,
  0xC0, 0x24, 0x96, 0x5F, 0x49, 0x2C, 0x80, 0x3C, 0x41, 0x04, 0x30, 0xC7,
  0x80, 0x3C, 0x30, 0xC2, 0x08, 0x67, 0x00, 0x24, 0x51, 0xE3, 0x85, 0x0B,
  0x32, 0x00, 0x21, 0x08, 0xC4, 0x21, 0xE0, 0x24, 0xB6, 0xD5, 0x5F, 0x28,
  0x80, 0x24, 0xD7, 0x57, 0x59, 0x6C, 0x80, 0x72, 0x63, 0x39, 0xCB, 0x80,
  0x38, 0x96, 0x5B, 0x79, 0x04, 0x00, 0x72, 0x63, 0x39, 0xCB, 0x88, 0x20,
  0x38, 0xB6, 0xDE, 0x51, 0x2C, 0x80, 0x3C, 0x82, 0x0E, 0x08, 0x2F, 0x00,
  0x7C, 0x82, 0x08, 0x61, 0x84, 0x00, 0x4A, 0x77, 0x39, 0x4B, 0x80, 0xCD,
  0x25, 0x94, 0x71, 0x86, 0x00, 0x26, 0xC9, 0x52, 0xA7, 0x8B, 0x32, 0x00,
  0x24, 0x78, 0x60, 0x83, 0x8D, 0x32, 0x00, 0x95, 0xA9, 0x8C, 0x62, 0x00,
  0x3C, 0x31, 0x8C, 0x21, 0x0F, 0x80, 0x39, 0x08, 0xC6, 0x21, 0x08, 0xC7,
  0x00, 0xFD, 0x55, 0x50, 0x38, 0x20, 0x86, 0x10, 0x41, 0x04, 0x33, 0x80,
  0x33, 0x97, 0x10, 0xF8, 0x90, 0x7E, 0xA5, 0x2F, 0x00, 0x20, 0x82, 0x1E,
  0x69, 0x24, 0xBC, 0x7E, 0x21, 0x0F, 0x00, 0x08, 0x42, 0xFD, 0x4A, 0x5E,
  0x76, 0xFD, 0x0F, 0x00, 0x0C, 0x20, 0x43, 0xE3, 0x06, 0x08, 0x10, 0x21,
  0x80, 0x3D, 0xB4, 0x92, 0x78, 0x6F, 0x00, 0x31, 0x08, 0xF6, 0xA5, 0x2B,
  0x32, 0x0E, 0x26, 0x47, 0x08, 0x40, 0x71, 0x8C, 0x42, 0x17, 0x00, 0x62,
  0x10, 0xBE, 0x72, 0xD2, 0xE9, 0x6D, 0x27, 0x7D, 0x55, 0xD2, 0x88, 0x3B,
  0x52, 0x95, 0x80, 0x76, 0xE5, 0x2E, 0x00, 0x39, 0xB4, 0x92, 0x73, 0x08,
  0x00, 0x7E, 0xE5, 0x2F, 0x18, 0x80, 0x7A, 0x31, 0x08, 0x00, 0x72, 0x1C,
  0x2E, 0x00, 0x21, 0x3E, 0x84, 0x21, 0xC0, 0xDE, 0xA5, 0x2F, 0x00, 0xDE,
  0xB4, 0xC6, 0x00, 0x8D, 0x7D, 0xEB, 0x00, 0x6C, 0xE3, 0x1E, 0x48, 0x6D,
  0xA6, 0x8C, 0x30, 0x8C, 0x00, 0x79, 0x99, 0x8F, 0x00, 0x19, 0x08, 0x4C,
  0x21, 0x08, 0x43, 0x00, 0x13, 0x22, 0x26, 0x64, 0x4C, 0x38, 0xC4, 0x20,
  0x88, 0xC4, 0x27, 0x00, 0xCD, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 2, -7 },
  { 4, 4, 3, 6, 2, -7 },
  { 6, 6, 7, 6, 0, -7 },
  { 12, 5, 9, 6, 1, -8 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 2, 3, 6, 3, -7 },
  { 32, 5, 10, 6, 1, -8 },
  { 39, 5, 10, 6, 0, -8 },
  { 46, 5, 5, 6, 1, -7 },
  { 50, 5, 5, 6, 1, -5 },
  { 54, 3, 4, 6, 1, -2 },
  { 56, 3, 1, 6, 2, -3 },
  { 57, 2, 2, 6, 2, -2 },
  { 58, 6, 10, 6, 0, -8 },
  { 66, 5, 7, 6, 1, -7 },
  { 71, 4, 7, 6, 1, -7 },
  { 75, 6, 7, 6, 0, -7 },
  { 81, 6, 7, 6, 0, -7 },
  { 87, 6, 7, 6, 0, -7 },
  { 93, 6, 7, 6, 0, -7 },
  { 99, 5, 7, 6, 1, -7 },
  { 104, 6, 7, 6, 1, -7 },
  { 110, 5, 7, 6, 1, -7 },
  { 115, 5, 7, 6, 1, -7 },
  { 120, 3, 5, 6, 2, -5 },
  { 122, 4, 7, 6, 1, -5 },
  { 126, 5, 4, 6, 1, -5 },
  { 129, 6, 3, 6, 0, -5 },
  { 132, 5, 4, 6, 1, -5 },
  { 135, 4, 7, 6, 2, -7 },
  { 139, 5, 8, 6, 1, -7 },
  { 144, 5, 7, 6, 0, -7 },
  { 149, 6, 7, 6, 0, -7 },
  { 155, 5, 7, 6, 1, -7 },
  { 160, 6, 7, 6, 0, -7 },
  { 166, 5, 7, 6, 1, -7 },
  { 171, 5, 7, 6, 1, -7 },
  { 176, 5, 7, 6, 1, -7 },
  { 181, 6, 7, 6, 0, -7 },
  { 187, 6, 7, 6, 0, -7 },
  { 193, 6, 7, 6, 0, -7 },
  { 199, 7, 7, 6, 0, -7 },
  { 206, 5, 7, 6, 0, -7 },
  { 211, 6, 7, 6, 0, -7 },
  { 217, 6, 7, 6, 0, -7 },
  { 223, 5, 7, 6, 1, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 5, 9, 6, 1, -7 },
  { 240, 6, 7, 6, 0, -7 },
  { 246, 6, 7, 6, 0, -7 },
  { 252, 6, 7, 6, 1, -7 },
  { 258, 5, 7, 6, 1, -7 },
  { 263, 6, 7, 6, 1, -7 },
  { 269, 7, 7, 6, 0, -7 },
  { 276, 7, 7, 6, 0, -7 },
  { 283, 5, 7, 6, 2, -7 },
  { 288, 6, 7, 6, 0, -7 },
  { 294, 5, 10, 6, 1, -8 },
  { 301, 2, 10, 6, 2, -8 },
  { 304, 6, 10, 6, 0, -8 },
  { 312, 5, 4, 6, 1, -7 },
  { 315, 5, 1, 6, 0, 1 },
  { 316, 2, 2, 6, 3, -8 },
  { 317, 5, 5, 6, 1, -5 },
  { 321, 6, 8, 6, 0, -8 },
  { 327, 5, 5, 6, 1, -5 },
  { 331, 5, 8, 6, 1, -8 },
  { 336, 5, 5, 6, 1, -5 },
  { 340, 7, 10, 6, 0, -8 },
  { 349, 6, 7, 6, 0, -5 },
  { 355, 5, 8, 6, 0, -8 },
  { 360, 4, 8, 6, 1, -8 },
  { 364, 5, 10, 6, 0, -8 },
  { 371, 5, 8, 6, 1, -8 },
  { 376, 3, 8, 6, 2, -8 },
  { 379, 6, 5, 6, 0, -5 },
  { 383, 5, 5, 6, 0, -5 },
  { 387, 5, 5, 6, 1, -5 },
  { 391, 6, 7, 6, 0, -5 },
  { 397, 5, 7, 6, 1, -5 },
  { 402, 5, 5, 6, 1, -5 },
  { 406, 5, 5, 6, 1, -5 },
  { 410, 5, 7, 6, 1, -7 },
  { 415, 5, 5, 6, 1, -5 },
  { 419, 5, 5, 6, 1, -5 },
  { 423, 5, 5, 6, 1, -5 },
  { 427, 6, 5, 6, 0, -5 },
  { 431, 6, 7, 6, 0, -5 },
  { 437, 5, 5, 6, 1, -5 },
  { 441, 5, 10, 6, 1, -8 },
  { 448, 4, 10, 6, 1, -8 },
  { 453, 5, 10, 6, 0, -8 },
  { 460, 5, 2, 6, 1, -4 },
};

const GFXfont UbuntuMono_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic11pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUMONO_BOLDITALIC11PT7B_H_
