#ifndef _UBUNTUMONO_BOLDITALIC21PT7B_H_
#define _UBUNTUMONO_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x30, 0xC0, 0x1C, 0x70, 0x67,
  0xE6, 0xEE, 0xEE, 0xCC, 0xCC, 0x06, 0x61, 0x98, 0x33, 0x3F, 0xF7, 0xFE,
  0x37, 0x0C, 0xC1, 0x98, 0xFF, 0xDF, 0xF1, 0x98, 0x66, 0x0C, 0xC0, 0x03,
  0x00, 0xC0, 0xFC, 0x7F, 0x38, 0x0E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0E, 0x43, 0xBF, 0xC7, 0xE0, 0x60, 0x38, 0x00, 0x1C, 0x10, 0xF1,
  0x8D, 0x98, 0x6D, 0x83, 0xD8, 0x1D, 0x80, 0x08, 0x00, 0xD8, 0x0D, 0xE0,
  0xDB, 0x0C, 0xD8, 0xC7, 0x8C, 0x18, 0x00, 0x0F, 0x07, 0xE1, 0x98, 0xE6,
  0x3B, 0x87, 0xC3, 0xE1, 0xF3, 0xEF, 0xB1, 0xEC, 0x73, 0xFE, 0x79, 0x80,
  0x6E, 0xEC, 0xCC, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x20, 0x04, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0x40, 0x18, 0x9B, 0xFF, 0xFF, 0x3C, 0x7E, 0xEE, 0x24, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x7F, 0xDF, 0xE0, 0xC0, 0x70, 0x18, 0x06, 0x00,
  0x39, 0xDE, 0x73, 0x7B, 0x00, 0xFF, 0xFF, 0xC0, 0x77, 0xF6, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0x0F, 0x87, 0xF3, 0x8C, 0xC3, 0x70, 0xD9, 0xB6, 0xCD, 0x87, 0x61,
  0xB8, 0xE6, 0x31, 0xFC, 0x3C, 0x00, 0x03, 0x83, 0x87, 0xC7, 0xE2, 0x70,
  0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x0F, 0xFF, 0xF0, 0x0F, 0x8F, 0xF1,
  0x1C, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x06, 0x03, 0xFE,
  0xFF, 0x00, 0x0F, 0x87, 0xF1, 0x1C, 0x07, 0x01, 0x87, 0xC1, 0xF0, 0x0E,
  0x03, 0x80, 0xE8, 0x3B, 0xFC, 0xFC, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3F,
  0x1D, 0x8E, 0x63, 0x39, 0x8E, 0xFF, 0xFF, 0xF0, 0x70, 0x1C, 0x06, 0x00,
  0x0F, 0xE3, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x7C, 0x0F, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x7F, 0x8F, 0xE0, 0x07, 0xC7, 0xE3, 0xC1, 0xC0, 0x60,
  0x3F, 0x8F, 0xF3, 0x0E, 0xC3, 0xB0, 0xCE, 0x73, 0xF8, 0x3C, 0x00, 0x7F,
  0xDF, 0xF0, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x00, 0x0F, 0x87, 0xF3, 0x8C, 0xE3, 0x39, 0xC7, 0xE1,
  0xF1, 0xCE, 0x61, 0xB8, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x0F, 0x0F, 0xE3,
  0x1D, 0xC3, 0x70, 0xDC, 0x33, 0xFC, 0x7F, 0x01, 0x80, 0xE0, 0xF3, 0xF8,
  0xF0, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x07, 0x1C, 0xF1, 0x80, 0x0C, 0x3C,
  0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x78, 0x70, 0xC7, 0x8C, 0x00, 0x00, 0x83,
  0xC7, 0xDF, 0x0E, 0x07, 0xC0, 0xF8, 0x1E, 0x02, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x20, 0x0E, 0x03, 0xF0, 0x3F, 0x01, 0x83,
  0xE7, 0xE3, 0xC0, 0xC0, 0x00, 0x3E, 0x7F, 0x47, 0x07, 0x07, 0x0E, 0x1E,
  0x38, 0x30, 0x70, 0x00, 0x70, 0xE0, 0x07, 0x83, 0xF8, 0xE3, 0x98, 0x36,
  0x3E, 0xDF, 0x9B, 0x36, 0x66, 0xD9, 0xDB, 0xB3, 0x3E, 0x67, 0xCE, 0x00,
  0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0x80, 0xE0, 0x7C, 0x1F, 0x0D, 0xC7, 0x31,
  0x8C, 0xE3, 0x3F, 0xCF, 0xF7, 0x1D, 0x87, 0xE1, 0xC0, 0x1F, 0x87, 0xF3,
  0x8C, 0xE3, 0x31, 0xCF, 0xE7, 0xF9, 0xC6, 0x61, 0xD8, 0x6E, 0x3B, 0xFC,
  0xFE, 0x00, 0x0F, 0x87, 0xF3, 0x81, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x38, 0x0E, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xE3, 0x9C, 0xC7,
  0x31, 0xDC, 0x77, 0x1D, 0xC7, 0x61, 0xB8, 0xEE, 0x73, 0xF8, 0xFC, 0x00,
  0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x80, 0x7F, 0x0F, 0xE3, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03,
  0x80, 0x7F, 0x0F, 0xE1, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x00,
  0x0F, 0x87, 0xF3, 0x81, 0xC0, 0xE0, 0x38, 0x0C, 0x3B, 0x0E, 0xC3, 0x31,
  0xCE, 0x73, 0xFC, 0x7E, 0x00, 0x18, 0x67, 0x1C, 0xE3, 0x98, 0x63, 0x0C,
  0xFF, 0x9F, 0xF3, 0x0E, 0x61, 0x9C, 0x73, 0x8E, 0x61, 0xCC, 0x30, 0x1F,
  0xE7, 0xFC, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x61, 0x1C, 0x7F, 0x07, 0xC0, 0x18,
  0xE3, 0x8E, 0x39, 0xC3, 0xB8, 0x37, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x67,
  0x0E, 0x70, 0xE3, 0x0E, 0x38, 0xC3, 0x80, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1F, 0xEF, 0xF0, 0x0C, 0x71,
  0xC7, 0x1C, 0xF1, 0xCB, 0x35, 0xE3, 0x76, 0x37, 0x63, 0x66, 0x70, 0xE6,
  0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xC0, 0x18, 0x67, 0x0C, 0xF3, 0x9E, 0x63,
  0xCC, 0xE9, 0x99, 0xF3, 0x3C, 0x67, 0x9C, 0xF3, 0x0E, 0x61, 0xCC, 0x30,
  0x0F, 0x87, 0xF3, 0x9C, 0xC3, 0x70, 0xDC, 0x36, 0x1D, 0x87, 0xE1, 0xF8,
  0xE6, 0x31, 0xFC, 0x3C, 0x00, 0x1F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x0E,
  0x61, 0x9C, 0x73, 0xFC, 0x7E, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F,
  0x87, 0xF3, 0x9C, 0xC3, 0x70, 0xDC, 0x36, 0x1D, 0x87, 0xE1, 0xF8, 0xE6,
  0x39, 0xFC, 0x3C, 0x06, 0x01, 0xF0, 0x18, 0x1F, 0x8F, 0xF3, 0x9C, 0xE3,
  0x31, 0xCC, 0x77, 0xF9, 0xFC, 0x66, 0x19, 0xCE, 0x33, 0x8E, 0xC3, 0x80,
  0x0F, 0xC7, 0xF3, 0x84, 0xC0, 0x38, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0x80,
  0xE4, 0x3B, 0xFC, 0x7E, 0x00, 0xFF, 0xFF, 0xE1, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x00, 0x38, 0xE7,
  0x1C, 0xE3, 0x98, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0x0C, 0x63, 0x9C, 0x73,
  0x8C, 0x3F, 0x83, 0xE0, 0xE1, 0xF0, 0x6C, 0x3B, 0x0C, 0xC7, 0x31, 0x8C,
  0xE3, 0x30, 0xDC, 0x3E, 0x0F, 0x83, 0xC0, 0x70, 0x00, 0x30, 0x73, 0x06,
  0x30, 0x63, 0x06, 0x60, 0xE6, 0xEC, 0x6E, 0xC7, 0xEC, 0x5F, 0x8F, 0x78,
  0xF3, 0x8E, 0x38, 0xC3, 0x00, 0x1C, 0x30, 0x63, 0x83, 0xB8, 0x1D, 0x80,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0xCC, 0x0E, 0x60, 0xE3,
  0x8E, 0x1C, 0x00, 0xE1, 0xF8, 0xEE, 0x31, 0x9C, 0x66, 0x1B, 0x07, 0xC0,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x00, 0x1F, 0xE7, 0xFC, 0x07,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x7F,
  0xCF, 0xF0, 0x0F, 0xC3, 0xF0, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xFC, 0x3F,
  0x00, 0xEE, 0x66, 0x66, 0x66, 0x77, 0x77, 0x73, 0x33, 0x33, 0x07, 0xC1,
  0xF8, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x7E, 0x1F, 0x80, 0x0E,
  0x07, 0x87, 0xC7, 0x67, 0x3F, 0x1F, 0x0E, 0x02, 0x7F, 0xFF, 0xF0, 0x47,
  0x1E, 0x20, 0x0F, 0xCF, 0xF3, 0x9D, 0xC6, 0x63, 0xB8, 0xEE, 0x3B, 0x8E,
  0x7F, 0x8F, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x3F, 0x0F, 0xE3, 0x19,
  0xC7, 0x71, 0xD8, 0x66, 0x3B, 0x9C, 0xFF, 0x3F, 0x00, 0x1F, 0x9F, 0xDC,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xFE, 0x1F, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0xFC, 0x7F, 0x9E, 0x73, 0x8C, 0x63, 0x9C, 0x73, 0x8E,
  0x71, 0xC7, 0xF8, 0x7F, 0x00, 0x1F, 0x1F, 0xDC, 0xFC, 0x7C, 0xF7, 0xF3,
  0x01, 0xC0, 0xFE, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x60, 0x07, 0x00,
  0xFF, 0x07, 0xF8, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE3, 0xFC,
  0x63, 0x9C, 0x63, 0x0C, 0x63, 0x8C, 0x71, 0xFC, 0x1F, 0x80, 0x70, 0x0C,
  0x7F, 0x87, 0xC0, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0xC6, 0xE3,
  0x71, 0xB9, 0xD8, 0xEC, 0x6E, 0x37, 0x38, 0x0C, 0x1E, 0x0C, 0x00, 0x7C,
  0xFC, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x1F, 0xC7, 0xF0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC4, 0xE3, 0xF8, 0x7C, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x8E, 0x73, 0x8E, 0xE1, 0xB8, 0x7C, 0x0F, 0xC1, 0xD8, 0x33, 0x86,
  0x31, 0xC7, 0x00, 0xFD, 0xF0, 0x61, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1,
  0x83, 0x07, 0xC7, 0x80, 0x1F, 0xE7, 0xFC, 0xCD, 0x9B, 0x33, 0x66, 0x6D,
  0x98, 0x33, 0x06, 0x60, 0xCC, 0x30, 0x1F, 0x1F, 0xCC, 0x6E, 0x37, 0x1B,
  0x9D, 0x8E, 0xC6, 0xE3, 0x73, 0x80, 0x0F, 0x0F, 0xE7, 0x1D, 0xC7, 0x61,
  0xF8, 0x6E, 0x3B, 0x8E, 0x7F, 0x0F, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x9C,
  0x73, 0x8E, 0x61, 0x8C, 0x73, 0x9C, 0x7F, 0x8F, 0xC1, 0x80, 0x70, 0x0E,
  0x00, 0x1F, 0x9F, 0xDC, 0xFC, 0x6C, 0x36, 0x3B, 0x1D, 0x8C, 0xFE, 0x3F,
  0x03, 0x81, 0x80, 0xC0, 0x0F, 0xCF, 0xF3, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x00, 0x0F, 0x8F, 0xE3, 0x80, 0xE0, 0x3E, 0x07,
  0xC0, 0x31, 0x0C, 0xFF, 0x1F, 0x80, 0x1C, 0x0E, 0x06, 0x0F, 0xFF, 0xF9,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0F, 0xE3, 0xF0, 0x73, 0xB1, 0xF8,
  0xDC, 0x6E, 0x76, 0x3B, 0x19, 0x8C, 0xFF, 0x3B, 0x80, 0xE1, 0xB8, 0xEE,
  0x39, 0x9C, 0x67, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x0C, 0x00, 0x60, 0x6C,
  0x0D, 0x9B, 0x37, 0x66, 0xEC, 0xBF, 0x35, 0xE7, 0xBC, 0xE7, 0x1C, 0xE0,
  0x18, 0xE1, 0xCC, 0x0D, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB8,
  0x31, 0x86, 0x1C, 0x1C, 0x30, 0xE3, 0x83, 0x18, 0x19, 0xC0, 0xCC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x30, 0x03, 0x01, 0xF8, 0x0F, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF,
  0x3F, 0xC0, 0x03, 0xC1, 0xF0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0xF0, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x7C, 0x0F,
  0x00, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xE1, 0x80, 0x0F, 0x03, 0xE0, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0xC0, 0xF0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0xFC, 0x3E, 0x00, 0x38, 0xDF, 0xEC, 0x70,
};

const GFXglyph UbuntuMono_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 13, 11, 3, -13 },
  { 11, 8, 6, 11, 4, -14 },
  { 17, 11, 13, 11, 1, -13 },
  { 35, 10, 17, 11, 1, -15 },
  { 57, 13, 13, 11, 0, -13 },
  { 79, 10, 13, 11, 1, -13 },
  { 96, 4, 6, 11, 6, -14 },
  { 99, 8, 18, 11, 3, -15 },
  { 117, 8, 18, 11, 1, -15 },
  { 135, 8, 8, 11, 3, -13 },
  { 143, 10, 10, 11, 1, -10 },
  { 156, 5, 7, 11, 2, -4 },
  { 161, 6, 3, 11, 3, -7 },
  { 164, 4, 4, 11, 3, -4 },
  { 166, 12, 18, 11, 0, -15 },
  { 193, 10, 13, 11, 1, -13 },
  { 210, 9, 13, 11, 1, -13 },
  { 225, 10, 13, 11, 1, -13 },
  { 242, 10, 13, 11, 1, -13 },
  { 259, 10, 13, 11, 1, -13 },
  { 276, 11, 13, 11, 1, -13 },
  { 294, 10, 13, 11, 2, -13 },
  { 311, 10, 13, 11, 2, -13 },
  { 328, 10, 13, 11, 1, -13 },
  { 345, 10, 13, 11, 1, -13 },
  { 362, 6, 10, 11, 3, -10 },
  { 370, 7, 13, 11, 2, -10 },
  { 382, 9, 9, 11, 2, -10 },
  { 393, 10, 6, 11, 1, -9 },
  { 401, 10, 9, 11, 1, -10 },
  { 413, 8, 13, 11, 3, -13 },
  { 426, 11, 16, 11, 1, -13 },
  { 448, 10, 13, 11, 0, -13 },
  { 465, 10, 13, 11, 1, -13 },
  { 482, 10, 13, 11, 2, -13 },
  { 499, 10, 13, 11, 1, -13 },
  { 516, 11, 13, 11, 1, -13 },
  { 534, 11, 13, 11, 1, -13 },
  { 552, 10, 13, 11, 2, -13 },
  { 569, 11, 13, 11, 1, -13 },
  { 587, 11, 13, 11, 1, -13 },
  { 605, 11, 13, 11, 1, -13 },
  { 623, 12, 13, 11, 1, -13 },
  { 643, 9, 13, 11, 1, -13 },
  { 658, 12, 13, 11, 0, -13 },
  { 678, 11, 13, 11, 1, -13 },
  { 696, 10, 13, 11, 1, -13 },
  { 713, 11, 13, 11, 1, -13 },
  { 731, 10, 16, 11, 1, -13 },
  { 751, 10, 13, 11, 1, -13 },
  { 768, 10, 13, 11, 1, -13 },
  { 785, 10, 13, 11, 3, -13 },
  { 802, 11, 13, 11, 1, -13 },
  { 820, 10, 13, 11, 3, -13 },
  { 837, 12, 13, 11, 1, -13 },
  { 857, 13, 13, 11, 0, -13 },
  { 879, 10, 13, 11, 3, -13 },
  { 896, 11, 13, 11, 1, -13 },
  { 914, 10, 18, 11, 2, -15 },
  { 937, 4, 18, 11, 4, -15 },
  { 946, 11, 18, 11, 0, -15 },
  { 971, 9, 8, 11, 2, -13 },
  { 980, 10, 2, 11, -1, 1 },
  { 983, 5, 4, 11, 5, -15 },
  { 986, 10, 10, 11, 1, -10 },
  { 999, 10, 14, 11, 1, -14 },
  { 1017, 9, 10, 11, 2, -10 },
  { 1029, 11, 14, 11, 1, -14 },
  { 1049, 9, 10, 11, 2, -10 },
  { 1061, 13, 17, 11, -1, -14 },
  { 1089, 11, 13, 11, 0, -10 },
  { 1107, 9, 14, 11, 1, -14 },
  { 1123, 8, 14, 11, 2, -14 },
  { 1137, 10, 17, 11, 0, -14 },
  { 1159, 11, 14, 11, 1, -14 },
  { 1179, 7, 14, 11, 3, -14 },
  { 1192, 11, 10, 11, 0, -10 },
  { 1206, 9, 10, 11, 1, -10 },
  { 1218, 10, 10, 11, 1, -10 },
  { 1231, 11, 13, 11, 0, -10 },
  { 1249, 9, 13, 11, 2, -10 },
  { 1264, 10, 10, 11, 1, -10 },
  { 1277, 10, 10, 11, 1, -10 },
  { 1290, 9, 13, 11, 2, -13 },
  { 1305, 9, 10, 11, 2, -10 },
  { 1317, 10, 10, 11, 2, -10 },
  { 1330, 11, 10, 11, 1, -10 },
  { 1344, 12, 10, 11, 0, -10 },
  { 1359, 13, 13, 11, -1, -10 },
  { 1381, 10, 10, 11, 1, -10 },
  { 1394, 10, 18, 11, 2, -15 },
  { 1417, 7, 18, 11, 3, -15 },
  { 1433, 10, 18, 11, 0, -15 },
  { 1456, 10, 3, 11, 1, -7 },
};

const GFXfont UbuntuMono_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic21pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _UBUNTUMONO_BOLDITALIC21PT7B_H_
