#ifndef _UBUNTUMONO_BOLDITALIC37PT7B_H_
#define _UBUNTUMONO_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xFC, 0x3F, 0x07, 0x80, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0x9E,
  0x3E, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xE1, 0xE3, 0x87, 0x00,
  0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE3,
  0xC0, 0x1E, 0x3C, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x0F, 0x1E, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xC7, 0x80, 0x3C, 0x70, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3E, 0x0C, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x1C, 0x0F, 0x87,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x0F, 0xE0, 0x70,
  0x1F, 0xC1, 0xE0, 0x73, 0x87, 0x80, 0xE7, 0x0E, 0x01, 0x8E, 0x38, 0x07,
  0x1C, 0xE0, 0x0E, 0x73, 0x80, 0x1F, 0xEF, 0x00, 0x1F, 0xBC, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xFC, 0x00, 0x7B,
  0xF8, 0x01, 0xEF, 0x70, 0x03, 0x9C, 0xE0, 0x0E, 0x39, 0xC0, 0x38, 0x73,
  0x80, 0xE0, 0xEF, 0x03, 0xC1, 0xFC, 0x0F, 0x03, 0xF0, 0x1C, 0x03, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x73, 0xFC, 0x3B, 0xFF, 0x3D, 0xE7, 0xDD, 0xE1, 0xFE, 0xF0,
  0x7E, 0x78, 0x3F, 0x3C, 0x1F, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFE, 0xF8,
  0xFC, 0x3C, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0x80,
  0x00, 0x08, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x02, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x10, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x02, 0x3C, 0x6F, 0x3B, 0xDF, 0x6F, 0xBF, 0xFF, 0x9F, 0xFC, 0x07,
  0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xCF, 0x83, 0x8E, 0x02, 0x10,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF1, 0xF8, 0x7C, 0x1E, 0x1E, 0x7E, 0x3E, 0x1C,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xFF, 0xDF,
  0x9E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0xE7, 0xFE,
  0xF3, 0xFE, 0x79, 0xEF, 0x18, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C,
  0xF0, 0x3E, 0x78, 0x3E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x83, 0xDF, 0x06, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x83, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x0F, 0xC1, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x03, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC7, 0x03, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xF0,
  0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x3C, 0x3E, 0x07, 0x07, 0x81,
  0xE0, 0xF0, 0x78, 0x1E, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x20,
  0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7D, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xF8, 0x3E, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1E, 0x3E, 0x0F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x0F, 0x9F, 0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07,
  0xCF, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F,
  0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xE0,
  0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFB, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0xC7, 0xF3, 0xF9, 0xF8, 0xFC, 0x3C,
  0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x03, 0xE0, 0x3C, 0x0F, 0x0F, 0xC1, 0xF0, 0x38, 0x00, 0x00, 0x01, 0x00,
  0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x08, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x07,
  0xF0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0x30, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0xF0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x79, 0xE1, 0xFF, 0x38, 0x7F, 0xCF, 0x1F, 0xF9, 0xC7,
  0xFF, 0x38, 0xF1, 0xEF, 0x3C, 0x39, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7, 0x9C,
  0x3C, 0xE3, 0x8F, 0x1C, 0x79, 0xE3, 0x8F, 0xFC, 0x79, 0xFF, 0x8F, 0x1F,
  0xE1, 0xE1, 0xFC, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83,
  0xE1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xC0,
  0x7D, 0xF0, 0x1F, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x01, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x0F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3C, 0x07, 0xC7, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xC1, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x7C, 0x3C,
  0x1F, 0x8F, 0x87, 0xE1, 0xF1, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xC1, 0x87, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x0F, 0xC3, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0x78, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x02, 0x03, 0xE0, 0x38, 0x7E, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0xC0, 0x78, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0x80,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xB1, 0xFC, 0x1D,
  0x8F, 0xC1, 0xEC, 0xEE, 0x0F, 0x67, 0x70, 0x7B, 0x77, 0x83, 0x9F, 0xBC,
  0x3C, 0xF9, 0xC1, 0xE7, 0xDE, 0x0F, 0x3C, 0xF0, 0x71, 0xE7, 0x87, 0x80,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0xF0,
  0x3F, 0x87, 0x81, 0xFC, 0x3C, 0x1E, 0xF1, 0xE0, 0xF3, 0x9E, 0x07, 0x9C,
  0xF0, 0x3C, 0xE7, 0x83, 0xE7, 0xBC, 0x1E, 0x1F, 0xC0, 0xF0, 0xFE, 0x07,
  0x87, 0xF0, 0x3C, 0x3F, 0x83, 0xC1, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x1E,
  0x0F, 0x87, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0x83, 0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x3E, 0x1F, 0x0F, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C,
  0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x3E, 0x78,
  0x3E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x78, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x01, 0xF3, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC0, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7C, 0x1C, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x3C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF0, 0xF8, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07,
  0xC1, 0xF1, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F,
  0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x87, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x38, 0x1E, 0x79, 0xE0, 0x79, 0xE7, 0x81, 0xCF, 0x9E, 0x0F,
  0x3E, 0x70, 0x3D, 0xF9, 0xC0, 0xF7, 0xEF, 0x03, 0xBB, 0xBC, 0x0E, 0xEE,
  0xE0, 0x7F, 0x3B, 0x81, 0xFC, 0xFE, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00,
  0x1E, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x1E,
  0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0,
  0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0x81, 0xF1, 0xE0,
  0x7C, 0x78, 0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF0,
  0x0F, 0x7C, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E,
  0x7C, 0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF3, 0xE7, 0xCF, 0x9F, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3E,
  0x78, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x07, 0xBF, 0x03, 0xFF, 0x01, 0xE3,
  0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20,
  0x70, 0xF8, 0xFE, 0x3F, 0x1E, 0x06, 0x00, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF3, 0xF0, 0xF9, 0xF0, 0x79, 0xF0, 0x3C, 0xF0, 0x3E, 0x78,
  0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F, 0x07, 0xC7, 0xC7, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0x9C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F,
  0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0xF8, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC7, 0xFF,
  0xE3, 0xF0, 0x23, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x87, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x0F,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x7E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0x9E, 0x00, 0x01, 0xF8, 0x07, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x7E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0x80, 0xF0, 0x00, 0xF8, 0x08, 0xFF, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0,
  0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x60, 0x7E, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x1F,
  0x3E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E,
  0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0, 0x7C,
  0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x8F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x06, 0x1F, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x87,
  0xE1, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBE, 0x00, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x1E, 0x00, 0x7F, 0xC7, 0xFC, 0x7F, 0xCF, 0xFC, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x17, 0xFF,
  0x3F, 0xF3, 0xFF, 0x0F, 0xC0, 0x07, 0xE7, 0x81, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xE7, 0x9E, 0x3C, 0xE3, 0x8F, 0x1C, 0x71, 0xE7, 0x9E,
  0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0x03, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1E, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F,
  0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF0,
  0x1F, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDF, 0x07, 0xC7, 0xC7, 0xE3,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x7E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F,
  0x07, 0xC1, 0xE3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF,
  0xE7, 0xF1, 0xF3, 0xE0, 0xFB, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x3E, 0x78,
  0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x87, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF0, 0x20, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC7, 0x07, 0xE3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x08, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xE0, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xBC, 0x3F,
  0x38, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7,
  0xC3, 0xE3, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x01, 0xE7, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x71, 0xE7,
  0x8E, 0x3C, 0xF3, 0xC7, 0x9C, 0x78, 0xE3, 0x9F, 0x3C, 0x73, 0xF7, 0x0E,
  0xEE, 0xE1, 0xDD, 0xFC, 0x3F, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0xF8, 0x3F,
  0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF8, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8,
  0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x7C, 0x00, 0x3D, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x03, 0x0F, 0xE0, 0xE7, 0xFE, 0x79,
  0xFF, 0xFC, 0xF1, 0xFF, 0x18, 0x3F, 0x80, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 10, 23, 19, 6, -23 },
  { 30, 14, 10, 19, 7, -25 },
  { 48, 20, 23, 19, 1, -23 },
  { 106, 18, 30, 19, 2, -26 },
  { 174, 23, 23, 19, 0, -23 },
  { 241, 17, 23, 19, 2, -23 },
  { 290, 7, 11, 19, 10, -25 },
  { 300, 15, 32, 19, 5, -26 },
  { 360, 14, 32, 19, 2, -26 },
  { 416, 15, 15, 19, 5, -23 },
  { 445, 17, 16, 19, 2, -18 },
  { 479, 9, 12, 19, 4, -7 },
  { 493, 11, 4, 19, 5, -12 },
  { 499, 7, 7, 19, 6, -7 },
  { 506, 21, 32, 19, 0, -26 },
  { 590, 17, 23, 19, 3, -23 },
  { 639, 15, 23, 19, 2, -23 },
  { 683, 18, 23, 19, 2, -23 },
  { 735, 18, 23, 19, 1, -23 },
  { 787, 19, 23, 19, 1, -23 },
  { 842, 20, 23, 19, 1, -23 },
  { 900, 18, 23, 19, 3, -23 },
  { 952, 18, 23, 19, 4, -23 },
  { 1004, 18, 23, 19, 2, -23 },
  { 1056, 18, 23, 19, 2, -23 },
  { 1108, 9, 18, 19, 6, -18 },
  { 1129, 11, 23, 19, 4, -18 },
  { 1161, 17, 16, 19, 3, -17 },
  { 1195, 18, 11, 19, 2, -15 },
  { 1220, 17, 16, 19, 2, -17 },
  { 1254, 14, 23, 19, 6, -23 },
  { 1295, 19, 28, 19, 2, -23 },
  { 1362, 18, 23, 19, 0, -23 },
  { 1414, 19, 23, 19, 1, -23 },
  { 1469, 18, 23, 19, 3, -23 },
  { 1521, 19, 23, 19, 1, -23 },
  { 1576, 19, 23, 19, 2, -23 },
  { 1631, 20, 23, 19, 2, -23 },
  { 1689, 18, 23, 19, 3, -23 },
  { 1741, 21, 23, 19, 1, -23 },
  { 1802, 20, 23, 19, 1, -23 },
  { 1860, 20, 23, 19, 1, -23 },
  { 1918, 21, 23, 19, 1, -23 },
  { 1979, 15, 23, 19, 2, -23 },
  { 2023, 21, 23, 19, 0, -23 },
  { 2084, 21, 23, 19, 1, -23 },
  { 2145, 18, 23, 19, 2, -23 },
  { 2197, 20, 23, 19, 1, -23 },
  { 2255, 17, 30, 19, 3, -23 },
  { 2319, 19, 23, 19, 1, -23 },
  { 2374, 19, 23, 19, 1, -23 },
  { 2429, 17, 23, 19, 5, -23 },
  { 2478, 19, 23, 19, 2, -23 },
  { 2533, 18, 23, 19, 5, -23 },
  { 2585, 22, 23, 19, 1, -23 },
  { 2649, 23, 23, 19, 0, -23 },
  { 2716, 18, 23, 19, 5, -23 },
  { 2768, 20, 23, 19, 1, -23 },
  { 2826, 18, 32, 19, 3, -26 },
  { 2898, 7, 32, 19, 8, -26 },
  { 2926, 18, 32, 19, 1, -26 },
  { 2998, 17, 13, 19, 3, -23 },
  { 3026, 17, 4, 19, -1, 2 },
  { 3035, 8, 7, 19, 9, -26 },
  { 3042, 17, 17, 19, 2, -17 },
  { 3079, 18, 25, 19, 1, -25 },
  { 3136, 17, 17, 19, 3, -17 },
  { 3173, 20, 25, 19, 2, -25 },
  { 3236, 16, 17, 19, 3, -17 },
  { 3270, 23, 31, 19, -1, -25 },
  { 3360, 20, 23, 19, 0, -17 },
  { 3418, 16, 25, 19, 2, -25 },
  { 3468, 13, 25, 19, 4, -25 },
  { 3509, 18, 31, 19, 0, -25 },
  { 3579, 19, 25, 19, 2, -25 },
  { 3639, 12, 25, 19, 5, -25 },
  { 3677, 19, 17, 19, 1, -17 },
  { 3718, 16, 17, 19, 2, -17 },
  { 3752, 17, 17, 19, 2, -17 },
  { 3789, 19, 23, 19, 0, -17 },
  { 3844, 17, 23, 19, 3, -17 },
  { 3893, 17, 17, 19, 3, -17 },
  { 3930, 17, 17, 19, 2, -17 },
  { 3967, 16, 22, 19, 4, -22 },
  { 4011, 16, 17, 19, 3, -17 },
  { 4045, 17, 17, 19, 4, -17 },
  { 4082, 19, 17, 19, 2, -17 },
  { 4123, 20, 17, 19, 0, -17 },
  { 4166, 22, 23, 19, -2, -17 },
  { 4230, 18, 17, 19, 2, -17 },
  { 4269, 17, 32, 19, 4, -26 },
  { 4337, 12, 32, 19, 5, -26 },
  { 4385, 18, 32, 19, 0, -26 },
  { 4457, 18, 7, 19, 2, -13 },
};

const GFXfont UbuntuMono_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic37pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUMONO_BOLDITALIC37PT7B_H_
