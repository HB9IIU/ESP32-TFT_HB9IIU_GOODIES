#ifndef _UBUNTUMONO_BOLDITALIC31PT7B_H_
#define _UBUNTUMONO_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x78, 0x7C, 0x1C, 0x00, 0x79,
  0xEF, 0x3D, 0xE7, 0xF8, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0xC3, 0x00,
  0x00, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x79, 0xC0, 0x38, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x9C, 0x0F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0xE7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x39, 0xC0, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x04, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x30, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xE1, 0xF8, 0x38,
  0x33, 0x0E, 0x0E, 0x63, 0x81, 0x8C, 0xE0, 0x33, 0x98, 0x06, 0x66, 0x00,
  0xFD, 0xC0, 0x0F, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x38, 0x01, 0xDF, 0x80,
  0x33, 0x30, 0x0E, 0xE6, 0x03, 0x98, 0xC0, 0xE3, 0x38, 0x38, 0x66, 0x0E,
  0x0F, 0xC1, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x78,
  0xE0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x78, 0x07, 0xE0, 0x1F, 0x98,
  0x7E, 0x39, 0xFE, 0x77, 0x1F, 0xCE, 0x1F, 0xBC, 0x3E, 0x78, 0x7C, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFC, 0xF0, 0x7B, 0xFD, 0xEF, 0x73, 0x9C, 0xC0, 0x00,
  0x20, 0x03, 0x80, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0x78, 0x03,
  0x80, 0x18, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0xCE, 0x6F, 0x6F, 0x7F,
  0xFB, 0xFF, 0xE1, 0xE0, 0x1F, 0x81, 0xEE, 0x1F, 0x78, 0x73, 0x81, 0x08,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x1E, 0x1E, 0x3F, 0x3E, 0x3E, 0x1E, 0x0E, 0x3C, 0xF8, 0xF0, 0x7F, 0xDF,
  0xE7, 0xFB, 0xFE, 0x79, 0xEF, 0xFE, 0xF9, 0xC0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBD, 0xCF,
  0x73, 0x9C, 0xE7, 0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x9E, 0x0F, 0x3C,
  0x1C, 0x38, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x1F,
  0x03, 0xF0, 0xFF, 0x3F, 0xE1, 0xFE, 0x19, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF3,
  0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x30, 0x7C, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xDE, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x3C, 0x3C, 0x38,
  0x78, 0x38, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x60, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x3E, 0x03, 0xFC, 0x1F, 0xF8,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3D, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF3, 0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x1C, 0x1E, 0x3C, 0x7C,
  0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF1,
  0xC1, 0xE3, 0x83, 0xC7, 0x8F, 0x0F, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7,
  0xC3, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE3,
  0x81, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x7C, 0x3C, 0x7F, 0xF8, 0xFF,
  0xF0, 0x7D, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xE0, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x78, 0xFC, 0xF8, 0xF8, 0x70, 0x03, 0x81, 0xF0, 0xFC, 0x3F,
  0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xFC, 0x3E, 0x0F,
  0x81, 0xE0, 0x38, 0x3C, 0x3E, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x78, 0x03,
  0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x03, 0x00, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x10, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x80, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0, 0x3C, 0x00, 0x80,
  0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0xB0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x07, 0xC3, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF8, 0x73,
  0xC0, 0xE7, 0x01, 0xDC, 0x3F, 0xB8, 0xFF, 0x63, 0xFF, 0xCF, 0x3B, 0x9C,
  0x77, 0x38, 0xEE, 0x73, 0xDD, 0xE7, 0x39, 0xCE, 0x73, 0xFC, 0xE7, 0xF9,
  0xC7, 0xE3, 0xC0, 0x03, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0x80,
  0xF7, 0x03, 0xCE, 0x07, 0x9C, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x78,
  0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x1F, 0x0E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0E, 0x1E, 0x3E, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC, 0x3C, 0x3C,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0xFF, 0xF0,
  0x7F, 0xC0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8, 0x63, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x10, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7E, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x79, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x83, 0x8F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0xFC, 0xFF, 0xF1, 0xFF, 0x83,
  0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFE,
  0x1F, 0x06, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78,
  0x78, 0x70, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0x07, 0x87, 0x83,
  0xC3, 0xC1, 0xE1, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x83, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x70, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0x07, 0x83, 0xC3,
  0xE0, 0xF1, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xEF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x39,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x0F,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE0,
  0xFD, 0xB8, 0x77, 0xEE, 0x1D, 0xF7, 0x07, 0x7D, 0xC1, 0xCE, 0x70, 0xE3,
  0x9C, 0x38, 0x0F, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x1E,
  0x1C, 0x07, 0x8F, 0x01, 0xC0, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x78, 0x77, 0x3C, 0x3B, 0x9C, 0x3D, 0xCE,
  0x1C, 0xEF, 0x0E, 0x37, 0x87, 0x1F, 0x87, 0x8F, 0xC3, 0xC7, 0xE1, 0xC1,
  0xF0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x9E, 0x0F,
  0x3C, 0x3E, 0x7C, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x07, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x1F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1F, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03,
  0x9E, 0x0F, 0x3C, 0x3E, 0x7C, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x7C, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xE0, 0x07, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0x1E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x38, 0xE0, 0x78,
  0xF0, 0x78, 0x70, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x60, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x1F, 0x80, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x03,
  0x9E, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x0E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x1C, 0x07, 0x87, 0x01, 0xC3, 0xC0, 0x70, 0xE7, 0x1C, 0x39, 0xEF, 0x0E,
  0xFB, 0x83, 0xBE, 0xE1, 0xDF, 0xB8, 0x76, 0xFC, 0x1F, 0x9F, 0x07, 0xC7,
  0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0xF0, 0x78, 0x0E, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xBC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7B, 0x80, 0x1E, 0x70, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x83, 0x83, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0xE0, 0x79,
  0xC0, 0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x0E, 0x78, 0x1C, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x0E, 0x1C, 0x38, 0x70, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x07, 0x8F, 0x1E,
  0x1E, 0x78, 0x3C, 0xF0, 0x3C, 0xC0, 0x40, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF0, 0x20, 0xE1, 0xE3, 0xF1, 0xE0, 0x80, 0x03, 0xF8, 0x3F, 0xF1, 0xFF,
  0xCF, 0x8F, 0x78, 0x39, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3,
  0xCF, 0x0F, 0x3C, 0x7C, 0x7F, 0xF1, 0xFF, 0xC3, 0xE7, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xBC, 0x0F,
  0xFC, 0x1F, 0xFC, 0x3C, 0x78, 0x70, 0x71, 0xE0, 0xF3, 0xC1, 0xE7, 0x83,
  0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xC7, 0xFF, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0xCF, 0xC0, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x04, 0x7F,
  0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E,
  0x3C, 0x78, 0x3C, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3E, 0x78, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x8F, 0x78, 0x1D, 0xE0, 0xF7, 0x0F, 0xBF,
  0xFE, 0xFF, 0xE3, 0xE0, 0x0F, 0x00, 0x1E, 0x04, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xE1,
  0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E,
  0x0E, 0x0F, 0x8F, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3D, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x60, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x03,
  0xFF, 0x1F, 0xFC, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCE, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0xF0, 0xF0,
  0x03, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0x8F, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x21, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x1E,
  0x1E, 0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x7B, 0xC0, 0x7B, 0xC0, 0x79, 0xE0, 0x71, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0x7F, 0x9F, 0xE7, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1F, 0x13, 0xFC, 0xFF, 0x1F, 0x80, 0x0F, 0x9C, 0x3F, 0xFC, 0x7F,
  0xF9, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xBD, 0xEF, 0x73, 0x9C,
  0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x00,
  0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1,
  0xCF, 0x0F, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x1E, 0x78, 0x3D,
  0xE0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3E, 0x7C,
  0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0x1E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF1, 0xE7, 0xC3, 0xCF, 0x07, 0x1E, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0xC7, 0x87, 0xFF, 0x0F, 0xFE,
  0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x03, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0x80,
  0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F,
  0x10, 0x3C, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x84, 0x3F, 0xE0,
  0xFF, 0x03, 0xF0, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x78, 0x79,
  0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0x73, 0xC3, 0xCF, 0x0F, 0x3E, 0x7C,
  0x7F, 0xF1, 0xFF, 0xC3, 0xE7, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0x9C,
  0x1E, 0x70, 0xF1, 0xE3, 0xC7, 0x9E, 0x1E, 0x78, 0x7B, 0xC1, 0xEF, 0x07,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x70,
  0x0E, 0x70, 0x0E, 0x73, 0x8E, 0x73, 0x9C, 0xE3, 0x9C, 0xE7, 0x9C, 0xE7,
  0x98, 0xEF, 0xB8, 0xED, 0xB8, 0xFD, 0xB0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xE1, 0xE0, 0x0F, 0x07, 0x87, 0x87, 0x81, 0xE7, 0x80, 0xF7, 0xC0,
  0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xDE, 0x03, 0xCF, 0x03, 0xE3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0x07,
  0x03, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x47,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x07, 0xE0, 0x1F,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0x1E, 0x08, 0xFC, 0x77, 0xFF, 0xFF, 0xFE, 0xE3, 0xF1,
  0x07, 0x80,
};

const GFXglyph UbuntuMono_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 19, 16, 5, -19 },
  { 23, 11, 9, 16, 6, -21 },
  { 36, 17, 19, 16, 1, -19 },
  { 77, 16, 25, 16, 1, -22 },
  { 127, 19, 19, 16, 0, -19 },
  { 173, 15, 19, 16, 1, -19 },
  { 209, 5, 9, 16, 9, -21 },
  { 215, 13, 27, 16, 4, -22 },
  { 259, 13, 27, 16, 1, -22 },
  { 303, 13, 13, 16, 4, -19 },
  { 325, 14, 13, 16, 2, -15 },
  { 348, 8, 10, 16, 3, -6 },
  { 358, 10, 4, 16, 4, -10 },
  { 363, 6, 6, 16, 5, -6 },
  { 368, 18, 27, 16, 0, -22 },
  { 429, 15, 19, 16, 2, -19 },
  { 465, 12, 19, 16, 2, -19 },
  { 494, 15, 19, 16, 1, -19 },
  { 530, 15, 19, 16, 1, -19 },
  { 566, 16, 19, 16, 1, -19 },
  { 604, 16, 19, 16, 1, -19 },
  { 642, 15, 19, 16, 2, -19 },
  { 678, 14, 19, 16, 4, -19 },
  { 712, 15, 19, 16, 2, -19 },
  { 748, 15, 19, 16, 2, -19 },
  { 784, 8, 15, 16, 5, -15 },
  { 799, 10, 19, 16, 3, -15 },
  { 823, 15, 13, 16, 2, -15 },
  { 848, 16, 9, 16, 1, -13 },
  { 866, 14, 13, 16, 2, -15 },
  { 889, 11, 19, 16, 5, -19 },
  { 916, 15, 23, 16, 2, -19 },
  { 960, 15, 19, 16, 0, -19 },
  { 996, 16, 19, 16, 1, -19 },
  { 1034, 15, 19, 16, 3, -19 },
  { 1070, 15, 19, 16, 1, -19 },
  { 1106, 16, 19, 16, 2, -19 },
  { 1144, 16, 19, 16, 2, -19 },
  { 1182, 16, 19, 16, 2, -19 },
  { 1220, 17, 19, 16, 1, -19 },
  { 1261, 17, 19, 16, 1, -19 },
  { 1302, 16, 19, 16, 1, -19 },
  { 1340, 18, 19, 16, 1, -19 },
  { 1383, 13, 19, 16, 1, -19 },
  { 1414, 18, 19, 16, 0, -19 },
  { 1457, 17, 19, 16, 1, -19 },
  { 1498, 15, 19, 16, 2, -19 },
  { 1534, 16, 19, 16, 1, -19 },
  { 1572, 15, 24, 16, 2, -19 },
  { 1617, 16, 19, 16, 1, -19 },
  { 1655, 16, 19, 16, 1, -19 },
  { 1693, 15, 19, 16, 4, -19 },
  { 1729, 16, 19, 16, 2, -19 },
  { 1767, 15, 19, 16, 4, -19 },
  { 1803, 18, 19, 16, 1, -19 },
  { 1846, 19, 19, 16, 0, -19 },
  { 1892, 15, 19, 16, 4, -19 },
  { 1928, 17, 19, 16, 1, -19 },
  { 1969, 15, 27, 16, 3, -22 },
  { 2020, 7, 27, 16, 6, -22 },
  { 2044, 16, 27, 16, 0, -22 },
  { 2098, 15, 11, 16, 2, -19 },
  { 2119, 15, 3, 16, -1, 2 },
  { 2125, 7, 6, 16, 7, -21 },
  { 2131, 14, 15, 16, 2, -15 },
  { 2158, 15, 21, 16, 1, -21 },
  { 2198, 14, 15, 16, 2, -15 },
  { 2225, 16, 21, 16, 2, -21 },
  { 2267, 14, 15, 16, 2, -15 },
  { 2294, 19, 26, 16, -1, -21 },
  { 2356, 17, 20, 16, 0, -15 },
  { 2399, 14, 21, 16, 1, -21 },
  { 2436, 11, 22, 16, 3, -22 },
  { 2467, 15, 27, 16, 0, -22 },
  { 2518, 16, 21, 16, 2, -21 },
  { 2560, 10, 21, 16, 4, -21 },
  { 2587, 15, 15, 16, 1, -15 },
  { 2616, 14, 15, 16, 1, -15 },
  { 2643, 14, 15, 16, 2, -15 },
  { 2670, 16, 20, 16, 0, -15 },
  { 2710, 15, 20, 16, 2, -15 },
  { 2748, 15, 15, 16, 2, -15 },
  { 2777, 14, 15, 16, 2, -15 },
  { 2804, 13, 19, 16, 3, -19 },
  { 2835, 14, 15, 16, 2, -15 },
  { 2862, 14, 15, 16, 3, -15 },
  { 2889, 16, 15, 16, 2, -15 },
  { 2919, 17, 15, 16, 0, -15 },
  { 2951, 18, 20, 16, -1, -15 },
  { 2996, 14, 15, 16, 2, -15 },
  { 3023, 15, 27, 16, 3, -22 },
  { 3074, 10, 27, 16, 4, -22 },
  { 3108, 15, 27, 16, 0, -22 },
  { 3159, 14, 6, 16, 2, -11 },
};

const GFXfont UbuntuMono_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic31pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUMONO_BOLDITALIC31PT7B_H_
