#ifndef _UBUNTUMONO_BOLDITALIC20PT7B_H_
#define _UBUNTUMONO_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0x06, 0x38, 0xEF, 0xDF,
  0xBE, 0x6C, 0xD1, 0x00, 0x0C, 0xC3, 0x30, 0xD9, 0xFF, 0x7F, 0xCC, 0xC3,
  0x33, 0xFE, 0xFF, 0x9B, 0x0C, 0xC3, 0x30, 0x03, 0x00, 0xC0, 0xF8, 0xFE,
  0x38, 0x8C, 0x03, 0x80, 0xF8, 0x0F, 0x01, 0xC0, 0x31, 0x0C, 0xFF, 0x1F,
  0x83, 0x80, 0xC0, 0x1C, 0x33, 0xE6, 0x36, 0xC2, 0x58, 0x3D, 0x03, 0xA0,
  0x07, 0xC0, 0xFC, 0x1B, 0x43, 0x24, 0x63, 0xC4, 0x38, 0x0F, 0x07, 0xE3,
  0x98, 0xCC, 0x37, 0x07, 0x07, 0xDB, 0xB6, 0xC7, 0x31, 0xCF, 0xF1, 0xEE,
  0xFF, 0x6D, 0x00, 0x02, 0x06, 0x1E, 0x3C, 0x38, 0x70, 0x60, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x70, 0x20, 0x08, 0x0C, 0x06, 0x06,
  0x07, 0x03, 0x03, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0x40, 0x1C, 0x26, 0x9A, 0xE7, 0xE1, 0xC1, 0xB1, 0xDC, 0x24, 0x06, 0x07,
  0x03, 0x0F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x33, 0xDE, 0x73, 0x73, 0x00,
  0xFF, 0xE0, 0x6F, 0xF6, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x0F, 0x07, 0xE3, 0x9D, 0xC7, 0x61,
  0xDB, 0x76, 0xDB, 0x86, 0xE3, 0x99, 0xC7, 0xE0, 0xF0, 0x03, 0x0F, 0x3F,
  0x36, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x7F, 0xFF, 0x0F, 0x0F, 0xE3,
  0x1C, 0x07, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x18, 0x0F, 0xF3, 0xFC,
  0x1F, 0x0F, 0xC0, 0x60, 0x30, 0x38, 0xF8, 0x7C, 0x06, 0x03, 0xC3, 0xBF,
  0xDF, 0x80, 0x01, 0xC0, 0xE0, 0x78, 0x36, 0x1B, 0x8C, 0xC6, 0x33, 0xFE,
  0xFF, 0x81, 0x80, 0x60, 0x18, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x3C, 0x0F,
  0xC0, 0x70, 0x0E, 0x03, 0x21, 0xCF, 0xF3, 0xF0, 0x03, 0xC3, 0xF1, 0xC0,
  0xC0, 0x6F, 0x1F, 0xE6, 0x39, 0x86, 0x61, 0x98, 0xE7, 0xF0, 0xF8, 0x7F,
  0xDF, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x31, 0x87, 0xC3, 0xE1, 0xCC,
  0xE3, 0xB8, 0xE7, 0xF0, 0xF8, 0x0F, 0x0F, 0xE3, 0x19, 0xC7, 0x61, 0xDC,
  0x77, 0xF8, 0xF6, 0x03, 0x03, 0xCF, 0xC3, 0xC0, 0x39, 0xCE, 0x70, 0x01,
  0x9E, 0xF3, 0x00, 0x1C, 0x71, 0xC7, 0x00, 0x03, 0x1E, 0x78, 0xE3, 0x38,
  0xC0, 0x01, 0x83, 0xCF, 0x9F, 0x0C, 0x07, 0xC1, 0xF8, 0x3C, 0x02, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x20, 0x3C, 0x0F, 0x81,
  0xF0, 0x38, 0x7D, 0xF9, 0xE0, 0xC0, 0x00, 0x3C, 0x7E, 0x47, 0x07, 0x0E,
  0x1E, 0x38, 0x70, 0x60, 0x00, 0xE0, 0xE0, 0x0F, 0x87, 0xF3, 0x8D, 0xC3,
  0x67, 0xDB, 0xFC, 0xCF, 0x66, 0xD9, 0xB6, 0x6D, 0xFB, 0x3C, 0x60, 0x1F,
  0x81, 0xE0, 0x03, 0x81, 0xE0, 0x78, 0x36, 0x0D, 0x86, 0x61, 0x98, 0xFE,
  0x3F, 0x98, 0x76, 0x1F, 0x87, 0x1F, 0x0F, 0xE3, 0x1C, 0xC7, 0x31, 0x9F,
  0xC7, 0xF1, 0x8E, 0x61, 0xB8, 0xEF, 0xF3, 0xF0, 0x0F, 0x9F, 0xDC, 0x2C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x3F, 0x87, 0x80, 0x3F, 0x0F,
  0xE3, 0x18, 0xC7, 0x71, 0xDC, 0x66, 0x19, 0x8E, 0xE3, 0xB9, 0xCF, 0xE3,
  0xE0, 0x1F, 0xC7, 0xF3, 0x80, 0xE0, 0x30, 0x0F, 0xC7, 0xF1, 0xC0, 0x60,
  0x18, 0x0F, 0xF3, 0xFC, 0x1F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03, 0x00, 0x7F,
  0x1F, 0xC3, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x00, 0x0F, 0x9F, 0xDC,
  0x2C, 0x0E, 0x06, 0x03, 0x0D, 0x8E, 0xC7, 0x73, 0x3F, 0x8F, 0xC0, 0x38,
  0xE7, 0x18, 0xC3, 0x18, 0xE7, 0x1C, 0xFF, 0x1F, 0xE3, 0x1C, 0xE3, 0x9C,
  0x63, 0x0C, 0x63, 0x80, 0x1F, 0xC7, 0xF8, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xC7, 0xF0,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x11, 0xCF, 0xE1, 0xF0,
  0x38, 0xE7, 0x38, 0xCE, 0x1B, 0x87, 0xE0, 0xF8, 0x1B, 0x03, 0x70, 0xE6,
  0x1C, 0xE3, 0x0C, 0x61, 0xC0, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0xFF, 0xFF, 0x0C, 0x61, 0xCE, 0x1C, 0xE1, 0x5E, 0x35,
  0x63, 0x76, 0x36, 0xC6, 0x6C, 0x60, 0xC6, 0x0C, 0x61, 0xCC, 0x18, 0x38,
  0xE7, 0x18, 0xE3, 0x1E, 0x67, 0xDC, 0xDB, 0x19, 0x63, 0x3C, 0xE7, 0x98,
  0xE3, 0x1C, 0x61, 0x80, 0x0F, 0x07, 0xE3, 0x9D, 0xC7, 0x71, 0xD8, 0x76,
  0x1B, 0x86, 0xE3, 0xB9, 0xC7, 0xE0, 0xF0, 0x1F, 0x0F, 0xF3, 0x9C, 0xC3,
  0x31, 0xDC, 0x77, 0xF9, 0xF8, 0x60, 0x38, 0x0E, 0x03, 0x00, 0x0F, 0x07,
  0xE3, 0x9D, 0xC7, 0x71, 0xD8, 0x76, 0x1B, 0x86, 0xE3, 0xB9, 0xC7, 0xE0,
  0xF0, 0x18, 0x07, 0x80, 0xE0, 0x1F, 0x0F, 0xE3, 0x1C, 0xC7, 0x31, 0x9C,
  0xE7, 0xF1, 0xF8, 0x66, 0x39, 0xCE, 0x33, 0x0C, 0x0F, 0x8F, 0xF3, 0x08,
  0xC0, 0x38, 0x0F, 0x81, 0xF0, 0x1C, 0x03, 0x20, 0xCF, 0xF1, 0xF0, 0xFF,
  0xFF, 0xC6, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x00, 0x38, 0xC6, 0x18, 0xC7, 0x18, 0xE7, 0x18, 0xC3, 0x18, 0xE3, 0x1C,
  0xE3, 0x1C, 0xE1, 0xF8, 0x1E, 0x00, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66,
  0x73, 0x31, 0xB8, 0xD8, 0x7C, 0x3C, 0x1C, 0x00, 0x30, 0x66, 0x0C, 0xC3,
  0x30, 0x66, 0x4C, 0xD9, 0x9F, 0x62, 0xBC, 0xF7, 0x9C, 0xE3, 0x9C, 0x63,
  0x80, 0x1C, 0x70, 0xCE, 0x0E, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x0F, 0x01,
  0xF0, 0x1F, 0x83, 0x98, 0x71, 0x8E, 0x18, 0xC3, 0xE1, 0xB9, 0xDD, 0xC6,
  0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0xCF, 0xF0,
  0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0F, 0xF3, 0xFC,
  0x0F, 0x83, 0xE1, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xF0, 0xF8, 0x00, 0xEE, 0xEE,
  0x66, 0x66, 0x66, 0x67, 0x77, 0x73, 0x30, 0x0F, 0xC3, 0xF0, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC1, 0xF0, 0xFC, 0x00, 0x0E, 0x0F, 0x0F, 0xC6, 0xE7, 0x37, 0x1F,
  0x0C, 0x7F, 0xFF, 0xE0, 0x4E, 0x73, 0x0F, 0x8F, 0xE7, 0x19, 0x8E, 0xE3,
  0x38, 0xCE, 0x71, 0xFC, 0x7B, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0xF9, 0xFE, 0xE7, 0x71, 0xB1, 0xF8, 0xFC, 0xEF, 0xE7, 0xE0, 0x1F, 0xBF,
  0xBC, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x1F, 0x0F, 0xE3, 0x8C, 0x63, 0x9C, 0x63, 0x8C,
  0x73, 0x87, 0xF0, 0xF6, 0x00, 0x0F, 0x1F, 0xDC, 0x6C, 0x37, 0xF7, 0xE1,
  0x80, 0xFE, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x60, 0x07, 0x00, 0x30,
  0x07, 0xF8, 0x3F, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0xE3,
  0x18, 0xE3, 0x1C, 0x63, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0xE3, 0xFC, 0x3E,
  0x00, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xF8, 0xFE, 0xE7, 0x73, 0xB1,
  0xD8, 0xDC, 0x6E, 0x76, 0x38, 0x1C, 0x38, 0x03, 0xEF, 0x83, 0x0E, 0x1C,
  0x30, 0x60, 0xF8, 0xF0, 0x01, 0x80, 0x60, 0x00, 0x7E, 0x1F, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x4E, 0x3F, 0x07, 0x80, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x73, 0x38, 0xDC, 0x7C, 0x1F, 0x06,
  0xE1, 0x98, 0xE7, 0x38, 0xC0, 0xFB, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x61,
  0x8E, 0x38, 0x7D, 0xF0, 0x1F, 0xC7, 0xFC, 0xD9, 0x9B, 0x63, 0x6C, 0xCD,
  0x98, 0x33, 0x0C, 0x61, 0x80, 0x3F, 0x1F, 0xCC, 0xEE, 0x77, 0x3B, 0x19,
  0x8D, 0xCE, 0xC7, 0x00, 0x1F, 0x1F, 0xDC, 0xEC, 0x3E, 0x1F, 0x1F, 0x9C,
  0xFC, 0x3C, 0x00, 0x1F, 0x87, 0xF3, 0x9C, 0xE3, 0x30, 0xCC, 0x77, 0x39,
  0xFC, 0x7E, 0x18, 0x0E, 0x03, 0x80, 0x0F, 0x8F, 0xE7, 0x19, 0x8E, 0x63,
  0xB8, 0xCE, 0x31, 0xFC, 0x3F, 0x01, 0x80, 0x60, 0x38, 0x1F, 0xCF, 0xE3,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x00, 0x1F, 0x9F, 0xCC,
  0x07, 0x01, 0xE0, 0x38, 0x1D, 0xFE, 0x7C, 0x00, 0x1C, 0x0C, 0x06, 0x0F,
  0xEF, 0xF1, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0x87, 0xC0, 0x63, 0x31,
  0xB9, 0xD8, 0xEC, 0x66, 0x33, 0x39, 0xFC, 0xF6, 0x00, 0xE3, 0xF1, 0xB9,
  0xDC, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x70, 0x00, 0x60, 0xCC, 0x19, 0xB3,
  0x26, 0xCD, 0xD9, 0xAB, 0x3D, 0xC7, 0x38, 0xE6, 0x00, 0x38, 0xE3, 0x38,
  0x7E, 0x07, 0x80, 0xE0, 0x3E, 0x06, 0xC1, 0x9C, 0x61, 0x80, 0x1C, 0x71,
  0xC6, 0x1C, 0xE0, 0xCE, 0x0C, 0xC0, 0xDC, 0x0F, 0x80, 0xF0, 0x07, 0x00,
  0xE0, 0x7C, 0x0F, 0x00, 0x3F, 0x8F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0x83, 0xE0, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0xF0, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0xF0,
  0x3C, 0x00, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1,
  0x83, 0x0E, 0x1C, 0x30, 0x60, 0x0F, 0x03, 0xC0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xC1, 0xE0, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC3,
  0xE0, 0xF0, 0x00, 0x38, 0xDF, 0xEC, 0xF0,
};

const GFXglyph UbuntuMono_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 12, 10, 3, -12 },
  { 10, 7, 6, 10, 4, -14 },
  { 16, 10, 12, 10, 1, -12 },
  { 31, 10, 16, 10, 1, -14 },
  { 51, 12, 12, 10, 0, -12 },
  { 69, 10, 12, 10, 1, -12 },
  { 84, 3, 6, 10, 6, -14 },
  { 87, 8, 17, 10, 3, -14 },
  { 104, 8, 17, 10, 1, -14 },
  { 121, 9, 8, 10, 2, -12 },
  { 130, 9, 8, 10, 1, -10 },
  { 139, 5, 7, 10, 2, -4 },
  { 144, 6, 2, 10, 3, -6 },
  { 146, 4, 4, 10, 3, -4 },
  { 148, 12, 17, 10, 0, -14 },
  { 174, 10, 12, 10, 1, -12 },
  { 189, 8, 12, 10, 1, -12 },
  { 201, 10, 12, 10, 1, -12 },
  { 216, 9, 12, 10, 1, -12 },
  { 230, 10, 12, 10, 1, -12 },
  { 245, 10, 12, 10, 1, -12 },
  { 260, 10, 12, 10, 1, -12 },
  { 275, 10, 12, 10, 2, -12 },
  { 290, 10, 12, 10, 1, -12 },
  { 305, 10, 12, 10, 1, -12 },
  { 320, 5, 10, 10, 3, -10 },
  { 327, 6, 13, 10, 2, -10 },
  { 337, 9, 9, 10, 2, -9 },
  { 348, 10, 6, 10, 1, -8 },
  { 356, 9, 9, 10, 1, -9 },
  { 367, 8, 12, 10, 3, -12 },
  { 379, 10, 15, 10, 1, -12 },
  { 398, 10, 12, 10, 0, -12 },
  { 413, 10, 12, 10, 1, -12 },
  { 428, 9, 12, 10, 2, -12 },
  { 442, 10, 12, 10, 1, -12 },
  { 457, 10, 12, 10, 1, -12 },
  { 472, 11, 12, 10, 1, -12 },
  { 489, 9, 12, 10, 2, -12 },
  { 503, 11, 12, 10, 1, -12 },
  { 520, 11, 12, 10, 1, -12 },
  { 537, 10, 12, 10, 1, -12 },
  { 552, 11, 12, 10, 1, -12 },
  { 569, 8, 12, 10, 1, -12 },
  { 581, 12, 12, 10, 0, -12 },
  { 599, 11, 12, 10, 1, -12 },
  { 616, 10, 12, 10, 1, -12 },
  { 631, 10, 12, 10, 1, -12 },
  { 646, 10, 15, 10, 1, -12 },
  { 665, 10, 12, 10, 1, -12 },
  { 680, 10, 12, 10, 1, -12 },
  { 695, 9, 12, 10, 3, -12 },
  { 709, 11, 12, 10, 1, -12 },
  { 726, 9, 12, 10, 3, -12 },
  { 740, 11, 12, 10, 1, -12 },
  { 757, 12, 12, 10, 0, -12 },
  { 775, 9, 12, 10, 3, -12 },
  { 789, 10, 12, 10, 1, -12 },
  { 804, 10, 17, 10, 2, -14 },
  { 826, 4, 17, 10, 4, -14 },
  { 835, 10, 17, 10, 0, -14 },
  { 857, 9, 7, 10, 2, -12 },
  { 865, 10, 2, 10, -1, 1 },
  { 868, 4, 4, 10, 5, -14 },
  { 870, 10, 9, 10, 1, -9 },
  { 882, 9, 14, 10, 1, -14 },
  { 898, 9, 9, 10, 2, -9 },
  { 909, 11, 14, 10, 1, -14 },
  { 929, 9, 9, 10, 1, -9 },
  { 940, 13, 17, 10, -1, -14 },
  { 968, 11, 12, 10, 0, -9 },
  { 985, 9, 14, 10, 1, -14 },
  { 1001, 7, 12, 10, 2, -12 },
  { 1012, 10, 15, 10, 0, -12 },
  { 1031, 10, 14, 10, 1, -14 },
  { 1049, 6, 14, 10, 3, -14 },
  { 1060, 11, 9, 10, 0, -9 },
  { 1073, 9, 9, 10, 1, -9 },
  { 1084, 9, 9, 10, 1, -9 },
  { 1095, 10, 12, 10, 0, -9 },
  { 1110, 10, 12, 10, 1, -9 },
  { 1125, 10, 9, 10, 1, -9 },
  { 1137, 9, 9, 10, 1, -9 },
  { 1148, 9, 12, 10, 2, -12 },
  { 1162, 9, 9, 10, 2, -9 },
  { 1173, 9, 9, 10, 2, -9 },
  { 1184, 11, 9, 10, 1, -9 },
  { 1197, 11, 9, 10, 0, -9 },
  { 1210, 12, 12, 10, -1, -9 },
  { 1228, 10, 9, 10, 1, -9 },
  { 1240, 10, 17, 10, 2, -14 },
  { 1262, 7, 17, 10, 2, -14 },
  { 1277, 10, 17, 10, 0, -14 },
  { 1299, 10, 3, 10, 1, -7 },
};

const GFXfont UbuntuMono_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic20pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUMONO_BOLDITALIC20PT7B_H_
