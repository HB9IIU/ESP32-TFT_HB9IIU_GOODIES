#ifndef _UBUNTUMONO_BOLDITALIC8PT7B_H_
#define _UBUNTUMONO_BOLDITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x0C, 0xF0, 0x33, 0x95, 0xEA, 0x00, 0x17, 0x46, 0x1E, 0x40,
  0x6A, 0x88, 0xAB, 0x00, 0x35, 0x6B, 0xF0, 0xA0, 0x2D, 0x49, 0x10, 0x22,
  0x12, 0x26, 0x80, 0xFE, 0x80, 0x5D, 0x00, 0xE0, 0xC0, 0xC0, 0x10, 0x88,
  0x44, 0x22, 0x00, 0x77, 0xDC, 0x79, 0x2E, 0x71, 0x34, 0xF0, 0x71, 0x21,
  0xE0, 0x13, 0x5F, 0x20, 0x34, 0x61, 0xE0, 0x73, 0xDE, 0xF2, 0x44, 0x80,
  0x35, 0x35, 0x70, 0x75, 0x73, 0xE0, 0x4C, 0x4E, 0x3B, 0x30, 0x70, 0xF0,
  0x43, 0x3C, 0x65, 0x0C, 0x37, 0xBB, 0xB6, 0x33, 0x57, 0x90, 0x75, 0x75,
  0xF0, 0x68, 0x88, 0xE0, 0x75, 0x55, 0xE0, 0x72, 0x1C, 0x87, 0x00, 0x3A,
  0x1C, 0x84, 0x00, 0x68, 0xAA, 0xE0, 0x4A, 0x9C, 0xA9, 0x00, 0x79, 0x08,
  0x4F, 0x00, 0x31, 0x11, 0xE0, 0x53, 0x98, 0xC9, 0x00, 0x44, 0x44, 0xF0,
  0x5A, 0x9D, 0x29, 0x00, 0x4B, 0x9D, 0x69, 0x00, 0x76, 0xDC, 0x75, 0x74,
  0x80, 0x76, 0xDD, 0x10, 0x75, 0x76, 0x90, 0x34, 0x71, 0xE0, 0xF4, 0x44,
  0x80, 0x9A, 0xAA, 0xC0, 0x9A, 0xAC, 0xC0, 0x4A, 0x5C, 0xE9, 0x00, 0x51,
  0x88, 0xA9, 0x00, 0x9A, 0x44, 0x80, 0x70, 0x88, 0x8F, 0x00, 0x74, 0x44,
  0x88, 0xC0, 0xFE, 0x31, 0x22, 0x22, 0xC0, 0x76, 0x80, 0xE0, 0x80, 0xF6,
  0xF0, 0x64, 0x75, 0x5E, 0x72, 0x70, 0x12, 0xEA, 0xAE, 0xF7, 0x70, 0x19,
  0x1C, 0x44, 0x23, 0x00, 0x35, 0x56, 0xE0, 0x24, 0x75, 0x59, 0x43, 0x24,
  0xC0, 0x10, 0x72, 0x22, 0xC0, 0x22, 0x14, 0xC6, 0x28, 0xC9, 0x28, 0xC0,
  0x77, 0xB9, 0x75, 0x5A, 0xF6, 0xE0, 0x75, 0x5E, 0x80, 0xF6, 0xE4, 0xF2,
  0x40, 0x74, 0x3E, 0x5E, 0x4E, 0xB6, 0xF0, 0xB7, 0x60, 0x9E, 0xEC, 0x52,
  0x6D, 0x55, 0x66, 0xC0, 0x72, 0x46, 0x34, 0x48, 0x88, 0xC0, 0x29, 0x25,
  0x20, 0x22, 0x21, 0x24, 0xC0, 0x5B,
};

const GFXglyph UbuntuMono_BoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 2, -5 },
  { 4, 5, 5, 4, 0, -5 },
  { 8, 4, 7, 4, 0, -6 },
  { 12, 5, 5, 4, 0, -5 },
  { 16, 4, 5, 4, 0, -5 },
  { 19, 2, 2, 4, 2, -5 },
  { 20, 3, 7, 4, 1, -6 },
  { 23, 4, 7, 4, 0, -6 },
  { 27, 3, 3, 4, 1, -5 },
  { 29, 3, 3, 4, 1, -4 },
  { 31, 2, 2, 4, 1, -1 },
  { 32, 3, 1, 4, 1, -3 },
  { 33, 2, 1, 4, 1, -1 },
  { 34, 5, 7, 4, 0, -6 },
  { 39, 3, 5, 4, 1, -5 },
  { 41, 3, 5, 4, 1, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 3, 5, 4, 1, -5 },
  { 57, 4, 5, 4, 1, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 2, 3, 4, 1, -3 },
  { 67, 2, 4, 4, 1, -3 },
  { 68, 3, 4, 4, 1, -4 },
  { 70, 4, 3, 4, 0, -3 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 4, 6, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 1, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 5, 5, 4, 0, -5 },
  { 95, 5, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 1, -5 },
  { 102, 5, 5, 4, 0, -5 },
  { 106, 5, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 5, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 5, 5, 4, 0, -5 },
  { 124, 5, 5, 4, 0, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 3, 7, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 1, -5 },
  { 145, 4, 5, 4, 1, -5 },
  { 148, 4, 5, 4, 1, -5 },
  { 151, 5, 5, 4, 0, -5 },
  { 155, 5, 5, 4, 0, -5 },
  { 159, 4, 5, 4, 1, -5 },
  { 162, 5, 5, 4, 0, -5 },
  { 166, 4, 7, 4, 1, -6 },
  { 170, 1, 7, 4, 2, -6 },
  { 171, 4, 7, 4, 0, -6 },
  { 175, 3, 3, 4, 1, -5 },
  { 177, 4, 1, 4, 0, 0 },
  { 178, 2, 1, 4, 2, -6 },
  { 179, 3, 4, 4, 1, -4 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 3, 4, 4, 1, -4 },
  { 186, 4, 6, 4, 1, -6 },
  { 189, 3, 4, 4, 1, -4 },
  { 191, 5, 7, 4, 0, -6 },
  { 196, 4, 5, 4, 0, -4 },
  { 199, 4, 6, 4, 0, -6 },
  { 202, 3, 6, 4, 1, -6 },
  { 205, 4, 7, 4, 0, -6 },
  { 209, 5, 6, 4, 0, -6 },
  { 213, 3, 6, 4, 1, -6 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 3, 4, 4, 1, -4 },
  { 222, 4, 5, 4, 0, -4 },
  { 225, 3, 5, 4, 1, -4 },
  { 227, 3, 4, 4, 1, -4 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 3, 5, 4, 1, -5 },
  { 233, 3, 4, 4, 1, -4 },
  { 235, 3, 4, 4, 1, -4 },
  { 237, 4, 4, 4, 1, -4 },
  { 239, 4, 4, 4, 0, -4 },
  { 241, 4, 5, 4, 0, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 4, 7, 4, 1, -6 },
  { 250, 3, 7, 4, 1, -6 },
  { 253, 4, 7, 4, 0, -6 },
  { 257, 4, 2, 4, 0, -3 },
};

const GFXfont UbuntuMono_BoldItalic8pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic8pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic8pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUMONO_BOLDITALIC8PT7B_H_
