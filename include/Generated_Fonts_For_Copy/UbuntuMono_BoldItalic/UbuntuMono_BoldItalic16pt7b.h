#ifndef _UBUNTUMONO_BOLDITALIC16PT7B_H_
#define _UBUNTUMONO_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x76, 0x66, 0x40, 0xCC, 0x6F, 0x3D, 0xB6, 0x98, 0x1B, 0x12,
  0x7F, 0xFF, 0x24, 0x6C, 0xFE, 0xFE, 0xD8, 0x90, 0x0C, 0x1C, 0x3E, 0x60,
  0x70, 0x38, 0x3C, 0x0E, 0x8E, 0xFC, 0xF8, 0x20, 0x20, 0x18, 0x8A, 0x62,
  0xB1, 0xB8, 0x34, 0x02, 0xC1, 0x50, 0xD4, 0x65, 0x31, 0x80, 0x1C, 0x7C,
  0x99, 0x63, 0x8E, 0x77, 0xE6, 0xFD, 0xEC, 0x6D, 0xA4, 0x04, 0x18, 0x61,
  0x86, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x04, 0x00, 0x10, 0x60,
  0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x63, 0x1C, 0xE2, 0x00, 0x30, 0x63, 0x57,
  0xE3, 0x8D, 0x9A, 0x00, 0x08, 0x30, 0x67, 0xFF, 0xE6, 0x0C, 0x18, 0x6D,
  0xBC, 0x7F, 0xC0, 0xFC, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x1E, 0x3E, 0x63, 0x63,
  0xDA, 0xDE, 0xC6, 0xCE, 0xFC, 0x78, 0x0C, 0xF7, 0xC3, 0x18, 0x61, 0x86,
  0xFF, 0xF0, 0x1E, 0x7E, 0x26, 0x06, 0x0E, 0x1C, 0x30, 0x60, 0xFC, 0xFC,
  0x1E, 0x1F, 0x03, 0x03, 0x1E, 0x1E, 0x03, 0x07, 0x7E, 0x7C, 0x07, 0x0E,
  0x1E, 0x36, 0x66, 0x44, 0xFE, 0xFE, 0x0C, 0x08, 0x1F, 0x3F, 0x30, 0x38,
  0x7C, 0x0E, 0x06, 0x0C, 0xFC, 0xF8, 0x0F, 0x1F, 0x38, 0x60, 0x7C, 0xFE,
  0xC6, 0xC6, 0x7C, 0x38, 0x7E, 0xFE, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60,
  0xC0, 0xC0, 0x1E, 0x3F, 0x63, 0x36, 0x3C, 0x6C, 0xC6, 0xC6, 0xFC, 0x78,
  0x3C, 0x7E, 0x66, 0x63, 0x62, 0x3E, 0x06, 0x1C, 0xF8, 0xE0, 0x67, 0x60,
  0x0C, 0xCC, 0x31, 0xCC, 0x00, 0x31, 0x8C, 0x66, 0x00, 0x02, 0x1F, 0x7C,
  0xF0, 0xF0, 0x7C, 0x1C, 0x04, 0x7E, 0x7E, 0x00, 0xFE, 0xFE, 0x60, 0xF0,
  0xF8, 0x70, 0xEF, 0xFC, 0x40, 0x3C, 0xF9, 0x30, 0x61, 0x86, 0x18, 0x00,
  0x60, 0xC0, 0x1E, 0x33, 0x63, 0x4F, 0xDF, 0xF2, 0xB6, 0xBE, 0x9E, 0xC0,
  0x60, 0x3C, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x33, 0x3F, 0x7F, 0x63, 0xC3,
  0x3E, 0x3E, 0x63, 0x66, 0x7E, 0x7E, 0xC6, 0xC6, 0xFC, 0xF8, 0x0F, 0x3F,
  0x70, 0x60, 0x60, 0xC0, 0xC0, 0xE0, 0x7C, 0x3C, 0x1E, 0x1F, 0x33, 0x33,
  0x33, 0x33, 0x63, 0x67, 0x7E, 0x78, 0x3F, 0x3F, 0x30, 0x60, 0x7E, 0x7C,
  0x60, 0xC0, 0xFC, 0xFC, 0x3F, 0x3F, 0x30, 0x60, 0x7E, 0x7E, 0x60, 0xE0,
  0xC0, 0xC0, 0x1F, 0x3F, 0x70, 0x60, 0x60, 0xC6, 0xC6, 0xE6, 0x7C, 0x7C,
  0x19, 0x98, 0xCC, 0x66, 0x33, 0xF3, 0xF9, 0x8C, 0xC6, 0x66, 0x33, 0x00,
  0x3F, 0x3F, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x30, 0xFC, 0xFC, 0x1F, 0x3F,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x8C, 0xFC, 0xF8, 0x19, 0x84, 0xC3, 0x70,
  0xD8, 0x3C, 0x0F, 0x06, 0xC1, 0x98, 0x66, 0x18, 0xC0, 0x30, 0xC6, 0x18,
  0x61, 0x84, 0x30, 0xFF, 0xF0, 0x19, 0x9C, 0xCE, 0xE5, 0xF2, 0xD3, 0x69,
  0x8C, 0x86, 0xC3, 0x61, 0x00, 0x19, 0x9C, 0xCE, 0x67, 0x32, 0xD3, 0x39,
  0x9C, 0xCE, 0x66, 0x23, 0x00, 0x1E, 0x3E, 0x63, 0x63, 0xC3, 0xC6, 0xC6,
  0xCE, 0xFC, 0x78, 0x3E, 0x3F, 0x63, 0x63, 0x67, 0x7E, 0xFC, 0xC0, 0xC0,
  0xC0, 0x1E, 0x3E, 0x63, 0x63, 0xC3, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x30,
  0x3C, 0x18, 0x3C, 0x3E, 0x67, 0x62, 0x66, 0x7C, 0xF8, 0xCC, 0xCC, 0xC4,
  0x0F, 0x0F, 0x8C, 0x07, 0x03, 0xE0, 0xF0, 0x1C, 0x8C, 0x7E, 0x3E, 0x00,
  0xFF, 0xFE, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x33, 0x63,
  0x63, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0xC3, 0xC6, 0xC6, 0xCC,
  0xCC, 0xD8, 0xD8, 0xF0, 0x70, 0x60, 0x61, 0xB0, 0x98, 0xC8, 0x65, 0xB6,
  0xD3, 0xB9, 0xDC, 0xCC, 0x66, 0x00, 0x19, 0x86, 0x61, 0xB0, 0x38, 0x0E,
  0x03, 0x01, 0xE0, 0xD8, 0x66, 0x38, 0xC0, 0xC7, 0x46, 0x6C, 0x7C, 0x78,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x1F, 0x8F, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x40, 0x7E, 0x3F, 0x00, 0x0F, 0x1F, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x78, 0x78, 0xD9, 0x26, 0xDB, 0x6D, 0xB6,
  0x40, 0x1F, 0x1F, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x78, 0xF8, 0x0C, 0x1C, 0x36, 0x76, 0xE6, 0x42, 0x7F, 0xFF, 0x9C,
  0x80, 0x1E, 0xFD, 0x9E, 0x3C, 0xD9, 0xBF, 0x3B, 0x30, 0x60, 0xC3, 0xE7,
  0xEC, 0xD9, 0xE3, 0xCD, 0xFB, 0xE0, 0x1E, 0x3E, 0x60, 0xC0, 0xC0, 0xC0,
  0x7C, 0x3C, 0x03, 0x03, 0x03, 0x1E, 0x7E, 0x66, 0xC6, 0xCC, 0xCC, 0xFC,
  0x76, 0x1E, 0xFD, 0x9E, 0x7F, 0xD8, 0x1F, 0x1E, 0x03, 0xC1, 0xF0, 0x60,
  0x7E, 0x1F, 0x83, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x78,
  0x3C, 0x00, 0x0F, 0x9F, 0x8C, 0xCC, 0x66, 0x33, 0x31, 0xF8, 0x7C, 0x06,
  0x7E, 0x3E, 0x00, 0x30, 0x60, 0xC3, 0xE7, 0xEC, 0xD9, 0xA3, 0xCD, 0x9B,
  0x30, 0x39, 0x81, 0xEF, 0x19, 0x8C, 0x63, 0xCE, 0x07, 0x06, 0x00, 0x3E,
  0x3E, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x8C, 0xF8, 0xF0, 0x30, 0x30,
  0x30, 0x37, 0x6E, 0x7C, 0x78, 0x78, 0xDC, 0xCC, 0xCC, 0x7F, 0x8C, 0x63,
  0x11, 0x8C, 0x63, 0xDE, 0x3B, 0x3F, 0x2D, 0x6D, 0x6B, 0x63, 0x42, 0xC2,
  0x7C, 0xFD, 0x9B, 0x36, 0x79, 0xB3, 0x66, 0x3C, 0xFD, 0x9E, 0x3C, 0x79,
  0xFF, 0x3C, 0x3E, 0x3F, 0x33, 0x33, 0x63, 0x67, 0x7E, 0x7C, 0x40, 0xC0,
  0xC0, 0x1E, 0x7E, 0x66, 0xC6, 0xC6, 0xCC, 0xFC, 0x7C, 0x0C, 0x0C, 0x18,
  0x3E, 0x3E, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x3E, 0xFD, 0x83, 0x81,
  0xD1, 0xBF, 0x7C, 0x30, 0xCF, 0xFF, 0x61, 0x86, 0x30, 0x79, 0xE0, 0x66,
  0xCD, 0x9A, 0x3C, 0xD9, 0xBF, 0x3A, 0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x3C,
  0x30, 0x43, 0xC3, 0xDA, 0xDA, 0xEE, 0xAC, 0xCC, 0xCC, 0x33, 0x19, 0x87,
  0x83, 0x81, 0xC1, 0xF1, 0xD8, 0xCC, 0x18, 0xC6, 0x61, 0x98, 0x64, 0x1B,
  0x06, 0x80, 0xE0, 0x30, 0x1C, 0x1E, 0x0F, 0x00, 0x3E, 0xFC, 0x30, 0xC3,
  0x0C, 0x3F, 0x7E, 0x0E, 0x3C, 0x61, 0x83, 0x06, 0x38, 0x70, 0x60, 0xC1,
  0x02, 0x0F, 0x0E, 0x00, 0x18, 0xC6, 0x63, 0x18, 0xC6, 0x63, 0x18, 0xCC,
  0x60, 0x1C, 0x1E, 0x06, 0x06, 0x04, 0x0C, 0x07, 0x0E, 0x0C, 0x18, 0x18,
  0x18, 0xF0, 0xF0, 0x73, 0xFE, 0x70,
};

const GFXglyph UbuntuMono_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 3, -10 },
  { 6, 6, 5, 8, 3, -11 },
  { 10, 8, 10, 8, 1, -10 },
  { 20, 8, 13, 8, 1, -11 },
  { 33, 10, 10, 8, 0, -10 },
  { 46, 7, 10, 8, 1, -10 },
  { 55, 3, 5, 8, 4, -11 },
  { 57, 7, 14, 8, 2, -11 },
  { 70, 6, 14, 8, 1, -11 },
  { 81, 7, 7, 8, 2, -10 },
  { 88, 7, 8, 8, 1, -8 },
  { 95, 3, 5, 8, 2, -3 },
  { 97, 5, 2, 8, 2, -5 },
  { 99, 2, 3, 8, 3, -3 },
  { 100, 9, 14, 8, 0, -11 },
  { 116, 8, 10, 8, 1, -10 },
  { 126, 6, 10, 8, 1, -10 },
  { 134, 8, 10, 8, 1, -10 },
  { 144, 8, 10, 8, 0, -10 },
  { 154, 8, 10, 8, 1, -10 },
  { 164, 8, 10, 8, 1, -10 },
  { 174, 8, 10, 8, 1, -10 },
  { 184, 8, 10, 8, 2, -10 },
  { 194, 8, 10, 8, 1, -10 },
  { 204, 8, 10, 8, 1, -10 },
  { 214, 4, 8, 8, 3, -8 },
  { 218, 5, 10, 8, 2, -8 },
  { 225, 8, 8, 8, 1, -8 },
  { 233, 8, 5, 8, 1, -7 },
  { 238, 7, 8, 8, 1, -8 },
  { 245, 7, 10, 8, 2, -10 },
  { 254, 8, 12, 8, 1, -10 },
  { 266, 8, 10, 8, 0, -10 },
  { 276, 8, 10, 8, 1, -10 },
  { 286, 8, 10, 8, 1, -10 },
  { 296, 8, 10, 8, 0, -10 },
  { 306, 8, 10, 8, 1, -10 },
  { 316, 8, 10, 8, 1, -10 },
  { 326, 8, 10, 8, 1, -10 },
  { 336, 9, 10, 8, 0, -10 },
  { 348, 8, 10, 8, 1, -10 },
  { 358, 8, 10, 8, 1, -10 },
  { 368, 10, 10, 8, 0, -10 },
  { 381, 6, 10, 8, 1, -10 },
  { 389, 9, 10, 8, 0, -10 },
  { 401, 9, 10, 8, 0, -10 },
  { 413, 8, 10, 8, 1, -10 },
  { 423, 8, 10, 8, 1, -10 },
  { 433, 8, 13, 8, 1, -10 },
  { 446, 8, 10, 8, 1, -10 },
  { 456, 9, 10, 8, 0, -10 },
  { 468, 8, 10, 8, 2, -10 },
  { 478, 8, 10, 8, 1, -10 },
  { 488, 8, 10, 8, 2, -10 },
  { 498, 9, 10, 8, 1, -10 },
  { 510, 10, 10, 8, 0, -10 },
  { 523, 8, 10, 8, 2, -10 },
  { 533, 9, 10, 8, 0, -10 },
  { 545, 8, 14, 8, 1, -11 },
  { 559, 3, 14, 8, 3, -11 },
  { 565, 8, 14, 8, 0, -11 },
  { 579, 8, 6, 8, 1, -10 },
  { 585, 8, 2, 8, -1, 1 },
  { 587, 3, 3, 8, 4, -11 },
  { 589, 7, 8, 8, 1, -8 },
  { 596, 7, 11, 8, 1, -11 },
  { 606, 8, 8, 8, 1, -8 },
  { 614, 8, 11, 8, 1, -11 },
  { 625, 7, 8, 8, 1, -8 },
  { 632, 10, 14, 8, -1, -11 },
  { 650, 9, 11, 8, 0, -8 },
  { 663, 7, 11, 8, 1, -11 },
  { 673, 5, 11, 8, 2, -11 },
  { 680, 8, 14, 8, 0, -11 },
  { 694, 8, 11, 8, 1, -11 },
  { 705, 5, 11, 8, 2, -11 },
  { 712, 8, 8, 8, 0, -8 },
  { 720, 7, 8, 8, 1, -8 },
  { 727, 7, 8, 8, 1, -8 },
  { 734, 8, 11, 8, 0, -8 },
  { 745, 8, 11, 8, 1, -8 },
  { 756, 8, 8, 8, 1, -8 },
  { 764, 7, 8, 8, 1, -8 },
  { 771, 6, 10, 8, 2, -10 },
  { 779, 7, 8, 8, 1, -8 },
  { 786, 7, 8, 8, 2, -8 },
  { 793, 8, 8, 8, 1, -8 },
  { 801, 9, 8, 8, 0, -8 },
  { 810, 10, 11, 8, -1, -8 },
  { 824, 7, 8, 8, 1, -8 },
  { 831, 7, 14, 8, 2, -11 },
  { 844, 5, 14, 8, 2, -11 },
  { 853, 8, 14, 8, 0, -11 },
  { 867, 7, 3, 8, 1, -6 },
};

const GFXfont UbuntuMono_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic16pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUMONO_BOLDITALIC16PT7B_H_
