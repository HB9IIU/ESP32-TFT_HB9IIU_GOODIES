#ifndef _UBUNTUMONO_BOLDITALIC25PT7B_H_
#define _UBUNTUMONO_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x60, 0x00, 0x07,
  0x1E, 0x3C, 0x00, 0x73, 0xFB, 0xF9, 0xDC, 0xEE, 0x76, 0x33, 0x18, 0x03,
  0x38, 0x39, 0xC1, 0xCC, 0x0C, 0xE3, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0x38,
  0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xE6, 0x06, 0x70, 0x73, 0x03, 0x98, 0x00,
  0x01, 0xC0, 0x1C, 0x07, 0xC0, 0xFF, 0x1F, 0xF1, 0xC2, 0x3C, 0x01, 0xC0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x60, 0xE7, 0xFE, 0xFF, 0xC3, 0xF0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x06, 0x3E, 0x18, 0x6C, 0x61, 0x99,
  0x83, 0x36, 0x07, 0xDC, 0x07, 0x70, 0x00, 0xC0, 0x03, 0x70, 0x0D, 0xF0,
  0x33, 0x60, 0xCC, 0xC3, 0x99, 0x8E, 0x3E, 0x18, 0x38, 0x00, 0x07, 0xC0,
  0xFE, 0x1F, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x1F, 0x81, 0xF0, 0x3E, 0x77,
  0x77, 0xE3, 0xEE, 0x1C, 0xFF, 0xC7, 0xFE, 0x3C, 0xE0, 0x77, 0xFE, 0xEC,
  0xC0, 0x00, 0xC0, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x80, 0xE0, 0x18, 0x02, 0x00, 0x02, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x10, 0x00, 0x0E, 0x03, 0x84,
  0xCF, 0xF7, 0xFF, 0xC7, 0x83, 0xB1, 0xCE, 0x11, 0x00, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x0F, 0xFF, 0xFF, 0xBF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x00, 0x1C, 0xF3, 0xC7, 0x1D, 0xEF, 0x00, 0x7F, 0x7F, 0x7E, 0x7F, 0xF7,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0x9C, 0x77, 0x06, 0xE0,
  0xF9, 0xBF, 0x77, 0xEC, 0xFC, 0x3F, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F,
  0x80, 0x01, 0xC1, 0xE1, 0xF8, 0xFE, 0x37, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xEF, 0xF8, 0x07, 0xC1, 0xFF, 0x1F,
  0xF1, 0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x00, 0x7F, 0xEF, 0xFC, 0xFF, 0xC0, 0x07, 0xC1, 0xFF, 0x0F, 0xF0,
  0x87, 0x00, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xE4,
  0x1E, 0xFF, 0xCF, 0xF8, 0x7F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x06,
  0xE0, 0x6E, 0x06, 0x70, 0x63, 0x86, 0x18, 0x7F, 0xF7, 0xFF, 0xBF, 0xFC,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFC,
  0x18, 0x01, 0xC0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x03, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC7, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0x1F,
  0xF3, 0xE0, 0x78, 0x07, 0xF8, 0xFF, 0xCF, 0xFC, 0xE1, 0xEE, 0x0E, 0xE1,
  0xCF, 0x1C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE3, 0x8E,
  0x38, 0x63, 0x8E, 0x1F, 0xC3, 0xF8, 0x73, 0xCE, 0x1C, 0xC1, 0xCE, 0x3C,
  0xFF, 0xCF, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x38,
  0x73, 0x87, 0x38, 0x73, 0xFF, 0x1F, 0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x7F,
  0x87, 0xF0, 0xF8, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x73, 0xCF,
  0x1C, 0x07, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x78, 0xF0, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x9F, 0xEF, 0xE1,
  0xF0, 0x3E, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x0E, 0x00, 0x40, 0x3F, 0xF3,
  0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0x10, 0x03,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x01, 0xE0, 0xFE, 0x3F, 0xCF,
  0xE0, 0xF0, 0x04, 0x00, 0x3F, 0x3F, 0xDF, 0xE8, 0x70, 0x38, 0x38, 0x38,
  0x78, 0x38, 0x38, 0x00, 0x00, 0x0F, 0x07, 0x83, 0x80, 0x03, 0xE0, 0x7F,
  0x87, 0x8E, 0x70, 0x73, 0x1F, 0xB9, 0xFD, 0x9C, 0xCC, 0xCE, 0x6E, 0x77,
  0x73, 0xBB, 0x99, 0xDC, 0xCE, 0x7E, 0x31, 0xF1, 0xC0, 0x0F, 0x00, 0x3F,
  0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x70, 0x67,
  0x0E, 0x70, 0xC7, 0x1C, 0x73, 0xFF, 0x3F, 0xF3, 0xFF, 0x70, 0x77, 0x07,
  0xE0, 0x70, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x18, 0x73, 0xFE, 0x3F,
  0xC3, 0xFE, 0x70, 0xE7, 0x07, 0x70, 0xE7, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x00, 0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xC2, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x08, 0x7F, 0x87, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x70, 0x77, 0x0F, 0x71, 0xE7, 0x3E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0x87, 0xFC,
  0x3F, 0xC1, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFE, 0x3F, 0xE3, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xC2, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x1C, 0xFF, 0x87, 0xF8,
  0x3F, 0x00, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x78, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x70, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1,
  0xE3, 0x87, 0x0E, 0x1C, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0xC7, 0x8F, 0xF8, 0x7F, 0xC0, 0xF8, 0x00, 0x1C, 0x3C, 0x71, 0xE1, 0xC7,
  0x07, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xCE,
  0x07, 0x38, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x00, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0E, 0x1C, 0x38, 0x70, 0xF3, 0xC7, 0xCF,
  0x1F, 0x7C, 0x6D, 0xF1, 0xBD, 0x8E, 0xF6, 0x3B, 0xB8, 0xCE, 0xE7, 0x03,
  0x1C, 0x0C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x00, 0x1C, 0x1C, 0x70, 0x61,
  0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xFC, 0xC3, 0x37, 0x1C, 0xDC, 0x73, 0x71,
  0xCD, 0x87, 0x1E, 0x18, 0x78, 0xE1, 0xE3, 0x87, 0x0E, 0x1C, 0x00, 0x07,
  0x81, 0xFE, 0x3F, 0xE7, 0x8E, 0x70, 0xF7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x0F, 0xE0,
  0xFF, 0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x9C, 0x1C, 0xE3, 0xC7, 0xFE, 0x3F,
  0xE3, 0xFC, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07,
  0x83, 0xFC, 0xFF, 0xBC, 0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F, 0x81, 0xC0, 0x1C, 0x03, 0xE0,
  0x3C, 0x03, 0x80, 0x1F, 0xC1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0x87,
  0x38, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x73, 0x87, 0x1C, 0xF1, 0xCE, 0x1C,
  0xE0, 0xE0, 0x07, 0xE0, 0x7F, 0xC7, 0xFC, 0x38, 0x63, 0xC0, 0x1F, 0x00,
  0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x38, 0x83, 0xCF, 0xFC, 0x7F,
  0xC0, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x73, 0x87, 0x38, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0x70,
  0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0xFF, 0x8F, 0xF0, 0x7E,
  0x00, 0xF0, 0x7F, 0x07, 0xF0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0x63, 0x86,
  0x38, 0x67, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x78, 0x00,
  0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xCC, 0xE7, 0x73,
  0x1D, 0xCC, 0x7D, 0x71, 0xB5, 0xC7, 0x9E, 0x3E, 0x78, 0xF1, 0xE3, 0xC7,
  0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x3F,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0x80,
  0xE7, 0x03, 0x8E, 0x0F, 0x0E, 0x3C, 0x1C, 0x00, 0xE0, 0xFC, 0x3F, 0x87,
  0x71, 0xCE, 0x78, 0xCE, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x07, 0xE0,
  0xFE, 0x00, 0xE7, 0x39, 0xC7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xC7,
  0x39, 0xCE, 0x73, 0x80, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x3F, 0x0F, 0xE3, 0xDC, 0x73, 0xDC,
  0x3F, 0x07, 0x20, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x47, 0x3E, 0x71,
  0x80, 0x0F, 0xC7, 0xFD, 0xFF, 0xBC, 0xEF, 0x1D, 0xC3, 0xB8, 0x77, 0x1C,
  0xE3, 0x9F, 0xF3, 0xFF, 0x3E, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xFC, 0x3F, 0xE3, 0xFE, 0x38, 0xE3, 0x8F, 0x78, 0xE7, 0x0E,
  0x70, 0xE7, 0x1E, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xFC, 0xFF,
  0xBC, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1F, 0xF1, 0xFE, 0x1F,
  0xC0, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x07, 0xF0, 0xFF,
  0x8F, 0xFC, 0x79, 0xC7, 0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0x71, 0xC3,
  0xFE, 0x1F, 0xF8, 0x7D, 0xC0, 0x0F, 0x83, 0xFC, 0xFF, 0xBC, 0x7E, 0x0F,
  0xDF, 0xBF, 0xE7, 0xE0, 0xE0, 0x1F, 0xF1, 0xFE, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC7, 0xFE, 0x3C, 0x73, 0xC7,
  0x1C, 0x38, 0xE1, 0xC7, 0x1E, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x03, 0xC4,
  0x1C, 0x3F, 0xE3, 0xFE, 0x0F, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x3F, 0x87, 0xF9, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0x77, 0x0E,
  0xE3, 0x9C, 0x77, 0x8E, 0xE1, 0xC0, 0x0E, 0x0E, 0x0E, 0x0E, 0x00, 0xFE,
  0xFC, 0xFC, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x84, 0x78, 0xFF, 0x0F, 0xF0, 0x7C, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x3C, 0x73, 0xC3, 0xBC, 0x3B, 0xC1, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xB8, 0x39, 0xC1, 0xC7, 0x0E, 0x38, 0xF1, 0xE0, 0xFD,
  0xFB, 0xF0, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8E, 0x1E, 0x3F,
  0xBF, 0x3E, 0x1E, 0xE3, 0xFF, 0x3F, 0xF3, 0x33, 0x77, 0x37, 0x77, 0x66,
  0x66, 0x06, 0xE0, 0x6E, 0x0E, 0xC0, 0xEC, 0x0C, 0x0F, 0xC3, 0xFC, 0xFF,
  0x9C, 0x73, 0x8E, 0x71, 0xDE, 0x3B, 0x87, 0x71, 0xCE, 0x3B, 0xC7, 0x70,
  0xE0, 0x0F, 0x87, 0xF9, 0xFF, 0x38, 0xFE, 0x1F, 0xC1, 0xF8, 0x77, 0x0E,
  0xE3, 0xDF, 0xF3, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xFF, 0x87, 0xFC, 0x38,
  0xF1, 0xC3, 0x9E, 0x1C, 0xE1, 0xC7, 0x0E, 0x39, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFE, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xC3, 0xFC, 0xFF,
  0xBC, 0x7F, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE3, 0x9F, 0xF3, 0xFE, 0x3F,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xE7, 0xFC, 0xFF, 0x9C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x07,
  0xE1, 0xFE, 0x1F, 0xE3, 0xC2, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1C, 0x41,
  0xC7, 0xFC, 0xFF, 0x83, 0xF0, 0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF3, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0x1F, 0xC3, 0xF0,
  0x38, 0xEE, 0x1D, 0xC7, 0xB8, 0xE7, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C, 0xE3,
  0x9F, 0xF3, 0xFE, 0x3C, 0xE0, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39,
  0xCE, 0x39, 0xC7, 0x70, 0x7E, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xE0, 0x3E,
  0x07, 0xE6, 0x7E, 0xE6, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xEC, 0xF7, 0xCF,
  0x78, 0xE3, 0x8C, 0x30, 0x1C, 0x38, 0x79, 0xE0, 0xE7, 0x03, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xF3, 0x83, 0x8E, 0x1C,
  0x3C, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCF,
  0x03, 0xDC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x70, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFC, 0x7F, 0xCF,
  0xFC, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x07, 0xC0, 0x70, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0x07, 0x07,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x00, 0xF0, 0x3F,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x00, 0x1C, 0x33, 0xE7, 0x7F, 0xE6, 0x7E, 0x63, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 15, 13, 4, -15 },
  { 15, 9, 7, 13, 5, -17 },
  { 23, 13, 15, 13, 1, -15 },
  { 48, 12, 19, 13, 1, -17 },
  { 77, 15, 15, 13, 0, -15 },
  { 106, 12, 15, 13, 1, -15 },
  { 129, 4, 7, 13, 7, -17 },
  { 133, 10, 22, 13, 3, -18 },
  { 161, 10, 22, 13, 1, -18 },
  { 189, 10, 9, 13, 3, -15 },
  { 201, 11, 11, 13, 2, -12 },
  { 217, 6, 8, 13, 2, -4 },
  { 223, 8, 3, 13, 3, -8 },
  { 226, 4, 4, 13, 4, -4 },
  { 228, 15, 21, 13, 0, -17 },
  { 268, 11, 15, 13, 2, -15 },
  { 289, 10, 15, 13, 2, -15 },
  { 308, 12, 15, 13, 1, -15 },
  { 331, 12, 15, 13, 1, -15 },
  { 354, 13, 15, 13, 1, -15 },
  { 379, 13, 15, 13, 1, -15 },
  { 404, 12, 15, 13, 2, -15 },
  { 427, 12, 15, 13, 3, -15 },
  { 450, 12, 15, 13, 2, -15 },
  { 473, 12, 15, 13, 1, -15 },
  { 496, 6, 12, 13, 4, -12 },
  { 505, 8, 16, 13, 2, -12 },
  { 521, 11, 12, 13, 2, -12 },
  { 538, 12, 8, 13, 1, -10 },
  { 550, 12, 12, 13, 1, -12 },
  { 568, 9, 15, 13, 4, -15 },
  { 585, 13, 18, 13, 1, -15 },
  { 615, 12, 15, 13, 0, -15 },
  { 638, 12, 15, 13, 1, -15 },
  { 661, 12, 15, 13, 2, -15 },
  { 684, 12, 15, 13, 1, -15 },
  { 707, 13, 15, 13, 1, -15 },
  { 732, 14, 15, 13, 1, -15 },
  { 759, 12, 15, 13, 2, -15 },
  { 782, 14, 15, 13, 1, -15 },
  { 809, 13, 15, 13, 1, -15 },
  { 834, 13, 15, 13, 1, -15 },
  { 859, 14, 15, 13, 1, -15 },
  { 886, 10, 15, 13, 1, -15 },
  { 905, 14, 15, 13, 0, -15 },
  { 932, 14, 15, 13, 1, -15 },
  { 959, 12, 15, 13, 2, -15 },
  { 982, 13, 15, 13, 1, -15 },
  { 1007, 11, 20, 13, 2, -15 },
  { 1035, 12, 15, 13, 1, -15 },
  { 1058, 13, 15, 13, 1, -15 },
  { 1083, 12, 15, 13, 3, -15 },
  { 1106, 12, 15, 13, 2, -15 },
  { 1129, 12, 15, 13, 3, -15 },
  { 1152, 14, 15, 13, 1, -15 },
  { 1179, 15, 15, 13, 0, -15 },
  { 1208, 11, 15, 13, 4, -15 },
  { 1229, 13, 15, 13, 1, -15 },
  { 1254, 12, 21, 13, 2, -17 },
  { 1286, 5, 21, 13, 5, -17 },
  { 1300, 13, 21, 13, 0, -17 },
  { 1335, 11, 9, 13, 2, -15 },
  { 1348, 12, 3, 13, -1, 1 },
  { 1353, 5, 5, 13, 6, -17 },
  { 1357, 11, 12, 13, 2, -12 },
  { 1374, 12, 17, 13, 1, -17 },
  { 1400, 11, 12, 13, 2, -12 },
  { 1417, 13, 17, 13, 2, -17 },
  { 1445, 11, 12, 13, 2, -12 },
  { 1462, 16, 21, 13, -1, -17 },
  { 1504, 13, 16, 13, 0, -12 },
  { 1530, 11, 17, 13, 1, -17 },
  { 1554, 8, 17, 13, 3, -17 },
  { 1571, 12, 21, 13, 0, -17 },
  { 1603, 13, 17, 13, 1, -17 },
  { 1631, 7, 17, 13, 4, -17 },
  { 1646, 12, 12, 13, 1, -12 },
  { 1664, 11, 12, 13, 1, -12 },
  { 1681, 11, 12, 13, 2, -12 },
  { 1698, 13, 16, 13, 0, -12 },
  { 1724, 11, 16, 13, 2, -12 },
  { 1746, 11, 12, 13, 2, -12 },
  { 1763, 12, 12, 13, 1, -12 },
  { 1781, 10, 15, 13, 3, -15 },
  { 1800, 11, 12, 13, 2, -12 },
  { 1817, 11, 12, 13, 3, -12 },
  { 1834, 12, 12, 13, 2, -12 },
  { 1852, 14, 12, 13, 0, -12 },
  { 1873, 15, 16, 13, -1, -12 },
  { 1903, 12, 12, 13, 1, -12 },
  { 1921, 12, 21, 13, 2, -17 },
  { 1953, 8, 21, 13, 3, -17 },
  { 1974, 12, 21, 13, 0, -17 },
  { 2006, 12, 5, 13, 1, -9 },
};

const GFXfont UbuntuMono_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic25pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUMONO_BOLDITALIC25PT7B_H_
