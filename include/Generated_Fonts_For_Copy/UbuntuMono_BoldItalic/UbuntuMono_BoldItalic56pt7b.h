#ifndef _UBUNTUMONO_BOLDITALIC56PT7B_H_
#define _UBUNTUMONO_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3E,
  0x00, 0x3F, 0x87, 0xF7, 0xF8, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0x80,
  0x18, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0C, 0x00,
  0x3F, 0x83, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0xF8, 0x03,
  0xFF, 0x00, 0x7C, 0x01, 0xF3, 0xC0, 0x3E, 0x00, 0xF8, 0xF0, 0x1F, 0x80,
  0x3C, 0x3C, 0x07, 0xC0, 0x0F, 0x0F, 0x03, 0xE0, 0x03, 0xC3, 0xC1, 0xF0,
  0x01, 0xF0, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x1F,
  0x00, 0x07, 0xC7, 0x8F, 0x80, 0x01, 0xF3, 0xE7, 0xC0, 0x00, 0x7F, 0xF3,
  0xE0, 0x00, 0x0F, 0xF9, 0xF0, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x07, 0xCF, 0xF0, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x01, 0xF3, 0xFF, 0x80,
  0x00, 0x7C, 0xF9, 0xE0, 0x00, 0x3E, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x1E,
  0x00, 0x0F, 0x87, 0x87, 0x80, 0x07, 0xC3, 0xE1, 0xE0, 0x03, 0xE0, 0xF8,
  0x78, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x7C, 0x0F, 0x0F, 0x00, 0x3E, 0x03,
  0xC3, 0xC0, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x3F, 0xF8, 0x07, 0xE0,
  0x07, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7C, 0x1F, 0xF8, 0x1F, 0x1F, 0xFF, 0x0F, 0xCF, 0xFF, 0xE3, 0xE3,
  0xF1, 0xF9, 0xF9, 0xF8, 0x7F, 0x7E, 0xFC, 0x0F, 0xFF, 0x3F, 0x01, 0xFF,
  0x8F, 0xC0, 0x7F, 0xE3, 0xF0, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0xFF, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xE7, 0xF0, 0xFF, 0xF0, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x9F, 0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFD, 0xFC, 0xFE, 0x7F,
  0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x06, 0x0F, 0x83, 0x1F, 0x1F, 0x1E, 0x3F,
  0xBC, 0xFE, 0x7F, 0xBB, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xE0, 0x03, 0xF7,
  0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7C, 0x1F,
  0x00, 0x78, 0x38, 0x00, 0x20, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0x80, 0x7C, 0x07, 0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xC0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xF8, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0xF1, 0xFD,
  0xFC, 0x7C, 0x7F, 0x7F, 0x3F, 0x1F, 0xDF, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1,
  0xFB, 0xF8, 0x70, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xDF, 0xC0, 0x7C, 0x7F, 0x01, 0xE3, 0xF8, 0x04, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC,
  0x1F, 0xF0, 0x0E, 0x00, 0xFF, 0x00, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1E, 0x07, 0xF8, 0x02, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x40, 0x01, 0xFE,
  0x1F, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0x7F, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x0F, 0xF0,
  0x1E, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x1F,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0x83, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFD, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xF8, 0x3F,
  0xE6, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8,
  0x0F, 0xFF, 0x1F, 0x03, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x3E, 0x0F, 0xFF,
  0xF3, 0xE1, 0xFF, 0xFE, 0x7E, 0x1F, 0xC7, 0xE7, 0xC3, 0xF8, 0x7E, 0x7C,
  0x3F, 0x07, 0xE7, 0xC7, 0xE0, 0xFC, 0x7C, 0x7E, 0x0F, 0xCF, 0xC7, 0xE0,
  0xFC, 0xFC, 0x7C, 0x0F, 0xCF, 0x87, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0x8F,
  0x87, 0xC1, 0xF8, 0xF8, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xF8, 0x7F,
  0x3F, 0x0F, 0x87, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0x0F, 0xC3, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x10,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03,
  0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xF0,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xE0, 0x3F,
  0xC0, 0x0C, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x20, 0x1F, 0xF0, 0x1C, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xF8, 0x3F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF0, 0x3F,
  0xE0, 0x7F, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xC0, 0x7F, 0xC0,
  0x0C, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC1, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x20, 0x03, 0xFC, 0x01, 0x80, 0x3F, 0xC0,
  0x1F, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x87, 0xBE, 0x01, 0xF7, 0x87, 0xBE, 0x01, 0xF7, 0x8F, 0x7E, 0x01,
  0xF7, 0x8F, 0x7C, 0x03, 0xF7, 0x9E, 0x7C, 0x03, 0xE7, 0x9E, 0x7C, 0x03,
  0xE7, 0xBC, 0xFC, 0x07, 0xE7, 0xFC, 0xFC, 0x07, 0xE3, 0xF8, 0xF8, 0x07,
  0xC3, 0xF8, 0xF8, 0x07, 0xC3, 0xF1, 0xF8, 0x0F, 0xC3, 0xF1, 0xF8, 0x0F,
  0xC3, 0xE1, 0xF8, 0x0F, 0xC3, 0xE1, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x01,
  0xFF, 0x80, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x81, 0xFC, 0x03,
  0xF7, 0xC1, 0xF8, 0x03, 0xF7, 0xC1, 0xF8, 0x03, 0xF7, 0xC1, 0xF8, 0x03,
  0xF7, 0xC3, 0xF8, 0x07, 0xE3, 0xE3, 0xF0, 0x07, 0xE3, 0xE3, 0xF0, 0x07,
  0xE3, 0xE3, 0xF0, 0x07, 0xE3, 0xE3, 0xF0, 0x0F, 0xC1, 0xF7, 0xE0, 0x0F,
  0xC1, 0xF7, 0xE0, 0x0F, 0xC1, 0xF7, 0xE0, 0x0F, 0xC1, 0xF7, 0xE0, 0x1F,
  0xC1, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xC0, 0x1F,
  0x80, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC3, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFC, 0x3F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF,
  0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFF,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x0F,
  0x00, 0x7F, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x7F, 0x80,
  0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC3, 0xE1, 0xF8, 0x0F, 0xC7,
  0xE1, 0xF0, 0x0F, 0x87, 0xE3, 0xF0, 0x1F, 0x8F, 0xE3, 0xF0, 0x1F, 0x8F,
  0xE3, 0xF0, 0x1F, 0x9F, 0xE3, 0xE0, 0x1F, 0x1F, 0xE3, 0xE0, 0x1F, 0x3F,
  0xE7, 0xE0, 0x3F, 0x3D, 0xE7, 0xE0, 0x3F, 0x79, 0xE7, 0xC0, 0x3E, 0x79,
  0xE7, 0xC0, 0x3E, 0xF1, 0xEF, 0xC0, 0x3E, 0xF1, 0xEF, 0x80, 0x3F, 0xE1,
  0xEF, 0x80, 0x7D, 0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xE3, 0xFC, 0x03,
  0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF1, 0xE0,
  0x01, 0xE0, 0x10, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0xE0, 0x0F, 0x80, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFE, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xC1, 0xFC, 0x7F, 0xC0, 0xFE, 0x3F, 0x80, 0x7F, 0x3F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x87, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0x7E, 0x07, 0xFF, 0x3F, 0x00, 0xFC, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x7F, 0xC7, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x30,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x0E,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFE, 0x03, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0x80, 0x07, 0xF0, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xE7, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x20,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x10, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x07, 0xF8,
  0x03, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x30,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x20, 0x0F, 0xE0, 0x07, 0x03, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x07, 0xC0, 0x1F, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0x8F, 0xC7,
  0xE0, 0xFC, 0x7C, 0x3E, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x1F, 0x0F, 0x83,
  0xF1, 0xF8, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0xC7,
  0xE1, 0xF0, 0x7E, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x7F, 0x80, 0xFC, 0x3F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFF, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x20, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0x38, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x83,
  0x00, 0x1F, 0xC1, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x70, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x7E, 0x01, 0xF8, 0x30, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE1, 0xF0, 0x7E, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0,
  0xFC, 0x7C, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0xF8, 0xFC, 0x7F, 0x0F, 0x8F,
  0xC7, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF9, 0xFF,
  0xBE, 0x0F, 0x9E, 0xFB, 0xE0, 0xFB, 0xEF, 0xBE, 0x0F, 0xFC, 0x7F, 0xC0,
  0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0x80, 0x7E, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x83, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x00, 0xFF, 0x00, 0xFC, 0x3F, 0xF8,
  0x1F, 0x0F, 0xFF, 0x87, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0xFC, 0x0F, 0xFE, 0x1F, 0x00, 0xFF,
  0x80, 0x60, 0x07, 0xC0, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 16, 36, 28, 9, -35 },
  { 73, 20, 16, 28, 11, -38 },
  { 113, 30, 35, 28, 2, -35 },
  { 245, 27, 44, 28, 3, -39 },
  { 394, 34, 37, 28, 0, -36 },
  { 552, 26, 37, 28, 3, -36 },
  { 673, 9, 17, 28, 16, -38 },
  { 693, 22, 50, 28, 8, -40 },
  { 831, 23, 50, 28, 2, -40 },
  { 975, 23, 22, 28, 7, -35 },
  { 1039, 25, 26, 28, 4, -27 },
  { 1121, 14, 18, 28, 5, -9 },
  { 1153, 17, 7, 28, 8, -18 },
  { 1168, 10, 10, 28, 9, -9 },
  { 1181, 33, 48, 28, -1, -39 },
  { 1379, 26, 37, 28, 4, -36 },
  { 1500, 22, 35, 28, 4, -35 },
  { 1597, 28, 36, 28, 2, -36 },
  { 1723, 27, 37, 28, 2, -36 },
  { 1848, 28, 35, 28, 2, -35 },
  { 1971, 29, 36, 28, 2, -35 },
  { 2102, 27, 36, 28, 4, -35 },
  { 2224, 26, 35, 28, 7, -35 },
  { 2338, 27, 37, 28, 3, -36 },
  { 2463, 27, 36, 28, 3, -36 },
  { 2585, 14, 27, 28, 9, -26 },
  { 2633, 18, 35, 28, 5, -26 },
  { 2712, 26, 25, 28, 4, -26 },
  { 2794, 27, 17, 28, 3, -23 },
  { 2852, 26, 25, 28, 3, -26 },
  { 2934, 21, 37, 28, 9, -36 },
  { 3032, 28, 44, 28, 3, -36 },
  { 3186, 27, 35, 28, 0, -35 },
  { 3305, 28, 36, 28, 2, -35 },
  { 3431, 27, 37, 28, 5, -36 },
  { 3556, 28, 37, 28, 2, -36 },
  { 3686, 29, 35, 28, 3, -35 },
  { 3813, 30, 35, 28, 3, -35 },
  { 3945, 28, 37, 28, 4, -36 },
  { 4075, 32, 35, 28, 1, -35 },
  { 4215, 30, 35, 28, 2, -35 },
  { 4347, 29, 36, 28, 2, -35 },
  { 4478, 32, 35, 28, 2, -35 },
  { 4618, 22, 35, 28, 3, -35 },
  { 4715, 32, 35, 28, 0, -35 },
  { 4855, 32, 35, 28, 1, -35 },
  { 4995, 26, 37, 28, 4, -36 },
  { 5116, 29, 35, 28, 2, -35 },
  { 5243, 26, 47, 28, 4, -36 },
  { 5396, 28, 35, 28, 2, -35 },
  { 5519, 29, 37, 28, 2, -36 },
  { 5654, 27, 35, 28, 7, -35 },
  { 5773, 28, 36, 28, 4, -35 },
  { 5899, 27, 35, 28, 8, -35 },
  { 6018, 32, 35, 28, 2, -35 },
  { 6158, 34, 35, 28, 0, -35 },
  { 6307, 27, 35, 28, 8, -35 },
  { 6426, 30, 35, 28, 2, -35 },
  { 6558, 27, 48, 28, 5, -39 },
  { 6720, 11, 48, 28, 12, -39 },
  { 6786, 27, 48, 28, 1, -39 },
  { 6948, 26, 20, 28, 4, -35 },
  { 7013, 27, 6, 28, -2, 3 },
  { 7034, 13, 10, 28, 13, -39 },
  { 7051, 25, 28, 28, 4, -27 },
  { 7139, 26, 41, 28, 2, -40 },
  { 7273, 26, 28, 28, 4, -27 },
  { 7364, 29, 41, 28, 4, -40 },
  { 7513, 25, 28, 28, 4, -27 },
  { 7601, 35, 50, 28, -2, -40 },
  { 7820, 30, 37, 28, 0, -27 },
  { 7959, 26, 40, 28, 2, -40 },
  { 8089, 20, 39, 28, 6, -38 },
  { 8187, 27, 48, 28, 0, -38 },
  { 8349, 29, 40, 28, 3, -40 },
  { 8494, 17, 40, 28, 8, -39 },
  { 8579, 29, 26, 28, 1, -26 },
  { 8674, 26, 27, 28, 2, -27 },
  { 8762, 24, 28, 28, 4, -27 },
  { 8846, 28, 36, 28, 0, -27 },
  { 8972, 26, 36, 28, 4, -27 },
  { 9089, 26, 27, 28, 4, -27 },
  { 9177, 25, 28, 28, 3, -27 },
  { 9265, 24, 35, 28, 6, -34 },
  { 9370, 25, 27, 28, 4, -26 },
  { 9455, 25, 26, 28, 6, -26 },
  { 9537, 28, 26, 28, 4, -26 },
  { 9628, 30, 26, 28, 1, -26 },
  { 9726, 33, 36, 28, -2, -26 },
  { 9875, 27, 26, 28, 3, -26 },
  { 9963, 26, 48, 28, 6, -39 },
  { 10119, 19, 48, 28, 7, -39 },
  { 10233, 27, 48, 28, 0, -39 },
  { 10395, 27, 11, 28, 3, -20 },
};

const GFXfont UbuntuMono_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic56pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUMONO_BOLDITALIC56PT7B_H_
