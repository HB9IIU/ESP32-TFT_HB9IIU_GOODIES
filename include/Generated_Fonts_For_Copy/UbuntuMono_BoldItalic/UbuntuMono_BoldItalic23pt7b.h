#ifndef _UBUNTUMONO_BOLDITALIC23PT7B_H_
#define _UBUNTUMONO_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC0, 0x00, 0xE3, 0x80,
  0x73, 0xBB, 0x9D, 0xCC, 0xE6, 0x66, 0x30, 0x07, 0x70, 0x66, 0x06, 0x60,
  0xEE, 0x7F, 0xF7, 0xFF, 0x19, 0x83, 0x98, 0xFF, 0xEF, 0xFC, 0x66, 0x06,
  0x60, 0xEE, 0x0C, 0xC0, 0x01, 0x80, 0x30, 0x1F, 0x0F, 0xF3, 0xC0, 0x70,
  0x0E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x87, 0xBF,
  0xE1, 0xF8, 0x18, 0x03, 0x00, 0x0E, 0x0C, 0x78, 0x61, 0x33, 0x0C, 0x98,
  0x36, 0xC0, 0xFE, 0x01, 0xF8, 0x00, 0xF8, 0x06, 0xF0, 0x36, 0xC1, 0x93,
  0x0C, 0x4C, 0x61, 0xE1, 0x87, 0x00, 0x07, 0x81, 0xF8, 0x73, 0x0C, 0x61,
  0x98, 0x37, 0x07, 0x81, 0xF3, 0x76, 0xFC, 0xFB, 0x8E, 0x71, 0xCF, 0xFC,
  0xFB, 0x80, 0x77, 0x76, 0x66, 0xC0, 0x01, 0x81, 0xC1, 0xE1, 0xC1, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x3C, 0x0E, 0x02, 0x00, 0x04, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x0E, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x3C,
  0x3C, 0x38, 0x08, 0x00, 0x1C, 0x0E, 0x17, 0x7D, 0x7F, 0xF8, 0xE0, 0xDC,
  0xEE, 0x22, 0x00, 0x06, 0x03, 0x80, 0xE0, 0x30, 0xFF, 0xFF, 0xE1, 0x80,
  0x60, 0x18, 0x0E, 0x00, 0x18, 0xF3, 0xCF, 0x1B, 0xCE, 0x00, 0x7E, 0xFF,
  0xF8, 0x6F, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00,
  0x0F, 0x87, 0xF3, 0x9D, 0xC3, 0x60, 0xFB, 0x3E, 0xDF, 0x07, 0xC1, 0xF0,
  0x6C, 0x3B, 0x9C, 0xFE, 0x1F, 0x00, 0x01, 0xC1, 0xE1, 0xF8, 0xFE, 0x1B,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xE0,
  0x07, 0xC3, 0xFC, 0x63, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x38, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0x83, 0xFC, 0x43,
  0x80, 0x70, 0x0E, 0x03, 0x83, 0xE0, 0x7C, 0x01, 0xC0, 0x38, 0x07, 0x41,
  0xEF, 0xF8, 0xFC, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x7E, 0x0E, 0xC1,
  0xCC, 0x39, 0xC7, 0x1C, 0x61, 0xCF, 0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x00,
  0x30, 0x0F, 0xF0, 0xFE, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0xE0, 0x3F, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xCC, 0x38, 0xFF, 0x87, 0xE0, 0x03, 0xE1,
  0xFC, 0x78, 0x1C, 0x07, 0x01, 0xDE, 0x3F, 0xE7, 0x1C, 0xC1, 0xD8, 0x3B,
  0x86, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x7F, 0xFF, 0xF8, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0xC1, 0xFC, 0x73, 0x9C, 0x33, 0x86, 0x39, 0xC7, 0xF0,
  0xFC, 0x73, 0xCC, 0x3B, 0x87, 0x70, 0xE7, 0xF8, 0x7E, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0x98, 0x77, 0x06, 0xE0, 0xCE, 0x39, 0xFF, 0x1E, 0xE0, 0x38,
  0x0E, 0x07, 0x87, 0xE1, 0xF0, 0x00, 0x39, 0xDE, 0x70, 0x00, 0x0C, 0xF7,
  0xB8, 0x0E, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x0C, 0x3C, 0x78, 0xF0, 0xCF,
  0x1C, 0x00, 0x00, 0x40, 0xF0, 0xF9, 0xF0, 0xE0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x30,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1C, 0x1F, 0x8F, 0x87, 0x80, 0xC0, 0x00,
  0x3E, 0x7F, 0x47, 0x07, 0x07, 0x0E, 0x1E, 0x38, 0x70, 0x60, 0x00, 0x00,
  0xE0, 0xE0, 0x07, 0xC0, 0xFE, 0x1C, 0x73, 0x83, 0x33, 0xF6, 0x7F, 0x6E,
  0x66, 0xC6, 0xEC, 0xEC, 0xCE, 0xCC, 0xCC, 0xFC, 0xE7, 0xC6, 0x00, 0x70,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xF0, 0x6E, 0x19,
  0xC3, 0x38, 0xC7, 0x1F, 0xE7, 0xFC, 0xC3, 0xB8, 0x76, 0x0F, 0xC1, 0xC0,
  0x1F, 0xC3, 0xFC, 0x63, 0x9C, 0x33, 0x8E, 0x71, 0xCF, 0xF3, 0xFE, 0x71,
  0xCE, 0x1D, 0x83, 0x70, 0xEF, 0xF9, 0xFC, 0x00, 0x07, 0xC3, 0xFC, 0xF0,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x9C, 0x73, 0x8E, 0x71,
  0xCC, 0x3B, 0x87, 0x70, 0xEE, 0x39, 0x87, 0x71, 0xCF, 0xF1, 0xF8, 0x00,
  0x0F, 0xF1, 0xFF, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0xFC, 0x3F, 0xC3, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xCF, 0xF8, 0x0F, 0xF1, 0xFF,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0xFC, 0x3F, 0xC3, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC3, 0xFC, 0xF0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x71, 0xC7, 0xF0,
  0x7E, 0x00, 0x1C, 0x31, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x63, 0x8E, 0x7F,
  0xE7, 0xFE, 0x70, 0xC7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0x1F,
  0xF1, 0xFF, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x84, 0x38, 0xFF, 0x07, 0xE0, 0x1C, 0x70, 0xE3, 0x86, 0x38, 0x73, 0x83,
  0xB8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x77, 0x03, 0xBC, 0x18, 0xE1, 0xC7,
  0x0E, 0x1C, 0x70, 0xE0, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xFF, 0xFC, 0x0E, 0x38, 0x71, 0xC7,
  0x9E, 0x3C, 0xF1, 0xEF, 0x8F, 0x78, 0xCE, 0xC6, 0x66, 0x33, 0x73, 0x83,
  0x9C, 0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x70, 0x1C, 0x31, 0xC3, 0x3C, 0x73,
  0xC7, 0x36, 0x63, 0x66, 0x76, 0xE7, 0x6E, 0x63, 0xC6, 0x3C, 0xE3, 0xCE,
  0x3C, 0xC3, 0x8C, 0x18, 0x0F, 0x87, 0xF3, 0x9D, 0xC3, 0x60, 0xF8, 0x3E,
  0x1F, 0x87, 0xC1, 0xF0, 0x6C, 0x3B, 0x9C, 0xFE, 0x1F, 0x00, 0x1F, 0xC1,
  0xFE, 0x18, 0xF3, 0x87, 0x38, 0x73, 0x86, 0x38, 0xE7, 0xFC, 0x7F, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0x9D, 0xC3,
  0x60, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x6C, 0x3B, 0x9C, 0xFE, 0x1F,
  0x03, 0x00, 0xF0, 0x1E, 0x01, 0x80, 0x1F, 0x83, 0xFC, 0x63, 0x9C, 0x73,
  0x8E, 0x71, 0xCC, 0x73, 0xFC, 0x7F, 0x0E, 0x61, 0x8E, 0x71, 0xCE, 0x19,
  0xC3, 0x80, 0x07, 0xE1, 0xFE, 0x18, 0x23, 0x80, 0x38, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC4, 0x3C, 0xFF, 0x87, 0xE0, 0xFF,
  0xFF, 0xF8, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x38, 0xE6, 0x1D, 0xC3, 0xB8,
  0x67, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0x73, 0x0E, 0x73, 0x8F,
  0xF0, 0xF8, 0x00, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x39,
  0xC7, 0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x38,
  0x39, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x07, 0x3B, 0xB1, 0x9D, 0x8D, 0xEC,
  0x6B, 0xE3, 0xDE, 0x34, 0xF1, 0xE7, 0x8E, 0x38, 0x71, 0xC0, 0x0E, 0x1C,
  0x38, 0xE0, 0x67, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x80, 0x7F, 0x01, 0xDC, 0x0E, 0x30, 0x70, 0xE3, 0xC3, 0x80, 0xE0,
  0xEC, 0x39, 0x87, 0x39, 0xC7, 0x70, 0xEC, 0x0F, 0x81, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xE1, 0xFC, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0xF8, 0x7F, 0x00, 0xCE, 0xEE, 0xEE, 0xEE,
  0x66, 0x67, 0x77, 0x77, 0x77, 0x73, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x7E, 0x0F, 0xE0,
  0x07, 0x03, 0xC1, 0xF8, 0x7E, 0x39, 0x9C, 0x7E, 0x1D, 0x02, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x21, 0xC7, 0x86, 0x07, 0xC3, 0xFC, 0xE3, 0xB8, 0x67,
  0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0x73, 0x8F, 0xF8, 0xF7, 0x00, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x7F, 0x0F, 0xF1, 0xCE, 0x30, 0xEE, 0x1D,
  0xC3, 0x38, 0xE7, 0x1D, 0xC7, 0x3F, 0xC3, 0xF0, 0x0F, 0xCF, 0xF7, 0x81,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xC3, 0xF0, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x7E, 0x1F, 0xE3, 0x8E, 0x70, 0xC7,
  0x1C, 0x61, 0xCE, 0x1C, 0xE1, 0x87, 0x38, 0x7F, 0xC3, 0xDC, 0x0F, 0x8F,
  0xF7, 0x1F, 0x87, 0xE3, 0xFF, 0xEF, 0xE3, 0x80, 0xE0, 0x1F, 0xC3, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0xFF, 0x1C, 0x73, 0x87, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x3F, 0xC1, 0xFC, 0x01, 0xC0, 0x1C, 0x43, 0x8F, 0xF0, 0x7E,
  0x00, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xE3, 0xFC, 0xE7, 0x38,
  0xCC, 0x77, 0x1D, 0xC7, 0x71, 0xD8, 0xEE, 0x3B, 0x8E, 0x0C, 0x1E, 0x1C,
  0x1C, 0x00, 0xFC, 0xFC, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x3F,
  0x1F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x1F, 0xC7, 0xF8, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x08, 0xE3, 0xF8, 0x3E, 0x00, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xCF, 0x39, 0xE3, 0xBC, 0x3F, 0x83, 0xE0, 0x3E, 0x07, 0x70, 0x77,
  0x07, 0x38, 0x63, 0x8E, 0x1C, 0x7F, 0xF8, 0x70, 0xE1, 0xC3, 0x0E, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1F, 0x9F, 0x1F, 0xF1, 0xFF, 0x1B, 0x33,
  0xB3, 0x33, 0x73, 0x37, 0x37, 0x67, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xC0,
  0x1F, 0x8F, 0xF3, 0x9C, 0xE3, 0x31, 0xDC, 0x77, 0x1D, 0xC7, 0x63, 0xB8,
  0xEE, 0x38, 0x0F, 0x83, 0xF8, 0xE7, 0x38, 0x77, 0x0E, 0xC1, 0x98, 0x73,
  0x0E, 0x73, 0x8F, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xFE, 0x1C, 0xE1, 0x87,
  0x38, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0xF8, 0x7F, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xCF, 0xF7, 0x1F, 0x87, 0xE3, 0xB8,
  0xEC, 0x3B, 0x8E, 0xE7, 0x3F, 0xC7, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x1F, 0xCF, 0xF3, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x0F, 0xC3, 0xF8, 0xE1, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xE0,
  0x1C, 0x43, 0x9F, 0xF1, 0xF8, 0x00, 0x1C, 0x0C, 0x0E, 0x1F, 0xFF, 0xF9,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0E, 0x07, 0xE1, 0xF0, 0x71, 0xDC,
  0x77, 0x19, 0x8E, 0xE3, 0xB8, 0xEE, 0x33, 0x8C, 0xE7, 0x3F, 0xE7, 0xB8,
  0xE0, 0xEC, 0x39, 0x87, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x7C,
  0x07, 0x80, 0xE0, 0x00, 0x70, 0x37, 0x07, 0x66, 0x66, 0x66, 0x6E, 0x66,
  0xEC, 0x7A, 0xC7, 0xBC, 0x73, 0x8F, 0x38, 0xE3, 0x00, 0x1C, 0x70, 0xE3,
  0x83, 0xB8, 0x1F, 0x80, 0x78, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x39, 0xC1,
  0xCE, 0x1C, 0x38, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70,
  0x39, 0x80, 0xEE, 0x03, 0xB0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xE0,
  0xFC, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x0F, 0x03,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xF8,
  0x0F, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x00, 0x0F, 0x81, 0xF8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x3C, 0x0F, 0x81,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x83, 0xF0, 0x7C, 0x00,
  0x38, 0x6F, 0xCD, 0xFF, 0x73, 0xE4, 0x38,
};

const GFXglyph UbuntuMono_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 14, 12, 4, -14 },
  { 12, 9, 6, 12, 4, -16 },
  { 19, 12, 14, 12, 1, -14 },
  { 40, 11, 18, 12, 1, -16 },
  { 65, 14, 14, 12, 0, -14 },
  { 90, 11, 14, 12, 1, -14 },
  { 110, 4, 7, 12, 6, -16 },
  { 114, 9, 20, 12, 3, -16 },
  { 137, 9, 20, 12, 1, -16 },
  { 160, 9, 9, 12, 3, -14 },
  { 171, 10, 10, 12, 2, -11 },
  { 184, 6, 7, 12, 2, -4 },
  { 190, 7, 3, 12, 3, -7 },
  { 193, 4, 4, 12, 4, -4 },
  { 195, 13, 20, 12, 0, -16 },
  { 228, 10, 14, 12, 2, -14 },
  { 246, 10, 14, 12, 1, -14 },
  { 264, 11, 14, 12, 1, -14 },
  { 284, 11, 14, 12, 1, -14 },
  { 304, 12, 14, 12, 1, -14 },
  { 325, 12, 14, 12, 1, -14 },
  { 346, 11, 14, 12, 2, -14 },
  { 366, 11, 14, 12, 3, -14 },
  { 386, 11, 14, 12, 1, -14 },
  { 406, 11, 14, 12, 1, -14 },
  { 426, 5, 11, 12, 4, -11 },
  { 433, 7, 14, 12, 2, -11 },
  { 446, 10, 9, 12, 2, -11 },
  { 458, 11, 6, 12, 1, -9 },
  { 467, 11, 9, 12, 1, -11 },
  { 480, 8, 14, 12, 4, -14 },
  { 494, 12, 17, 12, 1, -14 },
  { 520, 11, 14, 12, 0, -14 },
  { 540, 11, 14, 12, 1, -14 },
  { 560, 11, 14, 12, 2, -14 },
  { 580, 11, 14, 12, 1, -14 },
  { 600, 12, 14, 12, 1, -14 },
  { 621, 12, 14, 12, 1, -14 },
  { 642, 11, 14, 12, 2, -14 },
  { 662, 12, 14, 12, 1, -14 },
  { 683, 12, 14, 12, 1, -14 },
  { 704, 12, 14, 12, 1, -14 },
  { 725, 13, 14, 12, 1, -14 },
  { 748, 9, 14, 12, 1, -14 },
  { 764, 13, 14, 12, 0, -14 },
  { 787, 12, 14, 12, 1, -14 },
  { 808, 10, 14, 12, 2, -14 },
  { 826, 12, 14, 12, 1, -14 },
  { 847, 10, 18, 12, 2, -14 },
  { 870, 11, 14, 12, 1, -14 },
  { 890, 12, 14, 12, 1, -14 },
  { 911, 11, 14, 12, 3, -14 },
  { 931, 11, 14, 12, 2, -14 },
  { 951, 11, 14, 12, 3, -14 },
  { 971, 13, 14, 12, 1, -14 },
  { 994, 14, 14, 12, 0, -14 },
  { 1019, 11, 14, 12, 3, -14 },
  { 1039, 12, 14, 12, 1, -14 },
  { 1060, 11, 20, 12, 2, -16 },
  { 1088, 4, 20, 12, 5, -16 },
  { 1098, 12, 20, 12, 0, -16 },
  { 1128, 10, 8, 12, 2, -14 },
  { 1138, 11, 3, 12, -1, 1 },
  { 1143, 6, 4, 12, 5, -16 },
  { 1146, 11, 11, 12, 1, -11 },
  { 1162, 11, 16, 12, 1, -16 },
  { 1184, 10, 11, 12, 2, -11 },
  { 1198, 12, 16, 12, 1, -16 },
  { 1222, 10, 11, 12, 2, -11 },
  { 1236, 15, 20, 12, -1, -16 },
  { 1274, 12, 15, 12, 0, -11 },
  { 1297, 10, 16, 12, 1, -16 },
  { 1317, 8, 16, 12, 3, -16 },
  { 1333, 11, 20, 12, 0, -16 },
  { 1361, 12, 16, 12, 1, -16 },
  { 1385, 7, 16, 12, 3, -16 },
  { 1399, 12, 11, 12, 0, -11 },
  { 1416, 10, 11, 12, 1, -11 },
  { 1430, 11, 11, 12, 1, -11 },
  { 1446, 12, 15, 12, 0, -11 },
  { 1469, 10, 15, 12, 2, -11 },
  { 1488, 10, 11, 12, 2, -11 },
  { 1502, 11, 11, 12, 1, -11 },
  { 1518, 9, 14, 12, 3, -14 },
  { 1534, 10, 11, 12, 2, -11 },
  { 1548, 11, 11, 12, 2, -11 },
  { 1564, 12, 11, 12, 1, -11 },
  { 1581, 13, 11, 12, 0, -11 },
  { 1599, 14, 15, 12, -1, -11 },
  { 1626, 11, 11, 12, 1, -11 },
  { 1642, 11, 20, 12, 2, -16 },
  { 1670, 7, 20, 12, 3, -16 },
  { 1688, 11, 20, 12, 0, -16 },
  { 1716, 11, 5, 12, 1, -8 },
};

const GFXfont UbuntuMono_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic23pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUMONO_BOLDITALIC23PT7B_H_
