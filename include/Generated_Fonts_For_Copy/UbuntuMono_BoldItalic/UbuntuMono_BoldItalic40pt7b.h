#ifndef _UBUNTUMONO_BOLDITALIC40PT7B_H_
#define _UBUNTUMONO_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x70, 0x00,
  0x7C, 0x7D, 0xF1, 0xF7, 0xCF, 0xFE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0x81, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x3C, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xC0, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE3,
  0x80, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F,
  0x03, 0xF0, 0x0E, 0x07, 0xF8, 0x1C, 0x07, 0x38, 0x3C, 0x0E, 0x38, 0x78,
  0x0E, 0x38, 0xF0, 0x0E, 0x39, 0xE0, 0x0E, 0x71, 0xC0, 0x0E, 0x73, 0x80,
  0x0F, 0xF7, 0x80, 0x0F, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x73, 0xF0, 0x00, 0xF7, 0xF8, 0x01, 0xE7, 0x38,
  0x03, 0xCE, 0x38, 0x03, 0x8E, 0x38, 0x07, 0x0E, 0x38, 0x0F, 0x0E, 0x70,
  0x1E, 0x0E, 0x70, 0x3C, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x70, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0x78,
  0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x00, 0xF3, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x1C, 0x3F, 0xC3, 0xCF, 0xFC, 0xF3,
  0xE7, 0xDE, 0xF8, 0xFF, 0xDE, 0x0F, 0xF3, 0xC0, 0xFC, 0x78, 0x0F, 0x8F,
  0x87, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x3C, 0x1F, 0x87, 0x80,
  0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE3, 0xC7, 0x00, 0x00,
  0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x63, 0xC2, 0x7B, 0xCE, 0x7D, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x0F, 0xF0, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x1C, 0x38, 0x04,
  0x10, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0x87, 0xE0,
  0xF8, 0x1E, 0x0F, 0x3F, 0x8F, 0xC3, 0xE0, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x39, 0xFB, 0xFF, 0xFF, 0xDF, 0x9E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x7C,
  0x03, 0xDF, 0x00, 0xF7, 0x8E, 0x3D, 0xE7, 0xCF, 0xF9, 0xE7, 0xFE, 0x71,
  0xFF, 0x80, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01, 0xF3,
  0xE0, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1C, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF0, 0x78, 0x7E, 0x0C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x70, 0x1F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFB,
  0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0xF0,
  0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x83, 0x01, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x9F, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8,
  0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x0F, 0x87, 0xC3, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E,
  0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0x3F, 0x03, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x8F, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0x80, 0xF9,
  0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x83, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFE, 0xF0, 0x1F, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xF3,
  0xF8, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0xE3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x1E, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x78, 0x0F,
  0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xF8, 0xFF, 0xF9,
  0xFF, 0xF3, 0x87, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xE1, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xE1,
  0xFF, 0x3C, 0x3F, 0xF3, 0xC7, 0xFF, 0x78, 0xFF, 0xF7, 0x9F, 0x1E, 0x79,
  0xE1, 0xE7, 0x1E, 0x1E, 0xF1, 0xE3, 0xEF, 0x3C, 0x3C, 0xF3, 0xC3, 0xCF,
  0x3C, 0x3C, 0xF3, 0xE7, 0xCF, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x0F, 0xF8,
  0xF8, 0x7F, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1E,
  0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1,
  0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x03, 0xC3, 0xE0,
  0x78, 0x78, 0x0F, 0x1F, 0x03, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x83, 0xF1, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xEF, 0x81, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x18, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0x7C, 0x3F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0xC1,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC1,
  0xF0, 0x7E, 0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x20, 0x3E,
  0x03, 0x83, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x77,
  0x03, 0xF8, 0xFE, 0x07, 0xF3, 0xBC, 0x1E, 0xE7, 0x78, 0x3C, 0xDC, 0xE0,
  0x79, 0xFB, 0xC0, 0xF3, 0xE7, 0x83, 0xC7, 0xCF, 0x07, 0x8F, 0x1E, 0x0F,
  0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x7E, 0x07,
  0xC1, 0xF8, 0x1F, 0x07, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0xFF, 0x07, 0x83,
  0xFC, 0x3E, 0x0F, 0x78, 0xF0, 0x3D, 0xE3, 0xC1, 0xF7, 0x8F, 0x07, 0xCE,
  0x7C, 0x1E, 0x3D, 0xE0, 0x78, 0xF7, 0x81, 0xE3, 0xDE, 0x0F, 0x87, 0xF8,
  0x3C, 0x1F, 0xE0, 0xF0, 0x7F, 0x03, 0xC1, 0xFC, 0x1F, 0x07, 0xF0, 0x78,
  0x0F, 0xC1, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8,
  0x7C, 0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x79, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F,
  0x8F, 0xC7, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0,
  0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0xF8, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x0E,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x40, 0x0F, 0x83, 0x81, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x87, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x07,
  0x83, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00,
  0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x3E, 0x00, 0xF0,
  0xF1, 0xE3, 0xC3, 0xCF, 0x9F, 0x0F, 0x3E, 0x78, 0x3D, 0xF9, 0xE1, 0xE7,
  0xE7, 0x87, 0xBF, 0x9C, 0x1E, 0xEE, 0xF0, 0x7F, 0x3B, 0xC1, 0xDC, 0xEF,
  0x07, 0xE3, 0xB8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF9, 0xF8, 0x00, 0x7B, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xE7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x87, 0xC0, 0x1F,
  0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF0, 0xF0,
  0x7C, 0x1E, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBF, 0x00, 0xF7,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7D, 0xF8, 0x3E,
  0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x78, 0x07,
  0xCC, 0x00, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x20, 0x70, 0xFC, 0xFE, 0x7F, 0x1F, 0x06, 0x00, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x0F, 0x9F, 0x83, 0xE7,
  0xC0, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xF7, 0xC1, 0xF9, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xEF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xC3,
  0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xFB, 0xE1, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xC0, 0x8F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x21, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF8, 0x3E,
  0x0F, 0x87, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xF1,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x07,
  0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x7F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x61, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x20,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC3, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x38, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xC3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xC1, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F,
  0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7F, 0xEF, 0xFE,
  0xFF, 0xCF, 0xFC, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0x7F, 0xF7, 0xFF,
  0x3F, 0xF0, 0xFC, 0x03, 0xF3, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C,
  0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7D, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF,
  0x81, 0xF7, 0xC1, 0xFB, 0xF1, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x7E, 0x1F, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x87, 0xCF, 0x83, 0xE7, 0xC0, 0xF9,
  0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x0F, 0x8F, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x01, 0xF7, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x80, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F,
  0x81, 0x83, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0x03, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x41, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC7,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF7, 0xC1, 0xF1, 0xC0, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0xF8, 0xE1, 0xEF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x3F,
  0x3C, 0xF3, 0xF3, 0x8F, 0x7F, 0x78, 0xF7, 0x77, 0x8E, 0xF7, 0x70, 0xEE,
  0x7F, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F,
  0x07, 0xC0, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x83, 0xF8, 0x3C, 0xFF, 0xCF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xF3,
  0xFF, 0x3C, 0x1F, 0xC1, 0x81, 0xF0,
};

const GFXglyph UbuntuMono_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 25, 20, 7, -25 },
  { 36, 14, 11, 20, 8, -27 },
  { 56, 22, 25, 20, 1, -25 },
  { 125, 19, 32, 20, 2, -28 },
  { 201, 24, 25, 20, 0, -25 },
  { 276, 19, 25, 20, 2, -25 },
  { 336, 7, 12, 20, 11, -27 },
  { 347, 16, 35, 20, 5, -28 },
  { 417, 16, 35, 20, 2, -28 },
  { 487, 16, 15, 20, 5, -25 },
  { 517, 17, 18, 20, 3, -19 },
  { 556, 10, 13, 20, 4, -7 },
  { 573, 12, 5, 20, 6, -13 },
  { 581, 7, 7, 20, 7, -7 },
  { 588, 23, 35, 20, 0, -28 },
  { 689, 18, 25, 20, 3, -25 },
  { 746, 16, 25, 20, 3, -25 },
  { 796, 19, 25, 20, 2, -25 },
  { 856, 20, 25, 20, 1, -25 },
  { 919, 20, 25, 20, 2, -25 },
  { 982, 21, 25, 20, 1, -25 },
  { 1048, 19, 25, 20, 3, -25 },
  { 1108, 19, 25, 20, 5, -25 },
  { 1168, 20, 25, 20, 2, -25 },
  { 1231, 19, 25, 20, 2, -25 },
  { 1291, 9, 19, 20, 7, -19 },
  { 1313, 12, 25, 20, 4, -19 },
  { 1351, 18, 17, 20, 3, -19 },
  { 1390, 19, 12, 20, 2, -16 },
  { 1419, 18, 17, 20, 2, -19 },
  { 1458, 15, 25, 20, 6, -25 },
  { 1505, 20, 30, 20, 2, -25 },
  { 1580, 19, 25, 20, 0, -25 },
  { 1640, 19, 25, 20, 2, -25 },
  { 1700, 19, 25, 20, 4, -25 },
  { 1760, 20, 25, 20, 1, -25 },
  { 1823, 21, 25, 20, 2, -25 },
  { 1889, 21, 25, 20, 2, -25 },
  { 1955, 20, 25, 20, 3, -25 },
  { 2018, 22, 25, 20, 1, -25 },
  { 2087, 22, 25, 20, 1, -25 },
  { 2156, 21, 25, 20, 1, -25 },
  { 2222, 23, 25, 20, 1, -25 },
  { 2294, 16, 25, 20, 2, -25 },
  { 2344, 23, 25, 20, 0, -25 },
  { 2416, 22, 25, 20, 1, -25 },
  { 2485, 19, 25, 20, 3, -25 },
  { 2545, 20, 25, 20, 2, -25 },
  { 2608, 19, 32, 20, 3, -25 },
  { 2684, 20, 25, 20, 1, -25 },
  { 2747, 21, 25, 20, 1, -25 },
  { 2813, 19, 25, 20, 5, -25 },
  { 2873, 20, 25, 20, 3, -25 },
  { 2936, 20, 25, 20, 5, -25 },
  { 2999, 22, 25, 20, 2, -25 },
  { 3068, 24, 25, 20, 0, -25 },
  { 3143, 19, 25, 20, 6, -25 },
  { 3203, 22, 25, 20, 1, -25 },
  { 3272, 19, 35, 20, 4, -28 },
  { 3356, 8, 35, 20, 8, -28 },
  { 3391, 19, 35, 20, 1, -28 },
  { 3475, 18, 14, 20, 3, -25 },
  { 3507, 19, 5, 20, -1, 2 },
  { 3519, 8, 7, 20, 10, -28 },
  { 3526, 18, 19, 20, 3, -19 },
  { 3569, 18, 28, 20, 2, -28 },
  { 3632, 18, 19, 20, 3, -19 },
  { 3675, 20, 28, 20, 3, -28 },
  { 3745, 18, 19, 20, 3, -19 },
  { 3788, 25, 35, 20, -1, -28 },
  { 3898, 21, 26, 20, 0, -19 },
  { 3967, 18, 28, 20, 2, -28 },
  { 4030, 14, 27, 20, 4, -27 },
  { 4078, 19, 34, 20, 0, -27 },
  { 4159, 21, 28, 20, 2, -28 },
  { 4233, 12, 28, 20, 6, -28 },
  { 4275, 20, 19, 20, 1, -19 },
  { 4323, 18, 19, 20, 2, -19 },
  { 4366, 17, 19, 20, 3, -19 },
  { 4407, 20, 26, 20, 0, -19 },
  { 4472, 18, 26, 20, 3, -19 },
  { 4531, 18, 19, 20, 3, -19 },
  { 4574, 18, 19, 20, 2, -19 },
  { 4617, 17, 25, 20, 4, -25 },
  { 4671, 18, 19, 20, 3, -19 },
  { 4714, 18, 19, 20, 4, -19 },
  { 4757, 20, 19, 20, 3, -19 },
  { 4805, 22, 19, 20, 0, -19 },
  { 4858, 24, 26, 20, -2, -19 },
  { 4936, 19, 19, 20, 2, -19 },
  { 4982, 19, 35, 20, 4, -28 },
  { 5066, 13, 35, 20, 5, -28 },
  { 5123, 19, 35, 20, 0, -28 },
  { 5207, 19, 8, 20, 2, -14 },
};

const GFXfont UbuntuMono_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic40pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUMONO_BOLDITALIC40PT7B_H_
