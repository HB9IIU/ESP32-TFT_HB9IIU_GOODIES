#ifndef _UBUNTUMONO_BOLDITALIC6PT7B_H_
#define _UBUNTUMONO_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xF0, 0x0F, 0xE0, 0x28, 0xF4, 0x46, 0x6E, 0x6D, 0xF0, 0x80,
  0x6A, 0x80, 0x44, 0xA8, 0x3C, 0x1D, 0x00, 0xC0, 0xC0, 0x80, 0x25, 0x28,
  0x6E, 0xB0, 0x2D, 0x30, 0x65, 0x70, 0x64, 0xF0, 0x2F, 0x90, 0x68, 0xF0,
  0x2A, 0xB0, 0xEA, 0x40, 0x6E, 0xF0, 0x75, 0xE0, 0xA0, 0xB0, 0x38, 0x80,
  0x60, 0x4E, 0x00, 0xDA, 0x77, 0xF4, 0x2D, 0xD0, 0x6E, 0xF0, 0x6B, 0x6E,
  0xF0, 0x69, 0x70, 0x64, 0x48, 0x2A, 0xB0, 0x46, 0xAA, 0x69, 0x70, 0x64,
  0xE0, 0x46, 0x4A, 0x4A, 0x70, 0x4F, 0xD0, 0x46, 0xAA, 0x6E, 0xB0, 0x6D,
  0xC0, 0x6E, 0xB4, 0x6D, 0x50, 0x68, 0xF0, 0xF2, 0x40, 0x4E, 0xF0, 0xBB,
  0x40, 0x59, 0xEA, 0x56, 0x4A, 0xBA, 0x40, 0x65, 0x70, 0xEA, 0x80, 0xF0,
  0x25, 0x2C, 0x2C, 0xE0, 0x40, 0x77, 0x80, 0x4E, 0xF0, 0x71, 0x80, 0x26,
  0xAE, 0x7D, 0x80, 0x26, 0x44, 0x80, 0x75, 0xE0, 0x4E, 0xD0, 0x2B, 0x2C,
  0xAC, 0x4D, 0x50, 0xEB, 0x7E, 0x80, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0,
  0x75, 0x80, 0x6A, 0x00, 0x6B, 0x80, 0x3B, 0x77, 0x80, 0x78, 0x1E, 0x80,
  0x6A, 0x80, 0x2D, 0x40, 0x6B, 0x80, 0x6A, 0x80, 0x6A, 0x80, 0x24, 0xAC,
  0xE0,
};

const GFXglyph UbuntuMono_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 4, 3, 1, -4 },
  { 2, 2, 2, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -4 },
  { 7, 4, 4, 3, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 3, 2, -4 },
  { 12, 2, 5, 3, 1, -4 },
  { 14, 3, 5, 3, 0, -4 },
  { 16, 2, 3, 3, 1, -4 },
  { 17, 3, 3, 3, 0, -3 },
  { 19, 1, 2, 3, 1, -1 },
  { 20, 2, 1, 3, 1, -2 },
  { 21, 1, 1, 3, 1, -1 },
  { 22, 3, 5, 3, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 1, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 3, 1, -3 },
  { 45, 1, 4, 3, 1, -3 },
  { 46, 3, 3, 3, 0, -3 },
  { 48, 3, 1, 3, 0, -2 },
  { 49, 3, 3, 3, 0, -3 },
  { 51, 2, 4, 3, 1, -4 },
  { 52, 3, 5, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 2, 4, 3, 1, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 4, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 4, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 4, 4, 3, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 4, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 5, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 1, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 1, -4 },
  { 97, 4, 4, 3, 0, -4 },
  { 99, 4, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 1, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 2, 5, 3, 1, -4 },
  { 107, 1, 5, 3, 1, -4 },
  { 108, 3, 5, 3, 0, -4 },
  { 110, 3, 2, 3, 0, -4 },
  { 111, 3, 1, 3, 0, 0 },
  { 112, 2, 1, 3, 1, -4 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 4, 3, 0, -4 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 4, 4, 3, 0, -4 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 4, 5, 3, 0, -4 },
  { 126, 3, 4, 3, 0, -3 },
  { 128, 3, 4, 3, 0, -4 },
  { 130, 2, 4, 3, 1, -4 },
  { 131, 3, 5, 3, 0, -4 },
  { 133, 3, 4, 3, 0, -4 },
  { 135, 2, 4, 3, 1, -4 },
  { 136, 3, 3, 3, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 3, 4, 3, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 2, 4, 3, 1, -4 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 2, 3, 3, 1, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 3, 4, 3, 0, -3 },
  { 160, 3, 3, 3, 0, -3 },
  { 162, 2, 5, 3, 1, -4 },
  { 164, 2, 5, 3, 1, -4 },
  { 166, 3, 5, 3, 0, -4 },
  { 168, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuMono_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic6pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 6
};

#endif // _UBUNTUMONO_BOLDITALIC6PT7B_H_
