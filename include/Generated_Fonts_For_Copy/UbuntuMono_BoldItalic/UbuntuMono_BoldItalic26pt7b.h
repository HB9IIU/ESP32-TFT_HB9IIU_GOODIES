#ifndef _UBUNTUMONO_BOLDITALIC26PT7B_H_
#define _UBUNTUMONO_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x00, 0x00, 0x70, 0xF8, 0x70, 0x73, 0xB9, 0xFC, 0xFC, 0xEE, 0x77, 0x3B,
  0x18, 0x03, 0x98, 0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x3F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x87, 0x38, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x73, 0x81,
  0x8C, 0x0E, 0x70, 0x39, 0x80, 0x00, 0xE0, 0x06, 0x00, 0xF0, 0x1F, 0xF1,
  0xFF, 0x0F, 0x08, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x1E, 0x00, 0x71, 0x83, 0x8F, 0xFC, 0xFF, 0xC1, 0xFC, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0x06, 0x0F, 0x0E, 0x1B, 0x9C, 0x1B, 0x18,
  0x33, 0x30, 0x3B, 0x60, 0x1E, 0xC0, 0x1D, 0xC0, 0x03, 0xB8, 0x03, 0x78,
  0x06, 0xCC, 0x0C, 0xCC, 0x18, 0xD8, 0x39, 0xD8, 0x70, 0xF0, 0x60, 0xE0,
  0x03, 0xC0, 0x7F, 0x03, 0xF8, 0x38, 0xC1, 0xC6, 0x0E, 0x70, 0x7F, 0x01,
  0xE4, 0x3F, 0x33, 0xBB, 0x98, 0xFD, 0xC3, 0xCE, 0x1C, 0x7F, 0xF1, 0xFF,
  0x87, 0xCC, 0x7B, 0x9C, 0xEF, 0x73, 0x98, 0x00, 0x80, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x04, 0x00, 0x02,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x80, 0x00, 0x0E, 0x01, 0xC1, 0xB9, 0x3A, 0xEF,
  0xFE, 0x1C, 0x06, 0xE1, 0xDC, 0x3B, 0x82, 0x20, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x61, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x1C, 0x7C, 0xF9, 0xF1, 0xC1, 0x8E, 0x38, 0x40, 0xFF, 0xFF,
  0xF8, 0x73, 0xFF, 0xF7, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0x77, 0x07, 0x76, 0x7E, 0xE7, 0xE6,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x01,
  0xC1, 0xF1, 0xF8, 0xFE, 0x3B, 0x88, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x38, 0xF0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x3F, 0xF3, 0xFF, 0x9F, 0xFC, 0x07, 0xE0, 0xFF,
  0x83, 0xFC, 0x10, 0xF0, 0x07, 0x00, 0x78, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC4, 0x1E, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00,
  0x78, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x38, 0x73, 0x87, 0x1C,
  0x30, 0xE3, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x00, 0xC0, 0x0F, 0x80, 0x7F,
  0x03, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC4, 0x1E, 0x7F, 0xF3,
  0xFF, 0x0F, 0xE0, 0x00, 0xF0, 0x7F, 0x0F, 0xF1, 0xF0, 0x3C, 0x07, 0x80,
  0x7F, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xE7, 0xFC,
  0x7F, 0x81, 0xF0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xC7, 0x38, 0x73, 0x87,
  0x3C, 0xE1, 0xFC, 0x3F, 0x87, 0x3C, 0xE1, 0xEE, 0x1E, 0xE1, 0xEF, 0xFC,
  0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF8, 0x7F, 0x80, 0x3C, 0x03, 0xC0, 0x7C,
  0x3F, 0xC1, 0xFC, 0x1F, 0x00, 0x1C, 0x7C, 0xF9, 0xE1, 0xC0, 0x00, 0x00,
  0x70, 0xF3, 0xE7, 0xC7, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x87, 0xC1, 0xC0, 0x60, 0xE0, 0xE0, 0x40,
  0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFE, 0x7F, 0x0F, 0x80, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x08, 0x3F, 0xF9, 0xFF, 0xDF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0x10, 0x03, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0x3F, 0xCF, 0xE0, 0xF8,
  0x04, 0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0x8F, 0x03, 0xC0, 0xE0, 0x78, 0x78,
  0x3C, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0x03, 0xF0,
  0x1F, 0xE0, 0xE3, 0x87, 0x07, 0x38, 0x1C, 0xC7, 0xE7, 0x3F, 0x9D, 0xFE,
  0x67, 0x39, 0x9C, 0xE6, 0x63, 0x3B, 0x9C, 0xEE, 0x73, 0x99, 0xC6, 0x7E,
  0x18, 0xF8, 0x70, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xC7,
  0x3F, 0xF3, 0xFF, 0x7F, 0xF7, 0x07, 0xF0, 0x7E, 0x07, 0x0F, 0xE0, 0xFF,
  0x87, 0xFE, 0x38, 0x71, 0xC3, 0x9E, 0x38, 0xFF, 0xC7, 0xF8, 0x3F, 0xF3,
  0xC7, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0x03,
  0xF0, 0x7F, 0xC7, 0xFC, 0x7C, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x04, 0x3F, 0xE0, 0xFF, 0x03,
  0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x38, 0xE1, 0xC7, 0x9E, 0x1C, 0xE1,
  0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x3C, 0xE1, 0xC7, 0x3E, 0x7F, 0xE3,
  0xFE, 0x1F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC7, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x7F, 0xC7, 0xFC, 0x7C, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x1C,
  0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0x8F, 0x1C, 0x3F, 0xE1, 0xFF, 0x07,
  0xF0, 0x1E, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x3C, 0x38, 0xE0, 0xE3,
  0xFF, 0x8F, 0xFC, 0x7F, 0xF1, 0xC1, 0xC7, 0x0F, 0x1C, 0x38, 0x70, 0xE3,
  0xC3, 0x8E, 0x1E, 0x38, 0x70, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC6, 0x3C, 0x7F, 0xE3, 0xFE, 0x07, 0xC0, 0x0E,
  0x1C, 0x3C, 0x78, 0x71, 0xE0, 0xE7, 0x81, 0xDE, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xCF, 0x03, 0x8E, 0x07, 0x1C, 0x1E,
  0x3C, 0x38, 0x38, 0x70, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xFF,
  0xDF, 0xF7, 0xFE, 0x07, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE1, 0xF3,
  0xC3, 0xED, 0x86, 0xDF, 0x0D, 0xEE, 0x3B, 0x9C, 0x77, 0x30, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x1C, 0x70, 0x38, 0x1C, 0x1C, 0x78,
  0x71, 0xE1, 0xC7, 0x86, 0x3F, 0x38, 0xFC, 0xE3, 0xB3, 0x8E, 0xCC, 0x73,
  0xF1, 0xCF, 0xC7, 0x1F, 0x1C, 0x78, 0x61, 0xE3, 0x87, 0x8E, 0x1E, 0x38,
  0x30, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0x77, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE3, 0xCF, 0xF8, 0x7F, 0x03,
  0xE0, 0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0xF0,
  0xE7, 0x0F, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0x77, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE3, 0xCF, 0xF8,
  0x7F, 0x03, 0xE0, 0x18, 0x01, 0xE0, 0x1F, 0x80, 0xF0, 0x03, 0x00, 0x0F,
  0xE0, 0xFF, 0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x9E, 0x3C, 0xE3, 0xC7, 0xFE,
  0x3F, 0xE3, 0xFC, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x78, 0x73, 0x83, 0x9C,
  0x1C, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x38, 0x21, 0xC0, 0x0E, 0x00, 0x7C,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x01, 0xC6, 0x1E, 0x7F, 0xF3,
  0xFF, 0x07, 0xE0, 0x7F, 0xFB, 0xFF, 0xBF, 0xFC, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x39, 0xC3, 0xCE, 0x1C, 0x70, 0xE7,
  0x87, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x71, 0xC3,
  0x8E, 0x3C, 0x7F, 0xC3, 0xFE, 0x07, 0xC0, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE,
  0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x78, 0xE7, 0x0E, 0xF0, 0xEE, 0x0E,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x1C, 0x0E, 0x38, 0x18, 0xE0,
  0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0C, 0xEE, 0x3B, 0xDC, 0x77, 0xB8,
  0xFB, 0x61, 0xB7, 0xC3, 0xCF, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x70,
  0xE0, 0x0E, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x03, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x70, 0xF0, 0x70, 0xE0, 0xFE, 0x0E,
  0xE1, 0xCE, 0x3C, 0xF3, 0x87, 0x70, 0x7F, 0x07, 0xE0, 0x7C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF0, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xFE, 0x07, 0xF0, 0x7F,
  0x80, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC,
  0x1D, 0xE3, 0xCE, 0x78, 0xFF, 0x07, 0x60, 0x40, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x41, 0xCF, 0x8F, 0x08, 0x0F, 0xE1, 0xFE, 0x7F, 0xE7, 0x8E, 0xF0,
  0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0xFC, 0xFF, 0xC7, 0xDC, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1F, 0xC3, 0xFE, 0x3F,
  0xF3, 0x8F, 0x38, 0x77, 0x87, 0x70, 0x77, 0x0F, 0x71, 0xEF, 0xFC, 0xFF,
  0x87, 0xE0, 0x07, 0xE1, 0xFF, 0x3F, 0xE7, 0xC0, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x4F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xC3, 0xFC, 0x7F, 0xE3, 0xC7,
  0x3C, 0x39, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x1F, 0xF8, 0xFF, 0xC3,
  0xEE, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F, 0xF0, 0xEE, 0x7E, 0xFF,
  0x8F, 0x80, 0xF0, 0x4F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0x8E, 0x3C,
  0x38, 0xE1, 0xE3, 0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00,
  0x38, 0x41, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1F, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x38,
  0x73, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x1E, 0xF1, 0xCE, 0x1C, 0x06,
  0x07, 0x83, 0xC1, 0xC0, 0x07, 0xF3, 0xF9, 0xF8, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xFE, 0x7F, 0x1F, 0x80, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x84, 0x78, 0xFF, 0x8F,
  0xF0, 0x7E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC3, 0x87, 0x1C, 0x1C, 0xE0, 0xF7, 0x03, 0xB8, 0x0F, 0xC0,
  0x3F, 0x81, 0xEE, 0x07, 0x3C, 0x1C, 0x70, 0x71, 0xE1, 0xC3, 0x80, 0xFE,
  0xFE, 0xFC, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0xF1, 0x7F, 0x7F, 0x3E, 0x1E, 0xF1, 0xFF, 0xCF, 0xFE, 0x66, 0x77,
  0x33, 0x3B, 0x99, 0xDD, 0xCC, 0x0E, 0xE0, 0x67, 0x03, 0x38, 0x39, 0x81,
  0xC0, 0x0F, 0xC1, 0xFE, 0x1F, 0xF3, 0xCF, 0x38, 0x73, 0x8F, 0x38, 0xE7,
  0x8E, 0x70, 0xE7, 0x1E, 0x71, 0xCE, 0x1C, 0x0F, 0x87, 0xF9, 0xFF, 0xBC,
  0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE3, 0xDF, 0xF3, 0xFC, 0x1F, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7,
  0x0F, 0x38, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0x07, 0xE1, 0xFF, 0x3F, 0xE7, 0x8E, 0xF0, 0xEE, 0x1E, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xF8, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0xF3, 0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xE1, 0xFF, 0x1F,
  0xE1, 0xC0, 0x1C, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x61, 0xE7, 0xFC, 0xFF,
  0xC3, 0xF0, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x0F, 0xFF, 0xFF, 0xBF, 0xF1,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x08, 0xFF, 0x1F, 0xE0, 0xF8,
  0x38, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xEF, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE3, 0xCF, 0xFC, 0xFF, 0xC7, 0xDC, 0xE0, 0xFC, 0x3F, 0x87, 0x70, 0xEE,
  0x39, 0xC7, 0x3D, 0xC3, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x60,
  0x3F, 0x01, 0xF9, 0x8D, 0xCC, 0xEE, 0xE7, 0x67, 0x33, 0x6F, 0x9B, 0x78,
  0xF3, 0xC7, 0x9E, 0x38, 0xE1, 0x87, 0x00, 0x1C, 0x1C, 0x38, 0xE0, 0xE7,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xE0, 0x73,
  0x83, 0x8F, 0x1C, 0x1C, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE0,
  0xF3, 0x81, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x1C, 0x00, 0x78, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0xF8,
  0xFF, 0x87, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xFF, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0xF8, 0x0E, 0x00,
  0xF8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0,
  0x1F, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0xFC,
  0x0F, 0xE0, 0x7E, 0x00, 0x1C, 0x31, 0xF9, 0x9F, 0xFC, 0xCF, 0xC6, 0x1C,
  0x00,
};

const GFXglyph UbuntuMono_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 16, 13, 4, -16 },
  { 17, 9, 7, 13, 5, -18 },
  { 25, 14, 16, 13, 1, -16 },
  { 53, 13, 21, 13, 1, -18 },
  { 88, 16, 16, 13, 0, -16 },
  { 120, 13, 16, 13, 1, -16 },
  { 146, 5, 8, 13, 7, -18 },
  { 151, 10, 22, 13, 4, -18 },
  { 179, 11, 22, 13, 1, -18 },
  { 210, 11, 10, 13, 3, -16 },
  { 224, 11, 13, 13, 2, -13 },
  { 242, 7, 9, 13, 2, -5 },
  { 250, 7, 3, 13, 4, -8 },
  { 253, 5, 5, 13, 4, -5 },
  { 257, 15, 22, 13, 0, -18 },
  { 299, 12, 16, 13, 2, -16 },
  { 323, 10, 16, 13, 2, -16 },
  { 343, 13, 16, 13, 1, -16 },
  { 369, 13, 16, 13, 1, -16 },
  { 395, 13, 16, 13, 1, -16 },
  { 421, 13, 16, 13, 1, -16 },
  { 447, 12, 16, 13, 2, -16 },
  { 471, 12, 16, 13, 3, -16 },
  { 495, 12, 16, 13, 2, -16 },
  { 519, 13, 16, 13, 1, -16 },
  { 545, 7, 13, 13, 4, -13 },
  { 557, 9, 17, 13, 2, -13 },
  { 577, 12, 12, 13, 2, -12 },
  { 595, 13, 8, 13, 1, -11 },
  { 608, 12, 12, 13, 1, -12 },
  { 626, 10, 16, 13, 4, -16 },
  { 646, 14, 20, 13, 1, -16 },
  { 681, 12, 16, 13, 0, -16 },
  { 705, 13, 16, 13, 1, -16 },
  { 731, 13, 16, 13, 2, -16 },
  { 757, 13, 16, 13, 1, -16 },
  { 783, 14, 16, 13, 1, -16 },
  { 811, 14, 16, 13, 1, -16 },
  { 839, 13, 16, 13, 2, -16 },
  { 865, 14, 16, 13, 1, -16 },
  { 893, 14, 16, 13, 1, -16 },
  { 921, 13, 16, 13, 1, -16 },
  { 947, 15, 16, 13, 1, -16 },
  { 977, 11, 16, 13, 1, -16 },
  { 999, 15, 16, 13, 0, -16 },
  { 1029, 14, 16, 13, 1, -16 },
  { 1057, 12, 16, 13, 2, -16 },
  { 1081, 13, 16, 13, 1, -16 },
  { 1107, 12, 21, 13, 2, -16 },
  { 1139, 13, 16, 13, 1, -16 },
  { 1165, 13, 16, 13, 1, -16 },
  { 1191, 13, 16, 13, 3, -16 },
  { 1217, 13, 16, 13, 2, -16 },
  { 1243, 12, 16, 13, 4, -16 },
  { 1267, 15, 16, 13, 1, -16 },
  { 1297, 16, 16, 13, 0, -16 },
  { 1329, 12, 16, 13, 4, -16 },
  { 1353, 14, 16, 13, 1, -16 },
  { 1381, 13, 22, 13, 2, -18 },
  { 1417, 6, 22, 13, 5, -18 },
  { 1434, 13, 22, 13, 0, -18 },
  { 1470, 12, 9, 13, 2, -16 },
  { 1484, 12, 3, 13, -1, 1 },
  { 1489, 6, 5, 13, 6, -18 },
  { 1493, 12, 12, 13, 2, -12 },
  { 1511, 12, 18, 13, 1, -18 },
  { 1538, 12, 12, 13, 2, -12 },
  { 1556, 13, 18, 13, 2, -18 },
  { 1586, 12, 12, 13, 2, -12 },
  { 1604, 16, 22, 13, -1, -18 },
  { 1648, 14, 16, 13, 0, -12 },
  { 1676, 12, 18, 13, 1, -18 },
  { 1703, 9, 17, 13, 3, -17 },
  { 1723, 12, 21, 13, 0, -17 },
  { 1755, 14, 18, 13, 1, -18 },
  { 1787, 8, 18, 13, 4, -18 },
  { 1805, 13, 12, 13, 1, -12 },
  { 1825, 12, 12, 13, 1, -12 },
  { 1843, 11, 12, 13, 2, -12 },
  { 1860, 13, 16, 13, 0, -12 },
  { 1886, 12, 16, 13, 2, -12 },
  { 1910, 12, 12, 13, 2, -12 },
  { 1928, 12, 12, 13, 1, -12 },
  { 1946, 11, 16, 13, 3, -16 },
  { 1968, 12, 12, 13, 2, -12 },
  { 1986, 11, 12, 13, 3, -12 },
  { 2003, 13, 12, 13, 2, -12 },
  { 2023, 14, 12, 13, 0, -12 },
  { 2044, 15, 16, 13, -1, -12 },
  { 2074, 13, 12, 13, 1, -12 },
  { 2094, 12, 22, 13, 3, -18 },
  { 2127, 9, 22, 13, 3, -18 },
  { 2152, 13, 22, 13, 0, -18 },
  { 2188, 13, 5, 13, 1, -9 },
};

const GFXfont UbuntuMono_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic26pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUMONO_BOLDITALIC26PT7B_H_
