#ifndef _UBUNTUMONO_BOLDITALIC29PT7B_H_
#define _UBUNTUMONO_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF3, 0xFC, 0xFF, 0x3F, 0x8E,
  0xE3, 0xB9, 0xCC, 0x73, 0x1C, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x70, 0x1C,
  0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0x38, 0x0E, 0x70, 0x38, 0xE0,
  0x73, 0x83, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1C, 0x70, 0x39, 0xC0, 0x73,
  0x81, 0xCE, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x87, 0x82, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0xF8, 0xFF,
  0xE3, 0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0x01, 0x83, 0xE0, 0xC1, 0xD8, 0x70, 0x67, 0x38, 0x19, 0x9C, 0x06, 0x66,
  0x01, 0xBB, 0x00, 0x7D, 0x80, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x3B, 0xE0,
  0x0D, 0x98, 0x06, 0x66, 0x03, 0x39, 0x81, 0xCE, 0x60, 0xE3, 0xB0, 0x70,
  0x7C, 0x18, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0x8E, 0x0E,
  0x38, 0x39, 0xC0, 0xEF, 0x03, 0xF8, 0x0F, 0x88, 0x7E, 0x73, 0xB9, 0xDC,
  0x7E, 0x71, 0xFB, 0x83, 0xCF, 0x1F, 0x1F, 0xFC, 0x7F, 0xF8, 0xF8, 0xE0,
  0x7B, 0xDE, 0xEF, 0x7B, 0x9C, 0xC0, 0x00, 0x40, 0x0E, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0x01, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x04, 0x00,
  0x0E, 0x00, 0xE0, 0x0E, 0x0C, 0xE6, 0xF7, 0xEF, 0xFE, 0x7F, 0xC1, 0xF0,
  0x3B, 0x87, 0xBC, 0x79, 0xC1, 0x10, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xC3, 0x8E, 0x78, 0xE0,
  0x7F, 0xBF, 0xBF, 0xDF, 0xE0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0x8E, 0x3C, 0x39,
  0xE0, 0xF7, 0x83, 0xDC, 0xCE, 0x77, 0x3B, 0xDC, 0xEE, 0x07, 0xB8, 0x1E,
  0xE0, 0x73, 0x83, 0xCF, 0x1E, 0x1F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0x00,
  0xE0, 0x3C, 0x1F, 0x8F, 0xF3, 0xFC, 0x73, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xF0, 0x3F, 0xE1, 0xFF, 0xC3, 0x8F, 0x08, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC1, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x81, 0xFC, 0x07, 0xC0,
  0x1F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE4, 0x0F, 0x3F, 0xFC,
  0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x77, 0x01, 0xCE, 0x07, 0x1C, 0x1C, 0x78, 0x70, 0xF1, 0xC1,
  0xC3, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x80, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x18, 0x3C, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0x00,
  0x00, 0x7C, 0x0F, 0xF0, 0x7F, 0xC7, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xF0, 0x7F, 0xF3, 0xFF, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1,
  0xC7, 0x8F, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x0F, 0x3C,
  0x3C, 0xF0, 0xE3, 0xC3, 0x87, 0xBC, 0x0F, 0xE0, 0x7F, 0x07, 0x9E, 0x3C,
  0x3C, 0xE0, 0x73, 0x83, 0xCF, 0x1F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1E, 0x78, 0x39, 0xE0, 0xE7, 0x03,
  0xDE, 0x0E, 0x78, 0x78, 0xFF, 0xE3, 0xFF, 0x87, 0xDC, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x1C, 0x7C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x9E, 0x00, 0x07, 0x07, 0xC3,
  0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x87, 0xC3, 0xE1,
  0xE0, 0x70, 0x70, 0xF0, 0x70, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x1F,
  0xE7, 0xFC, 0x3F, 0x01, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xC0, 0x06, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0x30, 0x01, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xC0, 0x7E, 0x1F, 0xF3,
  0xFC, 0x3F, 0x01, 0xE0, 0x08, 0x00, 0x00, 0x0F, 0x87, 0xFC, 0xFF, 0x90,
  0xF0, 0x0E, 0x03, 0xC0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x0E, 0x00, 0x03, 0xF0, 0x1F, 0xE1,
  0xFF, 0xC7, 0x87, 0x38, 0x1D, 0xC3, 0xF7, 0x3F, 0xD9, 0xFF, 0xE7, 0x3F,
  0xBC, 0xEE, 0xE3, 0xB3, 0x8E, 0xCE, 0x7B, 0x39, 0xCC, 0xFF, 0x31, 0xFC,
  0xE3, 0xE3, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x81,
  0xCE, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7,
  0x83, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0x87, 0x0F, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF0, 0xE1, 0xE1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1C, 0x3E, 0x3F,
  0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x84,
  0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x04, 0x3F, 0xF0, 0x7F, 0xC0, 0x7E,
  0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x1E, 0x3C, 0x70, 0x71,
  0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xE0, 0xF3, 0x83, 0xDE, 0x0F, 0x78, 0x79,
  0xE3, 0xE7, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF8, 0x43, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0xF3, 0xC1, 0xC7,
  0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x1E, 0x38, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C,
  0x1E, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x38, 0x78,
  0x38, 0x78, 0x78, 0x70, 0x78, 0x70, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xE0,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x18, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x0F,
  0x0F, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1D,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3B, 0xC0, 0x79, 0xE0, 0x79,
  0xE0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0x07, 0x07, 0x83, 0xC3, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF9,
  0xB0, 0x6C, 0xF8, 0x76, 0xDC, 0x3B, 0x6E, 0x1D, 0xEE, 0x1C, 0xF7, 0x0E,
  0x73, 0x87, 0x39, 0xC3, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0x70, 0x3C, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x0F, 0x0F, 0x1F, 0x0E, 0x1F,
  0x0E, 0x1F, 0x0E, 0x1F, 0x9E, 0x3F, 0x9C, 0x39, 0x9C, 0x39, 0x9C, 0x39,
  0xDC, 0x39, 0xF8, 0x71, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0,
  0xF0, 0xE0, 0xF0, 0xE0, 0x70, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x8E,
  0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x1E, 0x1F, 0xF0, 0x7F, 0x80, 0x7C,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x8E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC,
  0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF,
  0x1E, 0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E,
  0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0E,
  0x70, 0x78, 0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0xC1, 0xE0,
  0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x61, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x18, 0x3C, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xE1, 0xE3,
  0x83, 0xC7, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0x78, 0xE0, 0xE3, 0xC1,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7E, 0x00, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3,
  0x8F, 0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x3D, 0xC0, 0xF7,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x8E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xE7,
  0x38, 0x73, 0x9C, 0x3B, 0xDC, 0x19, 0xEE, 0x1D, 0xB7, 0x0E, 0xDB, 0x07,
  0xCD, 0x83, 0x67, 0xC1, 0xE3, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x00, 0x07, 0x03, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x0E, 0x78, 0x03, 0xDC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0xF0,
  0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x1C,
  0x3C, 0x71, 0xE1, 0xC7, 0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xE3, 0xCF,
  0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x78, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x0F,
  0xF0, 0x79, 0xC3, 0xC7, 0x9E, 0x1E, 0xF0, 0x3D, 0xC0, 0xC0, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0x80, 0x41, 0xCF, 0x8F, 0x08, 0x03, 0xF0, 0xFF, 0xCF,
  0xFE, 0xF8, 0xF7, 0x87, 0x78, 0x3B, 0xC3, 0xDC, 0x1E, 0xE0, 0xE7, 0x07,
  0x3C, 0x79, 0xFF, 0xC7, 0xFE, 0x1F, 0x70, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0xF1,
  0xE3, 0xC3, 0xCF, 0x0F, 0x38, 0x39, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x70,
  0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x7C,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x08,
  0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0xF1,
  0xE1, 0xC7, 0x83, 0x8F, 0x0F, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x70, 0xF1,
  0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xF7, 0x80, 0x03, 0xE0, 0x7F, 0x8F, 0xFE,
  0x78, 0xF7, 0x83, 0xB8, 0x3F, 0xFF, 0xDF, 0xFC, 0xFF, 0x07, 0x80, 0x3E,
  0x08, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x78, 0xF1, 0xE1,
  0xE3, 0x83, 0x8F, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x20, 0xF8, 0x7F, 0xE1, 0xFF,
  0x81, 0xFC, 0x00, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xE3, 0xCF, 0x0E, 0x78, 0x73, 0xC7,
  0x9C, 0x3C, 0xE1, 0xEF, 0x0E, 0x78, 0x73, 0x87, 0x9C, 0x3D, 0xE1, 0xC0,
  0x03, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x3F,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xFC,
  0x7F, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x04, 0x3C, 0x3F, 0xE0, 0xFF, 0x81, 0xF8,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC3, 0xCF, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xBC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFE, 0x07, 0x78, 0x1C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x1E, 0x38, 0x3C,
  0x7F, 0x3F, 0xBF, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xCF, 0xE3, 0xE0, 0x0F,
  0x38, 0x7F, 0xF3, 0xFF, 0xCE, 0x77, 0x39, 0x9C, 0xEE, 0x77, 0x39, 0xDC,
  0xE6, 0x73, 0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xC0,
  0x07, 0xF0, 0xFF, 0xC7, 0xFE, 0x38, 0xF1, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7,
  0x0F, 0x38, 0x7B, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x78, 0x70, 0x07,
  0xC0, 0xFF, 0x8F, 0xFC, 0xF9, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E,
  0xE0, 0xF7, 0x87, 0xBC, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E,
  0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xE3, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xF0,
  0x7F, 0xC7, 0xFE, 0x78, 0xF7, 0x87, 0xB8, 0x3B, 0xC1, 0xDE, 0x1E, 0xF0,
  0xF7, 0x87, 0x3C, 0x78, 0xFF, 0xC7, 0xFE, 0x1E, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x87,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xC6,
  0x0F, 0x1F, 0xFC, 0x7F, 0xE0, 0xFE, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x03, 0xFC, 0x3F, 0xC1, 0xF8, 0x3C, 0x39,
  0xC3, 0xCE, 0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x79, 0xC3, 0xDE, 0x1C, 0xF0,
  0xE7, 0x8F, 0x3C, 0x79, 0xFF, 0xC7, 0xFE, 0x1F, 0x70, 0xF0, 0x7F, 0x83,
  0xFC, 0x3D, 0xE1, 0xEF, 0x1E, 0x38, 0xF1, 0xCF, 0x0E, 0x78, 0x77, 0x83,
  0xB8, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x1E, 0xE0, 0x39,
  0xC0, 0x77, 0x18, 0xEE, 0x73, 0x9C, 0xF7, 0x3B, 0xEE, 0x77, 0xD8, 0xFD,
  0xF1, 0xB3, 0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1C, 0x1C, 0x38, 0x00, 0x1E,
  0x0F, 0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x38,
  0x78, 0x78, 0x38, 0x0F, 0x07, 0x87, 0x83, 0x83, 0xC3, 0xC0, 0xE1, 0xE0,
  0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x1E, 0x0C, 0xFE, 0x77, 0xFF, 0x9C,
  0xFE, 0x60, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 18, 15, 5, -18 },
  { 19, 10, 8, 15, 6, -20 },
  { 29, 15, 18, 15, 1, -18 },
  { 63, 15, 23, 15, 1, -20 },
  { 107, 18, 18, 15, 0, -18 },
  { 148, 14, 18, 15, 1, -18 },
  { 180, 5, 9, 15, 8, -20 },
  { 186, 12, 26, 15, 4, -21 },
  { 225, 12, 26, 15, 1, -21 },
  { 264, 12, 12, 15, 4, -18 },
  { 282, 13, 13, 15, 2, -14 },
  { 304, 7, 9, 15, 3, -5 },
  { 312, 9, 4, 15, 4, -9 },
  { 317, 5, 5, 15, 5, -5 },
  { 321, 17, 25, 15, 0, -20 },
  { 375, 14, 18, 15, 2, -18 },
  { 407, 11, 18, 15, 2, -18 },
  { 432, 14, 18, 15, 1, -18 },
  { 464, 14, 18, 15, 1, -18 },
  { 496, 15, 18, 15, 1, -18 },
  { 530, 15, 18, 15, 1, -18 },
  { 564, 14, 18, 15, 2, -18 },
  { 596, 14, 18, 15, 3, -18 },
  { 628, 14, 18, 15, 2, -18 },
  { 660, 14, 18, 15, 2, -18 },
  { 692, 7, 14, 15, 5, -14 },
  { 705, 9, 18, 15, 3, -14 },
  { 726, 13, 13, 15, 2, -14 },
  { 748, 15, 9, 15, 1, -12 },
  { 765, 13, 13, 15, 2, -14 },
  { 787, 11, 18, 15, 4, -18 },
  { 812, 14, 22, 15, 2, -18 },
  { 851, 14, 18, 15, 0, -18 },
  { 883, 15, 18, 15, 1, -18 },
  { 917, 14, 18, 15, 3, -18 },
  { 949, 14, 18, 15, 1, -18 },
  { 981, 14, 18, 15, 2, -18 },
  { 1013, 15, 18, 15, 2, -18 },
  { 1047, 15, 18, 15, 2, -18 },
  { 1081, 16, 18, 15, 1, -18 },
  { 1117, 16, 18, 15, 1, -18 },
  { 1153, 15, 18, 15, 1, -18 },
  { 1187, 16, 18, 15, 1, -18 },
  { 1223, 12, 18, 15, 1, -18 },
  { 1250, 17, 18, 15, 0, -18 },
  { 1289, 16, 18, 15, 1, -18 },
  { 1325, 14, 18, 15, 2, -18 },
  { 1357, 15, 18, 15, 1, -18 },
  { 1391, 14, 23, 15, 2, -18 },
  { 1432, 14, 18, 15, 1, -18 },
  { 1464, 15, 18, 15, 1, -18 },
  { 1498, 13, 18, 15, 4, -18 },
  { 1528, 15, 18, 15, 2, -18 },
  { 1562, 14, 18, 15, 4, -18 },
  { 1594, 17, 18, 15, 1, -18 },
  { 1633, 18, 18, 15, 0, -18 },
  { 1674, 14, 18, 15, 4, -18 },
  { 1706, 16, 18, 15, 1, -18 },
  { 1742, 14, 25, 15, 3, -20 },
  { 1786, 6, 25, 15, 6, -20 },
  { 1805, 15, 25, 15, 0, -20 },
  { 1852, 14, 10, 15, 2, -18 },
  { 1870, 14, 3, 15, -1, 2 },
  { 1876, 6, 5, 15, 7, -20 },
  { 1880, 13, 14, 15, 2, -14 },
  { 1903, 14, 20, 15, 1, -20 },
  { 1938, 13, 14, 15, 2, -14 },
  { 1961, 15, 20, 15, 2, -20 },
  { 1999, 13, 14, 15, 2, -14 },
  { 2022, 18, 25, 15, -1, -20 },
  { 2079, 15, 19, 15, 0, -14 },
  { 2115, 13, 20, 15, 1, -20 },
  { 2148, 10, 21, 15, 3, -21 },
  { 2175, 14, 26, 15, 0, -21 },
  { 2221, 14, 20, 15, 2, -20 },
  { 2256, 9, 20, 15, 4, -20 },
  { 2279, 14, 14, 15, 1, -14 },
  { 2304, 13, 14, 15, 1, -14 },
  { 2327, 13, 14, 15, 2, -14 },
  { 2350, 15, 19, 15, 0, -14 },
  { 2386, 13, 19, 15, 2, -14 },
  { 2417, 14, 14, 15, 2, -14 },
  { 2442, 14, 14, 15, 1, -14 },
  { 2467, 12, 18, 15, 3, -18 },
  { 2494, 13, 14, 15, 2, -14 },
  { 2517, 13, 14, 15, 3, -14 },
  { 2540, 15, 14, 15, 2, -14 },
  { 2567, 16, 14, 15, 0, -14 },
  { 2595, 17, 19, 15, -1, -14 },
  { 2636, 14, 14, 15, 1, -14 },
  { 2661, 14, 25, 15, 3, -20 },
  { 2705, 9, 25, 15, 4, -20 },
  { 2734, 14, 25, 15, 0, -20 },
  { 2778, 14, 5, 15, 1, -10 },
};

const GFXfont UbuntuMono_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic29pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUMONO_BOLDITALIC29PT7B_H_
