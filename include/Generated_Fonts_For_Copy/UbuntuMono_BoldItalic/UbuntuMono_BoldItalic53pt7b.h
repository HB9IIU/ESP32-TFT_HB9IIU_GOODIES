#ifndef _UBUNTUMONO_BOLDITALIC53PT7B_H_
#define _UBUNTUMONO_BOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x00, 0x78, 0x00, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1,
  0xF0, 0x3C, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xE0, 0x04, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x04,
  0x00, 0x3F, 0x83, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0x80, 0x3C, 0x03, 0xE7,
  0x80, 0x78, 0x03, 0xC7, 0x80, 0xF8, 0x03, 0xC7, 0x81, 0xF0, 0x07, 0x87,
  0x83, 0xE0, 0x07, 0x87, 0x87, 0xC0, 0x07, 0x87, 0x87, 0x80, 0x07, 0x8F,
  0x8F, 0x80, 0x07, 0x8F, 0x1F, 0x00, 0x07, 0x9F, 0x3E, 0x00, 0x07, 0xFE,
  0x7C, 0x00, 0x07, 0xFE, 0xF8, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F,
  0x9F, 0xC0, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3E,
  0x79, 0xF0, 0x00, 0x7C, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0xF0, 0x01, 0xF0,
  0xF0, 0xF0, 0x03, 0xE0, 0xF1, 0xE0, 0x03, 0xC1, 0xE1, 0xE0, 0x07, 0xC1,
  0xE1, 0xE0, 0x0F, 0x81, 0xE3, 0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0x01,
  0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0x80, 0x78, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC1,
  0xF0, 0x7F, 0xE0, 0xFC, 0x3F, 0xFC, 0x3E, 0x1F, 0xFF, 0x8F, 0x8F, 0xC7,
  0xE7, 0xC3, 0xF0, 0xFD, 0xF1, 0xF8, 0x3F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F,
  0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xFC,
  0x1F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0x7E, 0x07, 0xFF, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xDF, 0xCF,
  0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3,
  0xC1, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x06, 0x0F, 0x83, 0x3C, 0x7C, 0x79, 0xFB, 0xCF, 0xDF, 0xEE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xEF, 0x80, 0x3F, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0xF8,
  0x7E, 0x01, 0xC1, 0xC0, 0x04, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0xCF, 0xFC, 0x7F,
  0xC3, 0xF8, 0x1F, 0x80, 0xC0, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x7F, 0x1E, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x7E, 0x3F, 0x7E, 0x7E, 0x3F,
  0xFE, 0x3C, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0,
  0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0x7C, 0x7E,
  0x00, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xF0, 0x1E, 0x01, 0xFC,
  0x02, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3C, 0x1F, 0xE0,
  0x08, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x20,
  0x01, 0xFC, 0x1F, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x18, 0x00, 0xFE,
  0x07, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0x83, 0xFC,
  0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0xC0, 0xFF,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7,
  0xE0, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1E,
  0x0F, 0xF1, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7C, 0x07,
  0xFF, 0x8F, 0x83, 0xFF, 0xE3, 0xE0, 0xFF, 0xFC, 0x7C, 0x3F, 0xFF, 0x8F,
  0x8F, 0xFF, 0xF3, 0xE1, 0xFC, 0x7C, 0x7C, 0x7E, 0x0F, 0x8F, 0x8F, 0xC3,
  0xF1, 0xE1, 0xF0, 0x7E, 0x7C, 0x7E, 0x0F, 0x8F, 0x8F, 0xC1, 0xF1, 0xF1,
  0xF0, 0x7E, 0x3E, 0x3E, 0x0F, 0xC7, 0xC7, 0xC1, 0xF8, 0xF8, 0xF8, 0x3E,
  0x1F, 0x1F, 0x8F, 0xC3, 0xE3, 0xF9, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F, 0x87,
  0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0x80,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x10, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x3F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0,
  0x78, 0x1F, 0xC0, 0x08, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x02,
  0x03, 0xFC, 0x07, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1,
  0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xE0, 0x7F, 0x80,
  0x10, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE0, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0x80,
  0x7F, 0x80, 0x3E, 0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x0F, 0x78, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xBC, 0x7B, 0xE0, 0x1F, 0x39, 0xF7, 0xC0, 0x3E, 0x73, 0xCF,
  0x80, 0x7C, 0xEF, 0xBE, 0x01, 0xF9, 0xFE, 0x7C, 0x03, 0xE3, 0xFC, 0xF8,
  0x07, 0xC7, 0xF1, 0xF0, 0x0F, 0x8F, 0xE7, 0xE0, 0x3F, 0x1F, 0x8F, 0x80,
  0x7C, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x80, 0x7E, 0x01, 0xFE, 0x01,
  0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0xFC,
  0x03, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0, 0x3E, 0xF8, 0x3F, 0x01,
  0xFB, 0xE0, 0xF8, 0x07, 0xE7, 0x87, 0xE0, 0x1F, 0x9F, 0x1F, 0x80, 0x7E,
  0x7C, 0x7E, 0x01, 0xF1, 0xF1, 0xF0, 0x0F, 0xC3, 0xCF, 0xC0, 0x3F, 0x0F,
  0x3F, 0x00, 0xFC, 0x3E, 0xFC, 0x03, 0xE0, 0xFB, 0xE0, 0x1F, 0x83, 0xFF,
  0x80, 0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xC0,
  0x3F, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F,
  0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x0F,
  0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80,
  0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07,
  0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0xFE, 0x00, 0x40, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x1F, 0xC0,
  0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xC7,
  0xE0, 0x7E, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x7C, 0x07, 0xC7, 0xF1, 0xF0,
  0x1F, 0x3F, 0xC7, 0xC0, 0x7C, 0xFF, 0x3F, 0x03, 0xF7, 0xFC, 0xF8, 0x0F,
  0x9E, 0xF3, 0xE0, 0x3E, 0xFB, 0xCF, 0x80, 0xFB, 0xCF, 0x7C, 0x03, 0xFF,
  0x3D, 0xF0, 0x1F, 0x78, 0xF7, 0xC0, 0x7F, 0xC3, 0xDF, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0x87, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xF1,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xFD, 0xFC, 0x07, 0xF9, 0xFC, 0x07, 0xF0,
  0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x1C, 0x00, 0x3C, 0x08, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x10, 0x07, 0x01, 0xF0,
  0x3F, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7E, 0x03, 0xC0, 0x10, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xC3, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0x7E, 0x01, 0xFC, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0,
  0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xF8, 0x0C, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x70, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFC, 0x00, 0x7F, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x03, 0xFE, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x70, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x02, 0x00, 0x3F, 0x80, 0x3C, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80,
  0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01,
  0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC1, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x40, 0x3F, 0x80, 0x78, 0x3F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF8, 0x00,
  0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x83, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xF8, 0x00,
  0x7E, 0x0F, 0x80, 0x7F, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x8F, 0xCF, 0xC1, 0xF1, 0xF0, 0xF8, 0x7E,
  0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F,
  0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x1F, 0x07, 0xC7,
  0xC3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F,
  0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC,
  0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xCF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF0, 0x04, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x1C, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x20, 0x03, 0xF8, 0x7C, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x30, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF9, 0xF8,
  0x0F, 0xE1, 0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0xF0, 0xFC,
  0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3,
  0xF1, 0xF0, 0x7C, 0x7F, 0x1F, 0x07, 0xC7, 0xF1, 0xF0, 0x7C, 0xFF, 0x1E,
  0x07, 0xCF, 0xF3, 0xE0, 0x79, 0xF7, 0x3E, 0x07, 0x9E, 0x7B, 0xC0, 0x7B,
  0xE7, 0xFC, 0x07, 0xBC, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F,
  0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0C, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x0C, 0x07, 0xFC, 0x07, 0xC7, 0xFF, 0x07, 0xE7, 0xFF, 0xC3,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xF1, 0xFF, 0xF1, 0xF0, 0x3F,
  0xF8, 0x30, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 15, 34, 27, 9, -33 },
  { 65, 19, 15, 27, 10, -36 },
  { 101, 28, 33, 27, 2, -33 },
  { 217, 26, 42, 27, 2, -37 },
  { 354, 32, 35, 27, 0, -34 },
  { 494, 26, 35, 27, 2, -34 },
  { 608, 9, 16, 27, 15, -36 },
  { 626, 21, 48, 27, 7, -38 },
  { 752, 21, 48, 27, 2, -38 },
  { 878, 21, 20, 27, 7, -33 },
  { 931, 23, 23, 27, 4, -26 },
  { 998, 13, 17, 27, 5, -8 },
  { 1026, 16, 6, 27, 7, -17 },
  { 1038, 9, 9, 27, 9, -8 },
  { 1049, 32, 46, 27, -1, -37 },
  { 1233, 24, 35, 27, 4, -34 },
  { 1338, 22, 33, 27, 3, -33 },
  { 1429, 26, 34, 27, 2, -34 },
  { 1540, 26, 35, 27, 2, -34 },
  { 1654, 27, 33, 27, 2, -33 },
  { 1766, 27, 34, 27, 2, -33 },
  { 1881, 25, 34, 27, 4, -33 },
  { 1988, 25, 33, 27, 6, -33 },
  { 2092, 26, 35, 27, 3, -34 },
  { 2206, 25, 34, 27, 3, -34 },
  { 2313, 13, 25, 27, 9, -24 },
  { 2354, 17, 33, 27, 5, -24 },
  { 2425, 24, 23, 27, 4, -25 },
  { 2494, 26, 15, 27, 2, -22 },
  { 2543, 24, 23, 27, 3, -25 },
  { 2612, 20, 35, 27, 8, -34 },
  { 2700, 27, 41, 27, 3, -34 },
  { 2839, 25, 33, 27, 0, -33 },
  { 2943, 26, 34, 27, 2, -33 },
  { 3054, 25, 35, 27, 5, -34 },
  { 3164, 26, 35, 27, 2, -34 },
  { 3278, 27, 33, 27, 3, -33 },
  { 3390, 28, 33, 27, 3, -33 },
  { 3506, 26, 35, 27, 4, -34 },
  { 3620, 30, 33, 27, 1, -33 },
  { 3744, 29, 33, 27, 2, -33 },
  { 3864, 28, 34, 27, 2, -33 },
  { 3983, 30, 33, 27, 2, -33 },
  { 4107, 22, 33, 27, 2, -33 },
  { 4198, 31, 33, 27, 0, -33 },
  { 4326, 30, 33, 27, 1, -33 },
  { 4450, 25, 35, 27, 4, -34 },
  { 4560, 27, 33, 27, 2, -33 },
  { 4672, 25, 44, 27, 4, -34 },
  { 4810, 26, 33, 27, 2, -33 },
  { 4918, 27, 35, 27, 2, -34 },
  { 5037, 25, 33, 27, 7, -33 },
  { 5141, 27, 34, 27, 4, -33 },
  { 5256, 26, 33, 27, 7, -33 },
  { 5364, 30, 33, 27, 2, -33 },
  { 5488, 32, 33, 27, 0, -33 },
  { 5620, 25, 33, 27, 8, -33 },
  { 5724, 29, 33, 27, 1, -33 },
  { 5844, 25, 46, 27, 5, -37 },
  { 5988, 10, 46, 27, 11, -37 },
  { 6046, 26, 46, 27, 1, -37 },
  { 6196, 24, 19, 27, 4, -33 },
  { 6253, 25, 6, 27, -2, 3 },
  { 6272, 11, 10, 27, 13, -37 },
  { 6286, 25, 27, 27, 3, -26 },
  { 6371, 25, 38, 27, 2, -37 },
  { 6490, 24, 27, 27, 4, -26 },
  { 6571, 28, 38, 27, 3, -37 },
  { 6704, 24, 27, 27, 4, -26 },
  { 6785, 33, 47, 27, -2, -37 },
  { 6979, 28, 36, 27, 0, -26 },
  { 7105, 24, 37, 27, 2, -37 },
  { 7216, 18, 37, 27, 6, -36 },
  { 7300, 25, 46, 27, 0, -36 },
  { 7444, 27, 37, 27, 3, -37 },
  { 7569, 16, 37, 27, 8, -36 },
  { 7643, 27, 25, 27, 1, -25 },
  { 7728, 24, 26, 27, 2, -26 },
  { 7806, 24, 27, 27, 3, -26 },
  { 7887, 27, 35, 27, 0, -26 },
  { 8006, 24, 35, 27, 4, -26 },
  { 8111, 24, 26, 27, 4, -26 },
  { 8189, 24, 27, 27, 3, -26 },
  { 8270, 22, 33, 27, 6, -32 },
  { 8361, 24, 26, 27, 4, -25 },
  { 8439, 23, 25, 27, 6, -25 },
  { 8511, 28, 25, 27, 3, -25 },
  { 8599, 28, 25, 27, 1, -25 },
  { 8687, 31, 35, 27, -2, -25 },
  { 8823, 25, 25, 27, 3, -25 },
  { 8902, 26, 46, 27, 5, -37 },
  { 9052, 17, 46, 27, 7, -37 },
  { 9150, 26, 46, 27, 0, -37 },
  { 9300, 25, 10, 27, 3, -19 },
};

const GFXfont UbuntuMono_BoldItalic53pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic53pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic53pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUMONO_BOLDITALIC53PT7B_H_
