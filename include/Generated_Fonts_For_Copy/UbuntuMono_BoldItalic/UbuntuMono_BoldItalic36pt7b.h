#ifndef _UBUNTUMONO_BOLDITALIC36PT7B_H_
#define _UBUNTUMONO_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x1E, 0x00, 0x7C, 0xFB, 0xE7, 0xDE, 0x3D, 0xF1, 0xEF,
  0x9F, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x79,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x1E, 0x38, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xF1, 0xC0, 0x1C, 0x78,
  0x07, 0x8E, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x3C, 0x70, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x1E, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0x06, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x10, 0x07, 0x8E, 0x07, 0xCF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x1F, 0x80, 0xE0, 0x7F, 0x07, 0x03,
  0x9C, 0x38, 0x0E, 0x71, 0xC0, 0x71, 0xCE, 0x01, 0xCE, 0x78, 0x07, 0x3B,
  0xC0, 0x1F, 0xEE, 0x00, 0x3F, 0x70, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0xEF, 0xC0, 0x07, 0xBF, 0x80, 0x3D, 0xCE, 0x00, 0xE7, 0x38, 0x07,
  0x18, 0xE0, 0x38, 0xE3, 0x01, 0xC3, 0x9C, 0x0F, 0x0F, 0xF0, 0x78, 0x1F,
  0x81, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xF9, 0xE0, 0x78, 0x70, 0x38, 0x78, 0x1C, 0x78, 0x0F, 0x78, 0x07,
  0xF8, 0x03, 0xF1, 0xC3, 0xF8, 0xF3, 0xFE, 0x73, 0xCF, 0x7B, 0xC3, 0xF9,
  0xE1, 0xFC, 0xF0, 0x7C, 0x78, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFD,
  0xE1, 0xF8, 0xF0, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0x3C, 0xF3, 0x8E, 0x00,
  0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0,
  0x0F, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x01, 0x1E, 0x27,
  0xB9, 0xCF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x7B,
  0xE1, 0xF3, 0xE1, 0xC7, 0x80, 0x84, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x1C, 0x1E,
  0xFE, 0x3E, 0x1C, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0x7F, 0xE0, 0x3B, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x79, 0xCF, 0xFB, 0xCF, 0xF3, 0xCF, 0xF3,
  0x8F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x00, 0x1E, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0x9E, 0x04, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x81, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x07, 0x87, 0xC1, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xF1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x1C, 0x0F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x79, 0xE0,
  0x1E, 0x3C, 0x03, 0x8F, 0x00, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x04, 0x07, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x79, 0xF0,
  0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x7C, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0,
  0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3E, 0x0F, 0x0F, 0x8F, 0x03, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x83, 0xE7, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xE0,
  0x3E, 0xF8, 0x1E, 0x7C, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF9, 0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x83, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x01, 0xE0, 0x3F,
  0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x70,
  0x0F, 0x0F, 0xE0, 0x7C, 0x07, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F,
  0x01, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x78,
  0x00, 0x18, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFE,
  0x7F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xC3,
  0xFF, 0x9F, 0xFE, 0xFF, 0xF7, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0x73,
  0xC0, 0x3C, 0xE0, 0xFF, 0x78, 0xFF, 0xDC, 0x7F, 0xE7, 0x1E, 0x79, 0xCF,
  0x1E, 0xF3, 0xC7, 0xBC, 0xE1, 0xCE, 0x38, 0xF3, 0x8E, 0x3C, 0xE3, 0x8F,
  0x38, 0xF3, 0xCE, 0x3F, 0xE3, 0xC7, 0xF8, 0xF0, 0xFC, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xB8,
  0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0xF0, 0x78, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x9E,
  0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0x87, 0xC3, 0xE0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x3E, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1E, 0x0F, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F,
  0x9F, 0x07, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0x30, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x04, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF0, 0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C,
  0x78, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x7C,
  0x3F, 0x1F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0x31, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE7,
  0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF8, 0x3C, 0x7E, 0x3E, 0x3F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xC0, 0xF0, 0x78, 0x1F,
  0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x03,
  0xE1, 0xF0, 0x3C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3E, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x0F,
  0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x20,
  0x3E, 0x06, 0x0F, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F,
  0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3C, 0xF8, 0x01, 0xEF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xDE,
  0x0E, 0x6E, 0xE0, 0x73, 0x67, 0x07, 0x9F, 0x78, 0x3C, 0xF3, 0xC1, 0xE7,
  0x9E, 0x0E, 0x38, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xE0, 0xFC, 0x1E, 0x0F,
  0xC1, 0xE0, 0xFE, 0x1E, 0x0F, 0xE1, 0xC1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC1,
  0xEF, 0x3C, 0x1E, 0x73, 0xC3, 0xC7, 0x78, 0x3C, 0x77, 0x83, 0xC7, 0xF8,
  0x3C, 0x3F, 0x83, 0x83, 0xF0, 0x78, 0x3F, 0x07, 0x83, 0xF0, 0x78, 0x3F,
  0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x3C, 0xF8, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xFF,
  0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x3E, 0x3E, 0x1F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E,
  0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F,
  0x87, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x07, 0xC7, 0xC3,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xC7, 0x80,
  0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1F, 0x3E, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x18, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x0E, 0x07, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE1, 0xE0,
  0x78, 0x3C, 0x0F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x07, 0x81,
  0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x0F,
  0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x0F, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7,
  0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0x77,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x71, 0xE0,
  0xE7, 0x8E, 0x0F, 0x3C, 0xF0, 0x7B, 0xE7, 0x83, 0x9B, 0xB8, 0x1D, 0xDD,
  0xC0, 0xEC, 0xFE, 0x0F, 0xE7, 0xF0, 0x76, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x00, 0x03, 0xC0,
  0x7C, 0x0F, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xC0,
  0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x01,
  0xF0, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0xF8,
  0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xE1,
  0xE1, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xFC, 0x0F, 0xBC, 0x1F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1F,
  0xF8, 0x1F, 0x70, 0x0F, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x40, 0xE3, 0xE7, 0xE7, 0xE3, 0xC1, 0x00, 0x00, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0xF1, 0xF0, 0xF9, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F,
  0x87, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xBC, 0x1F, 0x1C, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x0F, 0x9E,
  0x07, 0xCF, 0x03, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x02, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x08, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0xF0, 0xFC, 0x3E,
  0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0xF0,
  0x1F, 0x9C, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x7E,
  0x1F, 0x78, 0x0F, 0xF8, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF,
  0x80, 0xF0, 0x00, 0xF8, 0x08, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0x08, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFC, 0x3C, 0x1F, 0x07, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC1, 0x81, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E,
  0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78,
  0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x18, 0x7C, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xE1, 0xF1, 0xF0,
  0x7C, 0xF8, 0x1E, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0x7C, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x78, 0x1E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x7F, 0xCF, 0xF9, 0xFF,
  0x7F, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC2, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0, 0x07, 0xC7, 0x87, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x73, 0xC7, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3,
  0x8E, 0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x1C, 0x78, 0x07,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x0E, 0x00, 0x03, 0xF8,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3C,
  0xF8, 0x3C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0x01, 0xF8, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFC, 0x7C, 0x7F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x3E, 0x3F, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1E, 0x7C, 0x1E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x10, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x06, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x60, 0x7C, 0x7F,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x20, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x00, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78,
  0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0,
  0x78, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3E, 0x30, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x78, 0xF8, 0xF8, 0x79, 0xF0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x38, 0x01, 0xEF,
  0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x71, 0xE7, 0x8E, 0x38, 0xE3, 0xCF, 0x1C,
  0x79, 0xE3, 0x9F, 0x38, 0x73, 0xE7, 0x0E, 0xED, 0xE3, 0xDD, 0xB8, 0x7F,
  0x37, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF0,
  0x78, 0x00, 0x0F, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x78,
  0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x01, 0xF1,
  0xF0, 0x1E, 0x1F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x0F,
  0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9F,
  0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0x03, 0x1F, 0xE3, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0x1F, 0xE3,
  0x03, 0xC0,
};

const GFXglyph UbuntuMono_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 10, 22, 18, 6, -22 },
  { 29, 13, 10, 18, 7, -24 },
  { 46, 19, 22, 18, 1, -22 },
  { 99, 17, 28, 18, 2, -25 },
  { 159, 22, 22, 18, 0, -22 },
  { 220, 17, 22, 18, 2, -22 },
  { 267, 6, 11, 18, 10, -24 },
  { 276, 14, 32, 18, 5, -26 },
  { 332, 14, 32, 18, 2, -26 },
  { 388, 15, 14, 18, 4, -22 },
  { 415, 16, 16, 18, 2, -18 },
  { 447, 9, 11, 18, 3, -6 },
  { 460, 11, 4, 18, 5, -11 },
  { 466, 6, 6, 18, 6, -6 },
  { 471, 21, 31, 18, 0, -25 },
  { 553, 16, 22, 18, 3, -22 },
  { 597, 15, 22, 18, 2, -22 },
  { 639, 18, 22, 18, 1, -22 },
  { 689, 18, 22, 18, 1, -22 },
  { 739, 19, 22, 18, 1, -22 },
  { 792, 19, 22, 18, 1, -22 },
  { 845, 17, 22, 18, 3, -22 },
  { 892, 17, 22, 18, 4, -22 },
  { 939, 17, 22, 18, 2, -22 },
  { 986, 17, 22, 18, 2, -22 },
  { 1033, 9, 17, 18, 6, -17 },
  { 1053, 12, 22, 18, 3, -17 },
  { 1086, 16, 16, 18, 3, -17 },
  { 1118, 17, 11, 18, 2, -15 },
  { 1142, 16, 16, 18, 2, -17 },
  { 1174, 13, 22, 18, 6, -22 },
  { 1210, 18, 27, 18, 2, -22 },
  { 1271, 17, 22, 18, 0, -22 },
  { 1318, 18, 22, 18, 1, -22 },
  { 1368, 17, 22, 18, 3, -22 },
  { 1415, 18, 22, 18, 1, -22 },
  { 1465, 18, 22, 18, 2, -22 },
  { 1515, 19, 22, 18, 2, -22 },
  { 1568, 17, 22, 18, 3, -22 },
  { 1615, 20, 22, 18, 1, -22 },
  { 1670, 20, 22, 18, 1, -22 },
  { 1725, 19, 22, 18, 1, -22 },
  { 1778, 21, 22, 18, 1, -22 },
  { 1836, 14, 22, 18, 2, -22 },
  { 1875, 21, 22, 18, 0, -22 },
  { 1933, 20, 22, 18, 1, -22 },
  { 1988, 17, 22, 18, 2, -22 },
  { 2035, 19, 22, 18, 1, -22 },
  { 2088, 17, 29, 18, 2, -22 },
  { 2150, 18, 22, 18, 1, -22 },
  { 2200, 19, 22, 18, 1, -22 },
  { 2253, 17, 22, 18, 5, -22 },
  { 2300, 19, 22, 18, 2, -22 },
  { 2353, 17, 22, 18, 5, -22 },
  { 2400, 21, 22, 18, 1, -22 },
  { 2458, 22, 22, 18, 0, -22 },
  { 2519, 17, 22, 18, 5, -22 },
  { 2566, 20, 22, 18, 1, -22 },
  { 2621, 18, 31, 18, 3, -25 },
  { 2691, 8, 31, 18, 7, -25 },
  { 2722, 17, 31, 18, 1, -25 },
  { 2788, 16, 13, 18, 3, -22 },
  { 2814, 17, 4, 18, -1, 2 },
  { 2823, 7, 7, 18, 9, -25 },
  { 2830, 17, 17, 18, 2, -17 },
  { 2867, 17, 25, 18, 1, -25 },
  { 2921, 16, 17, 18, 3, -17 },
  { 2955, 19, 25, 18, 2, -25 },
  { 3015, 16, 17, 18, 3, -17 },
  { 3049, 22, 31, 18, -1, -25 },
  { 3135, 19, 23, 18, 0, -17 },
  { 3190, 16, 25, 18, 2, -25 },
  { 3240, 13, 25, 18, 4, -25 },
  { 3281, 17, 31, 18, 0, -25 },
  { 3347, 18, 25, 18, 2, -25 },
  { 3404, 11, 25, 18, 5, -25 },
  { 3439, 18, 17, 18, 1, -17 },
  { 3478, 16, 17, 18, 2, -17 },
  { 3512, 16, 17, 18, 2, -17 },
  { 3546, 18, 23, 18, 0, -17 },
  { 3598, 16, 23, 18, 3, -17 },
  { 3644, 17, 17, 18, 2, -17 },
  { 3681, 16, 17, 18, 2, -17 },
  { 3715, 15, 22, 18, 4, -22 },
  { 3757, 16, 17, 18, 3, -17 },
  { 3791, 16, 17, 18, 4, -17 },
  { 3825, 19, 17, 18, 2, -17 },
  { 3866, 20, 17, 18, 0, -17 },
  { 3909, 22, 23, 18, -2, -17 },
  { 3973, 17, 17, 18, 2, -17 },
  { 4010, 17, 31, 18, 4, -25 },
  { 4076, 12, 31, 18, 4, -25 },
  { 4123, 17, 31, 18, 0, -25 },
  { 4189, 17, 6, 18, 2, -13 },
};

const GFXfont UbuntuMono_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic36pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUMONO_BOLDITALIC36PT7B_H_
