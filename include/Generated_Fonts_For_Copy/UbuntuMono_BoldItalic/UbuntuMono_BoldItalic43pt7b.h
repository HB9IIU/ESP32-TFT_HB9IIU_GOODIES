#ifndef _UBUNTUMONO_BOLDITALIC43PT7B_H_
#define _UBUNTUMONO_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0x80, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E,
  0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8,
  0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0x0F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01,
  0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x81, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0,
  0x70, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x04, 0x00, 0xF8, 0x78, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xF0, 0x3F, 0xC0, 0x78, 0x1E, 0x70, 0x3C, 0x07, 0x1C, 0x0E, 0x01,
  0xC7, 0x07, 0x80, 0xF1, 0xC3, 0xC0, 0x38, 0xF1, 0xE0, 0x0E, 0x3C, 0xF0,
  0x03, 0x8E, 0x78, 0x00, 0xE7, 0x9C, 0x00, 0x3F, 0xCF, 0x00, 0x07, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x3D, 0xFC, 0x00, 0x1E, 0xFF, 0x00, 0x0F, 0x39, 0xC0, 0x07, 0x9E, 0x70,
  0x03, 0xC7, 0x1C, 0x00, 0xE1, 0xC7, 0x00, 0x78, 0x71, 0xC0, 0x3C, 0x3C,
  0x70, 0x1E, 0x0F, 0x3C, 0x0F, 0x03, 0xCE, 0x07, 0x80, 0x7F, 0x81, 0xC0,
  0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F,
  0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE3, 0xC1, 0xFE, 0x1E,
  0x3F, 0xF8, 0xF1, 0xF7, 0xEF, 0x9F, 0x1F, 0x79, 0xF0, 0x7F, 0xCF, 0x83,
  0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x7F, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xE7, 0xC1, 0xF8, 0x00, 0x00, 0x3E,
  0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF3, 0xC7, 0x8E, 0x00, 0x00,
  0x02, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x21, 0xE1, 0x9F, 0x79, 0xE7, 0xEF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xBE, 0x0F, 0xCF, 0xC1, 0xF1, 0xE0, 0x38, 0x70, 0x02, 0x08, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F,
  0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0x7E, 0x03, 0x81, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC1, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0xFE, 0x78, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC7, 0x1F, 0x7C, 0xF9,
  0xF7, 0xCF, 0x1F, 0x7C, 0xE1, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x7C, 0x0F, 0x3E,
  0x06, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x1C, 0x1F, 0x80, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x38, 0x1F, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0x9F,
  0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x0C, 0x01, 0xF8, 0x1E, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xFC,
  0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xFC,
  0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0x3F, 0x87, 0xE1, 0xF8, 0x7C, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x81,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x38, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF0, 0x7C, 0x1F,
  0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x07, 0xFC, 0x78, 0x7F,
  0xF3, 0xC3, 0xFF, 0xCF, 0x1F, 0xFE, 0x3C, 0xFC, 0xF9, 0xE3, 0xE3, 0xE7,
  0x8F, 0x0F, 0x9E, 0x7C, 0x3C, 0x79, 0xF0, 0xF1, 0xE7, 0x87, 0xCF, 0x1E,
  0x1F, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F, 0x0F, 0xFE,
  0x3E, 0x3F, 0xF0, 0x78, 0x7F, 0xC1, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3D,
  0xF0, 0x07, 0xDF, 0x00, 0x79, 0xF0, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3E, 0x07, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01,
  0xF1, 0xF0, 0x1F, 0x8F, 0x83, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xE0, 0x60, 0xFC, 0x02, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x06, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xE1, 0xF8, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7E, 0x3F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x03,
  0x03, 0xF0, 0x08, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7F, 0x0F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x02, 0x01,
  0xF0, 0x1E, 0x1F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0xC7, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x01,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xFC,
  0x07, 0xF1, 0xDE, 0x07, 0xB9, 0xEE, 0x03, 0xDC, 0xEF, 0x01, 0xEE, 0xF7,
  0x81, 0xF7, 0x73, 0xC0, 0xF3, 0xF9, 0xE0, 0x79, 0xF9, 0xF0, 0x3C, 0xFC,
  0xF0, 0x3E, 0x3C, 0x78, 0x1F, 0x1E, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x3E, 0x07, 0xF8, 0x3E,
  0x07, 0xF8, 0x3C, 0x0F, 0xB8, 0x7C, 0x0F, 0xBC, 0x7C, 0x0F, 0xBC, 0x7C,
  0x0F, 0x3C, 0x78, 0x0F, 0x1C, 0x78, 0x1F, 0x1E, 0xF8, 0x1F, 0x1E, 0xF8,
  0x1F, 0x1E, 0xF8, 0x1E, 0x1E, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x3C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3,
  0xF0, 0xF8, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0xC1, 0xF0,
  0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F,
  0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81,
  0xF8, 0x7C, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x3F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE1, 0xFC,
  0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7C, 0x7C, 0x03,
  0xF1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xF0, 0x38, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x08, 0x01, 0xF8, 0x3C, 0x0F, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00,
  0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x7C,
  0x1E, 0x00, 0x7C, 0x3E, 0x3C, 0x78, 0x3E, 0x7C, 0x78, 0x3C, 0x7C, 0x78,
  0x3C, 0xFC, 0xF8, 0x3C, 0xFC, 0xF0, 0x7D, 0xDC, 0xF0, 0x79, 0xDC, 0xF0,
  0x7B, 0x9D, 0xE0, 0x7B, 0x9D, 0xE0, 0x7F, 0x1D, 0xE0, 0x77, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xE3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBF, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E,
  0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x87, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0,
  0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC1, 0xF8, 0x7E,
  0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0x18, 0x01,
  0xE0, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x10, 0x0E, 0x07, 0xC1, 0xFC, 0x7F, 0x87, 0xE0,
  0x78, 0x04, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x81, 0xF8, 0x60, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE1, 0xF0,
  0x3E, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x1F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xE0, 0x41, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x10, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x0F,
  0x81, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFE,
  0xF8, 0x07, 0xE1, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xF1, 0xFC, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C,
  0x07, 0xEF, 0x83, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x60, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xE3, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x70, 0x3F, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x1F,
  0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x7E, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0x81, 0xF9, 0xF0,
  0x3E, 0x3E, 0x07, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xC0, 0x00,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x04,
  0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x08, 0x0F, 0xC0, 0x70, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F,
  0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0x7C, 0x00,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x8F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0x01, 0xF1, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x3E, 0x7C, 0x7C, 0x79, 0xF1,
  0xF3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x78, 0xF8, 0xF3, 0xE3, 0xE7,
  0x8F, 0x8F, 0x1E, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C,
  0x00, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xF8, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0xFC, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F,
  0x83, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0x81, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0x81, 0xFB, 0xE0, 0x3F, 0x7C,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x1F, 0x87, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE1, 0xF8, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xC3, 0xE3, 0xF0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFC, 0x1F, 0x07, 0xC3, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x80,
  0x40, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xC0, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83,
  0x81, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x60, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F,
  0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0,
  0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFE, 0xF8, 0x1F, 0x8E, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1,
  0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x3E, 0x78, 0x70, 0xF1, 0xE3, 0xE3, 0xCF, 0x8F,
  0x9F, 0x3E, 0x7E, 0x78, 0xF1, 0xF9, 0xE3, 0xCF, 0xE7, 0x8F, 0x3B, 0xBC,
  0x3D, 0xEE, 0xF0, 0xF7, 0x3B, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F,
  0x00, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0,
  0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xC7,
  0xC0, 0x0F, 0x87, 0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x01,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07,
  0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0x87, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x60, 0xFF, 0x07, 0xCF, 0xFE, 0x3C, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3C, 0x7F, 0xE3, 0xC0, 0xFE, 0x06, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 12, 28, 22, 7, -27 },
  { 43, 16, 12, 22, 8, -29 },
  { 67, 23, 27, 22, 1, -27 },
  { 145, 21, 34, 22, 2, -30 },
  { 235, 26, 29, 22, 0, -28 },
  { 330, 21, 29, 22, 2, -28 },
  { 407, 7, 13, 22, 12, -29 },
  { 419, 17, 39, 22, 6, -31 },
  { 502, 17, 39, 22, 2, -31 },
  { 585, 18, 17, 22, 5, -27 },
  { 624, 19, 18, 22, 3, -21 },
  { 667, 11, 14, 22, 4, -7 },
  { 687, 13, 5, 22, 6, -14 },
  { 696, 8, 8, 22, 7, -7 },
  { 704, 25, 37, 22, 0, -30 },
  { 820, 20, 29, 22, 3, -28 },
  { 893, 17, 27, 22, 3, -27 },
  { 951, 21, 28, 22, 2, -28 },
  { 1025, 21, 29, 22, 1, -28 },
  { 1102, 21, 27, 22, 2, -27 },
  { 1173, 23, 28, 22, 1, -27 },
  { 1254, 21, 28, 22, 3, -27 },
  { 1328, 21, 27, 22, 5, -27 },
  { 1399, 20, 29, 22, 3, -28 },
  { 1472, 21, 28, 22, 2, -28 },
  { 1546, 11, 21, 22, 7, -20 },
  { 1575, 14, 27, 22, 4, -20 },
  { 1623, 20, 19, 22, 3, -20 },
  { 1671, 21, 12, 22, 2, -18 },
  { 1703, 20, 19, 22, 2, -20 },
  { 1751, 16, 29, 22, 7, -28 },
  { 1809, 22, 34, 22, 2, -28 },
  { 1903, 20, 27, 22, 0, -27 },
  { 1971, 21, 28, 22, 2, -27 },
  { 2045, 20, 29, 22, 4, -28 },
  { 2118, 22, 29, 22, 1, -28 },
  { 2198, 22, 27, 22, 2, -27 },
  { 2273, 23, 27, 22, 2, -27 },
  { 2351, 21, 29, 22, 3, -28 },
  { 2428, 24, 27, 22, 1, -27 },
  { 2509, 24, 27, 22, 1, -27 },
  { 2590, 22, 28, 22, 2, -27 },
  { 2667, 25, 27, 22, 1, -27 },
  { 2752, 17, 27, 22, 2, -27 },
  { 2810, 25, 27, 22, 0, -27 },
  { 2895, 24, 27, 22, 1, -27 },
  { 2976, 20, 29, 22, 3, -28 },
  { 3049, 22, 27, 22, 2, -27 },
  { 3124, 20, 36, 22, 3, -28 },
  { 3214, 22, 27, 22, 1, -27 },
  { 3289, 22, 29, 22, 1, -28 },
  { 3369, 20, 27, 22, 6, -27 },
  { 3437, 22, 28, 22, 3, -27 },
  { 3514, 21, 27, 22, 6, -27 },
  { 3585, 24, 27, 22, 2, -27 },
  { 3666, 26, 27, 22, 0, -27 },
  { 3754, 21, 27, 22, 6, -27 },
  { 3825, 24, 27, 22, 1, -27 },
  { 3906, 21, 37, 22, 4, -30 },
  { 4004, 8, 37, 22, 9, -30 },
  { 4041, 21, 37, 22, 1, -30 },
  { 4139, 20, 16, 22, 3, -27 },
  { 4179, 20, 5, 22, -1, 2 },
  { 4192, 10, 8, 22, 10, -30 },
  { 4202, 20, 22, 22, 3, -21 },
  { 4257, 20, 32, 22, 2, -31 },
  { 4337, 20, 22, 22, 3, -21 },
  { 4392, 22, 32, 22, 3, -31 },
  { 4480, 19, 22, 22, 3, -21 },
  { 4533, 27, 39, 22, -2, -31 },
  { 4665, 23, 29, 22, 0, -21 },
  { 4749, 19, 31, 22, 2, -31 },
  { 4823, 15, 30, 22, 5, -29 },
  { 4880, 21, 37, 22, 0, -29 },
  { 4978, 22, 31, 22, 2, -31 },
  { 5064, 14, 31, 22, 6, -30 },
  { 5119, 22, 20, 22, 1, -20 },
  { 5174, 19, 21, 22, 2, -21 },
  { 5224, 19, 22, 22, 3, -21 },
  { 5277, 22, 28, 22, 0, -21 },
  { 5354, 20, 28, 22, 3, -21 },
  { 5424, 20, 21, 22, 3, -21 },
  { 5477, 20, 22, 22, 2, -21 },
  { 5532, 18, 27, 22, 5, -26 },
  { 5593, 20, 21, 22, 3, -20 },
  { 5646, 19, 20, 22, 5, -20 },
  { 5694, 22, 20, 22, 3, -20 },
  { 5749, 24, 20, 22, 0, -20 },
  { 5809, 26, 28, 22, -2, -20 },
  { 5900, 21, 20, 22, 2, -20 },
  { 5953, 21, 37, 22, 4, -30 },
  { 6051, 15, 37, 22, 5, -30 },
  { 6121, 21, 37, 22, 0, -30 },
  { 6219, 21, 8, 22, 2, -15 },
};

const GFXfont UbuntuMono_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic43pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUMONO_BOLDITALIC43PT7B_H_
