#ifndef _UBUNTUMONO_BOLDITALIC27PT7B_H_
#define _UBUNTUMONO_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x00, 0x00, 0x70, 0xF8, 0x70, 0x7B, 0xDC, 0xF7, 0x39, 0xCE, 0xE3,
  0xB8, 0xCE, 0x33, 0x0C, 0x03, 0x9C, 0x0E, 0x70, 0x33, 0x81, 0xCE, 0x3F,
  0xFC, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x1C, 0xE0, 0x73, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF1, 0xCE, 0x07, 0x38, 0x39, 0xC0, 0xE7, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x78, 0x43, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xCC, 0x1E,
  0x7F, 0xE7, 0xFF, 0x0F, 0xE0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x07, 0x03,
  0x07, 0xC3, 0x06, 0x63, 0x03, 0x33, 0x81, 0xBB, 0x81, 0xD9, 0x80, 0x7D,
  0x80, 0x3D, 0x80, 0x01, 0xC0, 0x01, 0xDC, 0x01, 0xDF, 0x00, 0xDD, 0x80,
  0xCC, 0xC0, 0xC6, 0x60, 0xE3, 0x70, 0xE1, 0xF0, 0x60, 0x70, 0x00, 0x03,
  0xE0, 0x3F, 0x83, 0xFC, 0x1C, 0xE1, 0xC7, 0x0E, 0x30, 0x73, 0x81, 0xF8,
  0x1F, 0x11, 0xF9, 0xDD, 0xEE, 0xC7, 0xEE, 0x1E, 0x78, 0xF3, 0xFF, 0x8F,
  0xEE, 0x3E, 0x70, 0x7F, 0xFE, 0xEE, 0xCC, 0x00, 0xC0, 0x70, 0x3C, 0x3C,
  0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0x00,
  0x03, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x10, 0x00, 0x0E, 0x01, 0xC1, 0x99,
  0xBB, 0xFF, 0xFE, 0x1E, 0x07, 0xE1, 0xDE, 0x39, 0xC2, 0x20, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0xF7, 0xDF, 0x3C, 0x67, 0xBC,
  0xC0, 0xFF, 0xFF, 0xFE, 0x33, 0xFF, 0xF7, 0x00, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7,
  0x38, 0x77, 0x07, 0x77, 0x7F, 0x77, 0xE6, 0x7E, 0x07, 0xE0, 0xFE, 0x0E,
  0xE1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x01, 0xC0, 0x78, 0x3F,
  0x1F, 0xE3, 0xF8, 0x67, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0x03, 0xE0, 0x7F, 0x87,
  0xFE, 0x18, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0,
  0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x10, 0xF0, 0x03, 0x80, 0x3C, 0x1F, 0xC0,
  0xF8, 0x0F, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x20, 0xFB, 0xFF,
  0x9F, 0xF8, 0x7F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xF8, 0x1D, 0xC0, 0xE7, 0x07, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xF0, 0x07, 0xF0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF1, 0x07, 0x87, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x1F, 0xC3, 0xFE, 0x3E, 0x03, 0xC0,
  0x3C, 0x01, 0xDE, 0x0F, 0xFC, 0xFF, 0xE7, 0x87, 0xB8, 0x3D, 0xC1, 0xEE,
  0x0E, 0x78, 0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x78, 0xF3, 0x87, 0x1C, 0x38, 0xF3, 0x83,
  0xF8, 0x3F, 0x83, 0xDE, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0xFF,
  0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x87, 0x1F, 0xF8, 0x7F, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x03, 0xF1, 0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x1C, 0x3C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x30, 0xF3, 0xE7, 0xC7, 0x00, 0x0E, 0x0F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x7C, 0x7C, 0x3C, 0x18, 0x78, 0xF0,
  0xC0, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFE, 0x7F, 0x07, 0x80, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xC0, 0x0C, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0xFF, 0xF0, 0x10, 0x00,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x3F,
  0xC7, 0xF0, 0x1E, 0x00, 0x80, 0x00, 0x1F, 0x1F, 0xF7, 0xFC, 0x8F, 0x01,
  0xC0, 0xF0, 0x3C, 0x3E, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x07,
  0x03, 0xE0, 0x70, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x07, 0x18,
  0x1C, 0xE3, 0xF3, 0x3F, 0xDC, 0xFF, 0x77, 0x99, 0x9C, 0xE6, 0x63, 0x99,
  0x8E, 0xE7, 0x73, 0x9F, 0xC6, 0x7F, 0x18, 0xF8, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0x60,
  0x3B, 0x03, 0x98, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0xFE, 0x7F,
  0xF3, 0xFF, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x38, 0x0F, 0xE0, 0x7F,
  0xC7, 0xFE, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0xFF, 0xC7, 0xFC, 0x3F, 0xF1,
  0xC3, 0x9E, 0x1E, 0xE0, 0xF7, 0x07, 0x38, 0x79, 0xFF, 0x9F, 0xF8, 0xFF,
  0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x3C, 0x23, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x21,
  0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0x87, 0xFC, 0x38, 0xF1,
  0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xDE, 0x1E, 0xE0,
  0xE7, 0x0F, 0x38, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0xC7, 0xFE, 0x3C, 0x23, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0xF7,
  0x87, 0xB8, 0x39, 0xC1, 0xCF, 0x1E, 0x78, 0xF1, 0xFF, 0x0F, 0xF8, 0x1F,
  0x80, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0xC7, 0x87,
  0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0xF1, 0xC1, 0xC3, 0x83, 0x87,
  0x0F, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE1, 0x87, 0x8F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x0E,
  0x1E, 0x3C, 0x78, 0x78, 0xE0, 0xE3, 0xC1, 0xCF, 0x03, 0xBC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xEF, 0x03, 0x9E, 0x07, 0x1E, 0x0E,
  0x3C, 0x3C, 0x38, 0x78, 0x78, 0xE0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xE0, 0x07, 0x0E, 0x0F, 0x0E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x6E, 0x1B, 0x6C, 0x39,
  0xDC, 0x39, 0xDC, 0x39, 0x9C, 0x30, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x78, 0x0E, 0x0E, 0x3C, 0x38, 0x78, 0x70, 0xF8,
  0xE1, 0xF1, 0xC7, 0x63, 0x8E, 0xCE, 0x1D, 0xDC, 0x3B, 0xB8, 0xE3, 0x71,
  0xC7, 0xC3, 0x8F, 0x87, 0x1F, 0x0C, 0x3E, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xE7, 0x87, 0xB8, 0x3D, 0xC1,
  0xFE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x79, 0xE3,
  0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0xC7, 0x8F,
  0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x1E, 0x3F, 0xF8, 0xFF, 0x83, 0xF8,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xE7, 0x87, 0xB8, 0x3D, 0xC1, 0xDE, 0x0E,
  0xE0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x79, 0xE3, 0xFF, 0x0F,
  0xF0, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0x80, 0x0F,
  0xE0, 0x7F, 0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0F,
  0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xF3, 0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x9E,
  0x1C, 0xE0, 0xF0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x87, 0x86, 0x1C, 0x00,
  0x70, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF1, 0x83, 0x8F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x79, 0xE1, 0xC7,
  0x07, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xE3,
  0x8F, 0x0F, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0xE0, 0x77, 0x03, 0xB8, 0x3D,
  0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39,
  0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0xE7,
  0x19, 0xCC, 0x77, 0xB8, 0xEF, 0x71, 0xF6, 0xE3, 0x6D, 0x87, 0x9B, 0x0F,
  0x3E, 0x3C, 0x78, 0x78, 0x70, 0xE0, 0xE0, 0x0F, 0x07, 0x07, 0x0E, 0x07,
  0x1E, 0x07, 0x9C, 0x03, 0xB8, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1C, 0x70, 0x3C,
  0x70, 0x78, 0x78, 0xF0, 0x78, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC3, 0xC7,
  0x1C, 0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xF7, 0x9C, 0xE0, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0xC1, 0xEE,
  0x1E, 0x71, 0xE3, 0xCE, 0x0E, 0x70, 0x71, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x21, 0xCF, 0x8F, 0x08, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0x8F, 0xF0,
  0xEF, 0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF, 0xC7, 0xFE, 0x3C,
  0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x77,
  0x83, 0xFE, 0x3F, 0xF1, 0xE3, 0x8E, 0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x39,
  0xC3, 0xCE, 0x3C, 0xFF, 0xE7, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFF, 0x3F,
  0xF7, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x7F,
  0xC7, 0xFC, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xF1, 0xE3, 0x8F, 0x0E, 0x3C,
  0x38, 0xE1, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xFF, 0xC1, 0xFF, 0x83,
  0xCE, 0x00, 0x07, 0xC1, 0xFF, 0x3F, 0xF7, 0x87, 0x70, 0x7E, 0x1F, 0xFF,
  0xEF, 0xF8, 0xE0, 0x0F, 0x04, 0x7F, 0xC7, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0x8F, 0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x8E,
  0x1E, 0x3C, 0x70, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0xE1, 0x07, 0x87,
  0xFC, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x1F, 0xF3, 0xC7, 0x3C, 0x73, 0x87, 0x38,
  0x77, 0x8F, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xE0, 0x07, 0x07,
  0x83, 0xC1, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0xFE, 0x0F, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0x8F, 0xC3, 0xE0, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x87, 0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE3, 0xC7, 0x1E,
  0x1C, 0xF0, 0x77, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0xBC,
  0x1E, 0x70, 0x71, 0xE1, 0xC3, 0x87, 0x0F, 0x00, 0xFE, 0xFE, 0xFE, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x7F, 0x7F, 0x3F, 0x1F, 0x71, 0xFF, 0xCF, 0xFE, 0x77, 0x33, 0x3B, 0xB9,
  0x9D, 0xCC, 0xEE, 0xE6, 0x60, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xCC, 0x0E,
  0x00, 0x0F, 0xE1, 0xFF, 0x1F, 0xF3, 0xC7, 0x3C, 0x73, 0x87, 0x38, 0x77,
  0x8F, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xE0, 0x07, 0x81, 0xFE,
  0x3F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF, 0x3C,
  0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F,
  0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x8F, 0x0E, 0x38, 0x78, 0xE3, 0xC3, 0xFF,
  0x1F, 0xF8, 0x7F, 0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07,
  0xE1, 0xFF, 0x3F, 0xF7, 0x8F, 0x70, 0xFF, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1,
  0xEF, 0x1C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x0F, 0xF1, 0xFF, 0x3F, 0xF3, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x87, 0xFC, 0x38, 0x21, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE3,
  0x0F, 0x1F, 0xF9, 0xFF, 0x83, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xE1, 0xFC, 0x1F, 0x80, 0x38, 0x73, 0x8F, 0x78, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCF, 0x3C, 0xFF, 0xC7,
  0xFC, 0x3C, 0xC0, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1E, 0xF1, 0xCF, 0x3C,
  0xF3, 0x87, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x38, 0x00, 0x70,
  0x19, 0x80, 0xEE, 0x03, 0xB9, 0xCC, 0xE7, 0x33, 0xBD, 0xCE, 0xF6, 0x36,
  0xD8, 0xDB, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0x80, 0x1E, 0x1E,
  0x1C, 0x78, 0x3C, 0xE0, 0x3B, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x3D, 0xC0, 0xF3, 0xC1, 0xC3, 0x87, 0x07, 0x00, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xFC,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x3F,
  0x01, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x03, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC0, 0x07,
  0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0xF0, 0x1F, 0x81, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x00, 0x1E, 0x19, 0xF9, 0xDF, 0xFC, 0xC7, 0xE6, 0x1E, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 17, 14, 4, -17 },
  { 18, 10, 8, 14, 5, -18 },
  { 28, 14, 17, 14, 1, -17 },
  { 58, 13, 22, 14, 1, -19 },
  { 94, 17, 17, 14, 0, -17 },
  { 131, 13, 17, 14, 1, -17 },
  { 159, 4, 8, 14, 8, -18 },
  { 163, 10, 23, 14, 4, -19 },
  { 192, 11, 23, 14, 1, -19 },
  { 224, 11, 10, 14, 3, -17 },
  { 238, 12, 13, 14, 2, -13 },
  { 258, 6, 9, 14, 3, -5 },
  { 265, 8, 3, 14, 4, -9 },
  { 268, 5, 5, 14, 4, -5 },
  { 272, 16, 23, 14, 0, -19 },
  { 318, 12, 17, 14, 2, -17 },
  { 344, 11, 17, 14, 2, -17 },
  { 368, 13, 17, 14, 1, -17 },
  { 396, 13, 17, 14, 1, -17 },
  { 424, 14, 17, 14, 1, -17 },
  { 454, 14, 17, 14, 1, -17 },
  { 484, 13, 17, 14, 2, -17 },
  { 512, 13, 17, 14, 3, -17 },
  { 540, 13, 17, 14, 2, -17 },
  { 568, 13, 17, 14, 1, -17 },
  { 596, 7, 13, 14, 4, -13 },
  { 608, 8, 17, 14, 3, -13 },
  { 625, 12, 12, 14, 2, -13 },
  { 643, 13, 9, 14, 1, -11 },
  { 658, 13, 12, 14, 1, -13 },
  { 678, 10, 17, 14, 4, -17 },
  { 700, 14, 21, 14, 1, -17 },
  { 737, 13, 17, 14, 0, -17 },
  { 765, 13, 17, 14, 1, -17 },
  { 793, 13, 17, 14, 2, -17 },
  { 821, 13, 17, 14, 1, -17 },
  { 849, 14, 17, 14, 1, -17 },
  { 879, 14, 17, 14, 2, -17 },
  { 909, 13, 17, 14, 2, -17 },
  { 937, 15, 17, 14, 1, -17 },
  { 969, 15, 17, 14, 1, -17 },
  { 1001, 14, 17, 14, 1, -17 },
  { 1031, 15, 17, 14, 1, -17 },
  { 1063, 11, 17, 14, 1, -17 },
  { 1087, 16, 17, 14, 0, -17 },
  { 1121, 15, 17, 14, 1, -17 },
  { 1153, 13, 17, 14, 2, -17 },
  { 1181, 14, 17, 14, 1, -17 },
  { 1211, 13, 22, 14, 2, -17 },
  { 1247, 13, 17, 14, 1, -17 },
  { 1275, 14, 17, 14, 1, -17 },
  { 1305, 13, 17, 14, 3, -17 },
  { 1333, 14, 17, 14, 2, -17 },
  { 1363, 13, 17, 14, 4, -17 },
  { 1391, 15, 17, 14, 1, -17 },
  { 1423, 16, 17, 14, 0, -17 },
  { 1457, 13, 17, 14, 4, -17 },
  { 1485, 14, 17, 14, 1, -17 },
  { 1515, 14, 23, 14, 2, -19 },
  { 1556, 5, 23, 14, 6, -19 },
  { 1571, 14, 23, 14, 0, -19 },
  { 1612, 13, 10, 14, 2, -17 },
  { 1629, 13, 2, 14, -1, 2 },
  { 1633, 6, 5, 14, 6, -19 },
  { 1637, 12, 13, 14, 2, -13 },
  { 1657, 13, 19, 14, 1, -19 },
  { 1688, 12, 13, 14, 2, -13 },
  { 1708, 14, 19, 14, 2, -19 },
  { 1742, 12, 13, 14, 2, -13 },
  { 1762, 17, 23, 14, -1, -19 },
  { 1811, 14, 17, 14, 0, -13 },
  { 1841, 12, 19, 14, 1, -19 },
  { 1870, 9, 19, 14, 3, -19 },
  { 1892, 13, 23, 14, 0, -19 },
  { 1930, 14, 19, 14, 1, -19 },
  { 1964, 8, 19, 14, 4, -19 },
  { 1983, 13, 13, 14, 1, -13 },
  { 2005, 12, 13, 14, 1, -13 },
  { 2025, 12, 13, 14, 2, -13 },
  { 2045, 14, 17, 14, 0, -13 },
  { 2075, 12, 17, 14, 2, -13 },
  { 2101, 12, 13, 14, 2, -13 },
  { 2121, 13, 13, 14, 1, -13 },
  { 2143, 11, 17, 14, 3, -17 },
  { 2167, 12, 13, 14, 2, -13 },
  { 2187, 12, 13, 14, 3, -13 },
  { 2207, 14, 13, 14, 2, -13 },
  { 2230, 15, 13, 14, 0, -13 },
  { 2255, 16, 17, 14, -1, -13 },
  { 2289, 13, 13, 14, 1, -13 },
  { 2311, 13, 23, 14, 3, -19 },
  { 2349, 9, 23, 14, 3, -19 },
  { 2375, 13, 23, 14, 0, -19 },
  { 2413, 13, 5, 14, 1, -10 },
};

const GFXfont UbuntuMono_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic27pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _UBUNTUMONO_BOLDITALIC27PT7B_H_
