#ifndef _UBUNTUMONO_BOLDITALIC57PT7B_H_
#define _UBUNTUMONO_BOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-BoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_BoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E,
  0x00, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC, 0xFF, 0x1F, 0xE7,
  0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7C, 0x07, 0xF8, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x30,
  0x00, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF0, 0x03, 0xC7,
  0xC0, 0x7C, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x1E, 0x1F, 0x07, 0xC0, 0x03,
  0xC3, 0xC1, 0xF8, 0x00, 0xF8, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x0F, 0x80,
  0x03, 0xE3, 0xE3, 0xE0, 0x00, 0x7C, 0x78, 0xF8, 0x00, 0x0F, 0x9F, 0x3E,
  0x00, 0x00, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x01, 0xFE,
  0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xF0,
  0x00, 0x03, 0xE7, 0xFE, 0x00, 0x00, 0xF9, 0xF3, 0xE0, 0x00, 0x3E, 0x3C,
  0x7C, 0x00, 0x0F, 0x8F, 0x8F, 0x80, 0x03, 0xE1, 0xE1, 0xF0, 0x00, 0xFC,
  0x3C, 0x3E, 0x00, 0x1F, 0x07, 0x87, 0x80, 0x07, 0xC1, 0xF0, 0xF0, 0x01,
  0xF0, 0x3E, 0x3E, 0x00, 0x7C, 0x07, 0xC7, 0x80, 0x1F, 0x00, 0x79, 0xF0,
  0x07, 0xC0, 0x0F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0x83, 0xFF,
  0x83, 0xF0, 0xFF, 0xF0, 0x7C, 0x7F, 0xFF, 0x1F, 0x8F, 0xC7, 0xF3, 0xF3,
  0xF0, 0xFE, 0xFC, 0xFE, 0x0F, 0xFF, 0x9F, 0x80, 0xFF, 0xE3, 0xF0, 0x1F,
  0xF8, 0x7E, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF8, 0x3F,
  0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFC, 0xFC, 0x1F, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x30, 0x7C, 0x0C, 0x3C, 0x7C, 0x3C, 0x7F, 0x3C, 0xFC, 0x7F, 0xBF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xC3, 0xE0, 0x03, 0x81, 0xC0,
  0x01, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC,
  0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x8F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x0F,
  0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xC3, 0xC3, 0xF3, 0xF8, 0xFC, 0x7E,
  0x7F, 0x3F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F,
  0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F,
  0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3C, 0x3F, 0x80, 0x40, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x04,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x83, 0x00, 0x0F, 0xF0, 0x7C, 0x03, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x30, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFE,
  0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0x07,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x07, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x78, 0x3F, 0xE2, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x83,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0xF1, 0xF0,
  0x1F, 0xFF, 0x0F, 0x83, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0xC7, 0xC1, 0xFF,
  0xFE, 0x3E, 0x1F, 0xC3, 0xF3, 0xF1, 0xFC, 0x3F, 0x1F, 0x0F, 0xC1, 0xF8,
  0xF8, 0x7E, 0x0F, 0xC7, 0xC7, 0xE0, 0x7E, 0x3E, 0x3F, 0x07, 0xE3, 0xF1,
  0xF8, 0x3F, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F, 0xC7, 0xC3, 0xF0,
  0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xF1, 0xF8,
  0x7E, 0x1F, 0xFF, 0x83, 0xF0, 0xFF, 0xFC, 0x1F, 0x83, 0xFF, 0xE0, 0xFC,
  0x0F, 0xFF, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x20,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x07, 0xFC, 0x3F, 0x80, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x3F, 0xE0, 0x04, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x1F, 0xF0,
  0x1E, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x04, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x7F, 0x80, 0x18, 0x01,
  0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x83, 0xDF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xE1, 0xEF, 0x80, 0x3E, 0xF9, 0xF7, 0xC0, 0x1F, 0x7C, 0xF3, 0xE0, 0x1F,
  0x9E, 0xFB, 0xF0, 0x0F, 0xCF, 0x79, 0xF0, 0x07, 0xC7, 0xFC, 0xF8, 0x07,
  0xE3, 0xFC, 0x7C, 0x03, 0xF1, 0xFE, 0x7E, 0x01, 0xF8, 0xFE, 0x3F, 0x00,
  0xF8, 0x7F, 0x1F, 0x00, 0xFC, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x8F, 0xC0,
  0x3F, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x01, 0xFF,
  0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xFF,
  0xC0, 0xFC, 0x03, 0xF7, 0xC1, 0xFC, 0x03, 0xF7, 0xE1, 0xF8, 0x03, 0xF3,
  0xE1, 0xF8, 0x07, 0xF3, 0xE1, 0xF8, 0x07, 0xE3, 0xE3, 0xF8, 0x07, 0xE3,
  0xE3, 0xF0, 0x07, 0xE1, 0xF3, 0xF0, 0x0F, 0xE1, 0xF3, 0xF0, 0x0F, 0xC1,
  0xF7, 0xF0, 0x0F, 0xC1, 0xF7, 0xE0, 0x0F, 0xC0, 0xFF, 0xE0, 0x1F, 0xC0,
  0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0x80,
  0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xE1, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x3F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x1F, 0xE0, 0x7E, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xF8, 0x0F, 0x80, 0x7F, 0x80, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1C, 0x00,
  0x3F, 0x80, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x3E, 0x1F, 0x80, 0x7E, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x87, 0xE0, 0x1F, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xE3, 0xF0, 0x0F,
  0xCF, 0xF1, 0xF8, 0x07, 0xE7, 0xF8, 0xFC, 0x03, 0xE7, 0xFC, 0x7C, 0x01,
  0xF3, 0xDE, 0x3E, 0x01, 0xFB, 0xEF, 0xBF, 0x00, 0xFD, 0xE7, 0xDF, 0x00,
  0x7D, 0xF3, 0xEF, 0x80, 0x3E, 0xF0, 0xF7, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x00,
  0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x1F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x07,
  0xE7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x78, 0x00, 0x7F, 0x06,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x10, 0x03, 0x80, 0x7C, 0x07, 0xF0, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE1, 0xFF, 0x07, 0xE0, 0x1C, 0x00, 0x40, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xE0,
  0x7F, 0xF3, 0xF8, 0x07, 0xF0, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x3F, 0xE1, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x30, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x9F, 0xC0, 0x07, 0xF0, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0x83, 0xFC, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7E, 0x01, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x02, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x02, 0x00, 0x1F, 0xE0, 0x0F, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x04, 0x01, 0xFE, 0x00, 0xE0, 0x7F, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0,
  0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x73, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0x8F, 0xC7, 0xE0, 0xFC, 0x7E, 0x3F, 0x07, 0xE3, 0xF1, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x8F, 0xC3, 0xE0, 0xFC,
  0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xF1, 0xF8,
  0x7C, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0,
  0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0x80, 0xFF, 0x3F, 0x80,
  0x7F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xE0,
  0x7F, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x70, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x0C, 0x00, 0x7F, 0x83, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x70,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0xCF, 0xE0, 0x1F, 0xC3,
  0x80, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x07, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0x83, 0xF0, 0xF8, 0x7C, 0x3F,
  0x87, 0xC3, 0xE1, 0xFC, 0x7E, 0x3F, 0x0F, 0xE3, 0xE1, 0xF8, 0xFF, 0x1F,
  0x0F, 0xC7, 0xF9, 0xF8, 0x7C, 0x7F, 0xCF, 0x83, 0xE3, 0xDE, 0x7C, 0x1F,
  0x3E, 0xF3, 0xE0, 0xFB, 0xE7, 0xBE, 0x07, 0xDF, 0x3D, 0xF0, 0x3F, 0xF1,
  0xEF, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x00, 0xFF, 0x80, 0x7C,
  0x3F, 0xF8, 0x1F, 0x8F, 0xFF, 0xC7, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xF1, 0xFF, 0xF8, 0xFC, 0x0F, 0xFE, 0x1F,
  0x00, 0xFF, 0x80, 0x60, 0x07, 0xC0, 0x00,
};

const GFXglyph UbuntuMono_BoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 16, 36, 29, 9, -35 },
  { 73, 21, 16, 29, 11, -39 },
  { 115, 30, 35, 29, 2, -35 },
  { 247, 28, 46, 29, 3, -40 },
  { 408, 35, 37, 29, 0, -36 },
  { 570, 27, 37, 29, 3, -36 },
  { 695, 10, 17, 29, 16, -39 },
  { 717, 23, 50, 29, 8, -40 },
  { 861, 23, 50, 29, 2, -40 },
  { 1005, 24, 22, 29, 7, -35 },
  { 1071, 25, 26, 29, 4, -28 },
  { 1153, 14, 18, 29, 5, -9 },
  { 1185, 17, 7, 29, 8, -18 },
  { 1200, 10, 10, 29, 9, -9 },
  { 1213, 34, 49, 29, -1, -40 },
  { 1422, 27, 37, 29, 4, -36 },
  { 1547, 23, 35, 29, 4, -35 },
  { 1648, 28, 36, 29, 2, -36 },
  { 1774, 28, 37, 29, 2, -36 },
  { 1904, 29, 35, 29, 2, -35 },
  { 2031, 30, 36, 29, 2, -35 },
  { 2166, 28, 36, 29, 4, -35 },
  { 2292, 27, 35, 29, 7, -35 },
  { 2411, 27, 37, 29, 4, -36 },
  { 2536, 28, 36, 29, 3, -36 },
  { 2662, 14, 27, 29, 9, -26 },
  { 2710, 18, 35, 29, 5, -26 },
  { 2789, 26, 25, 29, 4, -27 },
  { 2871, 28, 17, 29, 3, -23 },
  { 2931, 26, 25, 29, 3, -27 },
  { 3013, 21, 37, 29, 9, -36 },
  { 3111, 29, 44, 29, 3, -36 },
  { 3271, 27, 35, 29, 0, -35 },
  { 3390, 29, 36, 29, 2, -35 },
  { 3521, 27, 37, 29, 5, -36 },
  { 3646, 28, 37, 29, 2, -36 },
  { 3776, 29, 35, 29, 3, -35 },
  { 3903, 30, 35, 29, 3, -35 },
  { 4035, 28, 37, 29, 4, -36 },
  { 4165, 32, 35, 29, 1, -35 },
  { 4305, 31, 35, 29, 2, -35 },
  { 4441, 30, 36, 29, 2, -35 },
  { 4576, 32, 35, 29, 2, -35 },
  { 4716, 23, 35, 29, 3, -35 },
  { 4817, 33, 35, 29, 0, -35 },
  { 4962, 32, 35, 29, 1, -35 },
  { 5102, 27, 37, 29, 4, -36 },
  { 5227, 30, 35, 29, 2, -35 },
  { 5359, 27, 47, 29, 4, -36 },
  { 5518, 28, 35, 29, 2, -35 },
  { 5641, 29, 37, 29, 2, -36 },
  { 5776, 27, 35, 29, 7, -35 },
  { 5895, 29, 36, 29, 4, -35 },
  { 6026, 27, 35, 29, 8, -35 },
  { 6145, 33, 35, 29, 2, -35 },
  { 6290, 35, 35, 29, 0, -35 },
  { 6444, 27, 35, 29, 8, -35 },
  { 6563, 31, 35, 29, 2, -35 },
  { 6699, 28, 49, 29, 5, -40 },
  { 6871, 11, 49, 29, 12, -40 },
  { 6939, 28, 49, 29, 1, -40 },
  { 7111, 27, 21, 29, 4, -35 },
  { 7182, 27, 6, 29, -2, 3 },
  { 7203, 12, 11, 29, 14, -39 },
  { 7220, 26, 29, 29, 4, -28 },
  { 7315, 27, 41, 29, 2, -40 },
  { 7454, 26, 29, 29, 4, -28 },
  { 7549, 29, 41, 29, 4, -40 },
  { 7698, 26, 29, 29, 4, -28 },
  { 7793, 36, 50, 29, -2, -40 },
  { 8018, 30, 38, 29, 0, -28 },
  { 8161, 25, 40, 29, 3, -40 },
  { 8286, 20, 40, 29, 6, -39 },
  { 8386, 27, 49, 29, 0, -39 },
  { 8552, 29, 40, 29, 3, -40 },
  { 8697, 18, 40, 29, 8, -39 },
  { 8787, 29, 27, 29, 1, -27 },
  { 8885, 25, 28, 29, 3, -28 },
  { 8973, 25, 29, 29, 4, -28 },
  { 9064, 29, 37, 29, 0, -28 },
  { 9199, 26, 37, 29, 4, -28 },
  { 9320, 27, 28, 29, 4, -28 },
  { 9415, 26, 29, 29, 3, -28 },
  { 9510, 24, 36, 29, 6, -35 },
  { 9618, 26, 28, 29, 4, -27 },
  { 9709, 26, 27, 29, 6, -27 },
  { 9797, 29, 27, 29, 4, -27 },
  { 9895, 30, 27, 29, 1, -27 },
  { 9997, 33, 37, 29, -2, -27 },
  { 10150, 27, 27, 29, 3, -27 },
  { 10242, 27, 49, 29, 6, -40 },
  { 10408, 19, 49, 29, 7, -40 },
  { 10525, 28, 49, 29, 0, -40 },
  { 10697, 27, 11, 29, 3, -20 },
};

const GFXfont UbuntuMono_BoldItalic57pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_BoldItalic57pt7bBitmaps,
  (GFXglyph *)UbuntuMono_BoldItalic57pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _UBUNTUMONO_BOLDITALIC57PT7B_H_
