#ifndef _ROBOTOCONDENSED_LIGHTITALIC17PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x40, 0x60, 0xB6, 0xD0, 0x09, 0x12, 0x12, 0x7F,
  0x24, 0x24, 0x24, 0x48, 0xFE, 0x48, 0x90, 0x90, 0x08, 0x10, 0xF3, 0x24,
  0x28, 0x50, 0x10, 0x18, 0x0A, 0x14, 0x28, 0x8E, 0x08, 0x10, 0x61, 0x22,
  0x54, 0xAA, 0x9E, 0x07, 0x95, 0x53, 0x26, 0x48, 0x60, 0x18, 0x49, 0x12,
  0x63, 0x84, 0x14, 0xC9, 0x8D, 0x1A, 0x33, 0xA0, 0xF0, 0x08, 0x88, 0x44,
  0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x00, 0x10, 0x84, 0x10,
  0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x44, 0x00, 0x10, 0x22, 0x53,
  0xC3, 0x09, 0x22, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE4, 0x08, 0x10, 0x20,
  0x29, 0x40, 0x70, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x00, 0x3C, 0xC9, 0x0A, 0x18, 0x30, 0xA1, 0x42, 0x85,
  0x12, 0x23, 0x80, 0x1F, 0x11, 0x22, 0x22, 0x22, 0x44, 0x1C, 0x22, 0x22,
  0x42, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x3C, 0x89, 0x08,
  0x20, 0x47, 0x02, 0x02, 0x05, 0x0A, 0x23, 0x80, 0x02, 0x0C, 0x18, 0x51,
  0x24, 0x89, 0x22, 0xFE, 0x08, 0x10, 0x40, 0x3E, 0x41, 0x02, 0x07, 0x88,
  0x81, 0x02, 0x05, 0x0A, 0x23, 0x80, 0x0C, 0xC4, 0x10, 0x7B, 0x18, 0x61,
  0x86, 0x18, 0x9C, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41,
  0x02, 0x00, 0x1E, 0x32, 0x21, 0x21, 0x22, 0x1C, 0x64, 0x42, 0x42, 0x42,
  0x44, 0x38, 0x39, 0x14, 0x61, 0x86, 0x14, 0xDD, 0x04, 0x21, 0x38, 0x20,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x02, 0x44, 0x80, 0x04, 0x66, 0x20,
  0x40, 0xC0, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x20, 0x60, 0x30, 0x10, 0xC6,
  0x30, 0x00, 0x39, 0x24, 0x41, 0x08, 0x61, 0x08, 0x40, 0x00, 0x10, 0x0F,
  0x82, 0x08, 0x80, 0xA0, 0x14, 0x73, 0x12, 0x64, 0x4C, 0x89, 0x92, 0x34,
  0x46, 0x59, 0x4C, 0xC8, 0x01, 0x00, 0x10, 0x01, 0xE0, 0x02, 0x01, 0x01,
  0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x3F, 0x10, 0x50, 0x28, 0x10, 0x3C,
  0x85, 0x0A, 0x14, 0x6F, 0x21, 0x41, 0x83, 0x0A, 0x17, 0xC0, 0x1E, 0x23,
  0x41, 0x41, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82, 0xC4, 0x78, 0x3C, 0x42,
  0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x3F, 0x40,
  0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x40,
  0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x21,
  0x41, 0x41, 0x40, 0x80, 0x8F, 0x82, 0x82, 0x82, 0x46, 0x3C, 0x40, 0xA0,
  0x50, 0x28, 0x24, 0x13, 0xFA, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x40,
  0x29, 0x24, 0x94, 0x92, 0x40, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x84, 0x84, 0x4C, 0x78, 0x41, 0x21, 0x11, 0x09, 0x05, 0x03, 0x83,
  0x41, 0x10, 0x88, 0x42, 0x21, 0x10, 0x40, 0x42, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x21, 0xF0, 0x20, 0x2C, 0x0D, 0x81, 0xB0, 0x55, 0x0C, 0xA2, 0xA4,
  0x54, 0x92, 0x92, 0x52, 0x8A, 0x22, 0x44, 0x40, 0x20, 0xB0, 0x58, 0x2A,
  0x25, 0x12, 0x4A, 0x25, 0x12, 0x85, 0x43, 0x21, 0x90, 0x40, 0x1E, 0x21,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC4, 0x78, 0x3E, 0x42,
  0x41, 0x41, 0x41, 0x42, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x23,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC4, 0x78, 0x04, 0x04,
  0x1E, 0x10, 0x88, 0x24, 0x12, 0x11, 0x09, 0xF8, 0x88, 0x44, 0x21, 0x10,
  0x88, 0x40, 0x1E, 0x18, 0x88, 0x44, 0x22, 0x00, 0xC0, 0x18, 0x04, 0x81,
  0x21, 0x10, 0x87, 0x80, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x00, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x78, 0x41, 0x20, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x50,
  0x28, 0x18, 0x0C, 0x04, 0x00, 0x84, 0x30, 0x86, 0x31, 0x46, 0x29, 0x45,
  0x29, 0x28, 0xA5, 0x14, 0xA3, 0x18, 0x63, 0x0C, 0x41, 0x00, 0x20, 0x90,
  0x84, 0xC2, 0x40, 0xC0, 0x40, 0x20, 0x28, 0x24, 0x31, 0x10, 0x90, 0x40,
  0x82, 0x86, 0x84, 0x48, 0x48, 0x50, 0x60, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x3F, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x10,
  0x1F, 0xC0, 0x19, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x22, 0x10,
  0xC0, 0xAA, 0xA5, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x10, 0x84, 0xC0, 0x11, 0x8C, 0xA5, 0x40, 0xFC, 0x90, 0x1C, 0x45,
  0x08, 0x13, 0xC8, 0xA1, 0x46, 0x74, 0x20, 0x40, 0x81, 0x03, 0xC4, 0x50,
  0xA1, 0x42, 0x85, 0x0A, 0x2B, 0x80, 0x39, 0x18, 0x60, 0x82, 0x08, 0xA2,
  0x70, 0x02, 0x04, 0x08, 0x13, 0xC8, 0xA1, 0x42, 0x85, 0x0A, 0x24, 0x47,
  0x80, 0x39, 0x18, 0x61, 0xFE, 0x08, 0x22, 0x70, 0x19, 0x08, 0x8F, 0x21,
  0x08, 0x44, 0x21, 0x08, 0x00, 0x1D, 0x22, 0x42, 0x42, 0x42, 0x42, 0x44,
  0x44, 0x3C, 0x04, 0x88, 0x70, 0x20, 0x40, 0x81, 0x03, 0xC4, 0x50, 0xA1,
  0x42, 0x85, 0x12, 0x28, 0x40, 0x20, 0x02, 0x22, 0x44, 0x44, 0x48, 0x08,
  0x00, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x13, 0x00, 0x20, 0x40, 0x81,
  0x02, 0x24, 0x92, 0x28, 0x70, 0xA1, 0x22, 0x48, 0x40, 0x12, 0x22, 0x22,
  0x44, 0x44, 0x44, 0x80, 0x3C, 0xE2, 0x32, 0x42, 0x14, 0x21, 0x42, 0x24,
  0x22, 0x44, 0x24, 0x42, 0x84, 0x20, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x51,
  0x22, 0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x3C, 0x45, 0x0A,
  0x14, 0x28, 0x50, 0xA2, 0xB9, 0x02, 0x04, 0x00, 0x3C, 0x8A, 0x14, 0x28,
  0x50, 0xA2, 0x44, 0x78, 0x10, 0x20, 0x80, 0x39, 0x10, 0x84, 0x21, 0x08,
  0x80, 0x3C, 0x45, 0x09, 0x01, 0x80, 0xA1, 0x22, 0x78, 0x24, 0xF4, 0x44,
  0x48, 0x88, 0xC0, 0x45, 0x18, 0x61, 0x86, 0x28, 0xA2, 0x78, 0x86, 0x18,
  0xA2, 0x51, 0x46, 0x18, 0x40, 0x88, 0x63, 0x29, 0x4A, 0x54, 0x95, 0x19,
  0x46, 0x61, 0x18, 0x44, 0x00, 0x42, 0x48, 0xA0, 0xC1, 0x06, 0x1A, 0x24,
  0x84, 0x21, 0x21, 0x22, 0x12, 0x14, 0x14, 0x18, 0x18, 0x10, 0x10, 0x20,
  0xC0, 0x7E, 0x08, 0x20, 0x41, 0x04, 0x10, 0x20, 0xFC, 0x08, 0x88, 0x42,
  0x21, 0x10, 0x82, 0x11, 0x08, 0x41, 0x08, 0x24, 0x92, 0x52, 0x49, 0x29,
  0x00, 0x30, 0x82, 0x21, 0x08, 0x41, 0x10, 0x88, 0x42, 0x11, 0x10, 0x71,
  0x99, 0x8E,
};

const GFXglyph RobotoCondensed_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 4, 0, -12 },
  { 6, 3, 4, 5, 2, -13 },
  { 8, 8, 12, 8, 1, -12 },
  { 20, 7, 16, 8, 1, -14 },
  { 34, 7, 12, 11, 2, -12 },
  { 45, 7, 12, 9, 1, -12 },
  { 56, 1, 4, 3, 2, -13 },
  { 57, 5, 18, 5, 1, -14 },
  { 69, 5, 18, 5, -1, -14 },
  { 81, 7, 7, 7, 1, -12 },
  { 88, 7, 9, 8, 1, -10 },
  { 96, 3, 4, 3, -1, -2 },
  { 98, 4, 1, 4, 0, -6 },
  { 99, 2, 1, 4, 0, -1 },
  { 100, 7, 13, 6, -1, -12 },
  { 112, 7, 12, 8, 1, -12 },
  { 123, 4, 12, 8, 2, -12 },
  { 129, 8, 12, 8, 0, -12 },
  { 141, 7, 12, 8, 1, -12 },
  { 152, 7, 12, 8, 0, -12 },
  { 163, 7, 12, 8, 1, -12 },
  { 174, 6, 12, 8, 1, -12 },
  { 183, 7, 12, 8, 1, -12 },
  { 194, 8, 12, 8, 0, -12 },
  { 206, 6, 12, 8, 1, -12 },
  { 215, 3, 9, 3, 0, -9 },
  { 219, 4, 11, 3, -1, -9 },
  { 225, 6, 7, 7, 1, -9 },
  { 231, 6, 5, 8, 1, -8 },
  { 235, 7, 7, 8, 0, -9 },
  { 242, 6, 12, 7, 1, -12 },
  { 251, 11, 16, 13, 1, -12 },
  { 273, 9, 12, 9, -1, -12 },
  { 287, 7, 12, 9, 1, -12 },
  { 298, 8, 12, 9, 1, -12 },
  { 310, 8, 12, 9, 1, -12 },
  { 322, 8, 12, 8, 1, -12 },
  { 334, 8, 12, 8, 1, -12 },
  { 346, 8, 12, 10, 1, -12 },
  { 358, 9, 12, 10, 1, -12 },
  { 372, 3, 12, 4, 1, -12 },
  { 377, 8, 12, 8, 0, -12 },
  { 389, 9, 12, 9, 1, -12 },
  { 403, 5, 12, 8, 1, -12 },
  { 411, 11, 12, 12, 1, -12 },
  { 428, 9, 12, 10, 1, -12 },
  { 442, 8, 12, 10, 1, -12 },
  { 454, 8, 12, 9, 1, -12 },
  { 466, 8, 14, 10, 1, -12 },
  { 480, 9, 12, 9, 0, -12 },
  { 494, 9, 12, 9, 0, -12 },
  { 508, 7, 12, 9, 2, -12 },
  { 519, 8, 12, 9, 1, -12 },
  { 531, 9, 12, 9, 1, -12 },
  { 545, 11, 12, 13, 2, -12 },
  { 562, 9, 12, 9, 0, -12 },
  { 576, 8, 12, 9, 2, -12 },
  { 588, 9, 12, 9, 0, -12 },
  { 602, 5, 17, 4, 0, -14 },
  { 613, 2, 13, 6, 2, -12 },
  { 617, 5, 17, 4, -1, -14 },
  { 628, 5, 6, 6, 1, -12 },
  { 632, 6, 1, 6, -1, 0 },
  { 633, 2, 2, 5, 2, -12 },
  { 634, 7, 9, 8, 0, -9 },
  { 642, 7, 13, 8, 0, -13 },
  { 654, 6, 9, 7, 1, -9 },
  { 661, 7, 13, 8, 1, -13 },
  { 673, 6, 9, 8, 1, -9 },
  { 680, 5, 13, 5, 1, -13 },
  { 689, 8, 12, 8, 0, -9 },
  { 701, 7, 13, 8, 0, -13 },
  { 713, 4, 12, 3, 0, -12 },
  { 719, 5, 15, 4, -2, -12 },
  { 729, 7, 13, 7, 0, -13 },
  { 741, 4, 13, 3, 0, -13 },
  { 748, 12, 9, 13, 0, -9 },
  { 762, 7, 9, 8, 0, -9 },
  { 770, 6, 9, 8, 1, -9 },
  { 777, 7, 12, 8, 0, -9 },
  { 788, 7, 12, 8, 1, -9 },
  { 799, 5, 9, 5, 0, -9 },
  { 805, 7, 9, 7, 0, -9 },
  { 813, 4, 11, 5, 1, -11 },
  { 819, 6, 9, 8, 1, -9 },
  { 826, 6, 9, 7, 1, -9 },
  { 833, 10, 9, 11, 1, -9 },
  { 845, 7, 9, 7, 0, -9 },
  { 853, 8, 12, 7, -1, -9 },
  { 865, 7, 9, 7, 0, -9 },
  { 873, 5, 16, 5, 1, -13 },
  { 883, 3, 14, 4, 0, -12 },
  { 889, 5, 16, 5, -1, -13 },
  { 899, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC17PT7B_H_
