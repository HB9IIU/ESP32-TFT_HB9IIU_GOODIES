#ifndef _ROBOTOCONDENSED_LIGHTITALIC47PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0xC1,
  0xC0, 0x60, 0x00, 0x31, 0xB8, 0xD8, 0xEC, 0x66, 0x33, 0x1B, 0x8D, 0x86,
  0xC6, 0x63, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC1, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x83, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0x7C, 0x07, 0x81, 0xC1, 0xC0, 0x18, 0x38, 0x03, 0x86, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xCC, 0x00, 0x39, 0x80, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18, 0xE0, 0x07,
  0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0x8E, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x11,
  0x81, 0x80, 0xC6, 0x07, 0x07, 0x18, 0x18, 0x18, 0x60, 0x60, 0xC3, 0x81,
  0x86, 0x06, 0x06, 0x38, 0x18, 0x18, 0xC0, 0x60, 0xC6, 0x01, 0xC7, 0x30,
  0x03, 0xF9, 0xC0, 0x07, 0xC6, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC7, 0x80,
  0x06, 0x3F, 0x00, 0x31, 0x86, 0x01, 0x8C, 0x18, 0x0E, 0x30, 0x30, 0x31,
  0x80, 0xC1, 0x86, 0x03, 0x0E, 0x18, 0x0C, 0x30, 0x60, 0x31, 0x81, 0x80,
  0xCC, 0x06, 0x06, 0x70, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x00, 0xC7, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x3D,
  0xE0, 0x03, 0x83, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x1C,
  0x00, 0x19, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3B, 0x80, 0x03, 0x8C, 0x06, 0x38, 0x70, 0x33, 0x81, 0xC1,
  0xB8, 0x0E, 0x1D, 0xC0, 0x38, 0xCC, 0x01, 0xCE, 0x60, 0x07, 0x63, 0x00,
  0x3F, 0x18, 0x00, 0xF0, 0xE0, 0x03, 0x07, 0x00, 0x3C, 0x1C, 0x03, 0xE0,
  0xF8, 0xFB, 0x83, 0xFF, 0x0E, 0x07, 0xE0, 0x70, 0x33, 0x33, 0x76, 0x66,
  0x6E, 0x00, 0x08, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x04, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x0C,
  0x1F, 0xE3, 0x3F, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x03, 0x98, 0x01, 0xC7, 0x00, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x07, 0x02, 0x01, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x71,
  0xC1, 0x00, 0x7F, 0xFF, 0xE0, 0x6F, 0xF6, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x9E, 0x03, 0x80, 0xE0, 0x60,
  0x1C, 0x1C, 0x01, 0x83, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0xDC, 0x00,
  0x33, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00,
  0xE6, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03,
  0x1C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x38,
  0x0F, 0x1E, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x3C, 0x3F,
  0x9F, 0xEF, 0xCD, 0xC1, 0xA0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x03,
  0xE7, 0xC0, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xE7,
  0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03,
  0x87, 0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0xE0, 0x1F, 0x3E, 0x00, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0xDC,
  0x00, 0x39, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x0E, 0x18, 0x00, 0xC1,
  0x80, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x30, 0x38, 0x06, 0x03, 0x00, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x70, 0x38, 0x07, 0x07, 0x00, 0x70, 0x60,
  0x06, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x19, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xC0, 0xF0, 0x18, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00,
  0xE0, 0x60, 0x0E, 0x07, 0x01, 0xC0, 0x3C, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x63, 0xE0, 0x3B, 0xFE, 0x0D, 0xE7, 0xC3, 0xE0, 0x71,
  0xF0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00,
  0xE6, 0x00, 0x31, 0xC0, 0x1C, 0x70, 0x0E, 0x0E, 0x07, 0x81, 0xE7, 0xC0,
  0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xF3, 0xE0, 0x38, 0x0E, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x03,
  0xC7, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x70, 0x1C, 0x03, 0x83,
  0x80, 0x18, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x87, 0x00, 0x38, 0x70, 0x07,
  0x03, 0x80, 0xF0, 0x3E, 0x3E, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x07, 0xCF, 0x83, 0x81, 0xC3, 0x80, 0x73, 0x80, 0x39,
  0xC0, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x0F, 0x70,
  0x0F, 0x9C, 0x0F, 0x8F, 0x9E, 0xC3, 0xFE, 0xE0, 0x7C, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x1C,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x01, 0x80, 0xF0, 0x3C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xE0, 0x7F, 0xE1, 0xC0, 0xE7, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0x70,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x38, 0x03, 0xE0, 0x18, 0x60, 0x1F, 0xE0, 0x31, 0x80,
  0x70, 0xE0, 0x63, 0x01, 0xC0, 0xC0, 0xCC, 0x07, 0x01, 0x80, 0x98, 0x0C,
  0x07, 0x03, 0x70, 0x38, 0x0C, 0x06, 0xC0, 0x60, 0x18, 0x0D, 0x81, 0xC0,
  0x30, 0x1B, 0x03, 0x00, 0x60, 0x3E, 0x06, 0x01, 0x80, 0x78, 0x0C, 0x03,
  0x00, 0xF0, 0x38, 0x06, 0x01, 0xE0, 0x70, 0x0C, 0x06, 0xC0, 0xC0, 0x38,
  0x0D, 0x81, 0x80, 0x60, 0x1B, 0x03, 0x01, 0xC0, 0x66, 0x06, 0x03, 0x80,
  0xCC, 0x0C, 0x0F, 0x03, 0x18, 0x1C, 0x36, 0x06, 0x30, 0x3C, 0xEE, 0x38,
  0x60, 0x3F, 0x8F, 0xE0, 0xC0, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x38, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07,
  0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x30,
  0x03, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x30, 0x03, 0x80,
  0xE0, 0x03, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x38,
  0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x30, 0x3F, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x18,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x18,
  0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x03,
  0xC0, 0xC0, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x70, 0x07, 0x81,
  0xC0, 0x0E, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x80,
  0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x06,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x0F, 0x07, 0x03, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0x3F, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x01,
  0x87, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70, 0x03,
  0x81, 0xE0, 0x1C, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0C, 0x0F, 0xC0, 0x18, 0x03, 0xC0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xE0,
  0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0xF0, 0x18, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0x3F, 0x01, 0xE0, 0x1E, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0, 0x00,
  0x33, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x01,
  0xFF, 0xB8, 0x07, 0xFE, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x1C,
  0x00, 0x18, 0x70, 0x00, 0xE0, 0xE0, 0x0F, 0x81, 0xFB, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x00, 0x03, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x38, 0x0E, 0x00,
  0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x06, 0x03,
  0xC0, 0x01, 0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x3C, 0x00, 0x03, 0x1E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x33, 0xC0, 0x00,
  0x1D, 0xF8, 0x00, 0x07, 0xEE, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x0E,
  0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x0D, 0xC0, 0x00, 0xEC, 0x06, 0x60, 0x00, 0x66, 0x03, 0x30, 0x00, 0x73,
  0x03, 0x98, 0x00, 0x33, 0x81, 0xCC, 0x00, 0x39, 0xC0, 0xE7, 0x00, 0x18,
  0xE0, 0x63, 0x80, 0x1C, 0x60, 0x30, 0xC0, 0x0C, 0x30, 0x18, 0x60, 0x0E,
  0x38, 0x1C, 0x30, 0x06, 0x1C, 0x0E, 0x18, 0x07, 0x0E, 0x07, 0x0E, 0x03,
  0x06, 0x03, 0x07, 0x03, 0x83, 0x01, 0x81, 0x81, 0x83, 0x81, 0xC0, 0xC1,
  0xC1, 0xC0, 0xE0, 0x60, 0xC0, 0xE0, 0x70, 0x30, 0xE0, 0x70, 0x38, 0x1C,
  0x60, 0x30, 0x18, 0x0E, 0x70, 0x18, 0x0C, 0x03, 0x30, 0x1C, 0x0E, 0x01,
  0xB8, 0x0E, 0x07, 0x00, 0xD8, 0x07, 0x03, 0x80, 0x7C, 0x03, 0x81, 0xC0,
  0x3C, 0x01, 0x80, 0xC0, 0x1E, 0x00, 0xC0, 0x60, 0x06, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0F, 0x00, 0x03, 0x01, 0xE0,
  0x00, 0xE0, 0x7C, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0x81, 0xD8, 0x00, 0x70,
  0x3B, 0x80, 0x0C, 0x06, 0x70, 0x01, 0x80, 0xC6, 0x00, 0x70, 0x38, 0xE0,
  0x0E, 0x07, 0x1C, 0x01, 0xC0, 0xE1, 0x80, 0x38, 0x18, 0x38, 0x06, 0x03,
  0x03, 0x00, 0xC0, 0xE0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0xE0, 0x70, 0x1C, 0x18, 0x0C, 0x03, 0x83, 0x01, 0x80, 0x30, 0xE0, 0x70,
  0x07, 0x1C, 0x0E, 0x00, 0x63, 0x81, 0xC0, 0x0C, 0x70, 0x38, 0x01, 0xCC,
  0x06, 0x00, 0x19, 0x80, 0xC0, 0x03, 0xF0, 0x38, 0x00, 0x7E, 0x07, 0x00,
  0x07, 0xC0, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x1E, 0x03, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0xC6,
  0x00, 0x07, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00,
  0x03, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xC0,
  0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x70, 0x03, 0xC1,
  0xE0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0C, 0x07, 0xE0, 0x18, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78,
  0x38, 0x0F, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x01,
  0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x30, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE6,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0,
  0x00, 0x19, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE6, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x38, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x78,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0C, 0x07, 0xE0,
  0x18, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80, 0x07, 0x83, 0x00, 0x0E, 0x0E, 0x00,
  0x78, 0x1C, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xC0, 0x38,
  0x01, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x01, 0x80, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x1E,
  0x03, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x1C, 0x07, 0x80, 0x78, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30,
  0x00, 0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x60, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x1F, 0xBF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00,
  0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x18, 0x0E, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x19,
  0xC0, 0x00, 0x33, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x0E, 0xC0, 0x07,
  0x80, 0x0E, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x0F, 0x80, 0x1C, 0xE0, 0x0D,
  0x80, 0x1C, 0xE0, 0x0D, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x38, 0xE0, 0x19,
  0xC0, 0x30, 0xE0, 0x38, 0xC0, 0x70, 0xE0, 0x30, 0xC0, 0x70, 0xE0, 0x30,
  0xC0, 0x60, 0xE0, 0x70, 0xC0, 0xE0, 0xE0, 0x60, 0xC0, 0xE0, 0xE0, 0xE0,
  0xC0, 0xC0, 0x60, 0xC0, 0xC1, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0x61, 0xC0,
  0xC1, 0x80, 0x61, 0x80, 0xC3, 0x80, 0x63, 0x80, 0xE3, 0x00, 0x63, 0x00,
  0xE7, 0x00, 0x63, 0x00, 0xE7, 0x00, 0x67, 0x00, 0x66, 0x00, 0x66, 0x00,
  0x6E, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x6C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x1C, 0x30, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x06, 0x00, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x70, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xB0, 0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x61, 0x83,
  0x9C, 0x0C, 0xC0, 0x6E, 0x03, 0x60, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE1, 0xC7, 0x0E, 0x18, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0xF8,
  0x38, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0x03, 0x8E, 0x00,
  0xE7, 0x00, 0x39, 0x80, 0x0C, 0xE0, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x1F, 0x1C, 0x0F, 0x87, 0xFF, 0x60, 0xFF, 0x98, 0x1F,
  0x86, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0xF8, 0x07, 0x7F, 0xC0, 0xDE, 0xFC, 0x1E, 0x03, 0x87,
  0x80, 0x30, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x8C,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18, 0xE0,
  0x07, 0x1C, 0x01, 0xC7, 0xC0, 0x78, 0xEF, 0x3E, 0x1C, 0xFF, 0x83, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0x80, 0xE3, 0x80,
  0x39, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x7C,
  0x38, 0x0F, 0xF9, 0xC0, 0xF9, 0xEC, 0x0E, 0x03, 0x60, 0xE0, 0x0F, 0x07,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x38, 0x0E, 0x03, 0xC0, 0x7C, 0xF6, 0x01, 0xFF,
  0x70, 0x03, 0xE3, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x38,
  0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00,
  0xDC, 0x00, 0x37, 0x00, 0x1D, 0xFF, 0xFF, 0x7F, 0xFF, 0xD8, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x02, 0x0E, 0x03, 0xC3, 0xF3, 0xE0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3E, 0xC0, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0F, 0xFE, 0x3F, 0xF8, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7C, 0x38, 0x0F, 0xF9, 0xC0, 0xF9, 0xEC, 0x0F,
  0x03, 0x60, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x18, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1,
  0x80, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x0E, 0x03,
  0xC0, 0x7C, 0xFE, 0x01, 0xFF, 0x70, 0x07, 0xE3, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x01, 0x00, 0x38,
  0x1E, 0x03, 0x80, 0x7C, 0x7C, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE3, 0xE0,
  0x3B, 0xFE, 0x0D, 0xE7, 0x83, 0xE0, 0x71, 0xF0, 0x1C, 0x78, 0x07, 0x1C,
  0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x60, 0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x01, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x87, 0x00,
  0xE0, 0xC0, 0x38, 0x18, 0x0E, 0x03, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x38,
  0x03, 0x8E, 0x00, 0x63, 0x80, 0x0C, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xE6, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x01, 0xC1, 0xC0,
  0x38, 0x38, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x07, 0x03, 0x00, 0xE0,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x00,
  0x0C, 0x3E, 0x01, 0xF0, 0x19, 0xFE, 0x0F, 0xF0, 0x37, 0xBE, 0x3D, 0xF0,
  0x78, 0x1E, 0xC0, 0xF1, 0xE0, 0x1F, 0x00, 0xE3, 0xC0, 0x3E, 0x01, 0xC7,
  0x00, 0x38, 0x03, 0x8C, 0x00, 0x70, 0x07, 0x18, 0x01, 0xC0, 0x0E, 0x70,
  0x03, 0x80, 0x1C, 0xE0, 0x07, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x73, 0x80,
  0x18, 0x00, 0xC6, 0x00, 0x30, 0x01, 0x8C, 0x00, 0xE0, 0x07, 0x38, 0x01,
  0xC0, 0x0E, 0x70, 0x03, 0x80, 0x1C, 0xE0, 0x07, 0x00, 0x39, 0x80, 0x0C,
  0x00, 0x63, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x70, 0x03, 0x9C, 0x00, 0xE0,
  0x07, 0x38, 0x01, 0xC0, 0x0E, 0x70, 0x03, 0x80, 0x1C, 0xC0, 0x06, 0x00,
  0x30, 0x0E, 0x3E, 0x03, 0x3F, 0xE0, 0xDE, 0x78, 0x3E, 0x07, 0x1F, 0x01,
  0xC7, 0x80, 0x71, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x06, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xF9, 0xF0, 0x78, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0x73,
  0x00, 0x1D, 0xC0, 0x07, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x33, 0x80, 0x1C, 0x60, 0x0E, 0x1C, 0x07, 0x83,
  0xE7, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0x0F, 0x80, 0x19, 0xFF,
  0x00, 0xDE, 0xFC, 0x07, 0x80, 0xE0, 0x78, 0x03, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x01, 0xC1,
  0xC0, 0x1C, 0x0F, 0x01, 0xE0, 0xEF, 0x3E, 0x07, 0x3F, 0xE0, 0x38, 0xFC,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xF0, 0xE0, 0xFF, 0x9C, 0x3E, 0x7B, 0x0E, 0x03,
  0x63, 0x80, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01,
  0x8C, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0xE0, 0xE0, 0x3C, 0x1F, 0x3F, 0x81, 0xFF, 0x70,
  0x0F, 0x8E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x7C, 0x33, 0xF0, 0xDF, 0x83, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xF0, 0x38, 0x0E, 0x1C, 0x03, 0x87, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x1C, 0x07,
  0x87, 0xCF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x1F, 0xFF, 0xFF, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0x1C, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x18,
  0x70, 0x07, 0x06, 0x01, 0xE0, 0xE0, 0x7C, 0x1F, 0x7F, 0x81, 0xFF, 0x60,
  0x1F, 0x80, 0x00, 0xC0, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x00, 0xC6,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x38, 0x70, 0x18, 0x38, 0x1C,
  0x1C, 0x0C, 0x06, 0x0E, 0x03, 0x06, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x63,
  0x80, 0x39, 0x80, 0x1C, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0xEC, 0x01, 0xC0, 0x19, 0x80, 0x78, 0x07, 0x30, 0x0F, 0x00, 0xE6, 0x01,
  0xE0, 0x18, 0xC0, 0x7C, 0x07, 0x18, 0x0D, 0x80, 0xC3, 0x03, 0xB0, 0x38,
  0x60, 0x66, 0x07, 0x0C, 0x0C, 0xE0, 0xC1, 0xC3, 0x1C, 0x38, 0x38, 0x61,
  0x86, 0x07, 0x1C, 0x31, 0xC0, 0xE3, 0x06, 0x38, 0x1C, 0xE0, 0xC6, 0x03,
  0x98, 0x19, 0xC0, 0x33, 0x03, 0x30, 0x06, 0xC0, 0x66, 0x00, 0xD8, 0x0D,
  0xC0, 0x1F, 0x01, 0xB0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x00, 0xCE, 0x00, 0x07, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x3B, 0x00, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x00,
  0x1C, 0x1C, 0x01, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00,
  0x60, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x03,
  0x81, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x00,
  0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x00, 0x60,
  0xE0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80,
  0x01, 0xCC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xBE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x08, 0x00, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFE,
  0x00, 0xDF, 0xF8, 0x06, 0xC1, 0xE0, 0x7E, 0x07, 0x83, 0x60, 0x1F, 0xFB,
  0x00, 0x7F, 0x80, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 9, 10, 13, 5, -35 },
  { 51, 24, 33, 23, 1, -33 },
  { 150, 19, 42, 22, 2, -38 },
  { 250, 22, 33, 29, 4, -33 },
  { 341, 21, 33, 25, 1, -33 },
  { 428, 4, 10, 8, 4, -35 },
  { 433, 14, 49, 13, 2, -38 },
  { 519, 13, 48, 14, -2, -37 },
  { 597, 18, 19, 19, 3, -33 },
  { 640, 19, 25, 23, 2, -28 },
  { 700, 7, 11, 9, -2, -4 },
  { 710, 10, 2, 12, 1, -16 },
  { 713, 4, 4, 11, 1, -4 },
  { 715, 20, 36, 16, -2, -33 },
  { 805, 19, 33, 22, 2, -33 },
  { 884, 11, 33, 22, 6, -33 },
  { 930, 20, 33, 22, 1, -33 },
  { 1013, 20, 33, 22, 1, -33 },
  { 1096, 20, 33, 22, 1, -33 },
  { 1179, 20, 33, 22, 3, -33 },
  { 1262, 18, 33, 22, 2, -33 },
  { 1337, 19, 33, 22, 4, -33 },
  { 1416, 20, 33, 22, 1, -33 },
  { 1499, 17, 33, 22, 4, -33 },
  { 1570, 7, 25, 9, 1, -25 },
  { 1592, 10, 32, 9, -2, -25 },
  { 1632, 17, 20, 20, 2, -25 },
  { 1675, 18, 13, 22, 2, -22 },
  { 1705, 18, 20, 21, 1, -25 },
  { 1750, 15, 33, 18, 4, -33 },
  { 1812, 31, 43, 36, 2, -33 },
  { 1979, 23, 33, 25, -1, -33 },
  { 2074, 22, 33, 24, 1, -33 },
  { 2165, 22, 33, 26, 3, -33 },
  { 2256, 23, 33, 26, 1, -33 },
  { 2351, 23, 33, 23, 1, -33 },
  { 2446, 23, 33, 22, 1, -33 },
  { 2541, 22, 33, 27, 3, -33 },
  { 2632, 27, 33, 28, 1, -33 },
  { 2744, 8, 33, 11, 2, -33 },
  { 2777, 21, 33, 22, 1, -33 },
  { 2864, 26, 33, 25, 1, -33 },
  { 2972, 17, 33, 21, 1, -33 },
  { 3043, 33, 33, 34, 1, -33 },
  { 3180, 27, 33, 28, 1, -33 },
  { 3292, 22, 33, 27, 3, -33 },
  { 3383, 23, 33, 25, 1, -33 },
  { 3478, 23, 39, 27, 2, -33 },
  { 3591, 23, 33, 25, 1, -33 },
  { 3686, 23, 33, 24, 1, -33 },
  { 3781, 22, 33, 24, 4, -33 },
  { 3872, 24, 33, 26, 2, -33 },
  { 3971, 23, 33, 25, 4, -33 },
  { 4066, 32, 33, 35, 5, -33 },
  { 4198, 27, 33, 24, -1, -33 },
  { 4310, 22, 33, 24, 4, -33 },
  { 4401, 25, 33, 24, 0, -33 },
  { 4505, 14, 45, 10, 0, -38 },
  { 4584, 7, 36, 16, 5, -33 },
  { 4616, 14, 45, 10, -3, -38 },
  { 4695, 13, 17, 17, 2, -33 },
  { 4723, 17, 2, 18, -2, 0 },
  { 4728, 6, 6, 13, 6, -35 },
  { 4733, 18, 25, 21, 1, -25 },
  { 4790, 19, 35, 22, 1, -35 },
  { 4874, 17, 25, 21, 2, -25 },
  { 4928, 21, 35, 22, 2, -35 },
  { 5020, 18, 25, 21, 1, -25 },
  { 5077, 14, 35, 14, 3, -35 },
  { 5139, 21, 35, 22, 0, -25 },
  { 5231, 18, 35, 22, 1, -35 },
  { 5310, 9, 34, 10, 1, -34 },
  { 5349, 15, 44, 10, -5, -34 },
  { 5432, 19, 35, 20, 1, -35 },
  { 5516, 9, 35, 10, 1, -35 },
  { 5556, 31, 25, 35, 1, -25 },
  { 5653, 18, 25, 22, 1, -25 },
  { 5710, 18, 25, 22, 2, -25 },
  { 5767, 21, 35, 22, -1, -25 },
  { 5859, 19, 35, 22, 2, -25 },
  { 5943, 14, 25, 14, 1, -25 },
  { 5987, 18, 25, 20, 1, -25 },
  { 6044, 11, 31, 13, 2, -31 },
  { 6087, 19, 25, 22, 2, -25 },
  { 6147, 17, 25, 19, 3, -25 },
  { 6201, 27, 25, 30, 3, -25 },
  { 6286, 21, 25, 20, -1, -25 },
  { 6352, 22, 35, 19, -2, -25 },
  { 6449, 19, 25, 20, 0, -25 },
  { 6509, 14, 46, 14, 2, -37 },
  { 6590, 8, 39, 10, 1, -33 },
  { 6629, 15, 46, 14, -3, -37 },
  { 6716, 21, 8, 27, 3, -18 },
};

const GFXfont RobotoCondensed_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC47PT7B_H_
