#ifndef _ROBOTOCONDENSED_LIGHTITALIC15PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x02, 0x00, 0xFC, 0x09, 0x0A, 0x12, 0x3F, 0x14,
  0x14, 0x24, 0x7E, 0x28, 0x48, 0x50, 0x10, 0xE4, 0x51, 0x41, 0x03, 0x02,
  0x0A, 0x28, 0xBC, 0x40, 0x61, 0x26, 0x54, 0xA6, 0x82, 0x05, 0x95, 0x4A,
  0x14, 0x30, 0x1C, 0x48, 0x91, 0x21, 0x86, 0x12, 0xA5, 0x84, 0x89, 0xE8,
  0x58, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x10, 0x8F, 0xC8, 0x52, 0x40, 0x10, 0x42,
  0x3F, 0x20, 0x82, 0x08, 0x58, 0xE0, 0xC0, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x39, 0x14, 0x61, 0x86, 0x28, 0xA2,
  0x8A, 0x46, 0x00, 0x3C, 0x92, 0x52, 0x49, 0x00, 0x1C, 0x49, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x83, 0xF0, 0x1C, 0x49, 0x08, 0x10, 0x43, 0x01,
  0x02, 0x84, 0x89, 0xE0, 0x04, 0x08, 0x30, 0xA2, 0x44, 0x92, 0x7F, 0x08,
  0x10, 0x20, 0x3D, 0x04, 0x10, 0x70, 0x20, 0x82, 0x8A, 0x27, 0x00, 0x19,
  0x11, 0x0F, 0x46, 0x31, 0x8C, 0x5C, 0xFC, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x41, 0x08, 0x00, 0x1C, 0x44, 0x89, 0x12, 0x47, 0x11, 0x22, 0x84, 0x89,
  0xE0, 0x39, 0x28, 0x61, 0x86, 0x27, 0x82, 0x10, 0x4E, 0x00, 0x60, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x04, 0x48, 0x09, 0xB1, 0x06, 0x08, 0xF8, 0x01,
  0xF0, 0x40, 0xC0, 0xC3, 0x33, 0x00, 0x32, 0x62, 0x11, 0x10, 0x88, 0x00,
  0x10, 0x1F, 0x08, 0x24, 0x05, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x92, 0xA4,
  0xAE, 0xC8, 0x02, 0x00, 0x78, 0x00, 0x0C, 0x18, 0x50, 0xA2, 0x44, 0x89,
  0x3E, 0x43, 0x06, 0x08, 0x3C, 0x44, 0x89, 0x14, 0x2F, 0x90, 0xA1, 0x42,
  0x89, 0xE0, 0x3C, 0x85, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x85, 0x09, 0xE0,
  0x3C, 0x22, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x44, 0x78, 0x3F,
  0x20, 0x20, 0x20, 0x40, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x3F, 0x20,
  0x20, 0x20, 0x40, 0x7C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x3C, 0x85, 0x0C,
  0x08, 0x10, 0x23, 0xC2, 0x85, 0x09, 0xE0, 0x20, 0x90, 0x48, 0x44, 0x24,
  0x13, 0xF9, 0x04, 0x82, 0x42, 0x21, 0x20, 0x80, 0x55, 0x6A, 0xA8, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x85, 0x11, 0xC0, 0x21, 0x11, 0x09,
  0x05, 0x05, 0x03, 0x81, 0xA0, 0x90, 0x44, 0x22, 0x20, 0x80, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x41, 0x07, 0xC0, 0x20, 0x66, 0x08, 0xC3, 0x18,
  0x65, 0x14, 0xA2, 0x92, 0x92, 0x52, 0x4C, 0x89, 0x92, 0x22, 0x00, 0x20,
  0x98, 0x4C, 0x46, 0x24, 0x92, 0x49, 0x14, 0x8A, 0x46, 0x21, 0x20, 0x80,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x3E, 0x22,
  0x21, 0x21, 0x41, 0x42, 0x7C, 0x40, 0x40, 0x40, 0x80, 0x3C, 0x85, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x40, 0x40, 0x3E, 0x22, 0x21,
  0x21, 0x42, 0x7C, 0x44, 0x44, 0x44, 0x44, 0x82, 0x1C, 0x22, 0x21, 0x20,
  0x20, 0x18, 0x04, 0x02, 0x82, 0x44, 0x38, 0xFE, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0x42, 0x85, 0x0C, 0x18, 0x30, 0xA1, 0x42,
  0x85, 0x11, 0xC0, 0x82, 0x82, 0x44, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50,
  0x20, 0x20, 0x84, 0x30, 0x89, 0x31, 0x26, 0x25, 0x48, 0xA5, 0x14, 0xA3,
  0x18, 0x63, 0x08, 0x41, 0x08, 0x00, 0x21, 0x22, 0x22, 0x14, 0x18, 0x18,
  0x18, 0x28, 0x44, 0x44, 0x84, 0x82, 0x85, 0x12, 0x42, 0x86, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x3F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x40, 0xFC, 0x32, 0x22, 0x44, 0x44, 0x44, 0x48, 0x8C, 0xAA, 0xAA, 0x55,
  0x31, 0x11, 0x11, 0x22, 0x22, 0x22, 0x4C, 0x26, 0x59, 0x90, 0xFC, 0x90,
  0x39, 0x10, 0x4F, 0x46, 0x28, 0x9E, 0x20, 0x82, 0x08, 0x5D, 0x94, 0x51,
  0x45, 0x14, 0x6E, 0x39, 0x14, 0x50, 0x82, 0x14, 0x9C, 0x04, 0x10, 0x41,
  0x76, 0x28, 0xA2, 0x8A, 0x29, 0xBC, 0x39, 0x14, 0x5F, 0x82, 0x04, 0x1E,
  0x32, 0x44, 0xE4, 0x48, 0x88, 0x88, 0x3A, 0x89, 0x12, 0x24, 0x50, 0x93,
  0x3C, 0x09, 0x11, 0xC0, 0x20, 0x82, 0x08, 0x5D, 0x94, 0x51, 0x45, 0x18,
  0x62, 0x20, 0x14, 0x92, 0x4A, 0x00, 0x08, 0x00, 0x11, 0x08, 0x42, 0x10,
  0x88, 0x42, 0x60, 0x20, 0x40, 0x81, 0x04, 0x49, 0x14, 0x30, 0x50, 0xA2,
  0x24, 0x40, 0x24, 0x94, 0x92, 0x49, 0x40, 0x5D, 0xD9, 0x94, 0x45, 0x11,
  0x44, 0x51, 0x18, 0x46, 0x21, 0x5D, 0x94, 0x51, 0x45, 0x18, 0x62, 0x7C,
  0x63, 0x18, 0xC6, 0x3E, 0x5D, 0x94, 0x51, 0x45, 0x14, 0x6E, 0x82, 0x08,
  0x00, 0x76, 0x28, 0xA2, 0x8A, 0x28, 0xBC, 0x10, 0x41, 0x00, 0x5B, 0x10,
  0x84, 0x22, 0x10, 0x39, 0x14, 0x08, 0x18, 0x28, 0x9C, 0x4B, 0xA5, 0x24,
  0x98, 0x86, 0x28, 0xA2, 0x8A, 0x29, 0x3C, 0x8C, 0x65, 0x2A, 0x31, 0x08,
  0x89, 0x4C, 0xA6, 0x55, 0x4A, 0xA6, 0x61, 0x10, 0x88, 0x44, 0xA2, 0x8C,
  0x31, 0x44, 0xA2, 0x22, 0x44, 0x91, 0x22, 0x83, 0x04, 0x08, 0x10, 0x43,
  0x00, 0x7C, 0x20, 0x84, 0x21, 0x04, 0x3E, 0x08, 0x84, 0x42, 0x10, 0x88,
  0x42, 0x10, 0x84, 0x20, 0x80, 0x24, 0x94, 0x92, 0x4A, 0x48, 0x20, 0x84,
  0x21, 0x08, 0x41, 0x11, 0x08, 0x42, 0x22, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph RobotoCondensed_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 2, 3, 4, 2, -11 },
  { 7, 8, 11, 7, 0, -11 },
  { 18, 6, 13, 7, 1, -12 },
  { 28, 7, 11, 9, 1, -11 },
  { 38, 7, 11, 8, 0, -11 },
  { 48, 2, 3, 2, 1, -11 },
  { 49, 4, 15, 4, 1, -12 },
  { 57, 4, 15, 4, -1, -12 },
  { 65, 6, 6, 6, 1, -11 },
  { 70, 6, 8, 7, 1, -9 },
  { 76, 2, 3, 3, -1, -1 },
  { 77, 3, 1, 4, 0, -5 },
  { 78, 2, 1, 3, 0, -1 },
  { 79, 7, 12, 5, -1, -11 },
  { 90, 6, 11, 7, 1, -11 },
  { 99, 3, 11, 7, 2, -11 },
  { 104, 7, 11, 7, 0, -11 },
  { 114, 7, 11, 7, 0, -11 },
  { 124, 7, 11, 7, 0, -11 },
  { 134, 6, 11, 7, 1, -11 },
  { 143, 5, 11, 7, 1, -11 },
  { 150, 6, 11, 7, 1, -11 },
  { 159, 7, 11, 7, 0, -11 },
  { 169, 6, 11, 7, 1, -11 },
  { 178, 3, 8, 3, 0, -8 },
  { 181, 4, 10, 3, -1, -8 },
  { 186, 5, 6, 7, 1, -8 },
  { 190, 5, 4, 7, 1, -7 },
  { 193, 6, 6, 7, 0, -8 },
  { 198, 5, 11, 6, 1, -11 },
  { 205, 10, 13, 11, 1, -10 },
  { 222, 7, 11, 8, 0, -11 },
  { 232, 7, 11, 8, 0, -11 },
  { 242, 7, 11, 8, 1, -11 },
  { 252, 8, 11, 8, 0, -11 },
  { 263, 8, 11, 7, 0, -11 },
  { 274, 8, 11, 7, 0, -11 },
  { 285, 7, 11, 9, 1, -11 },
  { 295, 9, 11, 9, 0, -11 },
  { 308, 2, 11, 4, 1, -11 },
  { 311, 7, 11, 7, 0, -11 },
  { 321, 9, 11, 8, 0, -11 },
  { 334, 6, 11, 7, 0, -11 },
  { 343, 11, 11, 11, 0, -11 },
  { 359, 9, 11, 9, 0, -11 },
  { 372, 7, 11, 9, 1, -11 },
  { 382, 8, 11, 8, 0, -11 },
  { 393, 7, 13, 9, 1, -11 },
  { 405, 8, 11, 8, 0, -11 },
  { 416, 8, 11, 8, 0, -11 },
  { 427, 7, 11, 8, 1, -11 },
  { 437, 7, 11, 8, 1, -11 },
  { 447, 8, 11, 8, 1, -11 },
  { 458, 11, 11, 11, 1, -11 },
  { 474, 8, 11, 8, 0, -11 },
  { 485, 7, 11, 8, 1, -11 },
  { 495, 8, 11, 8, 0, -11 },
  { 506, 4, 14, 3, 0, -12 },
  { 513, 2, 12, 5, 2, -11 },
  { 516, 4, 14, 3, -1, -12 },
  { 523, 4, 5, 5, 1, -11 },
  { 526, 6, 1, 6, -1, 0 },
  { 527, 2, 2, 4, 2, -11 },
  { 528, 6, 8, 7, 0, -8 },
  { 534, 6, 12, 7, 0, -12 },
  { 543, 6, 8, 7, 0, -8 },
  { 549, 6, 12, 7, 1, -12 },
  { 558, 6, 8, 7, 0, -8 },
  { 564, 4, 12, 4, 1, -12 },
  { 570, 7, 11, 7, 0, -8 },
  { 580, 6, 12, 7, 0, -12 },
  { 589, 3, 11, 3, 0, -11 },
  { 594, 5, 14, 3, -2, -11 },
  { 603, 7, 12, 6, 0, -12 },
  { 614, 3, 12, 3, 0, -12 },
  { 619, 10, 8, 11, 0, -8 },
  { 629, 6, 8, 7, 0, -8 },
  { 635, 5, 8, 7, 1, -8 },
  { 640, 6, 11, 7, 0, -8 },
  { 649, 6, 11, 7, 1, -8 },
  { 658, 5, 8, 4, 0, -8 },
  { 663, 6, 8, 7, 0, -8 },
  { 669, 3, 10, 4, 1, -10 },
  { 673, 6, 8, 7, 1, -8 },
  { 679, 5, 8, 6, 1, -8 },
  { 684, 9, 8, 10, 1, -8 },
  { 693, 6, 8, 6, 0, -8 },
  { 699, 7, 11, 6, -1, -8 },
  { 709, 6, 8, 6, 0, -8 },
  { 715, 5, 15, 4, 0, -12 },
  { 725, 3, 13, 3, 0, -11 },
  { 730, 5, 15, 4, -1, -12 },
  { 740, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC15PT7B_H_
