#ifndef _ROBOTOCONDENSED_LIGHTITALIC18PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x24, 0x44, 0x00, 0xC0, 0xB6, 0xD0, 0x09, 0x04,
  0x84, 0x82, 0x47, 0xF1, 0x20, 0x90, 0x48, 0xFE, 0x24, 0x12, 0x0A, 0x09,
  0x00, 0x08, 0x10, 0x71, 0x14, 0x28, 0x50, 0x10, 0x18, 0x18, 0x14, 0x28,
  0x51, 0x9E, 0x10, 0x20, 0x60, 0x90, 0x92, 0x94, 0x94, 0xE8, 0x10, 0x16,
  0x29, 0x49, 0x49, 0x89, 0x0E, 0x1C, 0x24, 0x24, 0x24, 0x28, 0x30, 0x30,
  0x51, 0x8A, 0x8A, 0x84, 0x8C, 0x72, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x00, 0x10, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x10, 0x23, 0x49, 0xE3, 0x09,
  0x02, 0x00, 0x08, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x10, 0x20, 0x29, 0x40,
  0x70, 0x30, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x1C, 0x45, 0x0A, 0x14, 0x30, 0x60, 0xC1, 0x85,
  0x0A, 0x14, 0x47, 0x00, 0x17, 0x91, 0x11, 0x22, 0x22, 0x22, 0x40, 0x1E,
  0x33, 0x21, 0x21, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x40, 0xFE,
  0x1C, 0x4D, 0x0A, 0x10, 0x20, 0x8E, 0x02, 0x05, 0x0A, 0x14, 0x47, 0x00,
  0x03, 0x03, 0x06, 0x0A, 0x0A, 0x12, 0x22, 0x22, 0x44, 0xFF, 0x04, 0x04,
  0x04, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x78, 0x44, 0x04, 0x02, 0x84, 0x84,
  0x4C, 0x78, 0x0C, 0x20, 0x82, 0x07, 0x88, 0xA1, 0x42, 0x85, 0x0A, 0x16,
  0x47, 0x00, 0x7F, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0x8E, 0x22, 0x85, 0x0A,
  0x14, 0x67, 0x00, 0x3C, 0xC9, 0x0A, 0x18, 0x30, 0x61, 0xA2, 0x7C, 0x08,
  0x20, 0x86, 0x00, 0x24, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x24,
  0x48, 0x04, 0x33, 0x30, 0xC1, 0x81, 0x82, 0x7E, 0x00, 0x07, 0xE0, 0x20,
  0x60, 0x30, 0x10, 0x63, 0x18, 0x40, 0x74, 0x62, 0x10, 0x88, 0x88, 0x40,
  0x00, 0x08, 0x00, 0x07, 0x81, 0x86, 0x30, 0x22, 0x01, 0x47, 0x14, 0x89,
  0x89, 0x19, 0x11, 0x91, 0x19, 0x12, 0x92, 0x29, 0x22, 0x9D, 0xC8, 0x00,
  0x80, 0x04, 0x00, 0x3C, 0x00, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48,
  0x24, 0x21, 0x1F, 0x90, 0x48, 0x28, 0x14, 0x08, 0x3E, 0x22, 0x41, 0x41,
  0x43, 0x42, 0x7C, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x1E, 0x10, 0x98,
  0x48, 0x14, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0xA0, 0x88, 0xC3, 0x80,
  0x3E, 0x23, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x84,
  0xF8, 0x3F, 0x20, 0x40, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFC, 0x3F, 0x20, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1E, 0x10, 0x98, 0x28, 0x14, 0x02, 0x02, 0x01, 0x1E,
  0x81, 0x40, 0xA0, 0x48, 0x43, 0xC0, 0x20, 0x88, 0x24, 0x09, 0x02, 0x40,
  0x90, 0x27, 0xF2, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x00, 0x24,
  0xA4, 0x92, 0x92, 0x48, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x82, 0x84, 0x44, 0x78, 0x21, 0x90, 0x90, 0x88, 0x84, 0x82, 0x81,
  0xC1, 0x90, 0x88, 0x46, 0x21, 0x10, 0xC8, 0x20, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x30, 0x82, 0x08, 0x20, 0xFC, 0x20, 0x32, 0x03, 0x60, 0x55, 0x06,
  0x50, 0xA5, 0x0A, 0x51, 0x29, 0x12, 0x92, 0x48, 0xA4, 0x8C, 0x48, 0xC4,
  0x88, 0x40, 0x20, 0x48, 0x25, 0x09, 0x42, 0x50, 0x92, 0x24, 0x8B, 0x24,
  0x85, 0x21, 0x48, 0x32, 0x0C, 0x82, 0x00, 0x1E, 0x10, 0x90, 0x48, 0x14,
  0x0C, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x88, 0xC3, 0x80, 0x3E, 0x21,
  0x41, 0x41, 0x41, 0x41, 0x42, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x10, 0x90, 0x48, 0x14, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x88,
  0xC3, 0x80, 0x20, 0x08, 0x3E, 0x43, 0x41, 0x41, 0x41, 0x41, 0x42, 0xFC,
  0x84, 0x84, 0x84, 0x86, 0x82, 0x0F, 0x08, 0x88, 0x24, 0x12, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x20, 0x90, 0x48, 0x43, 0xC0, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x20, 0xA0, 0x50,
  0x28, 0x24, 0x12, 0x09, 0x05, 0x02, 0x81, 0x41, 0x20, 0x98, 0x87, 0x80,
  0x81, 0x83, 0x82, 0x82, 0x84, 0x84, 0x88, 0x48, 0x50, 0x50, 0x50, 0x60,
  0x60, 0x84, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0x8A, 0x29, 0x24, 0x92, 0x49,
  0x28, 0xA2, 0x8A, 0x28, 0xC3, 0x0C, 0x30, 0xC1, 0x00, 0x20, 0xCC, 0x21,
  0x10, 0x4C, 0x0A, 0x03, 0x00, 0x80, 0x70, 0x14, 0x08, 0x86, 0x21, 0x08,
  0x81, 0x00, 0x81, 0x82, 0x86, 0x44, 0x48, 0x48, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x18, 0x0F, 0xF0, 0x18, 0x88, 0x42, 0x10, 0x84, 0x42,
  0x10, 0x84, 0x21, 0x10, 0x87, 0x00, 0x92, 0x48, 0x92, 0x49, 0x22, 0x40,
  0x18, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x26, 0x00,
  0x11, 0x8C, 0x94, 0xC4, 0xFE, 0x48, 0x1C, 0x45, 0x08, 0x13, 0xE8, 0x50,
  0xC2, 0x4C, 0xE8, 0x10, 0x20, 0x20, 0x20, 0x3E, 0x22, 0x21, 0x41, 0x41,
  0x42, 0x42, 0x42, 0x44, 0xBC, 0x39, 0x18, 0x60, 0x82, 0x08, 0x21, 0x89,
  0xC0, 0x01, 0x02, 0x02, 0x02, 0x3A, 0x46, 0x82, 0x84, 0x84, 0x84, 0x84,
  0x84, 0x8C, 0x78, 0x39, 0x18, 0x61, 0xFE, 0x08, 0x20, 0x89, 0xC0, 0x1C,
  0x82, 0x08, 0xF1, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x00, 0x1D, 0x23,
  0x41, 0x42, 0x42, 0x42, 0x42, 0x42, 0x46, 0x3C, 0x04, 0x04, 0x8C, 0x78,
  0x10, 0x40, 0x81, 0x02, 0xE6, 0x48, 0xA1, 0x42, 0x85, 0x0A, 0x14, 0x30,
  0x80, 0x30, 0x02, 0x22, 0x24, 0x44, 0x44, 0x40, 0x0C, 0x00, 0x02, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0xC0, 0x10, 0x20, 0x20,
  0x20, 0x22, 0x24, 0x2C, 0x58, 0x70, 0x70, 0x48, 0x48, 0x44, 0x84, 0x11,
  0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x3E, 0xF2, 0x31, 0x23, 0x14, 0x21,
  0x42, 0x14, 0x21, 0x42, 0x14, 0x21, 0x44, 0x28, 0x42, 0x2E, 0x64, 0x8A,
  0x14, 0x28, 0x50, 0xA1, 0x43, 0x08, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x61,
  0x42, 0x88, 0xE0, 0x3E, 0x22, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x44,
  0xBC, 0x80, 0x80, 0x80, 0x80, 0x3A, 0x8E, 0x0C, 0x28, 0x50, 0xA1, 0x42,
  0x8C, 0xF0, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x00, 0x1C, 0x45, 0x09, 0x03, 0x01, 0x81, 0x42, 0x44, 0xF0, 0x22,
  0xF4, 0x44, 0x44, 0x88, 0x86, 0x42, 0x85, 0x14, 0x28, 0x50, 0xA1, 0x42,
  0x88, 0xF0, 0x85, 0x0A, 0x12, 0x44, 0x8A, 0x14, 0x30, 0x60, 0xC0, 0x84,
  0x51, 0x8A, 0x31, 0x2A, 0x45, 0x48, 0xAA, 0x19, 0x43, 0x28, 0x42, 0x08,
  0x40, 0x62, 0x26, 0x24, 0x18, 0x18, 0x10, 0x28, 0x48, 0x44, 0x84, 0x21,
  0x10, 0x88, 0x42, 0x41, 0x20, 0xA0, 0x50, 0x30, 0x18, 0x08, 0x04, 0x02,
  0x02, 0x06, 0x00, 0x3E, 0x04, 0x10, 0x41, 0x82, 0x08, 0x20, 0xC1, 0xF8,
  0x08, 0x88, 0x42, 0x10, 0x84, 0x44, 0x10, 0x84, 0x22, 0x08, 0x41, 0x00,
  0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x80, 0x10, 0x40, 0x82, 0x08,
  0x41, 0x02, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x42, 0x00, 0x71, 0x89,
  0x86,
};

const GFXglyph RobotoCondensed_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 3, 4, 5, 2, -14 },
  { 10, 9, 13, 9, 1, -13 },
  { 25, 7, 17, 8, 1, -15 },
  { 40, 8, 13, 11, 2, -13 },
  { 53, 8, 13, 9, 1, -13 },
  { 66, 1, 4, 3, 2, -14 },
  { 67, 5, 18, 5, 1, -14 },
  { 79, 5, 18, 5, -1, -14 },
  { 91, 7, 7, 7, 1, -13 },
  { 98, 7, 9, 9, 1, -11 },
  { 106, 3, 4, 3, -1, -2 },
  { 108, 4, 1, 5, 0, -6 },
  { 109, 2, 2, 4, 0, -2 },
  { 110, 8, 14, 6, -1, -13 },
  { 124, 7, 13, 8, 1, -13 },
  { 136, 4, 13, 8, 2, -13 },
  { 143, 8, 13, 8, 0, -13 },
  { 156, 7, 13, 8, 1, -13 },
  { 168, 8, 13, 8, 0, -13 },
  { 181, 8, 13, 8, 1, -13 },
  { 194, 7, 13, 8, 1, -13 },
  { 206, 8, 13, 8, 1, -13 },
  { 219, 7, 13, 8, 1, -13 },
  { 231, 7, 13, 8, 1, -13 },
  { 243, 3, 10, 4, 0, -10 },
  { 247, 4, 12, 3, -1, -10 },
  { 253, 6, 8, 8, 1, -10 },
  { 259, 7, 4, 8, 1, -8 },
  { 263, 7, 8, 8, 0, -10 },
  { 270, 5, 13, 7, 2, -13 },
  { 279, 12, 17, 14, 1, -13 },
  { 305, 9, 13, 10, -1, -13 },
  { 320, 8, 13, 9, 1, -13 },
  { 333, 9, 13, 10, 1, -13 },
  { 348, 8, 13, 10, 1, -13 },
  { 361, 8, 13, 9, 1, -13 },
  { 374, 8, 13, 9, 1, -13 },
  { 387, 9, 13, 10, 1, -13 },
  { 402, 10, 13, 11, 1, -13 },
  { 419, 3, 13, 4, 1, -13 },
  { 424, 8, 13, 8, 0, -13 },
  { 437, 9, 13, 10, 1, -13 },
  { 452, 6, 13, 8, 1, -13 },
  { 462, 12, 13, 13, 1, -13 },
  { 482, 10, 13, 11, 1, -13 },
  { 499, 9, 13, 10, 1, -13 },
  { 514, 8, 13, 9, 1, -13 },
  { 527, 9, 15, 10, 1, -13 },
  { 544, 8, 13, 10, 1, -13 },
  { 557, 9, 13, 9, 0, -13 },
  { 572, 8, 13, 9, 2, -13 },
  { 585, 9, 13, 10, 1, -13 },
  { 600, 8, 13, 9, 2, -13 },
  { 613, 12, 13, 13, 2, -13 },
  { 633, 10, 13, 9, 0, -13 },
  { 650, 8, 13, 9, 2, -13 },
  { 663, 9, 13, 9, 0, -13 },
  { 678, 5, 18, 4, 0, -15 },
  { 690, 3, 14, 6, 2, -13 },
  { 696, 5, 18, 4, -1, -15 },
  { 708, 5, 6, 6, 1, -13 },
  { 712, 7, 1, 7, -1, 0 },
  { 713, 3, 2, 5, 2, -13 },
  { 714, 7, 10, 8, 0, -10 },
  { 723, 8, 14, 8, 0, -14 },
  { 737, 6, 10, 8, 1, -10 },
  { 745, 8, 14, 9, 1, -14 },
  { 759, 6, 10, 8, 1, -10 },
  { 767, 6, 14, 5, 1, -14 },
  { 778, 8, 14, 9, 0, -10 },
  { 792, 7, 14, 8, 0, -14 },
  { 805, 4, 13, 4, 0, -13 },
  { 812, 6, 17, 4, -2, -13 },
  { 825, 8, 14, 8, 0, -14 },
  { 839, 4, 14, 4, 0, -14 },
  { 846, 12, 10, 13, 0, -10 },
  { 861, 7, 10, 8, 0, -10 },
  { 870, 7, 10, 9, 1, -10 },
  { 879, 8, 14, 8, 0, -10 },
  { 893, 7, 14, 9, 1, -10 },
  { 906, 6, 10, 5, 0, -10 },
  { 914, 7, 10, 8, 0, -10 },
  { 923, 4, 12, 5, 1, -12 },
  { 929, 7, 10, 8, 1, -10 },
  { 938, 7, 10, 7, 1, -10 },
  { 947, 11, 10, 11, 1, -10 },
  { 961, 8, 10, 8, 0, -10 },
  { 971, 9, 14, 7, -1, -10 },
  { 987, 7, 10, 8, 0, -10 },
  { 996, 5, 18, 5, 1, -14 },
  { 1008, 4, 15, 4, 0, -13 },
  { 1016, 6, 18, 5, -1, -14 },
  { 1030, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC18PT7B_H_
