#ifndef _ROBOTOCONDENSED_LIGHTITALIC14PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x10, 0x6E, 0x80, 0x0A, 0x24, 0x51, 0xF2, 0x45,
  0x0A, 0x7E, 0x50, 0xA0, 0x11, 0xD3, 0x14, 0x30, 0x41, 0x8C, 0xB8, 0x80,
  0x61, 0x22, 0x54, 0xC7, 0x03, 0x8C, 0xA9, 0x52, 0x18, 0x18, 0x48, 0x91,
  0x41, 0x0E, 0x53, 0x46, 0x8C, 0xE8, 0x68, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x84, 0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x21, 0x3E, 0x45,
  0x48, 0x21, 0x09, 0xF2, 0x11, 0x00, 0x58, 0xE0, 0x80, 0x04, 0x10, 0x82,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x97,
  0x00, 0x74, 0x94, 0x92, 0x48, 0x38, 0x94, 0x41, 0x08, 0x21, 0x08, 0x43,
  0xE0, 0x18, 0x94, 0x41, 0x18, 0x20, 0x61, 0x49, 0xC0, 0x04, 0x31, 0x49,
  0x29, 0x2F, 0xC2, 0x08, 0x20, 0x3D, 0x04, 0x10, 0x70, 0x20, 0xA2, 0x91,
  0xC0, 0x1B, 0x11, 0xE8, 0xC6, 0x31, 0x93, 0x00, 0xFC, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x00, 0x1C, 0x94, 0x51, 0x39, 0x28, 0x61, 0x49, 0xC0,
  0x32, 0x63, 0x18, 0xC5, 0xE2, 0x17, 0x00, 0x40, 0x00, 0x20, 0x20, 0x00,
  0x12, 0x80, 0x1B, 0x20, 0xC1, 0x00, 0xF8, 0x01, 0xE0, 0x60, 0x40, 0xCC,
  0xC0, 0x74, 0x42, 0x22, 0x21, 0x00, 0x04, 0x00, 0x0F, 0x04, 0x22, 0x05,
  0x19, 0x49, 0x54, 0x99, 0x26, 0x49, 0x96, 0xA6, 0xC4, 0x01, 0x00, 0x3C,
  0x00, 0x08, 0x21, 0x45, 0x24, 0x97, 0xD1, 0x86, 0x10, 0x3C, 0x44, 0x8A,
  0x17, 0xC8, 0x91, 0x22, 0x44, 0xF0, 0x3D, 0x14, 0x60, 0x82, 0x08, 0x21,
  0x89, 0xC0, 0x3C, 0x44, 0x8A, 0x14, 0x28, 0x50, 0xA1, 0x44, 0xF0, 0x3E,
  0x40, 0x82, 0x07, 0xC8, 0x10, 0x20, 0x40, 0xF8, 0x3E, 0x40, 0x82, 0x07,
  0xC8, 0x10, 0x20, 0x41, 0x00, 0x3C, 0x89, 0x0C, 0x08, 0x13, 0xA1, 0x42,
  0x84, 0xF0, 0x21, 0x21, 0x21, 0x41, 0x7E, 0x42, 0x42, 0x42, 0x42, 0x82,
  0x55, 0xAA, 0xA0, 0x04, 0x10, 0x41, 0x04, 0x10, 0xA2, 0x89, 0xC0, 0x22,
  0x22, 0x24, 0x48, 0x50, 0x70, 0x48, 0x48, 0x44, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x08, 0x43, 0xC0, 0x20, 0x48, 0x33, 0x0D, 0x45, 0x51, 0x94, 0xA5,
  0x29, 0x32, 0x48, 0xA2, 0x40, 0x21, 0x21, 0x31, 0x51, 0x49, 0x4A, 0x4A,
  0x46, 0x46, 0x82, 0x38, 0x8A, 0x0C, 0x18, 0x50, 0xA1, 0x42, 0x88, 0xE0,
  0x3C, 0x44, 0x8A, 0x14, 0x2F, 0x90, 0x20, 0x41, 0x00, 0x38, 0x8A, 0x0C,
  0x18, 0x50, 0xA1, 0x42, 0x88, 0xE0, 0x20, 0x40, 0x3C, 0x44, 0x8A, 0x14,
  0x2F, 0x92, 0x22, 0x45, 0x08, 0x1C, 0x45, 0x0A, 0x03, 0x01, 0x81, 0x42,
  0x44, 0xF0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x80, 0x42,
  0x86, 0x14, 0x28, 0x50, 0xA1, 0x42, 0x88, 0xE0, 0x83, 0x0A, 0x12, 0x44,
  0x89, 0x14, 0x28, 0x60, 0x40, 0x84, 0x63, 0x18, 0xCA, 0x52, 0x95, 0x15,
  0x46, 0x51, 0x98, 0x42, 0x10, 0x80, 0x22, 0x22, 0x24, 0x18, 0x18, 0x10,
  0x28, 0x48, 0x44, 0x84, 0x82, 0x89, 0x22, 0x45, 0x04, 0x08, 0x10, 0x20,
  0x80, 0x3E, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0xF8, 0x32, 0x24,
  0x44, 0x44, 0x48, 0x88, 0xC0, 0x91, 0x24, 0x92, 0x44, 0x80, 0x31, 0x11,
  0x12, 0x22, 0x22, 0x24, 0xC0, 0x26, 0x6A, 0x90, 0xF8, 0xA0, 0x39, 0x10,
  0x4E, 0x4A, 0x28, 0x9E, 0x20, 0x82, 0x1E, 0x45, 0x14, 0x51, 0x85, 0x2B,
  0x00, 0x39, 0x14, 0x50, 0x82, 0x04, 0x9C, 0x04, 0x10, 0x9E, 0x8A, 0x28,
  0xA2, 0x92, 0x4F, 0x00, 0x39, 0x14, 0x5F, 0x82, 0x04, 0x1C, 0x34, 0x4E,
  0x44, 0x88, 0x88, 0x80, 0x3D, 0x14, 0x51, 0x8A, 0x24, 0x9E, 0x0A, 0x27,
  0x00, 0x20, 0x82, 0x16, 0x65, 0x14, 0x51, 0x4A, 0x28, 0x80, 0x20, 0x24,
  0x92, 0x52, 0x00, 0x08, 0x00, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x60,
  0x20, 0x82, 0x11, 0x49, 0x46, 0x14, 0x52, 0x48, 0x80, 0x24, 0xA4, 0x92,
  0x52, 0x00, 0x7B, 0x91, 0x14, 0x45, 0x11, 0x44, 0x92, 0x28, 0x8A, 0x22,
  0x59, 0x94, 0x51, 0x45, 0x28, 0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x79,
  0x14, 0x51, 0x46, 0x14, 0xAC, 0x82, 0x08, 0x00, 0x7C, 0x63, 0x19, 0x4A,
  0x5E, 0x10, 0x84, 0x74, 0x44, 0x44, 0x88, 0x39, 0x14, 0x08, 0x10, 0x28,
  0x9C, 0x5D, 0x29, 0x24, 0xC0, 0x8C, 0x63, 0x18, 0xCA, 0x5E, 0x8C, 0xA5,
  0x2A, 0x51, 0x08, 0x91, 0x92, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0x88, 0x45,
  0x23, 0x0C, 0x21, 0x45, 0x22, 0x22, 0x48, 0x91, 0x22, 0x85, 0x04, 0x08,
  0x20, 0x43, 0x00, 0x7C, 0x21, 0x04, 0x21, 0x04, 0x3E, 0x08, 0x88, 0x42,
  0x13, 0x08, 0x42, 0x10, 0x84, 0x10, 0x24, 0xA4, 0x92, 0x52, 0x40, 0x20,
  0x84, 0x21, 0x08, 0x22, 0x21, 0x08, 0x44, 0x40, 0x66, 0x59, 0x80,
};

const GFXglyph RobotoCondensed_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 3, 4, 1, -11 },
  { 7, 7, 10, 7, 0, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 7, 10, 9, 1, -10 },
  { 33, 7, 10, 7, 0, -10 },
  { 42, 2, 3, 2, 1, -11 },
  { 43, 4, 14, 4, 1, -11 },
  { 50, 4, 14, 4, -1, -11 },
  { 57, 5, 6, 6, 1, -10 },
  { 61, 5, 7, 7, 1, -8 },
  { 66, 2, 3, 3, -1, -1 },
  { 67, 3, 1, 4, 0, -5 },
  { 68, 2, 1, 3, 0, -1 },
  { 69, 6, 11, 5, -1, -10 },
  { 78, 5, 10, 7, 1, -10 },
  { 85, 3, 10, 7, 2, -10 },
  { 89, 6, 10, 7, 0, -10 },
  { 97, 6, 10, 7, 0, -10 },
  { 105, 6, 10, 7, 0, -10 },
  { 113, 6, 10, 7, 1, -10 },
  { 121, 5, 10, 7, 1, -10 },
  { 128, 6, 10, 7, 1, -10 },
  { 136, 6, 10, 7, 0, -10 },
  { 144, 5, 10, 7, 1, -10 },
  { 151, 3, 7, 3, 0, -7 },
  { 154, 3, 9, 3, -1, -7 },
  { 158, 5, 5, 6, 1, -7 },
  { 162, 5, 4, 7, 1, -7 },
  { 165, 6, 5, 6, 0, -7 },
  { 169, 5, 10, 5, 1, -10 },
  { 176, 10, 13, 11, 0, -10 },
  { 193, 6, 10, 7, 0, -10 },
  { 201, 7, 10, 7, 0, -10 },
  { 210, 6, 10, 8, 1, -10 },
  { 218, 7, 10, 8, 0, -10 },
  { 227, 7, 10, 7, 0, -10 },
  { 236, 7, 10, 7, 0, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 8, 10, 8, 0, -10 },
  { 264, 2, 10, 3, 1, -10 },
  { 267, 6, 10, 7, 0, -10 },
  { 275, 8, 10, 7, 0, -10 },
  { 285, 5, 10, 6, 0, -10 },
  { 292, 10, 10, 10, 0, -10 },
  { 305, 8, 10, 8, 0, -10 },
  { 315, 7, 10, 8, 1, -10 },
  { 324, 7, 10, 7, 0, -10 },
  { 333, 7, 12, 8, 1, -10 },
  { 344, 7, 10, 7, 0, -10 },
  { 353, 7, 10, 7, 0, -10 },
  { 362, 7, 10, 7, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 7, 10, 7, 1, -10 },
  { 389, 10, 10, 10, 1, -10 },
  { 402, 8, 10, 7, 0, -10 },
  { 412, 7, 10, 7, 1, -10 },
  { 421, 7, 10, 7, 0, -10 },
  { 430, 4, 13, 3, 0, -11 },
  { 437, 3, 11, 5, 1, -10 },
  { 442, 4, 13, 3, -1, -11 },
  { 449, 4, 5, 5, 1, -10 },
  { 452, 5, 1, 5, -1, 0 },
  { 453, 2, 2, 4, 2, -11 },
  { 454, 6, 8, 6, 0, -8 },
  { 460, 6, 11, 7, 0, -11 },
  { 469, 6, 8, 6, 0, -8 },
  { 475, 6, 11, 7, 1, -11 },
  { 484, 6, 8, 6, 0, -8 },
  { 490, 4, 11, 4, 1, -11 },
  { 496, 6, 11, 7, 0, -8 },
  { 505, 6, 11, 7, 0, -11 },
  { 514, 3, 11, 3, 0, -11 },
  { 519, 5, 14, 3, -2, -11 },
  { 528, 6, 11, 6, 0, -11 },
  { 537, 3, 11, 3, 0, -11 },
  { 542, 10, 8, 10, 0, -8 },
  { 552, 6, 8, 7, 0, -8 },
  { 558, 5, 8, 7, 1, -8 },
  { 563, 6, 11, 7, 0, -8 },
  { 572, 5, 11, 7, 1, -8 },
  { 579, 4, 8, 4, 0, -8 },
  { 583, 6, 8, 6, 0, -8 },
  { 589, 3, 9, 4, 1, -9 },
  { 593, 5, 8, 7, 1, -8 },
  { 598, 5, 8, 6, 1, -8 },
  { 603, 8, 8, 9, 1, -8 },
  { 611, 6, 8, 6, 0, -8 },
  { 617, 7, 11, 6, -1, -8 },
  { 627, 6, 8, 6, 0, -8 },
  { 633, 5, 14, 4, 0, -11 },
  { 642, 3, 12, 3, 0, -10 },
  { 647, 5, 14, 4, -1, -11 },
  { 656, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC14PT7B_H_
