#ifndef _ROBOTOCONDENSED_LIGHTITALIC25PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x26, 0x64, 0x44, 0x40, 0x00, 0x88, 0xD9, 0x99,
  0x9B, 0x02, 0x30, 0x22, 0x02, 0x20, 0x46, 0x04, 0x43, 0xFF, 0x08, 0xC0,
  0x88, 0x08, 0x81, 0x18, 0x11, 0x01, 0x10, 0xFF, 0xC2, 0x20, 0x22, 0x06,
  0x20, 0x44, 0x04, 0x40, 0x01, 0x00, 0x80, 0xF8, 0x66, 0x30, 0xC8, 0x12,
  0x04, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0x60, 0x0A, 0x02,
  0x81, 0xB0, 0x46, 0x70, 0xF0, 0x10, 0x04, 0x00, 0x38, 0x06, 0x40, 0x44,
  0x2C, 0x46, 0x84, 0x4C, 0x48, 0x49, 0x07, 0x90, 0x02, 0x00, 0x40, 0x0C,
  0xE0, 0x92, 0x12, 0x13, 0x21, 0x22, 0x14, 0x22, 0x02, 0x20, 0x1C, 0x07,
  0x03, 0xB0, 0x42, 0x08, 0x41, 0x08, 0x22, 0x04, 0xC0, 0xE0, 0x18, 0x07,
  0x81, 0x90, 0xE3, 0x38, 0x25, 0x07, 0xA0, 0x66, 0x0C, 0x67, 0xC7, 0x88,
  0x49, 0x2C, 0x02, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x20, 0xC1, 0x02,
  0x04, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20,
  0x20, 0x10, 0x10, 0x30, 0x20, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x06, 0x08, 0x30, 0xC1, 0x00,
  0x06, 0x01, 0x00, 0x41, 0x13, 0x7F, 0x83, 0x01, 0xC0, 0xC8, 0x62, 0x10,
  0x40, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x25, 0xB5, 0x00, 0xF8, 0xE0, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x00, 0x0F, 0x06, 0x63, 0x0C, 0x81, 0x20, 0x58, 0x14, 0x05,
  0x01, 0x40, 0xD0, 0x3C, 0x0B, 0x02, 0xC0, 0xB0, 0x6C, 0x11, 0x0C, 0x66,
  0x0F, 0x00, 0x04, 0xFE, 0xE2, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x10,
  0xC3, 0x08, 0x20, 0x80, 0x07, 0x81, 0x98, 0x61, 0x98, 0x13, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x00, 0x60, 0x1F, 0xF8, 0x0F, 0x06, 0x63, 0x0C, 0x81, 0x60, 0x40,
  0x30, 0x08, 0x0C, 0x1E, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xA0, 0x68, 0x1B,
  0x04, 0x66, 0x0F, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x00, 0xA0, 0x24, 0x0C,
  0x81, 0x30, 0x46, 0x18, 0x86, 0x10, 0x82, 0x20, 0xCF, 0xFE, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0F, 0xE3, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0B, 0xC1, 0xDC, 0x21, 0x80, 0x10, 0x02, 0x00, 0x40, 0x09, 0x81,
  0x10, 0x62, 0x08, 0x63, 0x07, 0xC0, 0x03, 0x83, 0x06, 0x02, 0x03, 0x01,
  0x01, 0xBC, 0xA3, 0x60, 0xA0, 0x50, 0x38, 0x1C, 0x0E, 0x05, 0x06, 0x82,
  0x66, 0x1E, 0x00, 0x7F, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x00, 0x0F, 0x06, 0x73, 0x0C, 0x81, 0x20, 0x48, 0x12, 0x0C, 0xE6,
  0x1E, 0x18, 0x44, 0x1B, 0x02, 0x80, 0xA0, 0x28, 0x1B, 0x04, 0x66, 0x0F,
  0x00, 0x1E, 0x19, 0x98, 0x48, 0x3C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xE1,
  0x99, 0xC7, 0x20, 0x30, 0x10, 0x18, 0x18, 0x38, 0x70, 0x00, 0x13, 0x00,
  0x00, 0x00, 0x00, 0x04, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x42, 0x11, 0x88, 0x80, 0x00, 0x81, 0xC3, 0x87, 0x0E, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x40, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x00,
  0x3C, 0x66, 0x43, 0xC3, 0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0xF8, 0x01, 0x87, 0x01, 0x00,
  0xC1, 0x00, 0x21, 0x00, 0x11, 0x87, 0x04, 0x84, 0x42, 0xC4, 0x21, 0x46,
  0x10, 0xA2, 0x08, 0x71, 0x08, 0x70, 0x84, 0x28, 0xC2, 0x14, 0x43, 0x0A,
  0x31, 0x89, 0x19, 0x4C, 0x87, 0x3C, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x86, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x16, 0x01, 0x60, 0x32, 0x02, 0x20, 0x62, 0x04, 0x20, 0xC2, 0x08, 0x21,
  0x83, 0x1F, 0xF3, 0x01, 0x20, 0x16, 0x01, 0x40, 0x1C, 0x01, 0x1F, 0x82,
  0x18, 0xC1, 0x98, 0x12, 0x02, 0x40, 0xC8, 0x19, 0x0E, 0x7F, 0x8C, 0x19,
  0x01, 0x20, 0x24, 0x04, 0x80, 0xB0, 0x36, 0x04, 0x83, 0x9F, 0xC0, 0x07,
  0xC0, 0xC6, 0x18, 0x33, 0x01, 0x20, 0x12, 0x01, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x24, 0x06, 0x40, 0x46, 0x0C, 0x31,
  0x81, 0xE0, 0x1F, 0x81, 0x0C, 0x30, 0x63, 0x03, 0x20, 0x32, 0x03, 0x20,
  0x32, 0x03, 0x60, 0x36, 0x02, 0x40, 0x24, 0x02, 0x40, 0x64, 0x06, 0xC0,
  0xCC, 0x18, 0x83, 0x0F, 0xE0, 0x1F, 0xF1, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x7F, 0x86, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x07, 0xF8, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x81, 0x8C, 0x30, 0x66, 0x02, 0x40, 0x24, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x87, 0xE8, 0x04, 0x80, 0x48, 0x04, 0x80, 0xCC, 0x0C, 0x63,
  0x83, 0xE0, 0x10, 0x0C, 0x40, 0x23, 0x00, 0x8C, 0x02, 0x20, 0x08, 0x80,
  0x62, 0x01, 0x88, 0x04, 0x7F, 0xF1, 0x80, 0x44, 0x03, 0x10, 0x0C, 0x40,
  0x31, 0x00, 0x8C, 0x02, 0x30, 0x08, 0x80, 0x62, 0x01, 0x80, 0x11, 0x11,
  0x33, 0x22, 0x26, 0x66, 0x44, 0x4C, 0xC8, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x8C, 0x08, 0x41, 0x84, 0x10, 0x67, 0x03, 0xE0, 0x10, 0x18,
  0x81, 0x8C, 0x18, 0x61, 0x82, 0x18, 0x11, 0x80, 0x98, 0x05, 0x80, 0x6C,
  0x03, 0xA0, 0x19, 0x80, 0x84, 0x04, 0x30, 0x20, 0x83, 0x06, 0x18, 0x10,
  0x80, 0xC4, 0x02, 0x00, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0xFF, 0x18, 0x01,
  0x8C, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE2, 0x80, 0x51, 0x60, 0x68, 0xB0,
  0x2C, 0x48, 0x36, 0x64, 0x12, 0x32, 0x19, 0x11, 0x08, 0x88, 0x8C, 0x44,
  0x64, 0x62, 0x16, 0x33, 0x0A, 0x11, 0x87, 0x08, 0x83, 0x04, 0x41, 0x82,
  0x00, 0x10, 0x0C, 0x60, 0x23, 0x80, 0x8E, 0x02, 0x2C, 0x08, 0x90, 0x62,
  0x61, 0x88, 0x84, 0x62, 0x11, 0x8C, 0x44, 0x11, 0x10, 0x4C, 0x41, 0xB1,
  0x02, 0x8C, 0x0A, 0x30, 0x38, 0x80, 0x62, 0x01, 0x80, 0x07, 0xC0, 0xC6,
  0x18, 0x33, 0x01, 0x20, 0x16, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x3C, 0x03, 0xC0, 0x24, 0x02, 0x40, 0x66, 0x0C, 0x33, 0x81, 0xF0,
  0x1F, 0xC1, 0x06, 0x30, 0x23, 0x03, 0x20, 0x32, 0x03, 0x20, 0x32, 0x02,
  0x60, 0x66, 0x0C, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x33, 0x01, 0x20, 0x16, 0x01,
  0x60, 0x14, 0x01, 0x40, 0x14, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x2C, 0x02,
  0x40, 0x66, 0x0C, 0x33, 0x81, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x1F,
  0x81, 0x0E, 0x30, 0x23, 0x03, 0x20, 0x32, 0x03, 0x20, 0x22, 0x02, 0x60,
  0x66, 0x1C, 0x7F, 0x04, 0x10, 0x41, 0x04, 0x18, 0xC0, 0x8C, 0x08, 0x80,
  0xC8, 0x0C, 0x07, 0x81, 0xCC, 0x30, 0x62, 0x02, 0x20, 0x22, 0x00, 0x20,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x48, 0x04, 0x80,
  0xCC, 0x08, 0x63, 0x83, 0xE0, 0xFF, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x10, 0x19, 0x80, 0xCC,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x4C, 0x06, 0x60, 0x31, 0x01, 0x08, 0x18, 0x73, 0x81,
  0xF8, 0x00, 0xC0, 0x3C, 0x03, 0x40, 0x24, 0x06, 0x40, 0x44, 0x0C, 0x60,
  0x86, 0x18, 0x61, 0x02, 0x10, 0x23, 0x02, 0x20, 0x26, 0x02, 0x40, 0x3C,
  0x03, 0x80, 0x18, 0x01, 0x00, 0x40, 0xC0, 0x90, 0x30, 0x24, 0x1C, 0x19,
  0x05, 0x04, 0x41, 0x41, 0x10, 0xD0, 0xC4, 0x24, 0x21, 0x19, 0x08, 0x44,
  0x46, 0x11, 0x11, 0x04, 0xC4, 0x41, 0x21, 0xB0, 0x48, 0x68, 0x14, 0x0E,
  0x05, 0x03, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x00, 0x10, 0x08,
  0x60, 0x60, 0x83, 0x02, 0x08, 0x0C, 0x60, 0x13, 0x00, 0x68, 0x01, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x50, 0x03, 0x60, 0x19, 0x80, 0x42, 0x03, 0x0C,
  0x18, 0x10, 0x40, 0x43, 0x01, 0x80, 0xC0, 0x34, 0x06, 0x40, 0x46, 0x0C,
  0x20, 0x82, 0x18, 0x33, 0x03, 0x20, 0x16, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x1F, 0xF8, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x07, 0xFE, 0x00, 0x0E, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60,
  0xC1, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x78,
  0x92, 0x49, 0xB2, 0x49, 0x24, 0xD9, 0x24, 0x90, 0x0F, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x70, 0x0C, 0x18, 0x70, 0xA3,
  0x44, 0xD8, 0xA1, 0xC2, 0xFF, 0x80, 0xCC, 0x80, 0x1F, 0x19, 0xD8, 0x68,
  0x10, 0x19, 0xFD, 0x85, 0x82, 0x81, 0x41, 0xA0, 0xD9, 0xE7, 0xB0, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x05, 0xE1, 0xE6, 0x30, 0x44,
  0x0C, 0x81, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x12, 0x06, 0x60, 0x8A, 0x71,
  0x7C, 0x00, 0x1F, 0x18, 0x98, 0x28, 0x1C, 0x0E, 0x02, 0x01, 0x00, 0x80,
  0x40, 0xB0, 0xCC, 0xC3, 0xC0, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x87, 0x91, 0x9E, 0x60, 0xC8, 0x13, 0x02, 0x60, 0x4C, 0x09, 0x03,
  0x20, 0x64, 0x08, 0xC1, 0x0C, 0xE0, 0xF4, 0x00, 0x1E, 0x18, 0x98, 0x68,
  0x1C, 0x0C, 0x07, 0xFF, 0x00, 0x80, 0x40, 0x30, 0x0C, 0xE3, 0xC0, 0x07,
  0x0C, 0x18, 0x10, 0x10, 0x10, 0x7C, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x0F, 0x23, 0x3C, 0xC1, 0x90, 0x22,
  0x04, 0xC0, 0x98, 0x12, 0x06, 0x40, 0xC8, 0x11, 0x86, 0x19, 0xC3, 0xE8,
  0x03, 0x00, 0x40, 0x08, 0xE6, 0x07, 0x80, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x78, 0xF3, 0x30, 0x4C, 0x12, 0x04, 0x81, 0x20, 0xD8,
  0x36, 0x09, 0x02, 0x40, 0x90, 0x24, 0x18, 0x13, 0x00, 0x02, 0x26, 0x64,
  0x44, 0x4C, 0xC8, 0x88, 0x03, 0x03, 0x00, 0x00, 0x00, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x30, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x11, 0x84, 0x31, 0x04, 0x40, 0x90, 0x14, 0x03, 0xC0, 0xC8, 0x19, 0x82,
  0x10, 0x43, 0x08, 0x21, 0x06, 0x00, 0x11, 0x33, 0x22, 0x22, 0x66, 0x44,
  0x44, 0xCC, 0x88, 0x80, 0x17, 0x8F, 0x1E, 0x6C, 0xCC, 0x18, 0x66, 0x0C,
  0x12, 0x04, 0x09, 0x02, 0x0C, 0x83, 0x06, 0xC1, 0x83, 0x60, 0x81, 0x20,
  0x40, 0x90, 0x20, 0x48, 0x10, 0x64, 0x18, 0x30, 0x17, 0x8F, 0x33, 0x04,
  0xC1, 0x20, 0x48, 0x12, 0x0D, 0x83, 0x60, 0x90, 0x24, 0x09, 0x02, 0x41,
  0x80, 0x1F, 0x0C, 0x66, 0x09, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x02, 0x80,
  0xA0, 0x6C, 0x11, 0x98, 0x3C, 0x00, 0x17, 0x87, 0x98, 0xC1, 0x18, 0x32,
  0x06, 0x40, 0xC8, 0x13, 0x02, 0x60, 0x48, 0x19, 0x82, 0x39, 0xC5, 0xF1,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1E, 0x4C, 0xF6, 0x0D, 0x02,
  0xC0, 0xB0, 0x2C, 0x0A, 0x06, 0x81, 0xA0, 0x4C, 0x11, 0x9C, 0x39, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x17, 0x3D, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x1E, 0x19, 0x98, 0x68, 0x36,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x41, 0xA0, 0xD8, 0xC7, 0xC0, 0x10, 0x41,
  0x0C, 0xFC, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x18, 0x70, 0x20,
  0x58, 0x36, 0x0D, 0x02, 0x40, 0x90, 0x24, 0x1B, 0x06, 0xC1, 0x30, 0x4C,
  0x31, 0x9C, 0x7B, 0x00, 0x81, 0x41, 0xA0, 0x90, 0x48, 0x66, 0x21, 0x30,
  0x90, 0x58, 0x28, 0x1C, 0x0C, 0x06, 0x00, 0x83, 0x0E, 0x0C, 0x28, 0x70,
  0xA1, 0x46, 0x8D, 0x12, 0x24, 0xCD, 0x92, 0x34, 0x48, 0xD1, 0x43, 0x85,
  0x06, 0x1C, 0x10, 0x60, 0x41, 0x80, 0x10, 0x61, 0x84, 0x08, 0xC0, 0xD8,
  0x05, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0B, 0x01, 0x90, 0x31, 0x82, 0x18,
  0x60, 0x80, 0x10, 0x21, 0x06, 0x10, 0x41, 0x04, 0x18, 0xC1, 0x88, 0x19,
  0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x0E, 0x00, 0x3F, 0xC0, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x00, 0xFF, 0x00, 0x02, 0x06,
  0x0C, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x60, 0xC0, 0x40,
  0x60, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x60, 0x20, 0x10, 0x08,
  0xC6, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11, 0x8C, 0x42, 0x10, 0x8C,
  0x00, 0x10, 0x10, 0x30, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x30,
  0x61, 0x86, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x10, 0x40, 0x38, 0x16,
  0xC1, 0x46, 0x24, 0x36, 0xC1, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 5, 1, -18 },
  { 10, 4, 6, 7, 3, -19 },
  { 13, 12, 18, 12, 1, -18 },
  { 40, 10, 22, 12, 1, -20 },
  { 68, 12, 18, 16, 2, -18 },
  { 95, 11, 18, 13, 1, -18 },
  { 120, 3, 5, 4, 2, -19 },
  { 122, 7, 26, 7, 1, -20 },
  { 145, 7, 26, 7, -1, -20 },
  { 168, 10, 10, 10, 1, -18 },
  { 181, 10, 13, 12, 1, -15 },
  { 198, 3, 6, 5, -1, -2 },
  { 201, 5, 1, 6, 1, -8 },
  { 202, 2, 2, 6, 1, -2 },
  { 203, 11, 20, 9, -1, -18 },
  { 231, 10, 18, 12, 1, -18 },
  { 254, 6, 18, 12, 3, -18 },
  { 268, 11, 18, 12, 0, -18 },
  { 293, 10, 18, 12, 1, -18 },
  { 316, 11, 18, 12, 0, -18 },
  { 341, 11, 18, 12, 1, -18 },
  { 366, 9, 18, 12, 1, -18 },
  { 387, 10, 18, 12, 2, -18 },
  { 410, 10, 18, 12, 1, -18 },
  { 433, 9, 18, 12, 2, -18 },
  { 454, 4, 13, 5, 0, -13 },
  { 461, 5, 17, 5, -1, -13 },
  { 472, 9, 10, 11, 1, -13 },
  { 484, 10, 6, 12, 1, -11 },
  { 492, 9, 10, 11, 1, -13 },
  { 504, 8, 18, 10, 2, -18 },
  { 522, 17, 23, 19, 1, -17 },
  { 571, 12, 18, 13, -1, -18 },
  { 598, 11, 18, 13, 1, -18 },
  { 623, 12, 18, 14, 1, -18 },
  { 650, 12, 18, 14, 1, -18 },
  { 677, 12, 18, 12, 1, -18 },
  { 704, 12, 18, 12, 1, -18 },
  { 731, 12, 18, 14, 2, -18 },
  { 758, 14, 18, 15, 1, -18 },
  { 790, 4, 18, 6, 1, -18 },
  { 799, 12, 18, 12, 0, -18 },
  { 826, 13, 18, 13, 1, -18 },
  { 856, 8, 18, 11, 1, -18 },
  { 874, 17, 18, 18, 1, -18 },
  { 913, 14, 18, 15, 1, -18 },
  { 945, 12, 18, 14, 1, -18 },
  { 972, 12, 18, 13, 1, -18 },
  { 999, 12, 21, 14, 1, -18 },
  { 1031, 12, 18, 13, 1, -18 },
  { 1058, 12, 18, 13, 1, -18 },
  { 1085, 12, 18, 13, 2, -18 },
  { 1112, 13, 18, 14, 1, -18 },
  { 1142, 12, 18, 13, 2, -18 },
  { 1169, 18, 18, 19, 2, -18 },
  { 1210, 14, 18, 13, 0, -18 },
  { 1242, 12, 18, 13, 2, -18 },
  { 1269, 13, 18, 13, 0, -18 },
  { 1299, 7, 24, 5, 0, -20 },
  { 1320, 3, 20, 9, 3, -18 },
  { 1328, 8, 24, 5, -2, -20 },
  { 1352, 7, 9, 9, 1, -18 },
  { 1360, 9, 1, 9, -1, 0 },
  { 1362, 3, 3, 7, 3, -18 },
  { 1364, 9, 13, 11, 1, -13 },
  { 1379, 11, 19, 12, 0, -19 },
  { 1406, 9, 13, 11, 1, -13 },
  { 1421, 11, 19, 12, 1, -19 },
  { 1448, 9, 13, 11, 1, -13 },
  { 1463, 8, 19, 7, 1, -19 },
  { 1482, 11, 18, 12, 0, -13 },
  { 1507, 10, 19, 12, 0, -19 },
  { 1531, 4, 18, 5, 1, -18 },
  { 1540, 8, 23, 5, -3, -18 },
  { 1563, 11, 19, 11, 0, -19 },
  { 1590, 4, 19, 5, 1, -19 },
  { 1600, 17, 13, 19, 0, -13 },
  { 1628, 10, 13, 12, 0, -13 },
  { 1645, 10, 13, 12, 1, -13 },
  { 1662, 11, 18, 12, 0, -13 },
  { 1687, 10, 18, 12, 1, -13 },
  { 1710, 8, 13, 7, 0, -13 },
  { 1723, 9, 13, 11, 1, -13 },
  { 1738, 6, 17, 7, 1, -17 },
  { 1751, 10, 13, 12, 1, -13 },
  { 1768, 9, 13, 10, 2, -13 },
  { 1783, 14, 13, 16, 2, -13 },
  { 1806, 12, 13, 10, -1, -13 },
  { 1826, 12, 18, 10, -1, -13 },
  { 1853, 10, 13, 10, 0, -13 },
  { 1870, 8, 25, 7, 1, -20 },
  { 1895, 5, 21, 5, 0, -18 },
  { 1909, 7, 24, 7, -1, -19 },
  { 1930, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC25PT7B_H_
