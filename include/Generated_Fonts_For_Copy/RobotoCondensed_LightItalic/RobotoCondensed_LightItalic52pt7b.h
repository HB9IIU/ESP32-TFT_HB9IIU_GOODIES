#ifndef _ROBOTOCONDENSED_LIGHTITALIC52PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0xC7, 0x18, 0xC3, 0x18, 0x63, 0x1C, 0xE3, 0x9C, 0x63, 0x0C,
  0x61, 0x8C, 0x31, 0x8E, 0x71, 0x80, 0x00, 0x07, 0x03, 0x00, 0x03, 0x03,
  0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0x70, 0x00, 0x70, 0x30, 0x00, 0x30, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x0C, 0x0E, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03,
  0x01, 0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x70, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x70, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01,
  0xE1, 0xF0, 0x1E, 0x03, 0x81, 0xE0, 0x1E, 0x0E, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0x8E, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0F, 0x00, 0xF0, 0x3E,
  0x3F, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x70,
  0x70, 0x00, 0x60, 0x30, 0x08, 0xE0, 0x30, 0x1C, 0xE0, 0x30, 0x18, 0xC0,
  0x30, 0x38, 0xC0, 0x30, 0x70, 0xC0, 0x30, 0x60, 0xC0, 0x70, 0xE0, 0xC0,
  0x61, 0xC0, 0xE0, 0xE1, 0x80, 0x60, 0xC3, 0x00, 0x7F, 0xC7, 0x00, 0x3F,
  0x86, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x20, 0x00, 0xE1, 0xF8, 0x00, 0xC3, 0xFC, 0x01,
  0xC7, 0x0E, 0x03, 0x86, 0x06, 0x03, 0x0E, 0x06, 0x07, 0x0C, 0x07, 0x0E,
  0x0C, 0x07, 0x0C, 0x0C, 0x07, 0x1C, 0x1C, 0x06, 0x38, 0x1C, 0x06, 0x30,
  0x1C, 0x06, 0x70, 0x0C, 0x0E, 0x20, 0x0C, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0,
  0x00, 0xE3, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x03, 0xC7, 0x01, 0xC7,
  0x0E, 0x03, 0x1C, 0x0E, 0x06, 0x70, 0x1C, 0x1C, 0xE0, 0x1C, 0x3B, 0x80,
  0x38, 0x67, 0x00, 0x39, 0xCE, 0x00, 0x7B, 0x9C, 0x00, 0x7E, 0x38, 0x00,
  0xFC, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0xC1, 0xC0, 0x1F,
  0xC1, 0xE0, 0xFB, 0x83, 0xFF, 0xC3, 0x81, 0xFE, 0x07, 0x00, 0x20, 0x00,
  0x00, 0x33, 0x77, 0x76, 0x6E, 0xEC, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x40,
  0x70, 0x17, 0x07, 0x0F, 0xFE, 0x63, 0xF3, 0xFF, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x38, 0x00, 0xE3, 0x80,
  0x1E, 0x1C, 0x03, 0xC1, 0xC0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x8F, 0x1C, 0x78, 0xE3, 0x82, 0x00, 0x7F,
  0xEF, 0xFF, 0xFF, 0x80, 0x77, 0xBF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3C, 0x3C, 0x07, 0x00, 0xE0, 0xE0,
  0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38,
  0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xCE, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x70,
  0x1E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x0F, 0x07, 0xE1, 0xFE, 0xFE, 0xEF, 0x8E, 0xC0, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x3C, 0x03, 0xC0, 0x78, 0x0E, 0x00,
  0xE0, 0x70, 0x03, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x70, 0x00, 0x63,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1E, 0x01,
  0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0, 0xE0, 0x0E,
  0x03, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x33, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x70, 0x07,
  0x81, 0xE0, 0x3C, 0x03, 0xC3, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x71, 0xF8,
  0x0C, 0xFF, 0xC3, 0xBF, 0xF8, 0x7E, 0x07, 0x8F, 0x80, 0x79, 0xE0, 0x07,
  0x78, 0x00, 0xEF, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x70, 0x07, 0x0F, 0x01, 0xC0,
  0xF0, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x7C, 0x03,
  0x80, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x07, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0xC0, 0x0E, 0x07, 0x00, 0x70,
  0x0F, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xC7, 0xC1, 0xE0, 0x38,
  0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x00, 0xCE, 0x00, 0x1D,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xE7,
  0x00, 0x7C, 0xE0, 0x1F, 0x1E, 0x07, 0x61, 0xFF, 0xDC, 0x1F, 0xF3, 0x80,
  0xF8, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3F,
  0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x0F, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0, 0x40, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xE3, 0xC3, 0xC0, 0xF1, 0xC0, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x1F, 0x00, 0x30,
  0xE0, 0x0F, 0xF0, 0x06, 0x18, 0x03, 0xCF, 0x80, 0xC7, 0x00, 0xE0, 0x70,
  0x18, 0xE0, 0x38, 0x0E, 0x03, 0x18, 0x0E, 0x01, 0x80, 0x67, 0x01, 0xC0,
  0x30, 0x0C, 0xC0, 0x70, 0x06, 0x01, 0x98, 0x0E, 0x01, 0xC0, 0x37, 0x01,
  0x80, 0x30, 0x06, 0xC0, 0x70, 0x06, 0x01, 0xD8, 0x0E, 0x00, 0xC0, 0x33,
  0x01, 0x80, 0x38, 0x06, 0xE0, 0x30, 0x07, 0x00, 0xDC, 0x0E, 0x00, 0xC0,
  0x1B, 0x01, 0xC0, 0x18, 0x07, 0x60, 0x38, 0x07, 0x00, 0xCC, 0x06, 0x00,
  0xE0, 0x19, 0x80, 0xC0, 0x38, 0x07, 0x30, 0x18, 0x07, 0x00, 0xC6, 0x03,
  0x81, 0xE0, 0x38, 0xC0, 0x70, 0x7E, 0x06, 0x18, 0x0F, 0x1D, 0xC1, 0x83,
  0x00, 0xFF, 0x1F, 0xE0, 0x60, 0x0F, 0xC1, 0xF8, 0x0E, 0x00, 0x40, 0x08,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0x00, 0x3C, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1C,
  0x01, 0xF0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x60,
  0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x3C, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x03, 0xE1, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0x70, 0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x3C, 0x00, 0xE0, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x7F,
  0xE3, 0x80, 0x3F, 0xF1, 0xC0, 0x3F, 0xF8, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x03, 0xF0, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x3C, 0x03, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x80,
  0x06, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x3F, 0x1C, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03,
  0xF0, 0x37, 0x00, 0x00, 0x7E, 0x06, 0xE0, 0x00, 0x1D, 0xC1, 0xCC, 0x00,
  0x03, 0xB8, 0x39, 0x80, 0x00, 0xE6, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0xE7,
  0x00, 0x07, 0x38, 0x18, 0xE0, 0x00, 0xC7, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0xE1, 0x80, 0x06, 0x1C, 0x1C, 0x30, 0x01, 0xC3, 0x03, 0x87, 0x00, 0x30,
  0xE0, 0x70, 0xE0, 0x0E, 0x1C, 0x0C, 0x1C, 0x01, 0x83, 0x83, 0x83, 0x80,
  0x70, 0x70, 0x70, 0x30, 0x1C, 0x0E, 0x0E, 0x06, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x03, 0x87, 0x01, 0xC1,
  0xC0, 0x70, 0xE0, 0x38, 0x38, 0x06, 0x38, 0x07, 0x07, 0x00, 0xC7, 0x01,
  0xC0, 0xE0, 0x19, 0xC0, 0x38, 0x1C, 0x03, 0xB8, 0x07, 0x03, 0x00, 0x7E,
  0x00, 0xE0, 0xE0, 0x0F, 0xC0, 0x1C, 0x1C, 0x00, 0xF0, 0x03, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x0F,
  0x80, 0x00, 0xE0, 0x7C, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x38, 0x1F, 0x80,
  0x01, 0xC0, 0xEE, 0x00, 0x1C, 0x06, 0x70, 0x00, 0xE0, 0x73, 0x80, 0x07,
  0x03, 0x8E, 0x00, 0x38, 0x1C, 0x70, 0x01, 0xC0, 0xE1, 0x80, 0x0C, 0x07,
  0x0E, 0x00, 0xE0, 0x70, 0x70, 0x07, 0x03, 0x81, 0x80, 0x38, 0x1C, 0x0E,
  0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0xE0, 0x0E, 0x0E, 0x07,
  0x00, 0x30, 0x70, 0x38, 0x01, 0xC3, 0x01, 0xC0, 0x0E, 0x38, 0x1C, 0x00,
  0x31, 0xC0, 0xE0, 0x01, 0xCE, 0x07, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x3B,
  0x81, 0xC0, 0x01, 0xF8, 0x0C, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x3E, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x03, 0xE1, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x07, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x03, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x9E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0xC0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x1E, 0x07, 0x00, 0x3E, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1F,
  0x00, 0x0E, 0xE0, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x1F, 0x00, 0x1C, 0xE0,
  0x03, 0xF0, 0x01, 0x86, 0x00, 0x37, 0x00, 0x38, 0x60, 0x07, 0x70, 0x03,
  0x86, 0x00, 0x73, 0x00, 0x70, 0x60, 0x06, 0x30, 0x07, 0x07, 0x00, 0xE3,
  0x00, 0x70, 0x70, 0x0C, 0x30, 0x0E, 0x07, 0x01, 0xC3, 0x00, 0xE0, 0x70,
  0x1C, 0x30, 0x0E, 0x07, 0x01, 0x83, 0x01, 0xC0, 0x70, 0x38, 0x38, 0x1C,
  0x07, 0x03, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x07, 0x07, 0x03,
  0x83, 0x80, 0x70, 0x60, 0x38, 0x30, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x70,
  0xC0, 0x18, 0x70, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x18, 0xE0,
  0x07, 0x18, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x03, 0x30, 0x01,
  0x9C, 0x00, 0x33, 0x00, 0x19, 0xC0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0x36,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x38, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x1C,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x60, 0x60, 0x60,
  0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38,
  0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x0E, 0xC0, 0x33, 0x01, 0xCC,
  0x0E, 0x30, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x18, 0xE0, 0x67, 0x01,
  0x9C, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC1, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x07, 0x00, 0xE0, 0xE0, 0x0F,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0xE3, 0xE0,
  0x0E, 0x38, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0x70, 0x1F, 0x87,
  0xC7, 0xB8, 0x3F, 0xF3, 0x81, 0xFE, 0x38, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x63, 0xFC, 0x07, 0x7F, 0xF0, 0x3F,
  0x87, 0xC1, 0xF0, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x00, 0x0E,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x00,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x80, 0x07, 0x18, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00,
  0xE3, 0x80, 0x07, 0x1E, 0x00, 0x70, 0xD8, 0x07, 0x8E, 0xF0, 0xF8, 0x73,
  0xFF, 0x83, 0x8F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xC1, 0xE1, 0xE0, 0x1C, 0x38, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38,
  0x00, 0xE3, 0x80, 0x38, 0x70, 0x0E, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1F, 0xE3, 0x80, 0xFF, 0xE7, 0x03, 0xE1, 0xEE, 0x0F,
  0x00, 0xD8, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x7C, 0x07,
  0xC3, 0xF8, 0x07, 0xFF, 0x70, 0x07, 0xF8, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE0, 0xE0, 0x1C, 0x38,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0xB0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x18, 0x78, 0x07, 0x07, 0x83,
  0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xF1, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xF0, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x1C, 0x07, 0xFF,
  0x38, 0x1F, 0x0F, 0x70, 0x78, 0x06, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0xF0, 0x1C, 0x03, 0xE0, 0x3E, 0x1F, 0xC0, 0x3F, 0xFB, 0x80, 0x3F, 0xC6,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x78, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x20, 0x06, 0x3F, 0xC0, 0xE7, 0xFE, 0x0E, 0xE1, 0xE0, 0xFC,
  0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x73,
  0x80, 0x06, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xC6, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x80, 0x01,
  0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF0,
  0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1C,
  0x78, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1B, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x78, 0x00,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC7, 0xF8,
  0x1F, 0xE0, 0x39, 0xFF, 0x87, 0xFE, 0x07, 0x70, 0xF1, 0xC3, 0xE0, 0xF8,
  0x0F, 0x70, 0x1C, 0x1E, 0x00, 0xFC, 0x03, 0x83, 0x80, 0x1F, 0x00, 0x70,
  0xF0, 0x03, 0xC0, 0x06, 0x1C, 0x00, 0x78, 0x00, 0xC3, 0x80, 0x0E, 0x00,
  0x18, 0x70, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0x80, 0x07,
  0x00, 0x1C, 0x70, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0x71, 0xC0,
  0x07, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x80, 0x0E, 0x38, 0x00, 0x60, 0x01, 0xC7, 0x00, 0x1C, 0x00,
  0x38, 0xE0, 0x03, 0x80, 0x07, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x00, 0x38, 0xE0, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0x30, 0x00, 0xE3, 0x80,
  0x0E, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x02, 0x00, 0x63,
  0xFC, 0x0E, 0x7F, 0xE0, 0xEE, 0x1E, 0x0F, 0xC0, 0xF0, 0xF0, 0x07, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x63, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x78, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0x73,
  0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x03, 0xC1, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x03, 0x1F,
  0xE0, 0x0E, 0xFF, 0xE0, 0x1F, 0xC3, 0xE0, 0x3E, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x0F, 0x00, 0x38, 0x1B, 0x00, 0xF0, 0x77, 0x87, 0xC0, 0xE7, 0xFF,
  0x01, 0xC7, 0xF8, 0x03, 0x80, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF1, 0xC1, 0xFF, 0xCE, 0x1F, 0x0F, 0x71, 0xE0,
  0x1B, 0x0E, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73,
  0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0E,
  0x0E, 0x00, 0xF0, 0x70, 0x0F, 0x83, 0xE1, 0xFC, 0x0F, 0xFE, 0xE0, 0x3F,
  0xC6, 0x00, 0x10, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x0C, 0x7C, 0x3B,
  0xF8, 0x7F, 0xD0, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0x3C, 0x0F, 0x01,
  0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x07, 0x03, 0xC3, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0xE0, 0x3E, 0x00, 0x80, 0x18, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x63, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00,
  0xE7, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x60, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x01, 0xF0, 0x78, 0x7E, 0x07, 0xFF, 0x60,
  0x3F, 0xCE, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x39, 0x80, 0x07,
  0x30, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x0E, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x03, 0xC0, 0x1D, 0xC0, 0x1E, 0x00,
  0xEE, 0x01, 0xF0, 0x0E, 0x70, 0x0D, 0x80, 0x73, 0x80, 0xEC, 0x03, 0x9C,
  0x07, 0x60, 0x38, 0xE0, 0x33, 0x01, 0xC7, 0x03, 0x98, 0x1C, 0x18, 0x18,
  0xE0, 0xE0, 0xC1, 0xC7, 0x06, 0x06, 0x0C, 0x38, 0x70, 0x30, 0xE1, 0xC3,
  0x81, 0x87, 0x0E, 0x38, 0x0C, 0x70, 0x31, 0xC0, 0x73, 0x81, 0x8C, 0x03,
  0x98, 0x0C, 0xE0, 0x1D, 0xC0, 0x67, 0x00, 0xEC, 0x03, 0x70, 0x07, 0xE0,
  0x1B, 0x80, 0x3E, 0x00, 0xD8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x71, 0xC0, 0x00,
  0xE7, 0x80, 0x00, 0xCE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEC,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70,
  0x01, 0xC0, 0x60, 0x07, 0x80, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x01, 0x80, 0x70,
  0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x40,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0x3F, 0xF0, 0x07, 0x78, 0x78,
  0x06, 0x70, 0x3C, 0x0E, 0xE0, 0x1E, 0x1E, 0xE0, 0x0F, 0xFC, 0xC0, 0x07,
  0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 38, 11, 1, -37 },
  { 49, 11, 12, 15, 5, -39 },
  { 66, 25, 37, 26, 2, -37 },
  { 182, 21, 49, 25, 2, -43 },
  { 311, 24, 39, 32, 5, -38 },
  { 428, 23, 39, 27, 2, -38 },
  { 541, 4, 11, 9, 5, -39 },
  { 547, 14, 53, 15, 3, -41 },
  { 640, 15, 53, 15, -3, -41 },
  { 740, 20, 21, 21, 3, -37 },
  { 793, 21, 27, 25, 2, -31 },
  { 864, 7, 12, 10, -2, -5 },
  { 875, 11, 3, 13, 1, -18 },
  { 880, 5, 5, 12, 1, -4 },
  { 884, 22, 40, 18, -2, -37 },
  { 994, 20, 39, 25, 3, -38 },
  { 1092, 12, 37, 25, 7, -37 },
  { 1148, 22, 38, 25, 1, -38 },
  { 1253, 21, 39, 25, 2, -38 },
  { 1356, 22, 37, 25, 1, -37 },
  { 1458, 22, 38, 25, 3, -37 },
  { 1563, 19, 38, 25, 3, -37 },
  { 1654, 21, 37, 25, 4, -37 },
  { 1752, 22, 39, 25, 2, -38 },
  { 1860, 19, 38, 25, 4, -38 },
  { 1951, 8, 28, 10, 1, -27 },
  { 1979, 11, 34, 10, -2, -27 },
  { 2026, 19, 22, 23, 2, -28 },
  { 2079, 19, 14, 24, 3, -24 },
  { 2113, 20, 22, 23, 1, -28 },
  { 2168, 17, 39, 20, 4, -38 },
  { 2251, 35, 48, 40, 2, -36 },
  { 2461, 26, 37, 28, -2, -37 },
  { 2582, 24, 37, 27, 2, -37 },
  { 2693, 25, 39, 29, 3, -38 },
  { 2815, 25, 37, 29, 2, -37 },
  { 2931, 25, 37, 25, 2, -37 },
  { 3047, 25, 37, 25, 2, -37 },
  { 3163, 25, 39, 30, 3, -38 },
  { 3285, 29, 37, 31, 2, -37 },
  { 3420, 9, 37, 12, 2, -37 },
  { 3462, 23, 38, 24, 1, -37 },
  { 3572, 28, 37, 28, 2, -37 },
  { 3702, 18, 37, 23, 2, -37 },
  { 3786, 35, 37, 38, 2, -37 },
  { 3948, 29, 37, 31, 2, -37 },
  { 4083, 25, 39, 30, 3, -38 },
  { 4205, 25, 37, 27, 2, -37 },
  { 4321, 25, 44, 30, 3, -38 },
  { 4459, 25, 37, 28, 2, -37 },
  { 4575, 25, 39, 26, 1, -38 },
  { 4697, 24, 37, 26, 5, -37 },
  { 4808, 26, 38, 29, 3, -37 },
  { 4932, 25, 37, 27, 5, -37 },
  { 5048, 36, 37, 39, 5, -37 },
  { 5215, 30, 37, 27, -1, -37 },
  { 5354, 24, 37, 26, 5, -37 },
  { 5465, 27, 37, 26, 0, -37 },
  { 5590, 15, 50, 11, 0, -42 },
  { 5684, 8, 40, 18, 5, -37 },
  { 5724, 15, 50, 11, -3, -42 },
  { 5818, 14, 18, 19, 3, -37 },
  { 5850, 19, 3, 19, -3, 0 },
  { 5858, 7, 7, 14, 6, -39 },
  { 5865, 20, 29, 24, 1, -28 },
  { 5938, 21, 40, 25, 1, -39 },
  { 6043, 19, 29, 23, 2, -28 },
  { 6112, 23, 40, 25, 2, -39 },
  { 6227, 19, 29, 23, 2, -28 },
  { 6296, 16, 40, 15, 3, -40 },
  { 6376, 23, 39, 25, 0, -28 },
  { 6489, 20, 39, 24, 1, -39 },
  { 6587, 10, 37, 11, 1, -37 },
  { 6634, 17, 48, 11, -6, -37 },
  { 6736, 22, 39, 22, 1, -39 },
  { 6844, 10, 39, 11, 1, -39 },
  { 6893, 35, 28, 38, 1, -28 },
  { 7016, 20, 28, 24, 1, -28 },
  { 7086, 20, 29, 25, 2, -28 },
  { 7159, 23, 39, 25, -1, -28 },
  { 7272, 21, 39, 25, 2, -28 },
  { 7375, 15, 28, 15, 1, -28 },
  { 7428, 20, 29, 23, 1, -28 },
  { 7501, 12, 36, 15, 3, -35 },
  { 7555, 20, 28, 24, 3, -27 },
  { 7625, 19, 27, 21, 3, -27 },
  { 7690, 29, 27, 33, 4, -27 },
  { 7788, 23, 27, 22, -1, -27 },
  { 7866, 24, 38, 21, -2, -27 },
  { 7980, 21, 27, 22, 0, -27 },
  { 8051, 16, 51, 15, 2, -41 },
  { 8153, 9, 44, 11, 1, -37 },
  { 8203, 16, 51, 15, -3, -41 },
  { 8305, 24, 9, 30, 3, -20 },
};

const GFXfont RobotoCondensed_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC52PT7B_H_
