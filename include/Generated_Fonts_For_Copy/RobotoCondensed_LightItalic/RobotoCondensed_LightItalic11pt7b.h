#ifndef _ROBOTOCONDENSED_LIGHTITALIC11PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x52, 0xF0, 0x14, 0x67, 0xCA, 0x33, 0xE5, 0x00, 0x11, 0xD2,
  0x82, 0x08, 0x32, 0x71, 0x00, 0xC5, 0x6D, 0xC3, 0xB6, 0xA3, 0x32, 0x54,
  0x46, 0xCE, 0x4D, 0xC0, 0x2A, 0x49, 0x24, 0x92, 0x40, 0x22, 0x11, 0x11,
  0x22, 0x22, 0x48, 0x4F, 0x4A, 0x11, 0x08, 0xF2, 0x10, 0x80, 0xE0, 0xE0,
  0x80, 0x11, 0x22, 0x44, 0x88, 0x80, 0x69, 0x99, 0x99, 0xAC, 0x74, 0x94,
  0x92, 0x32, 0x42, 0x21, 0x11, 0x1E, 0x32, 0x42, 0x61, 0x06, 0x4E, 0x08,
  0x8A, 0xA5, 0x7C, 0x42, 0x74, 0x8E, 0x11, 0x9E, 0x24, 0x8E, 0x99, 0xAE,
  0xF1, 0x22, 0x44, 0x88, 0x3A, 0x52, 0x65, 0x46, 0x4E, 0x69, 0x99, 0xF2,
  0x2C, 0x40, 0x20, 0x40, 0x2A, 0x19, 0x30, 0xC1, 0x00, 0xF0, 0xE0, 0x42,
  0x12, 0xC0, 0x74, 0x95, 0x04, 0x1E, 0x21, 0x4D, 0x55, 0xA5, 0xA5, 0xA9,
  0xB6, 0x40, 0x38, 0x10, 0x8A, 0x54, 0xBE, 0x31, 0x3A, 0x52, 0xE4, 0xA6,
  0x3E, 0x74, 0x63, 0x08, 0x4A, 0x5C, 0x39, 0x14, 0x51, 0x45, 0x28, 0xBC,
  0x3D, 0x04, 0x1E, 0x41, 0x08, 0x3C, 0x3D, 0x04, 0x1E, 0x41, 0x08, 0x20,
  0x74, 0x61, 0x0B, 0xC6, 0x5E, 0x45, 0x14, 0x5F, 0x45, 0x18, 0x62, 0x55,
  0x5A, 0x08, 0x42, 0x10, 0x8A, 0x4C, 0x45, 0x25, 0x18, 0x51, 0x49, 0x22,
  0x44, 0x44, 0x44, 0x8F, 0x21, 0x63, 0x62, 0x66, 0x66, 0x5A, 0x92, 0x92,
  0x25, 0x96, 0x55, 0x55, 0x58, 0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x39,
  0x14, 0x51, 0x79, 0x08, 0x20, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x10, 0x39,
  0x14, 0x52, 0x71, 0x48, 0xA2, 0x39, 0x14, 0x08, 0x10, 0x28, 0x9C, 0xF9,
  0x08, 0x84, 0x21, 0x08, 0x8C, 0x63, 0x18, 0xCA, 0x5C, 0x8C, 0x65, 0x2A,
  0x31, 0x08, 0x91, 0x92, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0x88, 0x44, 0xA3,
  0x0C, 0x31, 0x45, 0x22, 0x8C, 0x94, 0xC4, 0x21, 0x08, 0x7C, 0x21, 0x04,
  0x21, 0x04, 0x3E, 0x29, 0x24, 0x94, 0x93, 0x00, 0xAA, 0x95, 0x40, 0x22,
  0x22, 0x22, 0x22, 0x44, 0xC0, 0x4A, 0xD0, 0xF0, 0x90, 0x71, 0x17, 0x9F,
  0x42, 0x10, 0xE4, 0xA6, 0x32, 0xF0, 0x72, 0x61, 0x09, 0x30, 0x08, 0x42,
  0xF4, 0xC6, 0x52, 0x70, 0x75, 0x78, 0x87, 0x6A, 0x69, 0x24, 0x80, 0x7A,
  0x63, 0x29, 0x38, 0x5C, 0x42, 0x10, 0xE4, 0xA6, 0x52, 0x90, 0x45, 0x6A,
  0x20, 0x92, 0x92, 0x50, 0x42, 0x10, 0xA6, 0x22, 0x94, 0x90, 0x55, 0x5A,
  0x80, 0x76, 0x49, 0x49, 0x92, 0x92, 0x92, 0x72, 0x53, 0x29, 0x48, 0x32,
  0x63, 0x19, 0x38, 0x72, 0x53, 0x19, 0x7A, 0x10, 0x7A, 0x63, 0x29, 0x38,
  0x42, 0x69, 0x49, 0x00, 0x74, 0x43, 0x96, 0xBA, 0xA8, 0x99, 0x9A, 0xAE,
  0x9A, 0xAC, 0xC8, 0xA6, 0x9D, 0xB6, 0x92, 0x40, 0x52, 0x88, 0x46, 0x48,
  0x4A, 0x94, 0xC6, 0x21, 0x10, 0x71, 0x24, 0x4F, 0x12, 0x22, 0x4C, 0x44,
  0x44, 0x40, 0x55, 0x5A, 0x80, 0x22, 0x22, 0x21, 0x22, 0x24, 0x80, 0xCD,
  0x80,
};

const GFXglyph RobotoCondensed_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 6, 8, 5, 0, -8 },
  { 10, 5, 10, 5, 0, -9 },
  { 17, 5, 8, 7, 1, -8 },
  { 22, 5, 8, 6, 0, -8 },
  { 27, 1, 2, 2, 1, -8 },
  { 28, 3, 12, 3, 1, -9 },
  { 33, 4, 12, 3, -1, -9 },
  { 39, 4, 4, 5, 1, -8 },
  { 41, 5, 7, 5, 0, -7 },
  { 46, 1, 3, 2, 0, -1 },
  { 47, 3, 1, 3, 0, -4 },
  { 48, 1, 1, 3, 0, -1 },
  { 49, 4, 9, 4, 0, -8 },
  { 54, 4, 8, 5, 1, -8 },
  { 58, 3, 8, 5, 1, -8 },
  { 61, 5, 8, 5, 0, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 1, -8 },
  { 80, 4, 8, 5, 1, -8 },
  { 84, 4, 8, 5, 1, -8 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 4, 8, 5, 1, -8 },
  { 97, 2, 6, 2, 0, -6 },
  { 99, 2, 8, 2, 0, -6 },
  { 101, 5, 5, 5, 0, -6 },
  { 105, 4, 3, 5, 1, -5 },
  { 107, 4, 5, 5, 0, -6 },
  { 110, 3, 8, 4, 1, -8 },
  { 113, 8, 10, 8, 0, -8 },
  { 123, 5, 8, 6, 0, -8 },
  { 128, 5, 8, 6, 0, -8 },
  { 133, 5, 8, 6, 1, -8 },
  { 138, 6, 8, 6, 0, -8 },
  { 144, 6, 8, 5, 0, -8 },
  { 150, 6, 8, 5, 0, -8 },
  { 156, 5, 8, 6, 1, -8 },
  { 161, 6, 8, 7, 0, -8 },
  { 167, 2, 8, 3, 0, -8 },
  { 169, 5, 8, 5, 0, -8 },
  { 174, 6, 8, 6, 0, -8 },
  { 180, 4, 8, 5, 0, -8 },
  { 184, 8, 8, 8, 0, -8 },
  { 192, 6, 8, 7, 0, -8 },
  { 198, 5, 8, 6, 1, -8 },
  { 203, 6, 8, 6, 0, -8 },
  { 209, 5, 9, 6, 1, -8 },
  { 215, 6, 8, 6, 0, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 5, 8, 6, 1, -8 },
  { 232, 5, 8, 6, 1, -8 },
  { 237, 5, 8, 6, 1, -8 },
  { 242, 8, 8, 8, 1, -8 },
  { 250, 6, 8, 6, 0, -8 },
  { 256, 5, 8, 6, 1, -8 },
  { 261, 6, 8, 6, 0, -8 },
  { 267, 3, 11, 2, 0, -9 },
  { 272, 2, 9, 4, 1, -8 },
  { 275, 4, 11, 2, -1, -9 },
  { 281, 3, 4, 4, 1, -8 },
  { 283, 4, 1, 4, -1, 0 },
  { 284, 2, 2, 3, 1, -9 },
  { 285, 4, 6, 5, 0, -6 },
  { 288, 5, 9, 5, 0, -9 },
  { 294, 5, 6, 5, 0, -6 },
  { 298, 5, 9, 5, 0, -9 },
  { 304, 4, 6, 5, 0, -6 },
  { 307, 3, 9, 3, 1, -9 },
  { 311, 5, 8, 5, 0, -6 },
  { 316, 5, 9, 5, 0, -9 },
  { 322, 2, 8, 2, 0, -8 },
  { 324, 3, 10, 2, -1, -8 },
  { 328, 5, 9, 5, 0, -9 },
  { 334, 2, 9, 2, 0, -9 },
  { 337, 8, 6, 8, 0, -6 },
  { 343, 5, 6, 5, 0, -6 },
  { 347, 5, 6, 5, 0, -6 },
  { 351, 5, 8, 5, 0, -6 },
  { 356, 5, 8, 5, 0, -6 },
  { 361, 3, 6, 3, 0, -6 },
  { 364, 4, 6, 5, 0, -6 },
  { 367, 2, 7, 3, 1, -7 },
  { 369, 4, 6, 5, 1, -6 },
  { 372, 4, 6, 5, 1, -6 },
  { 375, 6, 6, 7, 1, -6 },
  { 380, 5, 6, 5, 0, -6 },
  { 384, 5, 8, 4, 0, -6 },
  { 389, 4, 6, 5, 0, -6 },
  { 392, 4, 11, 3, 0, -9 },
  { 398, 2, 9, 2, 0, -8 },
  { 401, 4, 11, 3, -1, -9 },
  { 407, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC11PT7B_H_
