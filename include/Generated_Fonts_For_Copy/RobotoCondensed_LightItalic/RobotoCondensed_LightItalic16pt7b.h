#ifndef _ROBOTOCONDENSED_LIGHTITALIC16PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x40, 0x60, 0xB6, 0xE0, 0x09, 0x09, 0x0A, 0x3F,
  0x12, 0x12, 0x14, 0x24, 0x7E, 0x28, 0x48, 0x48, 0x08, 0x23, 0x91, 0x45,
  0x14, 0x08, 0x18, 0x20, 0xA2, 0x89, 0xC4, 0x00, 0x70, 0x50, 0x92, 0x94,
  0x64, 0x08, 0x10, 0x16, 0x29, 0x49, 0x49, 0x06, 0x1C, 0x12, 0x22, 0x24,
  0x18, 0x10, 0x30, 0x49, 0x46, 0x86, 0x46, 0x3A, 0x56, 0x11, 0x24, 0x44,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x40, 0x20, 0x84, 0x10, 0x84, 0x21, 0x08,
  0x84, 0x21, 0x10, 0x88, 0x80, 0x10, 0x4D, 0xC8, 0x52, 0x20, 0x10, 0x41,
  0x04, 0xFC, 0x82, 0x08, 0x20, 0x49, 0x40, 0x70, 0xC0, 0x02, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x00, 0x39, 0x14, 0x61,
  0x86, 0x18, 0x61, 0x8A, 0x28, 0x9C, 0x3D, 0x22, 0x22, 0x22, 0x44, 0x44,
  0x1C, 0x45, 0x08, 0x10, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x07, 0xE0, 0x1C,
  0x44, 0x88, 0x10, 0x63, 0x01, 0x02, 0x05, 0x09, 0x11, 0xC0, 0x02, 0x0C,
  0x28, 0x61, 0x44, 0x89, 0x22, 0xFE, 0x10, 0x20, 0x40, 0x3E, 0x41, 0x02,
  0x07, 0x89, 0x01, 0x02, 0x05, 0x12, 0x23, 0x80, 0x1C, 0x84, 0x10, 0xBB,
  0x28, 0x61, 0x86, 0x28, 0x9C, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x00, 0x1C, 0x44, 0x89, 0x12, 0x23, 0x99, 0x22, 0x83,
  0x09, 0x11, 0xC0, 0x39, 0x14, 0x61, 0x86, 0x18, 0xDD, 0x08, 0x21, 0x38,
  0x20, 0x00, 0x06, 0x30, 0x00, 0x00, 0x24, 0x48, 0x04, 0x66, 0x20, 0x40,
  0xC0, 0x80, 0xFC, 0x00, 0x3E, 0x20, 0x30, 0x10, 0x63, 0x08, 0x00, 0x3A,
  0x62, 0x10, 0x88, 0x84, 0x40, 0x00, 0x80, 0x0F, 0x84, 0x12, 0x05, 0x39,
  0x49, 0x64, 0x99, 0x26, 0x89, 0xA2, 0x69, 0xA9, 0xBA, 0x00, 0x80, 0x30,
  0x03, 0xC0, 0x02, 0x06, 0x06, 0x0A, 0x0A, 0x11, 0x11, 0x11, 0x3F, 0x21,
  0x41, 0x41, 0x3E, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x42, 0x42, 0x42, 0x42,
  0x46, 0x7C, 0x1C, 0x22, 0x42, 0x41, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84,
  0x84, 0x78, 0x3E, 0x21, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42,
  0x44, 0x78, 0x3F, 0x20, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x7C, 0x3F, 0x20, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x1E, 0x22, 0x41, 0x40, 0x80, 0x80, 0x8E, 0x82, 0x82, 0x82,
  0x44, 0x78, 0x20, 0x90, 0x48, 0x24, 0x12, 0x09, 0xF9, 0x04, 0x82, 0x41,
  0x20, 0x90, 0x48, 0x20, 0x49, 0x24, 0xA4, 0x92, 0x40, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x05, 0x0A, 0x23, 0x80, 0x21, 0x90, 0x88, 0x84,
  0x82, 0x82, 0x81, 0xA0, 0x90, 0x44, 0x22, 0x10, 0x88, 0x40, 0x20, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x1F, 0x30, 0x26, 0x04, 0xC1, 0x98,
  0x33, 0x0A, 0x91, 0x52, 0x52, 0x4A, 0x4A, 0x49, 0x49, 0x31, 0x22, 0x20,
  0x30, 0x98, 0x4C, 0x25, 0x12, 0x89, 0x45, 0x14, 0x8A, 0x45, 0x21, 0x90,
  0xC8, 0x60, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x78, 0x3E, 0x21, 0x21, 0x21, 0x21, 0x43, 0x7E, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x1C, 0x22, 0x42, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x78, 0x08, 0x04, 0x3E, 0x21, 0x21, 0x21, 0x21, 0x42, 0x7C, 0x44,
  0x44, 0x44, 0x42, 0x82, 0x1E, 0x21, 0x21, 0x20, 0x20, 0x18, 0x04, 0x02,
  0x02, 0x82, 0x46, 0x38, 0x7F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x78, 0x81, 0x42, 0x42, 0x42, 0x44, 0x44, 0x48, 0x48,
  0x50, 0x30, 0x30, 0x20, 0x8C, 0x51, 0x8A, 0x31, 0x4A, 0x49, 0x49, 0x29,
  0x29, 0x45, 0x28, 0xC5, 0x18, 0xC3, 0x18, 0x41, 0x00, 0x21, 0x10, 0x84,
  0x82, 0x81, 0x40, 0x40, 0x60, 0x30, 0x24, 0x22, 0x10, 0x90, 0x40, 0x41,
  0x42, 0x44, 0x44, 0x28, 0x28, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFE, 0x39,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x43, 0x00, 0xAA, 0xA9, 0x55,
  0x40, 0x38, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x13, 0x00, 0x23,
  0x55, 0x99, 0xFC, 0x90, 0x3C, 0x90, 0x41, 0x3D, 0x18, 0x63, 0x74, 0x20,
  0x40, 0x81, 0xE2, 0x28, 0x50, 0xA1, 0x42, 0x89, 0x15, 0xC0, 0x79, 0x28,
  0x60, 0x82, 0x08, 0xA2, 0xF0, 0x02, 0x04, 0x13, 0xA4, 0xD0, 0xA1, 0x44,
  0x89, 0x12, 0x27, 0xC0, 0x3C, 0x49, 0x0A, 0x17, 0xD0, 0x10, 0x20, 0x38,
  0x39, 0x11, 0xE4, 0x21, 0x08, 0x84, 0x21, 0x00, 0x3A, 0x4D, 0x0A, 0x14,
  0x48, 0x91, 0x22, 0x7C, 0x0A, 0x23, 0x80, 0x20, 0x40, 0x81, 0xE2, 0x48,
  0x50, 0xA2, 0x44, 0x8A, 0x14, 0x20, 0x20, 0x12, 0x92, 0x49, 0x40, 0x08,
  0x00, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x13, 0x00, 0x20, 0x40, 0x81,
  0x32, 0xC9, 0x14, 0x38, 0x50, 0x92, 0x24, 0x40, 0x24, 0x92, 0x92, 0x49,
  0x40, 0x3D, 0xC4, 0xC5, 0x08, 0xA2, 0x14, 0x42, 0x88, 0x51, 0x14, 0x22,
  0x84, 0x40, 0x3C, 0x49, 0x0A, 0x14, 0x48, 0x91, 0x42, 0x84, 0x39, 0x18,
  0x61, 0x86, 0x18, 0xA2, 0x70, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x51, 0x22,
  0xB9, 0x02, 0x04, 0x00, 0x75, 0x38, 0x61, 0x8A, 0x28, 0xA2, 0xF8, 0x21,
  0x04, 0x39, 0x10, 0x84, 0x21, 0x10, 0x80, 0x3C, 0x94, 0x08, 0x10, 0x20,
  0x62, 0x78, 0x4B, 0xA4, 0xA4, 0x93, 0x00, 0x46, 0x18, 0x61, 0x8A, 0x28,
  0xA6, 0xE8, 0x86, 0x28, 0xA4, 0x51, 0x46, 0x18, 0x40, 0x88, 0xC4, 0x66,
  0x53, 0x2A, 0x55, 0x32, 0x98, 0x88, 0x44, 0x00, 0x44, 0x48, 0xA1, 0x81,
  0x06, 0x12, 0x24, 0x88, 0x21, 0x22, 0x22, 0x24, 0x14, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x7C, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0xF8,
  0x12, 0x22, 0x44, 0x48, 0x84, 0x48, 0x88, 0x44, 0x24, 0x92, 0x92, 0x49,
  0x29, 0x00, 0x20, 0x84, 0x21, 0x08, 0x41, 0x11, 0x08, 0x42, 0x22, 0x00,
  0x63, 0x26, 0x30,
};

const GFXglyph RobotoCondensed_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 3, 0, -12 },
  { 6, 3, 4, 4, 2, -12 },
  { 8, 8, 12, 8, 0, -12 },
  { 20, 6, 15, 8, 1, -14 },
  { 32, 8, 12, 10, 1, -12 },
  { 44, 8, 12, 8, 0, -12 },
  { 56, 2, 4, 3, 1, -12 },
  { 57, 4, 17, 5, 1, -13 },
  { 66, 5, 17, 5, -1, -13 },
  { 77, 6, 6, 7, 1, -12 },
  { 82, 6, 9, 8, 1, -10 },
  { 89, 3, 4, 3, -1, -2 },
  { 91, 4, 1, 4, 0, -6 },
  { 92, 2, 1, 4, 0, -1 },
  { 93, 7, 13, 6, -1, -12 },
  { 105, 6, 12, 8, 1, -12 },
  { 114, 4, 12, 8, 2, -12 },
  { 120, 7, 12, 8, 0, -12 },
  { 131, 7, 12, 8, 0, -12 },
  { 142, 7, 12, 8, 0, -12 },
  { 153, 7, 12, 8, 1, -12 },
  { 164, 6, 12, 8, 1, -12 },
  { 173, 7, 12, 8, 1, -12 },
  { 184, 7, 12, 8, 0, -12 },
  { 195, 6, 12, 8, 1, -12 },
  { 204, 3, 8, 3, 0, -8 },
  { 207, 4, 10, 3, -1, -8 },
  { 212, 6, 7, 7, 1, -9 },
  { 218, 6, 4, 8, 1, -7 },
  { 221, 7, 6, 7, 0, -8 },
  { 227, 5, 12, 6, 1, -12 },
  { 235, 10, 15, 12, 1, -11 },
  { 254, 8, 12, 9, -1, -12 },
  { 266, 8, 12, 8, 0, -12 },
  { 278, 8, 12, 9, 1, -12 },
  { 290, 8, 12, 9, 0, -12 },
  { 302, 8, 12, 8, 0, -12 },
  { 314, 8, 12, 8, 0, -12 },
  { 326, 8, 12, 9, 1, -12 },
  { 338, 9, 12, 10, 0, -12 },
  { 352, 3, 12, 4, 1, -12 },
  { 357, 7, 12, 7, 0, -12 },
  { 368, 9, 12, 9, 0, -12 },
  { 382, 6, 12, 7, 0, -12 },
  { 391, 11, 12, 12, 0, -12 },
  { 408, 9, 12, 10, 0, -12 },
  { 422, 8, 12, 9, 1, -12 },
  { 434, 8, 12, 8, 0, -12 },
  { 446, 8, 14, 9, 1, -12 },
  { 460, 8, 12, 9, 0, -12 },
  { 472, 8, 12, 8, 0, -12 },
  { 484, 8, 12, 8, 1, -12 },
  { 496, 8, 12, 9, 1, -12 },
  { 508, 8, 12, 8, 1, -12 },
  { 520, 11, 12, 12, 2, -12 },
  { 537, 9, 12, 8, 0, -12 },
  { 551, 8, 12, 8, 1, -12 },
  { 563, 8, 12, 8, 0, -12 },
  { 575, 5, 15, 4, 0, -13 },
  { 585, 2, 13, 5, 2, -12 },
  { 589, 5, 15, 4, -1, -13 },
  { 599, 4, 6, 6, 1, -12 },
  { 602, 6, 1, 6, -1, 0 },
  { 603, 2, 2, 4, 2, -12 },
  { 604, 6, 9, 7, 0, -9 },
  { 611, 7, 12, 8, 0, -12 },
  { 622, 6, 9, 7, 1, -9 },
  { 629, 7, 12, 8, 1, -12 },
  { 640, 7, 9, 7, 0, -9 },
  { 648, 5, 12, 5, 1, -12 },
  { 656, 7, 12, 8, 0, -9 },
  { 667, 7, 12, 7, 0, -12 },
  { 678, 3, 12, 3, 0, -12 },
  { 683, 5, 15, 3, -2, -12 },
  { 693, 7, 12, 7, 0, -12 },
  { 704, 3, 12, 3, 0, -12 },
  { 709, 11, 9, 12, 0, -9 },
  { 722, 7, 9, 7, 0, -9 },
  { 730, 6, 9, 8, 1, -9 },
  { 737, 7, 12, 8, 0, -9 },
  { 748, 6, 12, 8, 1, -9 },
  { 757, 5, 9, 5, 0, -9 },
  { 763, 6, 9, 7, 0, -9 },
  { 770, 3, 11, 5, 1, -11 },
  { 775, 6, 9, 7, 1, -9 },
  { 782, 6, 9, 7, 1, -9 },
  { 789, 9, 9, 10, 1, -9 },
  { 800, 7, 9, 7, 0, -9 },
  { 808, 8, 12, 7, -1, -9 },
  { 820, 7, 9, 7, 0, -9 },
  { 828, 4, 16, 5, 1, -13 },
  { 836, 3, 14, 3, 0, -12 },
  { 842, 5, 15, 5, -1, -12 },
  { 852, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC16PT7B_H_
