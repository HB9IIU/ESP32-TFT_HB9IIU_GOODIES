#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_LightItalic
// Headers: 67

#include "RobotoCondensed_LightItalic6pt7b.h"
#include "RobotoCondensed_LightItalic7pt7b.h"
#include "RobotoCondensed_LightItalic8pt7b.h"
#include "RobotoCondensed_LightItalic9pt7b.h"
#include "RobotoCondensed_LightItalic10pt7b.h"
#include "RobotoCondensed_LightItalic11pt7b.h"
#include "RobotoCondensed_LightItalic12pt7b.h"
#include "RobotoCondensed_LightItalic13pt7b.h"
#include "RobotoCondensed_LightItalic14pt7b.h"
#include "RobotoCondensed_LightItalic15pt7b.h"
#include "RobotoCondensed_LightItalic16pt7b.h"
#include "RobotoCondensed_LightItalic17pt7b.h"
#include "RobotoCondensed_LightItalic18pt7b.h"
#include "RobotoCondensed_LightItalic19pt7b.h"
#include "RobotoCondensed_LightItalic20pt7b.h"
#include "RobotoCondensed_LightItalic21pt7b.h"
#include "RobotoCondensed_LightItalic22pt7b.h"
#include "RobotoCondensed_LightItalic23pt7b.h"
#include "RobotoCondensed_LightItalic24pt7b.h"
#include "RobotoCondensed_LightItalic25pt7b.h"
#include "RobotoCondensed_LightItalic26pt7b.h"
#include "RobotoCondensed_LightItalic27pt7b.h"
#include "RobotoCondensed_LightItalic28pt7b.h"
#include "RobotoCondensed_LightItalic29pt7b.h"
#include "RobotoCondensed_LightItalic30pt7b.h"
#include "RobotoCondensed_LightItalic31pt7b.h"
#include "RobotoCondensed_LightItalic32pt7b.h"
#include "RobotoCondensed_LightItalic33pt7b.h"
#include "RobotoCondensed_LightItalic34pt7b.h"
#include "RobotoCondensed_LightItalic35pt7b.h"
#include "RobotoCondensed_LightItalic36pt7b.h"
#include "RobotoCondensed_LightItalic37pt7b.h"
#include "RobotoCondensed_LightItalic38pt7b.h"
#include "RobotoCondensed_LightItalic39pt7b.h"
#include "RobotoCondensed_LightItalic40pt7b.h"
#include "RobotoCondensed_LightItalic41pt7b.h"
#include "RobotoCondensed_LightItalic42pt7b.h"
#include "RobotoCondensed_LightItalic43pt7b.h"
#include "RobotoCondensed_LightItalic44pt7b.h"
#include "RobotoCondensed_LightItalic45pt7b.h"
#include "RobotoCondensed_LightItalic46pt7b.h"
#include "RobotoCondensed_LightItalic47pt7b.h"
#include "RobotoCondensed_LightItalic48pt7b.h"
#include "RobotoCondensed_LightItalic49pt7b.h"
#include "RobotoCondensed_LightItalic50pt7b.h"
#include "RobotoCondensed_LightItalic51pt7b.h"
#include "RobotoCondensed_LightItalic52pt7b.h"
#include "RobotoCondensed_LightItalic53pt7b.h"
#include "RobotoCondensed_LightItalic54pt7b.h"
#include "RobotoCondensed_LightItalic55pt7b.h"
#include "RobotoCondensed_LightItalic56pt7b.h"
#include "RobotoCondensed_LightItalic57pt7b.h"
#include "RobotoCondensed_LightItalic58pt7b.h"
#include "RobotoCondensed_LightItalic59pt7b.h"
#include "RobotoCondensed_LightItalic60pt7b.h"
#include "RobotoCondensed_LightItalic61pt7b.h"
#include "RobotoCondensed_LightItalic62pt7b.h"
#include "RobotoCondensed_LightItalic63pt7b.h"
#include "RobotoCondensed_LightItalic64pt7b.h"
#include "RobotoCondensed_LightItalic65pt7b.h"
#include "RobotoCondensed_LightItalic66pt7b.h"
#include "RobotoCondensed_LightItalic67pt7b.h"
#include "RobotoCondensed_LightItalic68pt7b.h"
#include "RobotoCondensed_LightItalic69pt7b.h"
#include "RobotoCondensed_LightItalic70pt7b.h"
#include "RobotoCondensed_LightItalic71pt7b.h"
#include "RobotoCondensed_LightItalic72pt7b.h"
