#ifndef _ROBOTOCONDENSED_LIGHTITALIC37PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE1, 0x80,
  0x66, 0xCD, 0x9A, 0x2C, 0x59, 0xB3, 0x46, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x30, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x04, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x04,
  0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E,
  0x06, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0xE0, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60,
  0x18, 0x60, 0x38, 0x30, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x08, 0x60, 0x0C, 0x30, 0x24,
  0x08, 0x32, 0x04, 0x31, 0x06, 0x18, 0x83, 0x18, 0x41, 0x98, 0x31, 0x88,
  0x1F, 0x8C, 0x07, 0x8C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x38, 0x06,
  0x7E, 0x02, 0x31, 0x83, 0x30, 0x43, 0x18, 0x23, 0x08, 0x11, 0x84, 0x09,
  0x82, 0x0D, 0x81, 0x06, 0x00, 0xC6, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xFC, 0x01, 0xC7, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x30, 0x0E, 0x38, 0x03, 0x38, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x6C, 0x00, 0x67, 0x06, 0x61, 0x86, 0x70, 0xE3, 0x30,
  0x31, 0xB0, 0x0D, 0x98, 0x06, 0xCC, 0x01, 0xC7, 0x00, 0xE1, 0x80, 0x70,
  0xE0, 0xF8, 0x3F, 0xE6, 0x07, 0xC3, 0x80, 0x32, 0x66, 0x66, 0x44, 0x00,
  0x40, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x83, 0x84, 0x77, 0xF7, 0xC7, 0xF8, 0x07, 0x00, 0x3E, 0x00, 0xD8, 0x06,
  0x30, 0x30, 0xC1, 0x81, 0x82, 0x04, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x31, 0x8C, 0x67, 0x33, 0x10,
  0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x03, 0xE0, 0x1F, 0xE0, 0xE1, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0,
  0x33, 0x00, 0xCE, 0x06, 0x18, 0x30, 0x3F, 0x80, 0x7C, 0x00, 0x01, 0x0F,
  0x3F, 0xF3, 0xC3, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0x60, 0x31, 0x80, 0x63, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFF, 0xF9, 0xFF,
  0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0x60, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0,
  0x3F, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1B, 0x00,
  0x36, 0x00, 0x6C, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x38, 0x38, 0x3F, 0xE0,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0D, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x9C, 0x06, 0x30, 0x18, 0x60, 0x60,
  0xC0, 0xC1, 0x83, 0x03, 0x0C, 0x0C, 0x38, 0x18, 0x60, 0x31, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x13, 0xC0, 0x3F,
  0xF0, 0x38, 0x70, 0x30, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x60,
  0x30, 0x70, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x78, 0x0F, 0xC0, 0xE0,
  0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x3E, 0x1B,
  0xFC, 0xF0, 0x67, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x19, 0x81, 0xCE, 0x1C, 0x3F, 0xC0,
  0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0C, 0x06, 0x0C,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x0C,
  0x0C, 0x0C, 0x1C, 0x07, 0xF0, 0x0F, 0xE0, 0x1C, 0x38, 0x30, 0x18, 0x60,
  0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60,
  0x38, 0x70, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0x0E, 0x1C,
  0x60, 0x66, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xF0, 0x39, 0x83, 0xC7, 0xF6, 0x1E, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x01, 0xE0, 0xFC, 0x07,
  0x80, 0x00, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x0E, 0x30, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xC1, 0x83, 0x0E,
  0x18, 0x60, 0x80, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x04, 0x3F, 0xFD, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x10,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0E,
  0x00, 0x20, 0x00, 0x0F, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x6E, 0x06,
  0xC0, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x07, 0x80, 0x8C, 0x0F,
  0xE0, 0x46, 0x0E, 0x18, 0x26, 0x06, 0x0C, 0x13, 0x06, 0x04, 0x09, 0x06,
  0x06, 0x05, 0x83, 0x03, 0x02, 0xC1, 0x81, 0x83, 0x61, 0x80, 0x81, 0xA0,
  0xC0, 0xC0, 0xD0, 0x60, 0x60, 0x58, 0x30, 0x30, 0x2C, 0x18, 0x10, 0x36,
  0x0C, 0x18, 0x13, 0x06, 0x1C, 0x19, 0x83, 0x1B, 0x18, 0xC1, 0xF9, 0xF8,
  0x20, 0x78, 0x78, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x04, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0,
  0xC0, 0x70, 0x10, 0x18, 0x06, 0x0E, 0x01, 0x83, 0xFF, 0xE1, 0xFF, 0xF8,
  0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x30, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0x01, 0xC1, 0x80,
  0x70, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C,
  0x03, 0x86, 0x03, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0x80, 0x60, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x78, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x07, 0x30, 0x00, 0xD8, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xE0, 0x06, 0x18,
  0x03, 0x06, 0x01, 0xC0, 0xE0, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x80, 0xC0, 0x70, 0x30, 0x0E, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x67, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x03,
  0x86, 0x01, 0xC1, 0x80, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x70, 0x38, 0x38, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x1F, 0xE6, 0x07, 0xF9, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xC7, 0x00, 0xE0,
  0xE0, 0x70, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x18, 0x60, 0x01,
  0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x00, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xE0,
  0x60, 0x60, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x06, 0x00, 0x70, 0xC0, 0x0E,
  0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x1C,
  0x01, 0x83, 0x80, 0x18, 0x70, 0x01, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0xB8,
  0x00, 0x3F, 0x80, 0x03, 0xEC, 0x00, 0x3C, 0xC0, 0x03, 0x86, 0x00, 0x30,
  0x60, 0x03, 0x03, 0x00, 0x70, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83,
  0xC0, 0x03, 0x60, 0xB0, 0x01, 0xF0, 0x66, 0x00, 0x6C, 0x19, 0x80, 0x33,
  0x06, 0x60, 0x0C, 0xC1, 0x98, 0x06, 0x30, 0x66, 0x01, 0x9C, 0x39, 0x80,
  0xC6, 0x0C, 0x30, 0x31, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30,
  0xC3, 0x06, 0x0C, 0x30, 0xC3, 0x07, 0x04, 0x60, 0xC1, 0x81, 0x98, 0x30,
  0x60, 0x6C, 0x0C, 0x18, 0x1B, 0x03, 0x06, 0x07, 0x81, 0xC1, 0x81, 0xE0,
  0x60, 0xC0, 0x30, 0x18, 0x30, 0x0C, 0x06, 0x00, 0x06, 0x00, 0x18, 0x70,
  0x01, 0xC3, 0xC0, 0x0C, 0x1E, 0x00, 0x60, 0xF0, 0x03, 0x06, 0xC0, 0x18,
  0x36, 0x00, 0xC3, 0x30, 0x0E, 0x18, 0xC0, 0x60, 0xC6, 0x03, 0x06, 0x18,
  0x18, 0x30, 0xC0, 0xC3, 0x86, 0x06, 0x18, 0x18, 0x60, 0xC0, 0xC3, 0x06,
  0x06, 0x18, 0x30, 0x18, 0xC1, 0x80, 0xC6, 0x1C, 0x07, 0x70, 0xC0, 0x1B,
  0x06, 0x00, 0xD8, 0x30, 0x03, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xF0, 0xC0,
  0x03, 0x86, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70,
  0x30, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07, 0x60, 0x01, 0x98, 0x00,
  0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0xE0, 0x06, 0x18, 0x01, 0x87, 0x00, 0xC0, 0xE0, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30,
  0x07, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x0E, 0x38, 0x07, 0x0F, 0xFF, 0x83,
  0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x30, 0x0E,
  0x18, 0x01, 0x86, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0x70, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC0, 0xE0, 0xE0, 0x3F, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x38, 0x60, 0x0C, 0x38, 0x0E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xC0,
  0xC0, 0x30, 0x38, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x38,
  0x03, 0x86, 0x00, 0xC0, 0xE0, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x01, 0xC6,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0xC0, 0x18, 0x18,
  0x07, 0x03, 0x81, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x01, 0xC6, 0x00,
  0x61, 0x80, 0x38, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0x41, 0x80, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xB0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x01, 0xE0,
  0x0C, 0x01, 0xF0, 0x0E, 0x00, 0xD8, 0x07, 0x80, 0x6C, 0x03, 0xC0, 0x66,
  0x03, 0x60, 0x33, 0x01, 0xB0, 0x19, 0x81, 0x98, 0x18, 0xC0, 0xCC, 0x0C,
  0x60, 0x66, 0x06, 0x30, 0x63, 0x06, 0x18, 0x31, 0x83, 0x0C, 0x30, 0x43,
  0x06, 0x18, 0x21, 0x83, 0x0C, 0x10, 0xC1, 0x8C, 0x08, 0xC0, 0x46, 0x06,
  0x60, 0x26, 0x03, 0x30, 0x1B, 0x01, 0xB0, 0x0D, 0x80, 0xD8, 0x07, 0x80,
  0x6C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x38, 0x38, 0x01, 0x80,
  0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x07, 0x0E,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00,
  0x01, 0xDC, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00, 0xE0,
  0x60, 0x06, 0x03, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x01, 0x83,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x31, 0xC0, 0x1C,
  0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0x60, 0x60, 0x18, 0x30, 0x06,
  0x1C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0xE0, 0x7C, 0x00, 0xC3, 0x0C, 0x30, 0xC1, 0x06, 0x18,
  0x61, 0x86, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x04, 0x18, 0x61, 0x86,
  0x18, 0x60, 0x83, 0x07, 0xC1, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x0F, 0x83, 0xE0,
  0x03, 0x00, 0xC0, 0x70, 0x1C, 0x0D, 0x83, 0x61, 0x98, 0x66, 0x30, 0x8C,
  0x26, 0x0D, 0x83, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x61, 0xC3, 0x06,
  0x18, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x86, 0x07, 0x30, 0x0C, 0xC0, 0x30,
  0x00, 0xC0, 0x06, 0x07, 0xF8, 0x7F, 0xE3, 0x81, 0x98, 0x06, 0xC0, 0x1B,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x87, 0xC7, 0xFB, 0x0F, 0x8C,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x19, 0xF0, 0x37, 0xF0, 0x78, 0x70, 0xC0, 0x63, 0x80,
  0xC6, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0xB0,
  0xE3, 0x7F, 0x86, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x8E, 0x03,
  0x30, 0x0D, 0xC0, 0x36, 0x00, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0x98, 0x0E, 0x60, 0x31, 0xC1,
  0x83, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x03, 0xC6, 0x07,
  0xFB, 0x07, 0x05, 0x87, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x71, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x0E, 0x01,
  0x86, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x38, 0x38, 0x78, 0x0F,
  0xFC, 0x03, 0xE6, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x86, 0x03, 0x30,
  0x0D, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0x7F, 0xFD, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC1, 0xC3,
  0xFE, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x7F, 0x87, 0xF8, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xE3, 0x07,
  0xFB, 0x0E, 0x0B, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x60, 0x0C, 0x60,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x38, 0x7C, 0x1F, 0xF8, 0x0F,
  0x98, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x40, 0x70, 0xE0,
  0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x19, 0xF0, 0x6F, 0xE1, 0xE1,
  0xC7, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0,
  0x36, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x06, 0xC0,
  0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xC1, 0x83, 0x00, 0x00, 0x60, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x0E, 0x30, 0x38, 0x60, 0xE0, 0xC3, 0x83, 0x0E, 0x06,
  0x38, 0x0C, 0xE0, 0x1B, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xEC, 0x03, 0x98,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0x70, 0x60, 0x60, 0xC0, 0xE1, 0x80, 0xC3,
  0x01, 0xC6, 0x01, 0x80, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x00, 0x19, 0xF0, 0x7C, 0x1B, 0xF8, 0xFE, 0x1E,
  0x1D, 0x87, 0x3C, 0x0F, 0x03, 0x38, 0x0E, 0x03, 0x30, 0x0E, 0x03, 0x30,
  0x0C, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x60, 0x0C, 0x03, 0x60,
  0x18, 0x03, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60,
  0x18, 0x06, 0xC0, 0x18, 0x06, 0xC0, 0x30, 0x06, 0xC0, 0x30, 0x0C, 0xC0,
  0x30, 0x0C, 0xC0, 0x30, 0x0C, 0x19, 0xF0, 0x6F, 0xE1, 0xE1, 0xCF, 0x03,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0D, 0xC0, 0x36, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x70, 0xC0, 0x63,
  0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80,
  0x3F, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x30,
  0x60, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x06, 0x7C, 0x03, 0x7F, 0x01, 0xE1,
  0xC1, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x8E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x18, 0x70, 0x0C, 0x38, 0x0E, 0x1A, 0x0E, 0x0D, 0xFE, 0x06, 0x3E,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC6, 0x1F, 0xEC, 0x70, 0x79,
  0xC0, 0x73, 0x00, 0xE6, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0x80, 0x33, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x38, 0xE0, 0xE0, 0xFF, 0xC0, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x19,
  0xE3, 0x78, 0x78, 0x1E, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x18,
  0xC0, 0x33, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x71, 0x83, 0x87, 0xFC,
  0x07, 0xC0, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x78, 0x38, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x1C, 0xC0, 0xE3, 0x87, 0x87, 0xF6,
  0x0F, 0x98, 0xC0, 0x1D, 0x00, 0x66, 0x01, 0x98, 0x0C, 0x60, 0x31, 0x81,
  0x86, 0x06, 0x18, 0x30, 0x20, 0xC0, 0x82, 0x03, 0x18, 0x0C, 0x60, 0x33,
  0x00, 0xCC, 0x03, 0x60, 0x05, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x60, 0x36, 0x03, 0x01, 0xB0, 0x38, 0x0D, 0x81, 0xC0, 0xCC,
  0x1A, 0x06, 0x60, 0xD0, 0x63, 0x04, 0xC3, 0x18, 0x66, 0x18, 0xC3, 0x31,
  0x86, 0x31, 0x8C, 0x31, 0x8C, 0x41, 0x98, 0x66, 0x04, 0xC3, 0x30, 0x24,
  0x1B, 0x01, 0x60, 0xD8, 0x0F, 0x02, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x06, 0x03, 0x81, 0x83,
  0x80, 0xC1, 0x80, 0x61, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x36, 0x00, 0x33, 0x00,
  0x31, 0x80, 0x38, 0x60, 0x18, 0x30, 0x18, 0x0C, 0x1C, 0x06, 0x0C, 0x03,
  0x00, 0x18, 0x03, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x20, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x40, 0x0C, 0x30, 0xC3,
  0x0C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0xE0, 0x0C, 0x00, 0x1E, 0x00, 0x9F, 0x80, 0xDC, 0xE0, 0x6C, 0x38, 0x2C,
  0x0E, 0x36, 0x03, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 7, 8, 10, 4, -28 },
  { 31, 19, 26, 18, 1, -26 },
  { 93, 16, 33, 17, 1, -30 },
  { 159, 17, 26, 23, 3, -26 },
  { 215, 17, 26, 19, 1, -26 },
  { 271, 4, 8, 6, 3, -28 },
  { 275, 10, 38, 10, 2, -30 },
  { 323, 11, 38, 11, -2, -29 },
  { 376, 14, 15, 15, 2, -26 },
  { 403, 15, 19, 18, 2, -21 },
  { 439, 5, 8, 7, -1, -3 },
  { 444, 7, 2, 9, 1, -13 },
  { 446, 3, 3, 9, 1, -3 },
  { 448, 16, 28, 13, -2, -26 },
  { 504, 14, 26, 17, 2, -26 },
  { 550, 8, 26, 17, 5, -26 },
  { 576, 15, 26, 17, 1, -26 },
  { 625, 15, 26, 17, 1, -26 },
  { 674, 15, 26, 17, 1, -26 },
  { 723, 16, 26, 17, 2, -26 },
  { 775, 13, 26, 17, 2, -26 },
  { 818, 15, 26, 17, 3, -26 },
  { 867, 16, 26, 17, 1, -26 },
  { 919, 13, 26, 17, 3, -26 },
  { 962, 6, 20, 7, 1, -20 },
  { 977, 7, 25, 7, -1, -20 },
  { 999, 14, 16, 16, 1, -20 },
  { 1027, 14, 9, 17, 2, -17 },
  { 1043, 14, 16, 16, 1, -20 },
  { 1071, 12, 26, 14, 3, -26 },
  { 1110, 25, 34, 28, 1, -26 },
  { 1217, 18, 26, 20, -1, -26 },
  { 1276, 17, 26, 19, 1, -26 },
  { 1332, 18, 26, 20, 2, -26 },
  { 1391, 18, 26, 20, 1, -26 },
  { 1450, 18, 26, 18, 1, -26 },
  { 1509, 18, 26, 18, 1, -26 },
  { 1568, 18, 26, 21, 2, -26 },
  { 1627, 21, 26, 22, 1, -26 },
  { 1696, 7, 26, 9, 1, -26 },
  { 1719, 16, 26, 17, 1, -26 },
  { 1771, 20, 26, 20, 1, -26 },
  { 1836, 13, 26, 17, 1, -26 },
  { 1879, 26, 26, 27, 1, -26 },
  { 1964, 21, 26, 22, 1, -26 },
  { 2033, 18, 26, 21, 2, -26 },
  { 2092, 18, 26, 19, 1, -26 },
  { 2151, 18, 31, 21, 2, -26 },
  { 2221, 18, 26, 20, 1, -26 },
  { 2280, 18, 26, 19, 1, -26 },
  { 2339, 17, 26, 19, 3, -26 },
  { 2395, 19, 26, 20, 2, -26 },
  { 2457, 18, 26, 19, 3, -26 },
  { 2516, 25, 26, 28, 4, -26 },
  { 2598, 21, 26, 19, -1, -26 },
  { 2667, 18, 26, 19, 3, -26 },
  { 2726, 19, 26, 19, 0, -26 },
  { 2788, 11, 36, 8, 0, -30 },
  { 2838, 6, 28, 13, 4, -26 },
  { 2859, 10, 36, 8, -2, -30 },
  { 2904, 10, 13, 13, 2, -26 },
  { 2921, 14, 2, 14, -2, 0 },
  { 2925, 6, 5, 10, 4, -28 },
  { 2929, 14, 20, 17, 1, -20 },
  { 2964, 15, 28, 17, 1, -28 },
  { 3017, 14, 20, 16, 1, -20 },
  { 3052, 17, 28, 18, 1, -28 },
  { 3112, 14, 20, 16, 1, -20 },
  { 3147, 12, 28, 11, 2, -28 },
  { 3189, 16, 28, 17, 0, -20 },
  { 3245, 14, 28, 17, 1, -28 },
  { 3294, 7, 27, 8, 1, -27 },
  { 3318, 12, 35, 8, -4, -27 },
  { 3371, 15, 28, 16, 1, -28 },
  { 3424, 7, 28, 8, 1, -28 },
  { 3449, 24, 20, 27, 1, -20 },
  { 3509, 14, 20, 17, 1, -20 },
  { 3544, 15, 20, 18, 1, -20 },
  { 3582, 17, 28, 17, -1, -20 },
  { 3642, 15, 28, 18, 1, -20 },
  { 3695, 11, 20, 11, 1, -20 },
  { 3723, 14, 20, 16, 1, -20 },
  { 3758, 8, 25, 10, 2, -25 },
  { 3783, 14, 20, 17, 2, -20 },
  { 3818, 14, 20, 15, 2, -20 },
  { 3853, 21, 20, 23, 3, -20 },
  { 3906, 17, 20, 15, -1, -20 },
  { 3949, 17, 28, 15, -1, -20 },
  { 4009, 15, 20, 15, 0, -20 },
  { 4047, 12, 36, 11, 1, -29 },
  { 4101, 6, 31, 8, 1, -26 },
  { 4125, 12, 36, 11, -2, -29 },
  { 4179, 17, 7, 21, 2, -15 },
};

const GFXfont RobotoCondensed_LightItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC37PT7B_H_
