#ifndef _ROBOTOCONDENSED_LIGHTITALIC24PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0x00, 0x08, 0x80, 0x4A, 0x52,
  0xA5, 0x00, 0x02, 0x20, 0x22, 0x04, 0x40, 0x44, 0x04, 0x43, 0xFF, 0x08,
  0x80, 0x88, 0x11, 0x01, 0x10, 0x11, 0x0F, 0xFC, 0x22, 0x02, 0x20, 0x44,
  0x04, 0x40, 0x44, 0x00, 0x02, 0x00, 0x80, 0xF0, 0x66, 0x30, 0xC8, 0x32,
  0x0C, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x68, 0x1A, 0x04,
  0xC3, 0x19, 0x83, 0xC0, 0x40, 0x10, 0x00, 0x38, 0x09, 0x81, 0x11, 0x42,
  0x28, 0x49, 0x0A, 0x12, 0x43, 0x90, 0x04, 0x01, 0xB8, 0x2C, 0x89, 0x13,
  0x22, 0x44, 0x50, 0x88, 0x12, 0x01, 0xC0, 0x0F, 0x06, 0x41, 0x08, 0xC6,
  0x31, 0x04, 0xC1, 0x60, 0x70, 0x38, 0x1B, 0x14, 0x47, 0x19, 0x82, 0xA0,
  0x68, 0x19, 0x9A, 0x3C, 0xC0, 0x55, 0x80, 0x02, 0x08, 0x30, 0xC1, 0x06,
  0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x06,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x10, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x60, 0x80, 0x04, 0x01, 0x00, 0x41, 0x13, 0x7F, 0x83, 0x01, 0xC0,
  0xD8, 0x62, 0x10, 0x80, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x3F, 0xF0,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x25, 0xA8, 0xF0, 0xA0, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x06,
  0x63, 0x08, 0x83, 0x60, 0xD0, 0x34, 0x0D, 0x02, 0x40, 0xB0, 0x2C, 0x0B,
  0x06, 0x81, 0x30, 0x44, 0x31, 0x98, 0x3C, 0x00, 0x0C, 0xEE, 0x82, 0x08,
  0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x07, 0x81, 0x98,
  0x41, 0x18, 0x32, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0x80, 0x0F, 0x06, 0x62,
  0x08, 0x83, 0x60, 0xC0, 0x20, 0x18, 0x0C, 0x1E, 0x00, 0xC0, 0x10, 0x06,
  0x81, 0xA0, 0x4C, 0x31, 0x98, 0x3C, 0x00, 0x00, 0x40, 0x18, 0x05, 0x01,
  0xE0, 0x2C, 0x09, 0x03, 0x20, 0x44, 0x10, 0x86, 0x30, 0x86, 0x20, 0x8F,
  0xFC, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x1F, 0xC2, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x0B, 0x81, 0x98, 0x01, 0x80, 0x10, 0x02, 0x00, 0x4C,
  0x08, 0x83, 0x10, 0x43, 0x30, 0x3C, 0x00, 0x03, 0x87, 0x06, 0x06, 0x02,
  0x01, 0x01, 0x38, 0xE6, 0x61, 0xA0, 0x70, 0x38, 0x1C, 0x1E, 0x09, 0x0C,
  0xCC, 0x3C, 0x00, 0xFF, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80,
  0x00, 0x0F, 0x06, 0x63, 0x0C, 0x83, 0x20, 0xC8, 0x32, 0x08, 0xCC, 0x1E,
  0x18, 0xCC, 0x12, 0x06, 0x81, 0xA0, 0x48, 0x31, 0x98, 0x3C, 0x00, 0x1E,
  0x19, 0x90, 0x58, 0x28, 0x14, 0x0A, 0x05, 0x02, 0xC3, 0x32, 0x9E, 0xC0,
  0x40, 0x20, 0x20, 0x30, 0x70, 0xE0, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00,
  0x04, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x31, 0x10,
  0x00, 0x81, 0xC3, 0x87, 0x0E, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x00, 0x3C, 0xCF, 0x0C, 0x10, 0x20,
  0x41, 0x86, 0x18, 0x60, 0x81, 0x00, 0x00, 0x00, 0x20, 0x40, 0x01, 0xF8,
  0x07, 0x0C, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x01, 0x20, 0xE1, 0x23, 0x11,
  0x42, 0x11, 0x44, 0x21, 0xC4, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88, 0x62,
  0x88, 0x42, 0x88, 0xC2, 0x8C, 0xE4, 0x87, 0x38, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x30, 0x80, 0x1F, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x14,
  0x03, 0x40, 0x24, 0x06, 0x60, 0x42, 0x0C, 0x20, 0x82, 0x18, 0x21, 0xFE,
  0x30, 0x22, 0x03, 0x60, 0x34, 0x01, 0xC0, 0x10, 0x1F, 0x86, 0x18, 0xC1,
  0x90, 0x32, 0x06, 0x40, 0xC8, 0x13, 0x0C, 0x7F, 0x08, 0x11, 0x03, 0x20,
  0x64, 0x0D, 0x81, 0xB0, 0x64, 0x18, 0xFE, 0x00, 0x07, 0xC0, 0xC6, 0x10,
  0x23, 0x02, 0x20, 0x36, 0x03, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x04, 0xC0, 0x44, 0x0C, 0x40, 0x87, 0x38, 0x1E, 0x00, 0x1F, 0x86,
  0x18, 0xC1, 0x90, 0x12, 0x02, 0x40, 0x48, 0x0B, 0x01, 0x60, 0x28, 0x05,
  0x01, 0xA0, 0x24, 0x05, 0x81, 0xB0, 0x64, 0x38, 0xFC, 0x00, 0x1F, 0xE6,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x7F, 0x88, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0xFF, 0x80, 0x1F, 0xE6,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x7F, 0x88, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x00, 0x07, 0xC0,
  0xC6, 0x10, 0x33, 0x03, 0x20, 0x16, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x3E, 0x40, 0x24, 0x06, 0x40, 0x64, 0x04, 0x60, 0x43, 0x1C, 0x1F, 0x00,
  0x10, 0x09, 0x80, 0xCC, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x4C,
  0x06, 0x7F, 0xF2, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x60, 0x33, 0x01,
  0x90, 0x08, 0x80, 0x40, 0x11, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0xCC,
  0x80, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x4C, 0x09, 0x83, 0x10, 0x43, 0x30, 0x3C,
  0x00, 0x10, 0x31, 0x83, 0x0C, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x98,
  0x0D, 0x80, 0x7C, 0x03, 0xA0, 0x19, 0x80, 0x84, 0x04, 0x30, 0x60, 0x83,
  0x06, 0x10, 0x10, 0x80, 0xC0, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0xFF, 0x10, 0x03,
  0x38, 0x03, 0x28, 0x07, 0x28, 0x07, 0x28, 0x0A, 0x28, 0x0A, 0x28, 0x12,
  0x6C, 0x12, 0x64, 0x26, 0x44, 0x26, 0x44, 0x44, 0x44, 0x44, 0x44, 0x84,
  0xC6, 0x84, 0xC3, 0x0C, 0x83, 0x0C, 0x82, 0x08, 0x10, 0x09, 0xC0, 0x4E,
  0x06, 0x50, 0x32, 0xC1, 0x12, 0x08, 0x90, 0x4C, 0xC6, 0x62, 0x32, 0x11,
  0x10, 0x48, 0x82, 0x44, 0x1A, 0x60, 0x73, 0x03, 0x90, 0x18, 0x80, 0x40,
  0x07, 0xC1, 0xC6, 0x10, 0x22, 0x03, 0x20, 0x16, 0x01, 0x40, 0x34, 0x03,
  0x40, 0x34, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x64, 0x04, 0x40, 0xC7, 0x38,
  0x1E, 0x00, 0x1F, 0x86, 0x1C, 0xC0, 0x90, 0x12, 0x02, 0x40, 0x48, 0x0B,
  0x03, 0x61, 0xCF, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x00, 0x07, 0x81, 0xC6, 0x10, 0x22, 0x03, 0x20, 0x36, 0x03, 0x40,
  0x34, 0x03, 0x40, 0x24, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x64, 0x04, 0x40,
  0xC7, 0x38, 0x1F, 0x00, 0x10, 0x01, 0x80, 0x08, 0x1F, 0x86, 0x18, 0xC1,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x1B, 0x02, 0x61, 0x8F, 0xE1, 0x0C, 0x20,
  0x8C, 0x11, 0x83, 0x20, 0x64, 0x04, 0x80, 0xC0, 0x0F, 0x83, 0x18, 0xC1,
  0x90, 0x32, 0x02, 0x40, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x00,
  0x68, 0x0D, 0x01, 0x30, 0x63, 0x18, 0x3E, 0x00, 0xFF, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x00, 0x30, 0x13, 0x01, 0x20,
  0x12, 0x03, 0x20, 0x32, 0x02, 0x60, 0x26, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0x40, 0x86, 0x38, 0x3E, 0x00, 0xC0, 0x2C,
  0x02, 0xC0, 0x64, 0x04, 0x40, 0xC4, 0x08, 0x41, 0x84, 0x10, 0x63, 0x02,
  0x20, 0x26, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x03, 0x80, 0x10, 0x00,
  0xC0, 0x81, 0xE0, 0xC0, 0xB0, 0x60, 0x48, 0x30, 0x64, 0x2C, 0x22, 0x12,
  0x31, 0x19, 0x10, 0x88, 0x88, 0x44, 0x4C, 0x24, 0x24, 0x12, 0x12, 0x0B,
  0x0B, 0x05, 0x05, 0x02, 0x82, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x00, 0x10, 0x18, 0xC0, 0x86, 0x08, 0x10, 0xC0, 0xCC, 0x02, 0x40, 0x16,
  0x00, 0xE0, 0x02, 0x00, 0x38, 0x03, 0x40, 0x32, 0x01, 0x18, 0x18, 0x41,
  0x83, 0x08, 0x08, 0xC0, 0x40, 0xC0, 0x24, 0x06, 0x40, 0xC6, 0x08, 0x21,
  0x82, 0x30, 0x22, 0x03, 0x60, 0x14, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xFF, 0xC0, 0x0E,
  0x30, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x08,
  0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x70, 0x44, 0x44, 0x44, 0x62,
  0x22, 0x22, 0x23, 0x11, 0x11, 0x1C, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08,
  0x20, 0x86, 0x18, 0x41, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x38, 0x0C,
  0x18, 0x50, 0xA3, 0x44, 0x99, 0x23, 0xC2, 0xFF, 0x00, 0xC8, 0x80, 0x0F,
  0x06, 0x63, 0x08, 0x83, 0x00, 0x87, 0xE3, 0x09, 0x82, 0x41, 0x90, 0x64,
  0x31, 0x9C, 0x39, 0x00, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x05, 0xE3,
  0x9C, 0xC1, 0x20, 0x48, 0x12, 0x04, 0x81, 0x60, 0x58, 0x34, 0x09, 0x86,
  0x73, 0x17, 0x80, 0x1E, 0x19, 0x98, 0x68, 0x3C, 0x0C, 0x02, 0x01, 0x00,
  0x80, 0x40, 0xA0, 0xCC, 0xC3, 0xC0, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x3D, 0x8C, 0xE3, 0x0C, 0x40, 0x98, 0x13, 0x06, 0x40, 0xC8, 0x11,
  0x02, 0x20, 0x46, 0x18, 0x67, 0x0F, 0x60, 0x1E, 0x19, 0x98, 0x68, 0x3C,
  0x1C, 0x0F, 0xFF, 0x00, 0x80, 0x40, 0x30, 0x0C, 0xC3, 0xC0, 0x07, 0x0C,
  0x18, 0x10, 0x10, 0x7C, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x0F, 0x63, 0x38, 0xC3, 0x10, 0x26, 0x04, 0xC1,
  0x90, 0x32, 0x04, 0x40, 0x88, 0x11, 0x86, 0x19, 0xC3, 0xD8, 0x02, 0x00,
  0x40, 0x18, 0xE6, 0x07, 0x80, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x05,
  0xE3, 0x88, 0xC3, 0x30, 0xC8, 0x32, 0x0C, 0x82, 0x60, 0x98, 0x24, 0x09,
  0x06, 0x41, 0x90, 0x40, 0x33, 0x00, 0x02, 0x26, 0x64, 0x44, 0x4C, 0xC8,
  0x88, 0x03, 0x03, 0x00, 0x00, 0x00, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x30, 0xE0,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x33, 0x18, 0xCC, 0x26, 0x0B,
  0x02, 0x80, 0xF0, 0x64, 0x19, 0x04, 0x21, 0x08, 0x43, 0x10, 0x40, 0x13,
  0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0xC8, 0x88, 0x17, 0x8E, 0x38, 0xB3,
  0x30, 0xE1, 0x20, 0xC1, 0x20, 0xC1, 0x20, 0xC1, 0x60, 0x81, 0x60, 0x81,
  0x40, 0x83, 0x40, 0x83, 0x41, 0x82, 0x41, 0x82, 0xC1, 0x02, 0x17, 0x8E,
  0x23, 0x0C, 0xC3, 0x20, 0xC8, 0x32, 0x09, 0x82, 0x60, 0x90, 0x24, 0x19,
  0x06, 0x41, 0x00, 0x1E, 0x18, 0x98, 0x28, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xB0, 0xCC, 0xC3, 0xC0, 0x17, 0x8E, 0x73, 0x04, 0x81, 0x20,
  0x48, 0x12, 0x05, 0x81, 0x60, 0xD0, 0x26, 0x19, 0xCC, 0x5E, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0xCC, 0xE6, 0x19, 0x02, 0xC0, 0xB0,
  0x68, 0x1A, 0x04, 0x81, 0x20, 0x4C, 0x31, 0x9C, 0x7B, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x80, 0x16, 0x3C, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x40, 0x0F, 0x06, 0x63, 0x08, 0x82, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x10, 0x44, 0x11, 0x8C, 0x3E, 0x00, 0x10, 0x43,
  0x3F, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x04, 0x1C, 0x20, 0x98,
  0x26, 0x09, 0x02, 0x41, 0x90, 0x64, 0x13, 0x04, 0xC1, 0x30, 0x4C, 0x31,
  0x9C, 0x7A, 0x00, 0x40, 0xA0, 0xD0, 0x48, 0x64, 0x22, 0x31, 0x90, 0x48,
  0x28, 0x14, 0x0E, 0x06, 0x03, 0x00, 0x82, 0x0C, 0x30, 0xE1, 0x85, 0x1C,
  0x28, 0xA3, 0x45, 0x92, 0x4D, 0x92, 0x28, 0xF1, 0x47, 0x0E, 0x38, 0x61,
  0x83, 0x04, 0x10, 0x00, 0x20, 0xCC, 0x61, 0x10, 0x4C, 0x1E, 0x03, 0x00,
  0xC0, 0x70, 0x14, 0x09, 0x86, 0x21, 0x0C, 0x81, 0x00, 0x10, 0x22, 0x0C,
  0x41, 0x08, 0x61, 0x08, 0x33, 0x06, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x1C, 0x00, 0x3F, 0xC0,
  0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03,
  0x00, 0xFF, 0x00, 0x02, 0x08, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60,
  0x83, 0x08, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x0C, 0x08, 0x08,
  0x18, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11,
  0x80, 0x10, 0x10, 0x30, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x30, 0x20,
  0x61, 0x86, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x10, 0x40, 0x38, 0x2D,
  0x85, 0x1D, 0xE0, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 5, 5, 7, 2, -18 },
  { 14, 12, 17, 12, 1, -17 },
  { 40, 10, 21, 11, 1, -19 },
  { 67, 11, 17, 15, 2, -17 },
  { 91, 10, 17, 13, 1, -17 },
  { 113, 2, 5, 4, 2, -18 },
  { 115, 7, 25, 7, 1, -19 },
  { 137, 7, 25, 7, -1, -19 },
  { 159, 10, 10, 10, 1, -17 },
  { 172, 10, 12, 12, 1, -13 },
  { 187, 3, 5, 4, -1, -2 },
  { 189, 4, 1, 6, 1, -8 },
  { 190, 2, 2, 6, 1, -2 },
  { 191, 10, 18, 8, -1, -17 },
  { 214, 10, 17, 11, 1, -17 },
  { 236, 6, 17, 11, 3, -17 },
  { 249, 11, 17, 11, 0, -17 },
  { 273, 10, 17, 11, 1, -17 },
  { 295, 11, 17, 11, 0, -17 },
  { 319, 11, 17, 11, 1, -17 },
  { 343, 9, 17, 11, 1, -17 },
  { 363, 10, 17, 11, 2, -17 },
  { 385, 10, 17, 11, 1, -17 },
  { 407, 9, 17, 11, 2, -17 },
  { 427, 4, 13, 5, 0, -13 },
  { 434, 5, 16, 4, -1, -13 },
  { 444, 9, 10, 10, 1, -13 },
  { 456, 9, 6, 11, 1, -11 },
  { 463, 9, 10, 11, 1, -13 },
  { 475, 7, 17, 9, 2, -17 },
  { 490, 16, 22, 18, 1, -17 },
  { 534, 12, 17, 13, -1, -17 },
  { 560, 11, 17, 12, 1, -17 },
  { 584, 12, 17, 13, 1, -17 },
  { 610, 11, 17, 13, 1, -17 },
  { 634, 11, 17, 12, 1, -17 },
  { 658, 11, 17, 11, 1, -17 },
  { 682, 12, 17, 14, 1, -17 },
  { 708, 13, 17, 14, 1, -17 },
  { 736, 4, 17, 6, 1, -17 },
  { 745, 11, 17, 11, 0, -17 },
  { 769, 13, 17, 13, 1, -17 },
  { 797, 8, 17, 11, 1, -17 },
  { 814, 16, 17, 17, 1, -17 },
  { 848, 13, 17, 14, 1, -17 },
  { 876, 12, 17, 14, 1, -17 },
  { 902, 11, 17, 13, 1, -17 },
  { 926, 12, 20, 14, 1, -17 },
  { 956, 11, 17, 13, 1, -17 },
  { 980, 11, 17, 12, 1, -17 },
  { 1004, 11, 17, 12, 2, -17 },
  { 1028, 12, 17, 13, 1, -17 },
  { 1054, 12, 17, 13, 2, -17 },
  { 1080, 17, 17, 18, 2, -17 },
  { 1117, 13, 17, 12, 0, -17 },
  { 1145, 12, 17, 12, 2, -17 },
  { 1171, 13, 17, 12, 0, -17 },
  { 1199, 7, 24, 5, 0, -20 },
  { 1220, 4, 18, 8, 2, -17 },
  { 1229, 6, 24, 5, -1, -20 },
  { 1247, 7, 9, 9, 1, -17 },
  { 1255, 9, 1, 9, -1, 0 },
  { 1257, 3, 3, 7, 3, -18 },
  { 1259, 10, 13, 11, 0, -13 },
  { 1276, 10, 18, 11, 0, -18 },
  { 1299, 9, 13, 11, 1, -13 },
  { 1314, 11, 18, 11, 1, -18 },
  { 1339, 9, 13, 11, 1, -13 },
  { 1354, 8, 18, 7, 1, -18 },
  { 1372, 11, 18, 11, 0, -13 },
  { 1397, 10, 18, 11, 0, -18 },
  { 1420, 4, 18, 5, 1, -18 },
  { 1429, 8, 23, 5, -3, -18 },
  { 1452, 10, 18, 10, 0, -18 },
  { 1475, 4, 18, 5, 1, -18 },
  { 1484, 16, 13, 18, 0, -13 },
  { 1510, 10, 13, 11, 0, -13 },
  { 1527, 9, 13, 11, 1, -13 },
  { 1542, 10, 18, 11, 0, -13 },
  { 1565, 10, 18, 11, 1, -13 },
  { 1588, 8, 13, 7, 0, -13 },
  { 1601, 10, 13, 10, 0, -13 },
  { 1618, 6, 16, 7, 1, -16 },
  { 1630, 10, 13, 11, 1, -13 },
  { 1647, 9, 13, 10, 1, -13 },
  { 1662, 13, 13, 15, 2, -13 },
  { 1684, 10, 13, 10, 0, -13 },
  { 1701, 11, 18, 10, -1, -13 },
  { 1726, 10, 13, 10, 0, -13 },
  { 1743, 7, 24, 7, 1, -19 },
  { 1764, 5, 20, 5, 0, -17 },
  { 1777, 7, 24, 7, -1, -19 },
  { 1798, 11, 4, 14, 1, -9 },
};

const GFXfont RobotoCondensed_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC24PT7B_H_
