#ifndef _ROBOTOCONDENSED_LIGHTITALIC20PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x24, 0x00, 0x44, 0x55, 0x9A, 0x04, 0x82,
  0x20, 0x90, 0x24, 0x7F, 0x84, 0x81, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0x41,
  0x20, 0x48, 0x22, 0x00, 0x04, 0x04, 0x1E, 0x23, 0x21, 0x41, 0x40, 0x20,
  0x30, 0x0C, 0x06, 0x02, 0x82, 0x82, 0xC4, 0x78, 0x20, 0x20, 0x70, 0x48,
  0x22, 0x51, 0x49, 0x24, 0xA1, 0xA0, 0x16, 0x14, 0x94, 0x52, 0x29, 0x10,
  0x90, 0x38, 0x1C, 0x19, 0x08, 0x84, 0x42, 0x41, 0x40, 0x40, 0xF2, 0xC9,
  0x46, 0xA1, 0x90, 0x4C, 0x63, 0xC8, 0x6A, 0x04, 0x21, 0x0C, 0x20, 0x84,
  0x10, 0x43, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x20, 0x10,
  0x40, 0x82, 0x08, 0x20, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x82, 0x10, 0x80, 0x08, 0x08, 0x09, 0x77, 0x18, 0x28, 0x6C, 0x44, 0x08,
  0x08, 0x08, 0x08, 0x18, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x28,
  0xE0, 0x70, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x1E, 0x22, 0x61, 0x41, 0x41,
  0x41, 0xC1, 0x82, 0x82, 0x82, 0x82, 0x84, 0xCC, 0x78, 0x1F, 0x91, 0x22,
  0x22, 0x26, 0x44, 0x44, 0x0F, 0x08, 0x88, 0x24, 0x10, 0x18, 0x08, 0x0C,
  0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07, 0xF8, 0x1E, 0x22, 0x41, 0x41,
  0x03, 0x06, 0x18, 0x04, 0x02, 0x02, 0x82, 0x86, 0xC4, 0x78, 0x01, 0x81,
  0x80, 0xC0, 0xA0, 0x90, 0x88, 0x48, 0x44, 0x42, 0x7F, 0xC0, 0x80, 0x40,
  0x40, 0x20, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x02, 0xE1, 0x98, 0x04, 0x02,
  0x01, 0x20, 0x90, 0x44, 0x41, 0xC0, 0x06, 0x30, 0x81, 0x04, 0x0B, 0x98,
  0xE1, 0x83, 0x06, 0x0C, 0x14, 0x47, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x00, 0x1E,
  0x23, 0x61, 0x41, 0x41, 0x22, 0x3C, 0x44, 0x82, 0x82, 0x82, 0x86, 0xC4,
  0x78, 0x1C, 0x22, 0x43, 0x41, 0x41, 0x43, 0x43, 0x46, 0x3A, 0x02, 0x04,
  0x04, 0x18, 0x60, 0x22, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x11, 0x00, 0x00,
  0x00, 0x02, 0x24, 0x48, 0x02, 0x1C, 0x63, 0x08, 0x08, 0x0C, 0x06, 0x04,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x40, 0xC0, 0x60, 0x60, 0x21, 0x8C, 0x60,
  0x80, 0x39, 0x38, 0x61, 0x0C, 0x21, 0x08, 0x41, 0x00, 0x00, 0x02, 0x00,
  0x03, 0xE0, 0x61, 0x84, 0x02, 0x40, 0x12, 0x38, 0xA2, 0x25, 0x22, 0x31,
  0x11, 0x88, 0x8C, 0x84, 0x64, 0x23, 0x22, 0x29, 0x29, 0x46, 0x72, 0x00,
  0x18, 0x00, 0x61, 0x01, 0xF0, 0x00, 0x01, 0x00, 0xC0, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x10, 0x87, 0xF2, 0x04, 0x81, 0x40, 0x50, 0x10,
  0x3E, 0x10, 0x88, 0x2C, 0x14, 0x12, 0x19, 0xF0, 0x86, 0x41, 0x60, 0xA0,
  0x50, 0x68, 0x67, 0xE0, 0x0F, 0x04, 0x62, 0x09, 0x03, 0x40, 0xD0, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x68, 0x13, 0x04, 0x42, 0x0F, 0x00, 0x3E, 0x10,
  0x88, 0x2C, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xE0, 0xE0, 0x50, 0x68,
  0x67, 0xC0, 0x3F, 0x90, 0x08, 0x0C, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x08, 0x07, 0xF0, 0x3F, 0x90, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0xF8, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0x04,
  0x22, 0x0D, 0x81, 0x40, 0x10, 0x04, 0x01, 0x1E, 0x80, 0xA0, 0x28, 0x19,
  0x04, 0x63, 0x0F, 0x80, 0x20, 0x24, 0x08, 0x81, 0x30, 0x24, 0x04, 0x80,
  0x9F, 0xF2, 0x04, 0x40, 0x98, 0x12, 0x02, 0x40, 0x48, 0x19, 0x02, 0x00,
  0x24, 0x96, 0x92, 0x4B, 0x49, 0x00, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0xB0, 0x98, 0x44, 0x41, 0xC0, 0x20, 0xC8,
  0x62, 0x11, 0x88, 0x44, 0x12, 0x05, 0x81, 0xA0, 0x4C, 0x31, 0x08, 0x42,
  0x08, 0x82, 0x20, 0x40, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x1F, 0x80, 0x30, 0x09, 0x80, 0xCC, 0x06, 0xA0, 0x55,
  0x03, 0xA8, 0x29, 0x21, 0x49, 0x12, 0x49, 0x96, 0x48, 0xA2, 0xC9, 0x14,
  0x48, 0x42, 0x42, 0x10, 0x20, 0x26, 0x0C, 0xC1, 0x38, 0x24, 0x84, 0x90,
  0x93, 0x12, 0x24, 0x44, 0x98, 0x52, 0x0A, 0x41, 0x48, 0x19, 0x02, 0x00,
  0x0F, 0x0C, 0x62, 0x09, 0x01, 0x40, 0x50, 0x14, 0x0B, 0x02, 0x80, 0xA0,
  0x28, 0x1B, 0x04, 0x42, 0x0F, 0x00, 0x3F, 0x10, 0xC8, 0x2C, 0x14, 0x0A,
  0x05, 0x04, 0xFC, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0x0C,
  0x62, 0x09, 0x01, 0x40, 0x50, 0x14, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x1B,
  0x04, 0x42, 0x0F, 0x00, 0x20, 0x04, 0x3F, 0x10, 0xC8, 0x2C, 0x14, 0x0A,
  0x0D, 0x0C, 0xFC, 0x44, 0x63, 0x20, 0x90, 0x48, 0x24, 0x08, 0x0F, 0x06,
  0x23, 0x04, 0x81, 0x20, 0x04, 0x01, 0xC0, 0x0C, 0x01, 0x00, 0x24, 0x09,
  0x06, 0x63, 0x0F, 0x80, 0xFF, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x20, 0x48, 0x16, 0x05,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0xC0, 0xA0, 0x48, 0x12, 0x04, 0x42,
  0x0F, 0x00, 0x80, 0xC0, 0xE0, 0x50, 0x2C, 0x22, 0x11, 0x10, 0x88, 0x48,
  0x24, 0x16, 0x0A, 0x03, 0x01, 0x00, 0x82, 0x0E, 0x08, 0x28, 0x50, 0xA1,
  0x44, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x63, 0x45, 0x06,
  0x14, 0x18, 0x60, 0x41, 0x81, 0x06, 0x00, 0x30, 0x62, 0x08, 0x42, 0x0C,
  0xC0, 0x90, 0x14, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40, 0xC8, 0x30, 0x84,
  0x11, 0x03, 0x00, 0x80, 0xC0, 0x90, 0xC8, 0x44, 0x43, 0x60, 0xA0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x3F, 0xC0, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x3F,
  0xC0, 0x1C, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x10, 0xC2, 0x0E, 0x00, 0x92, 0x24, 0x92, 0x48, 0x92, 0x48, 0x18, 0x20,
  0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x8E,
  0x00, 0x10, 0x62, 0x8A, 0x49, 0x28, 0x80, 0xFE, 0x48, 0x80, 0x1E, 0x33,
  0x21, 0x01, 0x01, 0x3F, 0x62, 0x42, 0xC2, 0x46, 0x7A, 0x10, 0x10, 0x10,
  0x20, 0x2E, 0x31, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x43, 0x62, 0x9C,
  0x3C, 0xCD, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x85, 0x09, 0xE0, 0x01, 0x80,
  0x80, 0x40, 0x23, 0xD3, 0x29, 0x0D, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48,
  0x46, 0x61, 0xD0, 0x3C, 0xCD, 0x0C, 0x18, 0x3F, 0xE0, 0x40, 0x81, 0x89,
  0xE0, 0x0C, 0x42, 0x08, 0xF8, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08,
  0x00, 0x1E, 0x99, 0x48, 0x48, 0x24, 0x12, 0x09, 0x04, 0x82, 0x42, 0x33,
  0x0E, 0x80, 0x40, 0x24, 0x21, 0xE0, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31,
  0x21, 0x21, 0x21, 0x41, 0x41, 0x43, 0x42, 0x42, 0xC2, 0x24, 0x04, 0x92,
  0x5A, 0x49, 0x20, 0x04, 0x10, 0x00, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x8C, 0x00, 0x10, 0x08, 0x04, 0x04, 0x02, 0x11,
  0x10, 0x90, 0x50, 0x30, 0x3C, 0x12, 0x09, 0x84, 0x42, 0x23, 0x08, 0x24,
  0x94, 0x92, 0x5A, 0x49, 0x20, 0x2E, 0x78, 0xC6, 0x22, 0x18, 0x48, 0x41,
  0x61, 0x0D, 0x04, 0x24, 0x10, 0x90, 0xC2, 0x42, 0x09, 0x08, 0x2C, 0x21,
  0x80, 0x2E, 0x31, 0x21, 0x21, 0x61, 0x41, 0x41, 0x43, 0x42, 0x42, 0xC2,
  0x3C, 0x62, 0x42, 0x83, 0x83, 0x82, 0x82, 0x82, 0x86, 0xC4, 0x78, 0x2E,
  0x31, 0x21, 0x21, 0x61, 0x41, 0x41, 0x41, 0x43, 0x62, 0xDC, 0x80, 0x80,
  0x80, 0x80, 0x3D, 0x65, 0x42, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C,
  0x74, 0x04, 0x04, 0x04, 0x08, 0x2C, 0xC2, 0x08, 0x61, 0x04, 0x10, 0x41,
  0x0C, 0x00, 0x1E, 0x23, 0x21, 0x20, 0x30, 0x1C, 0x06, 0x02, 0xC2, 0x46,
  0x3C, 0x21, 0x3C, 0x46, 0x21, 0x08, 0x42, 0x21, 0x86, 0x00, 0x41, 0x43,
  0x42, 0x42, 0xC2, 0x82, 0x82, 0x86, 0x84, 0xCC, 0x74, 0x82, 0xC2, 0x44,
  0x44, 0x4C, 0x48, 0x48, 0x50, 0x50, 0x20, 0x20, 0x46, 0x34, 0x62, 0x46,
  0x24, 0xA4, 0x4A, 0x45, 0x24, 0x52, 0x85, 0x28, 0x63, 0x06, 0x30, 0x41,
  0x00, 0x21, 0x22, 0x36, 0x14, 0x18, 0x18, 0x18, 0x28, 0x64, 0x44, 0x86,
  0x20, 0x8C, 0x21, 0x10, 0x44, 0x12, 0x04, 0x81, 0x60, 0x50, 0x14, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x0C, 0x00, 0x3F, 0x03, 0x02, 0x04, 0x08,
  0x18, 0x10, 0x20, 0x40, 0xC0, 0xFE, 0x04, 0x21, 0x04, 0x20, 0x82, 0x08,
  0x21, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x08, 0x11, 0x12, 0x22,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x80, 0x10, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x11, 0x84, 0x10, 0x43, 0x08, 0x20, 0x84, 0x20, 0x70, 0xA4, 0x63,
  0x30, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 4, 6, 2, -15 },
  { 10, 10, 14, 10, 1, -14 },
  { 28, 8, 18, 9, 1, -16 },
  { 46, 9, 14, 12, 2, -14 },
  { 62, 9, 14, 10, 1, -14 },
  { 78, 2, 4, 3, 2, -15 },
  { 79, 6, 21, 6, 1, -16 },
  { 95, 6, 21, 6, -1, -16 },
  { 111, 8, 8, 8, 1, -14 },
  { 119, 8, 11, 10, 1, -12 },
  { 130, 3, 5, 4, -1, -2 },
  { 132, 4, 1, 5, 1, -7 },
  { 133, 2, 2, 5, 0, -2 },
  { 134, 9, 15, 7, -1, -14 },
  { 151, 8, 14, 9, 1, -14 },
  { 165, 4, 14, 9, 3, -14 },
  { 172, 9, 14, 9, 0, -14 },
  { 188, 8, 14, 9, 1, -14 },
  { 202, 9, 14, 9, 0, -14 },
  { 218, 9, 14, 9, 1, -14 },
  { 234, 7, 14, 9, 1, -14 },
  { 247, 9, 14, 9, 1, -14 },
  { 263, 8, 14, 9, 1, -14 },
  { 277, 8, 14, 9, 1, -14 },
  { 291, 4, 11, 4, 0, -11 },
  { 297, 4, 14, 4, -1, -11 },
  { 304, 7, 9, 9, 1, -11 },
  { 312, 8, 5, 9, 1, -9 },
  { 317, 7, 9, 9, 1, -11 },
  { 325, 6, 14, 8, 2, -14 },
  { 336, 13, 18, 15, 1, -14 },
  { 366, 10, 14, 11, -1, -14 },
  { 384, 9, 14, 10, 1, -14 },
  { 400, 10, 14, 11, 1, -14 },
  { 418, 9, 14, 11, 1, -14 },
  { 434, 9, 14, 10, 1, -14 },
  { 450, 9, 14, 10, 1, -14 },
  { 466, 10, 14, 12, 1, -14 },
  { 484, 11, 14, 12, 1, -14 },
  { 504, 3, 14, 5, 1, -14 },
  { 510, 9, 14, 9, 0, -14 },
  { 526, 10, 14, 11, 1, -14 },
  { 544, 7, 14, 9, 1, -14 },
  { 557, 13, 14, 15, 1, -14 },
  { 580, 11, 14, 12, 1, -14 },
  { 600, 10, 14, 11, 1, -14 },
  { 618, 9, 14, 10, 1, -14 },
  { 634, 10, 16, 11, 1, -14 },
  { 654, 9, 14, 11, 1, -14 },
  { 670, 10, 14, 10, 0, -14 },
  { 688, 9, 14, 10, 2, -14 },
  { 704, 10, 14, 11, 1, -14 },
  { 722, 9, 14, 11, 2, -14 },
  { 738, 14, 14, 15, 2, -14 },
  { 763, 11, 14, 10, 0, -14 },
  { 783, 9, 14, 10, 2, -14 },
  { 799, 10, 14, 10, 0, -14 },
  { 817, 6, 19, 4, 0, -16 },
  { 832, 3, 15, 7, 2, -14 },
  { 838, 6, 19, 4, -1, -16 },
  { 853, 6, 7, 7, 1, -14 },
  { 859, 7, 1, 7, -1, 0 },
  { 860, 3, 3, 6, 2, -15 },
  { 862, 8, 11, 9, 0, -11 },
  { 873, 8, 15, 9, 0, -15 },
  { 888, 7, 11, 9, 1, -11 },
  { 898, 9, 15, 9, 1, -15 },
  { 915, 7, 11, 9, 1, -11 },
  { 925, 6, 15, 6, 1, -15 },
  { 937, 9, 15, 9, 0, -11 },
  { 954, 8, 15, 9, 0, -15 },
  { 969, 3, 15, 4, 1, -15 },
  { 975, 6, 19, 4, -2, -15 },
  { 990, 9, 15, 8, 0, -15 },
  { 1007, 3, 15, 4, 1, -15 },
  { 1013, 14, 11, 15, 0, -11 },
  { 1033, 8, 11, 9, 0, -11 },
  { 1044, 8, 11, 10, 1, -11 },
  { 1055, 8, 15, 9, 0, -11 },
  { 1070, 8, 15, 10, 1, -11 },
  { 1085, 6, 11, 6, 0, -11 },
  { 1094, 8, 11, 9, 0, -11 },
  { 1105, 5, 13, 6, 1, -13 },
  { 1114, 8, 11, 9, 1, -11 },
  { 1125, 8, 11, 8, 1, -11 },
  { 1136, 12, 11, 13, 1, -11 },
  { 1153, 8, 11, 8, 0, -11 },
  { 1164, 10, 15, 8, -1, -11 },
  { 1183, 8, 11, 8, 0, -11 },
  { 1194, 6, 20, 6, 1, -16 },
  { 1209, 4, 17, 4, 0, -14 },
  { 1218, 6, 20, 6, -1, -16 },
  { 1233, 9, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC20PT7B_H_
