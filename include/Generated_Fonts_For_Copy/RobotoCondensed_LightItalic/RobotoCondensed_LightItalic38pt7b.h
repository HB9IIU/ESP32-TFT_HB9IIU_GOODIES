#ifndef _ROBOTOCONDENSED_LIGHTITALIC38PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xC3,
  0x00, 0x66, 0xCD, 0x9B, 0x34, 0x78, 0xB3, 0x66, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x82, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x06, 0x18, 0x01, 0x82,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x00, 0x82, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x82, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0x82, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x03,
  0xFC, 0x07, 0x0E, 0x0E, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x38, 0x38, 0x70, 0x1F,
  0xE0, 0x0F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x18, 0xC0, 0x18, 0x20, 0x4C, 0x10, 0x34, 0x0C, 0x32, 0x04, 0x31,
  0x02, 0x10, 0x83, 0x18, 0x61, 0x98, 0x31, 0x98, 0x0F, 0xCC, 0x03, 0xCC,
  0x00, 0x0C, 0x00, 0x06, 0x78, 0x06, 0x7E, 0x06, 0x61, 0x06, 0x20, 0xC3,
  0x30, 0x63, 0x18, 0x33, 0x0C, 0x19, 0x86, 0x0D, 0x83, 0x06, 0x81, 0x86,
  0x00, 0xC3, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0xC3, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x70, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x06, 0x18, 0x03, 0x38, 0x01, 0xB8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0x77, 0x00, 0x71, 0x83, 0x30, 0xE1, 0xB0, 0x30, 0xD8, 0x1C, 0xDC,
  0x06, 0x6C, 0x01, 0xE6, 0x00, 0xF3, 0x80, 0x30, 0xC0, 0x38, 0x70, 0x76,
  0x1F, 0xF3, 0x03, 0xE0, 0xC0, 0x6D, 0x6D, 0xB4, 0x00, 0x20, 0x1C, 0x07,
  0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x3E, 0x31, 0xDF, 0x5F, 0x87, 0xF0, 0x03,
  0x00, 0x0F, 0x00, 0x33, 0x00, 0xC6, 0x03, 0x06, 0x0E, 0x0C, 0x08, 0x08,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x18, 0x40, 0xFF, 0xFE,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0xC6, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x70, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x00,
  0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x30, 0x30, 0x70, 0xE0, 0x7F,
  0x80, 0x7C, 0x00, 0x01, 0x83, 0x8F, 0xDF, 0x6C, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x00, 0x01, 0xF0,
  0x03, 0xFC, 0x0E, 0x0E, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x07, 0x38, 0x03,
  0x30, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0x0E, 0x0C, 0x06,
  0x18, 0x07, 0x18, 0x03, 0x18, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x3C, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0x60, 0x18, 0x60, 0x38, 0x30, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xEC,
  0x00, 0xCC, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x18,
  0x1C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x70, 0x38, 0x60, 0x30, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1B, 0xE0, 0x3F, 0xF0, 0x3C, 0x38, 0x30, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18,
  0x60, 0x18, 0x60, 0x30, 0x30, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x3C,
  0x07, 0xE0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xCF, 0x86, 0xFF, 0x1F, 0x0E, 0x70, 0x19, 0x80, 0x6E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00,
  0x66, 0x03, 0x18, 0x1C, 0x70, 0xE0, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x07,
  0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06,
  0x0C, 0x0E, 0x0E, 0x1C, 0x07, 0xF8, 0x0F, 0xF0, 0x1C, 0x38, 0x30, 0x1C,
  0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xE0, 0x18, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0xC1, 0xC3, 0x0C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xE6, 0x07,
  0x9C, 0x36, 0x3F, 0xB0, 0x7C, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E,
  0x30, 0x06, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x80, 0x00, 0x04, 0x00, 0x60, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x38, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0E, 0x00, 0x08, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x10, 0x00,
  0x60, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x0E, 0x00,
  0x20, 0x00, 0x0F, 0x81, 0xFE, 0x38, 0x67, 0x07, 0x60, 0x36, 0x03, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x38, 0x00, 0x03, 0x0C, 0x07, 0x80,
  0xC6, 0x07, 0xF8, 0x31, 0x81, 0x86, 0x0C, 0xC0, 0xC1, 0x83, 0x30, 0x60,
  0x60, 0xC8, 0x18, 0x18, 0x36, 0x0C, 0x04, 0x0D, 0x83, 0x03, 0x03, 0x60,
  0xC0, 0xC0, 0xD0, 0x60, 0x30, 0x24, 0x18, 0x08, 0x0B, 0x06, 0x06, 0x06,
  0xC1, 0x81, 0x81, 0x30, 0x60, 0xE0, 0xCC, 0x18, 0x38, 0x33, 0x06, 0x16,
  0x18, 0xC0, 0xFC, 0xFC, 0x10, 0x3C, 0x1E, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1A, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x06, 0x06, 0x01,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x70, 0x06, 0x18, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0C, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x78, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x70, 0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x30,
  0x60, 0x38, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0x00, 0xE0, 0xC0, 0x1C, 0x30,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x01,
  0xC6, 0x00, 0x61, 0x80, 0x38, 0x60, 0x3C, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x38, 0x06, 0x1C, 0x01, 0xC6,
  0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x0C, 0xE0, 0x07, 0x18,
  0x01, 0x86, 0x00, 0xE1, 0xC0, 0x30, 0x38, 0x38, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x38, 0x1E, 0x06, 0x00, 0xC0, 0xC0,
  0x1C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xE3, 0x00,
  0x1C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x60, 0x60, 0x38,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x07,
  0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x07, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x1F, 0xE3, 0x03, 0xFC, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x80,
  0x0E, 0x70, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80,
  0x38, 0x38, 0x1E, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x18,
  0x30, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xC0, 0x01,
  0x86, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x0C, 0x30, 0xC3, 0x1C,
  0x61, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x63,
  0x8C, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x86, 0x01, 0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0x70, 0xE0, 0x1F, 0xE0,
  0x07, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x30, 0x07, 0x03, 0x80, 0x70, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x38, 0x01, 0x83, 0x80,
  0x18, 0x38, 0x00, 0xC3, 0x80, 0x06, 0x38, 0x00, 0x33, 0x80, 0x01, 0xB8,
  0x00, 0x1F, 0xE0, 0x00, 0xFB, 0x00, 0x07, 0x8C, 0x00, 0x38, 0x60, 0x01,
  0x83, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x70, 0x06, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x38, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xD8, 0x00, 0xD8, 0x36, 0x00, 0x36,
  0x19, 0x80, 0x19, 0x86, 0x60, 0x06, 0x61, 0x98, 0x03, 0x30, 0x66, 0x00,
  0xCC, 0x18, 0xC0, 0x63, 0x0E, 0x30, 0x18, 0xC3, 0x0C, 0x0C, 0x30, 0xC3,
  0x03, 0x1C, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x06, 0x30, 0x61,
  0xC1, 0x9C, 0x18, 0x60, 0x66, 0x06, 0x18, 0x1B, 0x83, 0x86, 0x06, 0xC0,
  0xC1, 0x81, 0xF0, 0x30, 0x60, 0x38, 0x0C, 0x38, 0x0C, 0x03, 0x0C, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0xC0, 0x06, 0x1E, 0x00,
  0x30, 0xF8, 0x03, 0x86, 0xC0, 0x18, 0x36, 0x00, 0xC1, 0x98, 0x06, 0x1C,
  0xC0, 0x30, 0xC6, 0x01, 0x86, 0x18, 0x1C, 0x30, 0xC0, 0xC1, 0x86, 0x06,
  0x1C, 0x18, 0x30, 0xC0, 0xC1, 0x86, 0x07, 0x0C, 0x30, 0x18, 0xE1, 0x80,
  0xC6, 0x0C, 0x03, 0x30, 0xE0, 0x19, 0x86, 0x00, 0xCC, 0x30, 0x03, 0x61,
  0x80, 0x1E, 0x0C, 0x00, 0xF0, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1C, 0x1E, 0x07, 0x00, 0xC1, 0xC0,
  0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x77, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01,
  0xCC, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x80, 0x70, 0x38, 0x3C,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x38,
  0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60,
  0x07, 0x1C, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80,
  0x38, 0x70, 0x0E, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x78, 0x38, 0x06, 0x1C, 0x01, 0xC6, 0x00,
  0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1F, 0x80, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x38, 0x01,
  0xC6, 0x00, 0x61, 0xC0, 0x30, 0x38, 0x3C, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x38, 0x30, 0x07, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C,
  0x60, 0x06, 0x18, 0x03, 0x8E, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x30,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x70, 0x60, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0xE1, 0x80, 0x18, 0x60, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0x70, 0x38, 0x06, 0x0C, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0x8E, 0x00, 0x61, 0xC0, 0x38, 0x38, 0x3C, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71,
  0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x03, 0x83, 0x00, 0xE0, 0x78,
  0x38, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3,
  0x80, 0x30, 0x30, 0x0E, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03,
  0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x0C, 0x01, 0xF0, 0x07, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x00, 0xF0,
  0x0E, 0xC0, 0x3C, 0x03, 0x30, 0x0F, 0x00, 0xCC, 0x06, 0xC0, 0x63, 0x01,
  0x90, 0x18, 0xC0, 0xC4, 0x06, 0x30, 0x31, 0x03, 0x0C, 0x0C, 0x60, 0xC3,
  0x06, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x63,
  0x81, 0x8C, 0x18, 0xC0, 0x66, 0x06, 0x30, 0x19, 0x81, 0x9C, 0x06, 0x40,
  0x66, 0x01, 0xB0, 0x19, 0x80, 0x6C, 0x02, 0xC0, 0x1E, 0x00, 0xB0, 0x07,
  0x80, 0x2C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x03,
  0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0xE0, 0x00, 0xC7, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xC1, 0x80, 0x06,
  0x06, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x01,
  0x81, 0xC0, 0x06, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xD8, 0x00, 0x67,
  0x00, 0x38, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x80, 0xC0, 0x60,
  0x70, 0x18, 0x18, 0x06, 0x0C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0xC0,
  0x03, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x7E, 0x0F, 0x80, 0xC3, 0x0C, 0x30, 0xC1, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x61,
  0x86, 0x18, 0x60, 0xC3, 0x0C, 0x07, 0xE0, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x7C, 0x0F, 0x80, 0x03, 0x00, 0xC0, 0x78,
  0x1E, 0x0D, 0x83, 0x61, 0x88, 0x62, 0x30, 0xCC, 0x36, 0x0D, 0x83, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x18, 0x61, 0x80, 0x03, 0xE0, 0x3F,
  0xE1, 0xC1, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x07,
  0xFC, 0x7F, 0xF3, 0x81, 0x98, 0x06, 0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x0E, 0xC0, 0x73, 0x87, 0xC7, 0xFB, 0x0F, 0x8C, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x33, 0xE0, 0x6F, 0xF0, 0xF0, 0xE1, 0xC0, 0xE7, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x6C,
  0x01, 0x98, 0x03, 0x30, 0x06, 0xE0, 0x19, 0xE0, 0x33, 0x61, 0xC6, 0xFF,
  0x0C, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x70, 0xC0, 0x63, 0x00,
  0xC6, 0x01, 0x98, 0x01, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x03, 0x30, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xE0,
  0xC0, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x01, 0xF1, 0x83, 0xFD, 0xC3, 0x83, 0xC1, 0x80, 0xE1, 0x80, 0x30, 0xC0,
  0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x1C,
  0x1C, 0x1E, 0x07, 0xFB, 0x01, 0xF1, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70,
  0x70, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0x7F, 0xFC,
  0xFF, 0xFB, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x10, 0xE0, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x3F,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x07, 0xF8,
  0x7F, 0x81, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xF1, 0x83, 0xFC, 0xC3, 0x83, 0xC1,
  0x80, 0xE1, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0,
  0x30, 0x60, 0x18, 0x30, 0x1C, 0x1C, 0x1E, 0x07, 0xFB, 0x01, 0xF3, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x40, 0x30, 0x70, 0x70,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x31, 0xE0,
  0x6F, 0xE0, 0xF0, 0xE1, 0xC0, 0xC7, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x06,
  0x30, 0x0C, 0xE0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x00,
  0x06, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x0E, 0x18, 0x1C, 0x18, 0x38, 0x18, 0x70, 0x30, 0xE0, 0x31, 0xC0, 0x33,
  0x80, 0x37, 0x00, 0x36, 0x00, 0x3F, 0x00, 0x7B, 0x00, 0x73, 0x80, 0x61,
  0x80, 0x61, 0x80, 0x60, 0xC0, 0xE0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0,
  0x30, 0xC0, 0x30, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x30,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x00, 0x19, 0xF0, 0x3E, 0x0D, 0xFC, 0x7F, 0x87,
  0x87, 0x70, 0xC3, 0x81, 0xA0, 0x73, 0x80, 0xF0, 0x19, 0x80, 0x70, 0x0C,
  0xC0, 0x38, 0x06, 0x60, 0x18, 0x03, 0x30, 0x0C, 0x01, 0xB8, 0x06, 0x01,
  0x98, 0x03, 0x00, 0xCC, 0x01, 0x80, 0x66, 0x01, 0x80, 0x33, 0x00, 0xC0,
  0x19, 0x80, 0x60, 0x1D, 0xC0, 0x30, 0x0C, 0xC0, 0x18, 0x06, 0x60, 0x0C,
  0x03, 0x30, 0x0C, 0x01, 0x98, 0x06, 0x00, 0xC0, 0x18, 0xF0, 0x37, 0xF0,
  0x78, 0x70, 0xE0, 0x63, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x18, 0x06,
  0x70, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x80, 0x03, 0xF0,
  0x0F, 0xF0, 0x38, 0x70, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xDC, 0x01, 0xB0,
  0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0xEC, 0x01,
  0x98, 0x03, 0x30, 0x0C, 0x60, 0x38, 0x60, 0xE0, 0xFF, 0x80, 0x7C, 0x00,
  0x06, 0x7C, 0x03, 0x7F, 0x81, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x38, 0x0E,
  0x1B, 0x0E, 0x0D, 0xFE, 0x06, 0x3E, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE3, 0x0F, 0xF3, 0x1C, 0x1E, 0x18, 0x0E, 0x30, 0x06, 0x30, 0x06,
  0x70, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0xE0, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0x70, 0x78,
  0x3F, 0xD8, 0x1F, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x19, 0xE3, 0x7C, 0x7C,
  0x0E, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x86, 0x07, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x31, 0xC3, 0x83, 0xFC, 0x07, 0xE0, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x87, 0xFF, 0xFC, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xF8, 0x38, 0x00, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0x71,
  0xC3, 0xE1, 0xFF, 0x81, 0xF3, 0x00, 0xC0, 0x0D, 0x80, 0x66, 0x01, 0x98,
  0x0E, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x30, 0xC0, 0xC3, 0x03,
  0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x05, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x1C,
  0x0D, 0x81, 0xE0, 0x6C, 0x0F, 0x06, 0x60, 0xD8, 0x33, 0x06, 0xC1, 0x98,
  0x66, 0x18, 0xC3, 0x30, 0xC6, 0x31, 0x8C, 0x31, 0x8C, 0x60, 0x8C, 0x23,
  0x06, 0xC1, 0x30, 0x36, 0x0D, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x87, 0x03, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x36, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x38, 0x60, 0x18, 0x38, 0x1C, 0x0C,
  0x1C, 0x06, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC1, 0x80, 0x70, 0x60, 0x18,
  0x18, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x60, 0x60, 0x18, 0x18, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFE,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x02, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x07, 0x00, 0xE0, 0x08, 0x00, 0x1E, 0x00, 0xCF,
  0xC0, 0x27, 0x18, 0x19, 0x83, 0x06, 0xC0, 0xE3, 0x30, 0x1F, 0xC0, 0x01,
  0xE0,
};

const GFXglyph RobotoCondensed_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 7, 8, 11, 4, -29 },
  { 32, 19, 27, 19, 1, -27 },
  { 97, 16, 34, 18, 1, -31 },
  { 165, 17, 27, 24, 4, -27 },
  { 223, 17, 27, 20, 1, -27 },
  { 281, 3, 8, 6, 4, -29 },
  { 284, 11, 39, 11, 2, -30 },
  { 338, 11, 39, 11, -2, -30 },
  { 392, 15, 15, 16, 2, -27 },
  { 421, 15, 20, 18, 2, -23 },
  { 459, 6, 9, 7, -2, -4 },
  { 466, 8, 2, 10, 1, -13 },
  { 468, 3, 3, 9, 1, -3 },
  { 470, 16, 29, 13, -2, -27 },
  { 528, 15, 27, 18, 2, -27 },
  { 579, 9, 27, 18, 5, -27 },
  { 610, 16, 27, 18, 1, -27 },
  { 664, 16, 27, 18, 1, -27 },
  { 718, 16, 27, 18, 1, -27 },
  { 772, 16, 27, 18, 2, -27 },
  { 826, 14, 27, 18, 2, -27 },
  { 874, 16, 27, 18, 3, -27 },
  { 928, 16, 27, 18, 1, -27 },
  { 982, 14, 27, 18, 3, -27 },
  { 1030, 6, 20, 8, 1, -20 },
  { 1045, 8, 25, 7, -1, -20 },
  { 1070, 14, 16, 17, 2, -20 },
  { 1098, 14, 9, 18, 2, -17 },
  { 1114, 14, 16, 17, 1, -20 },
  { 1142, 12, 27, 15, 3, -27 },
  { 1183, 26, 34, 29, 1, -26 },
  { 1294, 18, 27, 20, -1, -27 },
  { 1355, 18, 27, 20, 1, -27 },
  { 1416, 18, 27, 21, 2, -27 },
  { 1477, 19, 27, 21, 1, -27 },
  { 1542, 19, 27, 18, 1, -27 },
  { 1607, 19, 27, 18, 1, -27 },
  { 1672, 19, 27, 22, 2, -27 },
  { 1737, 21, 27, 23, 1, -27 },
  { 1808, 6, 27, 9, 2, -27 },
  { 1829, 17, 27, 18, 1, -27 },
  { 1887, 21, 27, 20, 1, -27 },
  { 1958, 13, 27, 17, 1, -27 },
  { 2002, 26, 27, 28, 1, -27 },
  { 2090, 21, 27, 23, 1, -27 },
  { 2161, 19, 27, 22, 2, -27 },
  { 2226, 19, 27, 20, 1, -27 },
  { 2291, 18, 32, 22, 2, -27 },
  { 2363, 18, 27, 20, 1, -27 },
  { 2424, 18, 27, 19, 1, -27 },
  { 2485, 18, 27, 19, 3, -27 },
  { 2546, 19, 27, 21, 2, -27 },
  { 2611, 19, 27, 20, 3, -27 },
  { 2676, 26, 27, 28, 4, -27 },
  { 2764, 22, 27, 20, -1, -27 },
  { 2839, 18, 27, 19, 3, -27 },
  { 2900, 20, 27, 19, 0, -27 },
  { 2968, 11, 37, 8, 0, -31 },
  { 3019, 6, 29, 13, 4, -27 },
  { 3041, 11, 37, 8, -2, -31 },
  { 3092, 10, 13, 14, 2, -27 },
  { 3109, 14, 2, 14, -2, 0 },
  { 3113, 5, 5, 11, 5, -28 },
  { 3117, 14, 20, 17, 1, -20 },
  { 3152, 15, 29, 18, 1, -29 },
  { 3207, 15, 20, 17, 1, -20 },
  { 3245, 17, 29, 18, 1, -29 },
  { 3307, 15, 20, 17, 1, -20 },
  { 3345, 12, 29, 11, 2, -29 },
  { 3389, 17, 28, 18, 0, -20 },
  { 3449, 15, 29, 18, 1, -29 },
  { 3504, 7, 27, 8, 1, -27 },
  { 3528, 12, 35, 8, -4, -27 },
  { 3581, 16, 29, 16, 1, -29 },
  { 3639, 7, 29, 8, 1, -29 },
  { 3665, 25, 20, 28, 1, -20 },
  { 3728, 15, 20, 18, 1, -20 },
  { 3766, 15, 20, 18, 1, -20 },
  { 3804, 17, 28, 18, -1, -20 },
  { 3864, 16, 28, 18, 1, -20 },
  { 3920, 11, 20, 11, 1, -20 },
  { 3948, 14, 20, 16, 1, -20 },
  { 3983, 9, 25, 11, 2, -25 },
  { 4012, 15, 20, 18, 2, -20 },
  { 4050, 14, 20, 16, 2, -20 },
  { 4085, 21, 20, 24, 3, -20 },
  { 4138, 17, 20, 16, -1, -20 },
  { 4181, 18, 28, 15, -2, -20 },
  { 4244, 16, 20, 16, 0, -20 },
  { 4284, 12, 37, 11, 1, -30 },
  { 4340, 7, 32, 8, 1, -27 },
  { 4368, 12, 38, 11, -2, -30 },
  { 4425, 18, 7, 22, 2, -15 },
};

const GFXfont RobotoCondensed_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC38PT7B_H_
