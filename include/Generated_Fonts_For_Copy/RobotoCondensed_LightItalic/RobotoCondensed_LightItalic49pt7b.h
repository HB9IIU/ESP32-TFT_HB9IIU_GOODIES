#ifndef _ROBOTOCONDENSED_LIGHTITALIC49PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0xF0, 0x78, 0x18, 0x00, 0x31, 0xCC, 0x67, 0x19, 0xC6, 0x61, 0x98,
  0xE6, 0x39, 0x8C, 0xE3, 0x30, 0xCC, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70,
  0x70, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0x81, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x87, 0x00, 0x70, 0x78, 0x1E,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0x8C, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x60, 0x13, 0x01, 0x80, 0xCC, 0x06,
  0x07, 0x30, 0x18, 0x18, 0xC0, 0x60, 0xC3, 0x01, 0x87, 0x0C, 0x0E, 0x18,
  0x30, 0x30, 0xC0, 0xC1, 0xC7, 0x01, 0x8E, 0x38, 0x07, 0xF0, 0xC0, 0x07,
  0x86, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x78, 0x00, 0xC7, 0xF0, 0x06, 0x38, 0xE0, 0x38, 0xC1, 0xC1, 0xC7, 0x03,
  0x06, 0x18, 0x0C, 0x30, 0x60, 0x31, 0xC1, 0x80, 0xC6, 0x06, 0x03, 0x30,
  0x38, 0x0D, 0xC0, 0x60, 0x66, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x1C,
  0x70, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x01, 0x8F, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xCE, 0x03, 0x1E, 0x38, 0x0C, 0x70, 0x70, 0x73, 0x80, 0xE1, 0xDC, 0x03,
  0x86, 0x70, 0x07, 0x39, 0xC0, 0x1C, 0xE6, 0x00, 0x3F, 0x18, 0x00, 0xFC,
  0x60, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x01, 0xF8, 0x3C,
  0x0F, 0x70, 0x7F, 0xF8, 0xC0, 0xFF, 0x83, 0x80, 0x20, 0x00, 0x77, 0x66,
  0x66, 0xEC, 0xCC, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x10, 0x38, 0x17, 0xC7, 0x1F, 0xFE, 0xDF, 0xE3, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x03, 0x8C, 0x00,
  0xE1, 0xC0, 0x38, 0x18, 0x0F, 0x03, 0x81, 0xC0, 0x30, 0x10, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x8E, 0x1C,
  0x71, 0xC1, 0x00, 0x7F, 0xDF, 0xFF, 0xFC, 0x7F, 0xF6, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0xC0, 0x38, 0x1C, 0x07,
  0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00,
  0x1C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0x60,
  0x03, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x03, 0x81, 0xE0, 0x3E, 0x7C, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x07, 0xE1, 0xFE, 0x7E,
  0xE7, 0x0E, 0xC0, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xC0, 0x78, 0x07, 0x03,
  0x80, 0x38, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01,
  0x87, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x38, 0x38, 0x00,
  0xC1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01,
  0xC1, 0xE0, 0x0E, 0x07, 0x81, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x1C,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00, 0xE1, 0xC0, 0x0C,
  0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x01, 0x80, 0x70, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x30, 0x70, 0x03, 0x06,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xCF, 0x80, 0x0D, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC0, 0xE0,
  0x38, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x30, 0x03,
  0x81, 0xC0, 0x38, 0x0F, 0x03, 0xC0, 0x3E, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x1F, 0x83, 0xBF, 0xF1, 0xFE, 0xF8, 0xF8, 0x0E,
  0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x71, 0xC0, 0x38, 0xF0, 0x38, 0x3F, 0xF8,
  0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x38, 0x07, 0x03, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x60, 0x60, 0x07, 0x03, 0x80, 0x70, 0x1E, 0x07,
  0x80, 0x7C, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38,
  0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x60, 0x00, 0xE3, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x01, 0xE0, 0x1F, 0x7E, 0x00,
  0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xC0, 0xE3, 0x80, 0x71, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xDC, 0x03, 0xCE, 0x07, 0x63,
  0xFF, 0x71, 0xFF, 0x38, 0x3F, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x0F, 0x0F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x01, 0xC0,
  0x38, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x03,
  0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x81, 0x80,
  0x3F, 0x00, 0xC1, 0xC0, 0x3F, 0xC0, 0x30, 0xC0, 0x3C, 0x70, 0x18, 0xE0,
  0x38, 0x18, 0x0C, 0x60, 0x38, 0x0C, 0x06, 0x70, 0x18, 0x06, 0x03, 0x30,
  0x18, 0x07, 0x01, 0x98, 0x0C, 0x03, 0x00, 0xDC, 0x0E, 0x01, 0x80, 0x6C,
  0x06, 0x00, 0xC0, 0x36, 0x07, 0x00, 0xE0, 0x37, 0x03, 0x80, 0x60, 0x1B,
  0x81, 0x80, 0x30, 0x0D, 0x80, 0xC0, 0x18, 0x06, 0xC0, 0x60, 0x1C, 0x03,
  0x60, 0x70, 0x0C, 0x03, 0x30, 0x38, 0x06, 0x01, 0x98, 0x1C, 0x07, 0x00,
  0xCC, 0x0E, 0x03, 0x80, 0xC6, 0x07, 0x03, 0xC0, 0x63, 0x01, 0x81, 0x60,
  0x61, 0x80, 0xE3, 0xB8, 0x70, 0xC0, 0x7F, 0x9F, 0xF0, 0x60, 0x1F, 0x87,
  0xF0, 0x30, 0x02, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0x70,
  0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x83,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x38, 0x03, 0x00, 0x1C,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1C, 0x01,
  0xE0, 0x38, 0x01, 0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x70, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x03, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C,
  0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0x80, 0x3C, 0x03,
  0x00, 0x1E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x70, 0x07, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0F, 0xFC, 0x60,
  0x0F, 0xFC, 0xE0, 0x0F, 0xFC, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x3C,
  0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x30, 0x01, 0xE0,
  0x06, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x18, 0x1E, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0C, 0xF8, 0x00, 0x01, 0xBF, 0x00, 0x00, 0x7E, 0x70, 0x00, 0x0F,
  0x8E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x76, 0x00, 0x01, 0xF8, 0x1D, 0x80, 0x00, 0x6E, 0x07,
  0x60, 0x00, 0x3B, 0x81, 0x9C, 0x00, 0x0C, 0xC0, 0x67, 0x00, 0x07, 0x30,
  0x19, 0xC0, 0x01, 0x8C, 0x0E, 0x30, 0x00, 0xE7, 0x03, 0x8C, 0x00, 0x31,
  0xC0, 0xE3, 0x00, 0x1C, 0x70, 0x38, 0xE0, 0x06, 0x18, 0x0C, 0x38, 0x03,
  0x86, 0x03, 0x0E, 0x00, 0xC3, 0x81, 0xC1, 0x80, 0x70, 0xE0, 0x70, 0x60,
  0x18, 0x38, 0x1C, 0x18, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x03, 0x01, 0x81,
  0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x60, 0x70, 0x38, 0x0C, 0x38, 0x1C, 0x0E,
  0x03, 0x0C, 0x07, 0x03, 0x80, 0xC7, 0x01, 0xC0, 0xE0, 0x31, 0x80, 0x60,
  0x30, 0x0E, 0xE0, 0x38, 0x1C, 0x03, 0xB0, 0x0E, 0x07, 0x00, 0x7C, 0x03,
  0x81, 0xC0, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x80, 0x38, 0x18, 0x01, 0xC0,
  0x0C, 0x06, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x60, 0x3C, 0x00, 0x06, 0x03, 0xE0, 0x00, 0xE0,
  0x36, 0x00, 0x0E, 0x07, 0x70, 0x00, 0xE0, 0x77, 0x00, 0x0E, 0x07, 0x30,
  0x00, 0xC0, 0x73, 0x80, 0x1C, 0x06, 0x38, 0x01, 0xC0, 0x61, 0x80, 0x1C,
  0x0E, 0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0x1C, 0x0E, 0x0C, 0x01, 0x80, 0xE0,
  0xE0, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0x30, 0x38, 0x1C, 0x03, 0x83, 0x01, 0xC0, 0x38, 0x70, 0x18,
  0x01, 0x87, 0x03, 0x80, 0x1C, 0x70, 0x38, 0x01, 0xC7, 0x03, 0x80, 0x0C,
  0x60, 0x38, 0x00, 0xE6, 0x03, 0x80, 0x0E, 0xE0, 0x30, 0x00, 0x7E, 0x07,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70,
  0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x1E, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0x80, 0x1E, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0F,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x0E,
  0x03, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0C, 0x00, 0x78,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1C, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x18, 0x03, 0x80, 0x38, 0x01, 0x80, 0x38, 0x01, 0xC0,
  0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x60, 0x00, 0x70, 0x60, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x70, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0xEE, 0x00, 0x3C, 0x00, 0x77, 0x00, 0x3E, 0x00, 0x33, 0x80,
  0x1B, 0x00, 0x39, 0xC0, 0x1D, 0x80, 0x1C, 0xE0, 0x0E, 0xE0, 0x0C, 0x70,
  0x06, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x0E,
  0x01, 0x86, 0x03, 0x83, 0x01, 0xC3, 0x01, 0xC1, 0x80, 0xC1, 0x80, 0xC0,
  0xC0, 0xE0, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x70,
  0x18, 0x38, 0x18, 0x38, 0x0C, 0x18, 0x0C, 0x18, 0x06, 0x1C, 0x06, 0x1C,
  0x03, 0x0C, 0x03, 0x8E, 0x01, 0xC6, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0xE7,
  0x00, 0x73, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x19, 0x80, 0x1D, 0xC0, 0x0D,
  0xC0, 0x0E, 0xC0, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0x60, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x78, 0x00, 0x01, 0x87, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE3, 0x00,
  0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30,
  0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C,
  0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x7C, 0x01, 0xB0, 0x0E, 0xC0,
  0x33, 0x01, 0xCC, 0x06, 0x38, 0x38, 0xE0, 0xC1, 0x87, 0x06, 0x18, 0x18,
  0xE0, 0x63, 0x01, 0xDC, 0x07, 0x60, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0x87, 0x00, 0x38,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0x03, 0x0F, 0x00, 0x63, 0xC0, 0x0C, 0x70, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x1C,
  0x0F, 0xC3, 0xFF, 0xB8, 0x3F, 0xE7, 0x03, 0xF0, 0xE0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE3, 0xF0, 0x0E, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x81, 0xE0, 0xF0,
  0x0E, 0x1E, 0x00, 0x61, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18,
  0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06, 0x38, 0x00, 0x63,
  0x80, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x78, 0x03, 0x86, 0xC0, 0x70, 0xEF, 0xFF,
  0x0E, 0x7F, 0xC0, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFD,
  0xF0, 0x78, 0x0E, 0x1C, 0x01, 0x8E, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xD8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x03, 0x87, 0x01, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x7E, 0x1C, 0x07, 0xFC, 0x60, 0x3F, 0xF9, 0x81, 0xE0, 0x3E, 0x07, 0x00,
  0x78, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0C, 0x1C, 0x00, 0x30,
  0x70, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0,
  0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0, 0x60, 0x0F, 0x01,
  0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xFD, 0x80, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0xFD, 0xF0, 0x78, 0x0E, 0x1C, 0x01, 0x8E, 0x00,
  0x73, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x01,
  0x87, 0x80, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x07, 0xFF, 0x1F, 0xFC,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E,
  0x1C, 0x07, 0xFC, 0x60, 0x3F, 0xF9, 0x81, 0xE0, 0x36, 0x07, 0x00, 0x78,
  0x38, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70,
  0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0x83, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0, 0x60, 0x0F, 0x01, 0xC0,
  0x7C, 0x07, 0xFF, 0xF0, 0x0F, 0xF9, 0xC0, 0x0F, 0xC6, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x18,
  0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x1F, 0x80, 0xE7, 0xF8, 0x1D, 0xFF, 0x83, 0x60,
  0x70, 0x78, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0x80, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xC0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x18, 0xE0, 0x03,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x0C,
  0x70, 0x01, 0x8E, 0x00, 0x70, 0x03, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x0F,
  0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x0C, 0x07, 0x80, 0xC0, 0xF0, 0x1C, 0x1E,
  0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x01, 0x9C,
  0x00, 0x3B, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0xE0, 0x03, 0xCE, 0x00, 0x38,
  0x70, 0x03, 0x07, 0x00, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x18, 0x07,
  0x01, 0xC0, 0x60, 0x1C, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x0E, 0x3F, 0x00,
  0xF8, 0x07, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0x81, 0xB0, 0x39,
  0xC0, 0xE0, 0xF0, 0x0F, 0x80, 0x70, 0xF0, 0x07, 0xC0, 0x18, 0x70, 0x03,
  0xC0, 0x0C, 0x38, 0x01, 0xE0, 0x06, 0x1C, 0x00, 0xE0, 0x03, 0x0C, 0x00,
  0x70, 0x01, 0x8E, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x18, 0x00, 0xE3, 0x80,
  0x0C, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x18, 0x60,
  0x03, 0x80, 0x0C, 0x70, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0xC0, 0x07, 0x1C,
  0x00, 0x60, 0x03, 0x8E, 0x00, 0x70, 0x01, 0xC6, 0x00, 0x38, 0x00, 0xC3,
  0x00, 0x1C, 0x00, 0x63, 0x80, 0x0E, 0x00, 0x71, 0xC0, 0x06, 0x00, 0x38,
  0xE0, 0x03, 0x00, 0x1C, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x3F, 0x01,
  0xCF, 0xF0, 0x3B, 0xFF, 0x06, 0xC0, 0xE0, 0xF0, 0x0E, 0x3C, 0x01, 0xC7,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x30,
  0x01, 0xCE, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0,
  0x07, 0x18, 0x00, 0xE7, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x01, 0xE1, 0xC0, 0x1C, 0x70,
  0x01, 0x8E, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x00,
  0x06, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00,
  0x30, 0xE0, 0x0E, 0x1E, 0x07, 0x81, 0xFB, 0xE0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0x8F, 0xC0, 0x0E, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xF8, 0x1E,
  0x03, 0x80, 0x38, 0x1E, 0x00, 0x60, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x18, 0x38, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x78,
  0x03, 0x81, 0xF0, 0x1C, 0x0E, 0xFB, 0xF0, 0x39, 0xFF, 0x00, 0xE1, 0xF8,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x70, 0x7F, 0xC6, 0x0F, 0xFE, 0x61,
  0xE0, 0x3E, 0x1C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x00, 0xE7, 0x00, 0x0C,
  0x70, 0x00, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x06, 0x00, 0xF0, 0x70,
  0x1F, 0x07, 0xEF, 0xF0, 0x3F, 0xF6, 0x00, 0xFC, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x3C,
  0x3B, 0xF0, 0xFF, 0xC3, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0C,
  0x70, 0x03, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xCE, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x1C, 0x01, 0xC7, 0x01, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x07, 0xFF, 0x7F, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x1C, 0x00, 0x63,
  0x80, 0x0C, 0x70, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38,
  0x00, 0xC7, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0x60,
  0x03, 0x9C, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x03, 0x86, 0x00, 0xF0, 0xE0,
  0x1E, 0x1C, 0x07, 0x81, 0xFF, 0xB0, 0x3F, 0xE6, 0x01, 0xF0, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0xEE, 0x00, 0x39, 0x80, 0x1C, 0x60, 0x07, 0x18, 0x01,
  0x87, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x03, 0x80,
  0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x38,
  0xC0, 0x06, 0x70, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00, 0xEC,
  0x03, 0xE0, 0x1D, 0xC0, 0x6C, 0x07, 0x38, 0x1D, 0x80, 0xE7, 0x03, 0xB0,
  0x18, 0xE0, 0x66, 0x07, 0x1C, 0x1C, 0xC0, 0xC3, 0x83, 0x18, 0x38, 0x70,
  0xE3, 0x07, 0x0E, 0x18, 0x70, 0xC1, 0xC7, 0x0E, 0x38, 0x18, 0xC1, 0xC6,
  0x03, 0x18, 0x19, 0xC0, 0x67, 0x03, 0x38, 0x0C, 0xC0, 0x66, 0x01, 0xB8,
  0x0D, 0xC0, 0x36, 0x01, 0xB0, 0x07, 0xC0, 0x36, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x30, 0x07, 0x00, 0xE0,
  0x38, 0x03, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x31, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x01, 0xDC,
  0x00, 0x0E, 0x30, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x06, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x18,
  0x01, 0xC0, 0x30, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E,
  0x00, 0x18, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x30, 0x00, 0x06, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x33, 0xFE, 0x00, 0xDC, 0x3C, 0x03, 0x60, 0x78, 0x1F, 0x80, 0xF0,
  0xEC, 0x01, 0xFF, 0x30, 0x03, 0xFC, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 35, 10, 1, -35 },
  { 41, 10, 11, 14, 5, -37 },
  { 55, 24, 35, 24, 2, -35 },
  { 160, 20, 44, 23, 2, -40 },
  { 270, 22, 35, 30, 5, -35 },
  { 367, 22, 36, 26, 1, -35 },
  { 466, 4, 11, 8, 5, -37 },
  { 472, 14, 50, 14, 2, -39 },
  { 560, 14, 50, 14, -3, -39 },
  { 648, 19, 20, 20, 3, -35 },
  { 696, 20, 26, 24, 2, -29 },
  { 761, 7, 11, 9, -2, -5 },
  { 771, 10, 3, 12, 1, -17 },
  { 775, 4, 4, 11, 1, -4 },
  { 777, 21, 38, 17, -2, -35 },
  { 877, 20, 35, 23, 2, -35 },
  { 965, 12, 35, 23, 6, -35 },
  { 1018, 21, 35, 23, 1, -35 },
  { 1110, 21, 35, 23, 1, -35 },
  { 1202, 20, 35, 23, 1, -35 },
  { 1290, 21, 35, 23, 3, -35 },
  { 1382, 17, 35, 23, 3, -35 },
  { 1457, 20, 35, 23, 4, -35 },
  { 1545, 21, 35, 23, 1, -35 },
  { 1637, 17, 35, 23, 4, -35 },
  { 1712, 8, 26, 10, 1, -26 },
  { 1738, 11, 32, 9, -2, -26 },
  { 1782, 18, 20, 21, 2, -26 },
  { 1827, 18, 13, 23, 3, -23 },
  { 1857, 19, 21, 22, 1, -26 },
  { 1907, 15, 35, 19, 4, -35 },
  { 1973, 33, 45, 37, 2, -34 },
  { 2159, 25, 35, 26, -2, -35 },
  { 2269, 23, 35, 25, 1, -35 },
  { 2370, 23, 35, 27, 3, -35 },
  { 2471, 24, 35, 27, 1, -35 },
  { 2576, 24, 35, 24, 1, -35 },
  { 2681, 24, 35, 23, 1, -35 },
  { 2786, 24, 35, 28, 3, -35 },
  { 2891, 28, 35, 29, 1, -35 },
  { 3014, 9, 35, 12, 2, -35 },
  { 3054, 22, 35, 23, 1, -35 },
  { 3151, 27, 35, 26, 1, -35 },
  { 3270, 18, 35, 22, 1, -35 },
  { 3349, 34, 35, 36, 1, -35 },
  { 3498, 28, 35, 29, 1, -35 },
  { 3621, 23, 35, 28, 3, -35 },
  { 3722, 24, 35, 26, 1, -35 },
  { 3827, 23, 41, 28, 3, -35 },
  { 3945, 24, 35, 26, 1, -35 },
  { 4050, 24, 35, 25, 1, -35 },
  { 4155, 22, 35, 25, 5, -35 },
  { 4252, 24, 35, 27, 3, -35 },
  { 4357, 24, 35, 26, 4, -35 },
  { 4462, 33, 35, 37, 5, -35 },
  { 4607, 28, 35, 25, -1, -35 },
  { 4730, 23, 35, 25, 5, -35 },
  { 4831, 26, 35, 25, 0, -35 },
  { 4945, 14, 47, 11, 0, -40 },
  { 5028, 8, 38, 17, 5, -35 },
  { 5066, 14, 47, 11, -3, -40 },
  { 5149, 14, 17, 18, 2, -35 },
  { 5179, 17, 2, 18, -2, 0 },
  { 5184, 7, 7, 14, 6, -37 },
  { 5191, 19, 26, 22, 1, -26 },
  { 5253, 20, 37, 23, 1, -37 },
  { 5346, 18, 26, 22, 2, -26 },
  { 5405, 22, 37, 23, 2, -37 },
  { 5507, 18, 26, 22, 2, -26 },
  { 5566, 15, 38, 14, 3, -38 },
  { 5638, 22, 36, 23, 0, -26 },
  { 5737, 19, 37, 23, 1, -37 },
  { 5825, 9, 36, 10, 1, -36 },
  { 5866, 16, 46, 10, -6, -36 },
  { 5958, 20, 37, 21, 1, -37 },
  { 6051, 9, 37, 10, 1, -37 },
  { 6093, 33, 26, 36, 1, -26 },
  { 6201, 19, 26, 23, 1, -26 },
  { 6263, 19, 26, 23, 2, -26 },
  { 6325, 22, 36, 23, -1, -26 },
  { 6424, 20, 36, 23, 2, -26 },
  { 6514, 14, 26, 14, 1, -26 },
  { 6560, 18, 26, 21, 1, -26 },
  { 6619, 12, 33, 14, 2, -33 },
  { 6669, 19, 26, 23, 2, -26 },
  { 6731, 18, 26, 20, 3, -26 },
  { 6790, 27, 26, 31, 4, -26 },
  { 6878, 22, 26, 20, -1, -26 },
  { 6950, 23, 36, 20, -2, -26 },
  { 7054, 20, 26, 20, 0, -26 },
  { 7119, 15, 48, 14, 2, -38 },
  { 7209, 9, 41, 11, 1, -35 },
  { 7256, 16, 48, 14, -3, -38 },
  { 7352, 22, 9, 28, 3, -19 },
};

const GFXfont RobotoCondensed_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC49PT7B_H_
