#ifndef _ROBOTOCONDENSED_LIGHTITALIC9PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x08, 0xC0, 0x01, 0xCC, 0xA6, 0x38, 0x80, 0x07, 0x44, 0x21,
  0x96, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x35, 0x64, 0xA9, 0x70, 0x80, 0x29,
  0x29, 0x24, 0x40, 0x15, 0x56, 0x80, 0x27, 0x26, 0x22, 0xF2, 0x40, 0xC0,
  0x00, 0x80, 0x04, 0xA5, 0x20, 0x75, 0x99, 0x99, 0x60, 0x55, 0x50, 0x71,
  0x12, 0x24, 0xE0, 0x71, 0x12, 0x19, 0x60, 0x13, 0x55, 0xE2, 0x20, 0x73,
  0x12, 0x70, 0x24, 0x69, 0x99, 0x60, 0x64, 0xA5, 0x20, 0x75, 0x56, 0x99,
  0x60, 0xF6, 0xDE, 0xA0, 0x40, 0x80, 0x40, 0xA0, 0x34, 0x42, 0x26, 0x42,
  0x2C, 0xC4, 0xA8, 0x20, 0x3D, 0x15, 0xEB, 0xAE, 0xF8, 0x1C, 0x22, 0x55,
  0x79, 0x80, 0x75, 0x57, 0x99, 0xE0, 0x69, 0x88, 0x8A, 0xE0, 0x52, 0x52,
  0x98, 0xCA, 0x80, 0x52, 0x10, 0xC8, 0x42, 0x80, 0x52, 0x10, 0xC8, 0x42,
  0x00, 0x69, 0x88, 0x99, 0xE0, 0x4A, 0x52, 0xD8, 0xC6, 0x40, 0x55, 0x68,
  0x01, 0x11, 0x1A, 0xE0, 0x4A, 0x98, 0xCA, 0x4A, 0x40, 0x49, 0x29, 0x20,
  0x45, 0x14, 0xDB, 0xB6, 0xDA, 0x40, 0x42, 0x5A, 0xD9, 0xCA, 0x40, 0x32,
  0x53, 0x18, 0xC9, 0xC0, 0x72, 0x52, 0xE8, 0x42, 0x00, 0x32, 0x53, 0x18,
  0xC9, 0xC2, 0x72, 0x52, 0xE9, 0x4A, 0x40, 0x32, 0x50, 0x41, 0x49, 0x80,
  0x64, 0x44, 0x44, 0x80, 0x4A, 0x53, 0x18, 0xC9, 0x80, 0x99, 0xAA, 0xC4,
  0x00, 0x06, 0x9A, 0xB6, 0xDA, 0x49, 0x00, 0x4A, 0x88, 0x46, 0x2A, 0x40,
  0x9A, 0xA4, 0x44, 0x00, 0x38, 0x88, 0x44, 0x43, 0x80, 0x49, 0x29, 0x24,
  0x7E, 0x24, 0x92, 0x92, 0x0C, 0x80, 0x40, 0x80, 0x61, 0x5A, 0xE0, 0x44,
  0x79, 0x99, 0xE0, 0x69, 0x88, 0x60, 0x01, 0x79, 0x99, 0x60, 0x69, 0xB8,
  0x60, 0x29, 0x25, 0x00, 0x79, 0x99, 0x62, 0xE0, 0x44, 0x79, 0x99, 0x80,
  0x41, 0xA8, 0x20, 0x14, 0x92, 0x80, 0x44, 0x5A, 0x4A, 0xA0, 0x55, 0xA8,
  0x7E, 0x59, 0x65, 0x84, 0x79, 0x99, 0x80, 0x79, 0x99, 0x60, 0x79, 0x99,
  0xE8, 0x00, 0x79, 0x99, 0x62, 0x20, 0x72, 0x48, 0x68, 0x42, 0xE0, 0x49,
  0x28, 0x80, 0x19, 0x99, 0x60, 0x3B, 0x48, 0x0F, 0xAD, 0x4A, 0x00, 0x56,
  0x44, 0xA0, 0x1A, 0x64, 0x44, 0x80, 0x12, 0x44, 0xC0, 0x29, 0x20, 0x14,
  0x40, 0x55, 0xAA, 0x55, 0x5A, 0x80, 0x68, 0x80,
};

const GFXglyph RobotoCondensed_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 4, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 4, 7, 5, 0, -7 },
  { 22, 1, 2, 1, 1, -7 },
  { 23, 3, 9, 3, 0, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 2, 1, 2, 0, -4 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 3, 8, 3, 0, -7 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 2, 7, 4, 1, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 3, 7, 4, 1, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 3, 7, 4, 1, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 3, 7, 4, 1, -7 },
  { 76, 2, 5, 2, 0, -5 },
  { 78, 2, 6, 2, 0, -5 },
  { 80, 4, 4, 4, 0, -5 },
  { 82, 4, 2, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -5 },
  { 85, 3, 7, 4, 1, -7 },
  { 88, 6, 8, 7, 0, -6 },
  { 94, 4, 7, 5, 0, -7 },
  { 98, 4, 7, 5, 0, -7 },
  { 102, 4, 7, 5, 1, -7 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 7, 4, 0, -7 },
  { 116, 5, 7, 4, 0, -7 },
  { 121, 4, 7, 5, 1, -7 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 2, 7, 2, 0, -7 },
  { 132, 4, 7, 4, 0, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 3, 7, 4, 0, -7 },
  { 144, 6, 7, 7, 0, -7 },
  { 150, 5, 7, 5, 0, -7 },
  { 155, 5, 7, 5, 0, -7 },
  { 160, 5, 7, 5, 0, -7 },
  { 165, 5, 8, 5, 0, -7 },
  { 170, 5, 7, 5, 0, -7 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 4, 7, 5, 1, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 6, 7, 7, 1, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 4, 7, 5, 1, -7 },
  { 208, 5, 7, 5, 0, -7 },
  { 213, 3, 8, 2, 0, -7 },
  { 216, 1, 8, 3, 1, -7 },
  { 217, 3, 8, 2, -1, -7 },
  { 220, 3, 3, 3, 0, -7 },
  { 222, 3, 1, 3, 0, 0 },
  { 223, 1, 2, 2, 1, -8 },
  { 224, 4, 5, 4, 0, -5 },
  { 227, 4, 7, 4, 0, -7 },
  { 231, 4, 5, 4, 0, -5 },
  { 234, 4, 7, 4, 0, -7 },
  { 238, 4, 5, 4, 0, -5 },
  { 241, 3, 7, 3, 0, -7 },
  { 244, 4, 7, 4, 0, -5 },
  { 248, 4, 7, 4, 0, -7 },
  { 252, 2, 7, 2, 0, -7 },
  { 254, 3, 9, 2, -1, -7 },
  { 258, 4, 7, 4, 0, -7 },
  { 262, 2, 7, 2, 0, -7 },
  { 264, 6, 5, 7, 0, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 4, 5, 4, 0, -5 },
  { 274, 4, 7, 4, 0, -5 },
  { 278, 4, 7, 4, 0, -5 },
  { 282, 3, 5, 3, 0, -5 },
  { 284, 4, 5, 4, 0, -5 },
  { 287, 3, 6, 3, 0, -6 },
  { 290, 4, 5, 4, 0, -5 },
  { 293, 3, 5, 4, 1, -5 },
  { 295, 5, 5, 6, 1, -5 },
  { 299, 4, 5, 4, 0, -5 },
  { 302, 4, 7, 4, 0, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 3, 9, 3, 0, -7 },
  { 313, 2, 8, 2, 0, -7 },
  { 315, 2, 9, 3, 0, -7 },
  { 318, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC9PT7B_H_
