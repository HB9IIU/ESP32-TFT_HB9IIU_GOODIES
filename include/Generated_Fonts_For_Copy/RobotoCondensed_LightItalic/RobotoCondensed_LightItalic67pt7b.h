#ifndef _ROBOTOCONDENSED_LIGHTITALIC67PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x60, 0x00, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF3, 0x87, 0x3C,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x39, 0xC1, 0xCE, 0x0E,
  0x70, 0x63, 0x83, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x04, 0x38, 0x03,
  0x80, 0x1C, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x01, 0xE1, 0xC0, 0x1C,
  0x03, 0x87, 0x00, 0x38, 0x0E, 0x0E, 0x00, 0x70, 0x3C, 0x1C, 0x00, 0xE0,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x30, 0x07, 0x07, 0x80, 0x70, 0x0E, 0x0E,
  0x00, 0xE0, 0x38, 0x38, 0x01, 0xE0, 0xF0, 0xF0, 0x01, 0xFF, 0xC1, 0xC0,
  0x01, 0xFF, 0x07, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x7E, 0x00,
  0x03, 0x83, 0xFE, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x1C, 0x1C, 0x1E, 0x00,
  0x70, 0x70, 0x1C, 0x01, 0xE1, 0xE0, 0x18, 0x03, 0x83, 0x80, 0x38, 0x0E,
  0x07, 0x00, 0x70, 0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x38, 0x01, 0xC1, 0xC0,
  0x70, 0x03, 0x87, 0x80, 0xE0, 0x07, 0x0E, 0x01, 0xC0, 0x0E, 0x38, 0x03,
  0x80, 0x38, 0xF0, 0x07, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0xE1, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x1C, 0x7C, 0x0F,
  0x00, 0xF1, 0xE0, 0x1E, 0x03, 0x8F, 0x00, 0x78, 0x0E, 0x3C, 0x00, 0xF0,
  0x39, 0xE0, 0x03, 0xC1, 0xE7, 0x80, 0x07, 0x87, 0x1C, 0x00, 0x1E, 0x3C,
  0xF0, 0x00, 0x3C, 0xE3, 0xC0, 0x00, 0xF7, 0x8F, 0x00, 0x01, 0xFE, 0x3C,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x3F, 0xC0, 0xFC, 0x03,
  0xE7, 0x81, 0xFF, 0xFF, 0x1E, 0x03, 0xFF, 0xF8, 0x3C, 0x03, 0xFF, 0x80,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x79,
  0xC7, 0x1C, 0x71, 0xCE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x0E, 0x00, 0x9E, 0x03,
  0x81, 0xEF, 0xE1, 0xE3, 0xFB, 0xFF, 0x73, 0xFF, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x83,
  0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x00, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0x00, 0x04, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x80,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0xB0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F,
  0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x7C, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xEE, 0x7F, 0x8E, 0x7C, 0x1E,
  0x70, 0x1E, 0x40, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF1, 0xFC, 0x00, 0x0E, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0xE0, 0x07, 0x9F, 0xFC, 0x03, 0x9F, 0xFF, 0x01, 0xDF, 0x9F, 0xC1, 0xFE,
  0x01, 0xF0, 0xFE, 0x00, 0x78, 0x7E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0x9F, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE0,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x0E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x3C, 0x00, 0xFE, 0x3E, 0x03,
  0xFC, 0x1F, 0xDF, 0xDC, 0x0F, 0xFF, 0x3C, 0x07, 0xFE, 0x3C, 0x03, 0xF8,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xFF, 0xC0, 0x06, 0x03, 0x80, 0x0F, 0xFF,
  0x80, 0x18, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x60, 0x70, 0x03, 0xE0, 0x1C,
  0x01, 0xC1, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x71, 0xE0, 0x0E, 0x00, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x1C,
  0xF0, 0x07, 0x00, 0x1C, 0x00, 0x63, 0x80, 0x3C, 0x00, 0x70, 0x01, 0x8E,
  0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x38, 0x03, 0x80, 0x07, 0x00, 0x39, 0xE0,
  0x1E, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x9C, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x31, 0xC0, 0x1C,
  0x00, 0x78, 0x01, 0xC7, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x1C, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x63, 0x80, 0x38, 0x00,
  0xF0, 0x03, 0x8E, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x38, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x03, 0xE0,
  0x0E, 0x0E, 0x00, 0xF0, 0x1D, 0xC0, 0x38, 0x38, 0x01, 0xC0, 0xE7, 0x01,
  0xC0, 0x70, 0x07, 0xEF, 0x1E, 0x1E, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x07, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7E,
  0x00, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x78,
  0x00, 0xFF, 0xFC, 0x78, 0x00, 0xFF, 0xFC, 0x70, 0x00, 0xFF, 0xFC, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xE0, 0x0F,
  0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x3E, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x0F, 0x3F, 0x80, 0x00,
  0x00, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x3C,
  0x00, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x1F,
  0x81, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x77, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xDC, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x1D, 0xE0, 0x00,
  0x00, 0xF7, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9C, 0x03, 0xCE, 0x00, 0x00,
  0x1E, 0xF0, 0x0E, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x38, 0x07, 0x8F, 0x00, 0x00, 0x70,
  0xE0, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x78, 0x70, 0x00, 0x0E, 0x1E,
  0x01, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xE0,
  0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x3C, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x3C,
  0x0E, 0x00, 0x3C, 0x0F, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0xF0, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x03,
  0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC0, 0x3C, 0x00, 0xE1, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0x8F, 0x00,
  0x3C, 0x03, 0x80, 0x0E, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x39, 0xE0, 0x07,
  0x80, 0x78, 0x00, 0xF7, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78,
  0x07, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x7C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0xFE,
  0x00, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x3F, 0xC0, 0x00, 0x1E,
  0x01, 0xFE, 0x00, 0x00, 0xF0, 0x0E, 0x70, 0x00, 0x07, 0x80, 0xF3, 0xC0,
  0x00, 0x3C, 0x07, 0x9E, 0x00, 0x01, 0xE0, 0x3C, 0x70, 0x00, 0x0E, 0x01,
  0xE3, 0xC0, 0x00, 0xF0, 0x0F, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x78, 0x00,
  0x3C, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0x0E, 0x01, 0xE0,
  0x78, 0x00, 0x70, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x0E, 0x00, 0x3C,
  0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x01, 0xC0,
  0x78, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x03, 0xC0,
  0x01, 0xC1, 0xE0, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x78,
  0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x78, 0x00, 0x0F, 0x1C, 0x03, 0xC0, 0x00,
  0x79, 0xE0, 0x1E, 0x00, 0x01, 0xCF, 0x00, 0xE0, 0x00, 0x0F, 0x78, 0x0F,
  0x00, 0x00, 0x3B, 0xC0, 0x78, 0x00, 0x01, 0xFE, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x03, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E,
  0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xF8, 0x00, 0x1E,
  0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xE3,
  0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x38, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0x8E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x38, 0x00, 0x70, 0x3C, 0x00,
  0x70, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x01, 0xC0, 0x0F,
  0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xE0,
  0x70, 0x07, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x3C,
  0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x07, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0x78, 0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x8F, 0x00, 0x07,
  0x9E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x79,
  0xC0, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x0F, 0x03, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x1E, 0x00, 0xE3, 0xC0,
  0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x7C, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x1C, 0x1F, 0x80, 0x0F,
  0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC1, 0xE0, 0x07, 0xF0,
  0x7E, 0x07, 0xDC, 0x0F, 0xFF, 0xE7, 0x01, 0xFF, 0xF1, 0xC0, 0x3F, 0xF0,
  0x70, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x3F, 0xF0, 0x03,
  0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0E, 0xF0, 0x1F, 0x01, 0xF8, 0x01,
  0xE0, 0x7E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x87, 0xE0, 0x01,
  0xF0, 0xFE, 0x00, 0x7C, 0x1C, 0xE0, 0x1F, 0x03, 0x9F, 0xFF, 0xC0, 0x71,
  0xFF, 0xF0, 0x1E, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x8F, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0xF8, 0x3C, 0x01, 0xFF, 0xF1,
  0xC0, 0x1F, 0xFF, 0x8E, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF8, 0x07, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0xE0, 0x07, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0x78, 0x00, 0x7F, 0xE3, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x3E,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x60, 0x78, 0x00, 0x70, 0x3F, 0x00, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0xF0, 0x03, 0xFF, 0xE3, 0x80, 0x1F, 0xFF, 0x8E, 0x00,
  0xF8, 0x0F, 0x38, 0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0xF0, 0x00, 0x7F, 0xE3, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x18, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x1F, 0xF8, 0x03, 0xCF, 0xFF, 0x00,
  0xF7, 0xFF, 0xE0, 0x3B, 0xC0, 0x78, 0x0F, 0xC0, 0x0F, 0x07, 0xE0, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0x80, 0x0F, 0x80, 0x38, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x78,
  0x1F, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x0E,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFD, 0xE0,
  0x00, 0x1F, 0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xF3, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3B,
  0x80, 0xF8, 0xF0, 0x1F, 0x03, 0xF8, 0x03, 0xEF, 0x00, 0x78, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xF1, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x0F, 0x7F, 0xFE,
  0x03, 0xBC, 0x07, 0x80, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x07, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x3D, 0xFF, 0xF0,
  0x01, 0xDF, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x78, 0x07,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x80,
  0x01, 0xE0, 0x7E, 0x00, 0x1E, 0x03, 0xF8, 0x01, 0xF0, 0x1E, 0xE0, 0x1F,
  0x00, 0xE7, 0xFF, 0xF0, 0x07, 0x1F, 0xFF, 0x00, 0x78, 0x3F, 0xF0, 0x03,
  0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x07, 0xFF,
  0xC7, 0x01, 0xFF, 0xFC, 0xE0, 0x7C, 0x03, 0x9C, 0x1F, 0x00, 0x3F, 0x87,
  0xC0, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x70, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFD,
  0xE0, 0x07, 0xFE, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x7F, 0x03, 0xDF, 0xF0,
  0x3F, 0xFF, 0x03, 0xBC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70,
  0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0,
  0x70, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x81, 0xF0, 0x1F,
  0xE0, 0x3F, 0xFF, 0x78, 0x07, 0xFF, 0x9E, 0x00, 0xFF, 0xC7, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x07, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03,
  0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x01, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0x80, 0x07, 0xBC, 0x00, 0x3E, 0x00, 0x1C, 0xF0,
  0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0xE0, 0x03, 0xCF, 0x00, 0x3F, 0x80,
  0x1E, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x70, 0x07, 0xB8, 0x01, 0xC1, 0xC0,
  0x1C, 0xE0, 0x0F, 0x07, 0x00, 0x73, 0x80, 0x3C, 0x1C, 0x03, 0xCE, 0x01,
  0xE0, 0x70, 0x0E, 0x38, 0x07, 0x81, 0xC0, 0x78, 0xE0, 0x1C, 0x07, 0x01,
  0xC3, 0xC0, 0xF0, 0x1C, 0x0F, 0x0F, 0x03, 0x80, 0x70, 0x38, 0x1C, 0x1E,
  0x01, 0xC0, 0xE0, 0x70, 0x78, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x1E, 0x1C,
  0x07, 0x0F, 0x00, 0x78, 0xF0, 0x1C, 0x38, 0x01, 0xE3, 0x80, 0x71, 0xE0,
  0x07, 0x9E, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x07, 0x1C, 0x00, 0x39, 0xC0,
  0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x01, 0xEE, 0x00,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x7C,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x39, 0xFF, 0xF0, 0x00,
  0xE3, 0xC1, 0xF0, 0x01, 0xCF, 0x01, 0xF0, 0x07, 0x9C, 0x01, 0xF0, 0x0E,
  0x78, 0x01, 0xF0, 0x3C, 0xE0, 0x01, 0xFF, 0xF1, 0xC0, 0x01, 0xFF, 0xC3,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 49, 14, 2, -48 },
  { 75, 13, 15, 19, 7, -50 },
  { 100, 33, 48, 33, 2, -48 },
  { 298, 27, 63, 32, 3, -56 },
  { 511, 31, 50, 42, 6, -49 },
  { 705, 30, 50, 35, 2, -49 },
  { 893, 6, 15, 11, 6, -50 },
  { 905, 19, 68, 19, 3, -53 },
  { 1067, 19, 68, 19, -4, -53 },
  { 1229, 26, 27, 28, 4, -48 },
  { 1317, 27, 35, 32, 3, -40 },
  { 1436, 9, 15, 12, -3, -6 },
  { 1453, 13, 3, 17, 2, -22 },
  { 1458, 5, 6, 16, 2, -5 },
  { 1462, 29, 52, 23, -3, -48 },
  { 1651, 27, 50, 32, 3, -49 },
  { 1820, 16, 48, 32, 8, -48 },
  { 1916, 29, 49, 32, 1, -49 },
  { 2094, 28, 50, 32, 2, -49 },
  { 2269, 28, 48, 32, 1, -48 },
  { 2437, 28, 49, 32, 4, -48 },
  { 2609, 25, 49, 32, 3, -48 },
  { 2763, 28, 48, 32, 5, -48 },
  { 2931, 28, 50, 32, 2, -49 },
  { 3106, 24, 49, 32, 5, -49 },
  { 3253, 11, 36, 13, 1, -35 },
  { 3303, 15, 44, 12, -3, -35 },
  { 3386, 25, 28, 29, 3, -36 },
  { 3474, 25, 18, 31, 4, -31 },
  { 3531, 25, 28, 30, 2, -35 },
  { 3619, 20, 50, 26, 6, -49 },
  { 3744, 46, 62, 51, 2, -47 },
  { 4101, 33, 48, 36, -2, -48 },
  { 4299, 31, 48, 35, 2, -48 },
  { 4485, 32, 50, 37, 4, -49 },
  { 4685, 33, 48, 37, 2, -48 },
  { 4883, 32, 48, 32, 2, -48 },
  { 5075, 32, 48, 32, 2, -48 },
  { 5267, 32, 50, 39, 4, -49 },
  { 5467, 37, 48, 40, 2, -48 },
  { 5689, 12, 48, 16, 3, -48 },
  { 5761, 30, 49, 31, 1, -48 },
  { 5945, 36, 48, 36, 2, -48 },
  { 6161, 23, 48, 30, 2, -48 },
  { 6299, 46, 48, 49, 2, -48 },
  { 6575, 37, 48, 40, 2, -48 },
  { 6797, 32, 50, 38, 4, -49 },
  { 6997, 33, 48, 35, 2, -48 },
  { 7195, 32, 57, 38, 4, -49 },
  { 7423, 32, 48, 36, 2, -48 },
  { 7615, 32, 50, 34, 2, -49 },
  { 7815, 31, 48, 34, 6, -48 },
  { 8001, 33, 49, 37, 4, -48 },
  { 8204, 32, 48, 35, 6, -48 },
  { 8396, 46, 48, 50, 7, -48 },
  { 8672, 38, 48, 35, -1, -48 },
  { 8900, 32, 48, 34, 6, -48 },
  { 9092, 35, 48, 34, 0, -48 },
  { 9302, 19, 64, 15, 0, -54 },
  { 9454, 10, 52, 23, 7, -48 },
  { 9519, 19, 64, 15, -4, -54 },
  { 9671, 19, 24, 24, 3, -48 },
  { 9728, 24, 3, 25, -3, 0 },
  { 9737, 9, 9, 19, 8, -50 },
  { 9748, 26, 37, 31, 1, -36 },
  { 9869, 27, 51, 32, 1, -50 },
  { 10042, 26, 37, 29, 2, -36 },
  { 10163, 29, 51, 32, 3, -50 },
  { 10348, 25, 37, 30, 2, -36 },
  { 10464, 20, 51, 20, 4, -51 },
  { 10592, 30, 50, 32, 0, -36 },
  { 10780, 26, 50, 31, 1, -50 },
  { 10943, 12, 48, 14, 2, -48 },
  { 11015, 22, 62, 14, -8, -48 },
  { 11186, 28, 50, 28, 1, -50 },
  { 11361, 12, 50, 14, 2, -50 },
  { 11436, 45, 36, 50, 1, -36 },
  { 11639, 26, 36, 31, 1, -36 },
  { 11756, 27, 37, 32, 2, -36 },
  { 11881, 29, 50, 32, -1, -36 },
  { 12063, 27, 50, 32, 3, -36 },
  { 12232, 20, 36, 20, 1, -36 },
  { 12322, 26, 37, 29, 1, -36 },
  { 12443, 16, 45, 19, 3, -44 },
  { 12533, 26, 36, 31, 3, -35 },
  { 12650, 25, 35, 28, 4, -35 },
  { 12760, 38, 35, 42, 5, -35 },
  { 12927, 29, 35, 28, -1, -35 },
  { 13054, 32, 49, 27, -3, -35 },
  { 13250, 27, 35, 28, 0, -35 },
  { 13369, 21, 65, 19, 2, -52 },
  { 13540, 12, 57, 14, 1, -48 },
  { 13626, 21, 65, 19, -4, -52 },
  { 13797, 31, 12, 39, 4, -26 },
};

const GFXfont RobotoCondensed_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC67PT7B_H_
