#ifndef _ROBOTOCONDENSED_LIGHTITALIC70PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0xCF,
  0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x78, 0x71, 0xC1, 0xC7,
  0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x03,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x10, 0x70, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x00,
  0x38, 0xE0, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00, 0xF0, 0xE0, 0x07, 0x00,
  0xE0, 0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0xE0, 0x0F, 0x03,
  0x80, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x0E, 0x0F, 0x00, 0xE0, 0x1E, 0x0E,
  0x00, 0xF0, 0x1C, 0x1C, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0x7F, 0xF8, 0x38,
  0x00, 0x3F, 0xF0, 0x70, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0xF0, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x3C, 0x3F, 0xFC, 0x00, 0x78, 0x3C,
  0x1C, 0x00, 0x70, 0x78, 0x0E, 0x00, 0xF0, 0x70, 0x0E, 0x01, 0xE0, 0xE0,
  0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x81, 0xE0,
  0x0F, 0x07, 0x01, 0xC0, 0x0E, 0x0F, 0x01, 0xC0, 0x0E, 0x1E, 0x01, 0xC0,
  0x0E, 0x1C, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x0E, 0x78, 0x01, 0xC0,
  0x1E, 0x30, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0xE0, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x01, 0xC3, 0xC0, 0x78, 0x03, 0x8F, 0x80, 0xF0, 0x0F, 0x3E, 0x00, 0xF0,
  0x1E, 0x78, 0x01, 0xE0, 0x39, 0xF0, 0x01, 0xE0, 0x73, 0xC0, 0x03, 0xE1,
  0xE7, 0x80, 0x03, 0xC3, 0x8E, 0x00, 0x07, 0xCF, 0x3C, 0x00, 0x07, 0x9E,
  0x78, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x0F, 0xC1,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0x80, 0x7E, 0x78, 0x1F,
  0xFF, 0xF8, 0xF8, 0x0F, 0xFF, 0xC0, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x38,
  0xE3, 0x8E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x07, 0x00, 0x2E, 0x01, 0xE0,
  0x3F, 0xF8, 0x38, 0x3F, 0xFF, 0xC7, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C,
  0x1E, 0x07, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x73,
  0xEF, 0xBE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xEE, 0x7F,
  0x9E, 0xFE, 0x1E, 0xF0, 0x1E, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x00,
  0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x01, 0xCF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0xE0, 0x07, 0x1F, 0xFC, 0x07, 0x9F, 0xFF, 0x03, 0xDF,
  0xFF, 0xC1, 0xDE, 0x01, 0xF0, 0xFE, 0x00, 0x78, 0xFE, 0x00, 0x1E, 0x7E,
  0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xE7, 0x80, 0x03, 0xF0, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0xFF, 0x0F, 0xC0, 0x7B, 0xC1, 0xFF, 0xFE, 0xE0, 0x3F, 0xFE,
  0x38, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0x81, 0xF0, 0x7C, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xFF, 0x80, 0x06, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0x03,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0x07,
  0x00, 0x1E, 0x00, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x0E,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x1E,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x38,
  0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x38,
  0x03, 0xC0, 0x03, 0x80, 0x0E, 0x78, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x70,
  0x03, 0x80, 0x07, 0x80, 0x0E, 0x70, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x70,
  0x07, 0x80, 0x07, 0x00, 0x1C, 0x70, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x70,
  0x07, 0x00, 0x0F, 0x00, 0x1C, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x70, 0x07, 0x00, 0x1E, 0x00, 0x38, 0xF0,
  0x07, 0x00, 0x1E, 0x00, 0x30, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0xF0,
  0x07, 0x00, 0x3E, 0x00, 0x70, 0x70, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x70,
  0x07, 0x80, 0xEE, 0x01, 0xC0, 0x70, 0x07, 0x81, 0xCF, 0x03, 0xC0, 0x70,
  0x03, 0xFF, 0x87, 0x8F, 0x80, 0x70, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x70,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x1E, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0xFC, 0x78, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0x1F,
  0xFF, 0x87, 0x80, 0x07, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x01, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0x3F, 0xC0, 0x00, 0x00, 0x3D,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBE, 0x00, 0x00, 0x03, 0xFC, 0x78, 0x00,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xEE, 0x00, 0x00, 0x03, 0xDE, 0x01,
  0xEE, 0x00, 0x00, 0x03, 0xDC, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x9C, 0x01,
  0xCF, 0x00, 0x00, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x3C, 0x03,
  0xC7, 0x00, 0x00, 0x1E, 0x38, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x03,
  0x87, 0x80, 0x00, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x07,
  0x83, 0x80, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x07,
  0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x03, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x0F,
  0x01, 0xC0, 0x07, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0xF1, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0x73, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x73, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x7F, 0x80, 0x07, 0x80, 0x78, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x78,
  0x00, 0x7F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xC0,
  0x1F, 0xC0, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x03, 0xDE, 0x00, 0x00, 0x78,
  0x07, 0x9C, 0x00, 0x00, 0xE0, 0x0F, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x1E,
  0x00, 0x07, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x78, 0x07,
  0x80, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0x00,
  0xF3, 0x80, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x01,
  0xE0, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x38, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x03, 0xF0, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3D, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x39, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0x71, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0xF0, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xC0, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x78,
  0x03, 0x80, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0x78,
  0x1E, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0x78,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x78, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x78, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x00, 0x38,
  0x78, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x38,
  0xF0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x79, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0x80, 0x07,
  0xB8, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x01,
  0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x38, 0x00, 0xE7, 0x80, 0x0F, 0x70, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0x80, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xFE, 0x01, 0xC0, 0xFC, 0x00, 0x38, 0x3E, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x7E,
  0x0F, 0x80, 0x1D, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xEF, 0x01, 0xFF,
  0xF1, 0xE0, 0x1F, 0xFC, 0x1C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC3, 0xFF, 0x00, 0x1E,
  0x7F, 0xFC, 0x00, 0xF7, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0x1E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x1E, 0x0F,
  0xE0, 0x01, 0xE0, 0x7B, 0x80, 0x1F, 0x03, 0xDE, 0x03, 0xF0, 0x1C, 0x7F,
  0xFF, 0x00, 0xE1, 0xFF, 0xF0, 0x0F, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x7F, 0xE0, 0xF0, 0x03, 0xFF, 0xE1, 0xE0, 0x0F,
  0xFF, 0xE3, 0xC0, 0x3F, 0x01, 0xE7, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C,
  0x07, 0xB8, 0x00, 0xFF, 0xFE, 0xF0, 0x00, 0xFF, 0xF9, 0xE0, 0x00, 0xFF,
  0xE3, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xF8,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x0E, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0C, 0x07, 0xC0,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8, 0x78,
  0x03, 0xFF, 0xF8, 0xF0, 0x0F, 0xC0, 0x79, 0xC0, 0x1F, 0x00, 0x3B, 0x80,
  0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00,
  0x1F, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x78, 0x00,
  0x3F, 0xF8, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x02, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC3, 0xFF, 0x00, 0x3C, 0x7F,
  0xF8, 0x03, 0xCF, 0xFF, 0xC0, 0x3D, 0xE0, 0x7C, 0x03, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x0E, 0x07, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0E, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x70, 0xF8, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x77, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x9E, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0x80, 0xF8, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0x87, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x1E, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7C, 0x7C, 0x0F, 0xC0,
  0x7F, 0x00, 0x7D, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x3F, 0xF0, 0x03, 0xC7, 0xFF,
  0x80, 0x3C, 0xFF, 0xFC, 0x03, 0xDE, 0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x03,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xE0, 0x7C, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x38, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xE1, 0xFF, 0x80, 0x03,
  0xCF, 0xFF, 0x80, 0x07, 0xBF, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0x3F,
  0x80, 0x0F, 0x80, 0x7B, 0xC0, 0x7E, 0x00, 0xF3, 0xFF, 0xF8, 0x01, 0xC3,
  0xFF, 0xE0, 0x07, 0x83, 0xFF, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0x01, 0xFF, 0xF8, 0xF0,
  0x3F, 0xFF, 0x8F, 0x07, 0xE0, 0x3C, 0xE0, 0xFC, 0x00, 0xEE, 0x0F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0,
  0x3E, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x3C, 0x00, 0xFF,
  0xE3, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x3F, 0xC0, 0xF3, 0xFE, 0x07,
  0xBF, 0xF0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x81, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x07,
  0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF,
  0xBC, 0x01, 0xFF, 0xF3, 0xC0, 0x0F, 0xFE, 0x38, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80,
  0xF0, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xE0,
  0x38, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0xFC,
  0x00, 0x3C, 0x70, 0x00, 0xFC, 0x00, 0x3C, 0x70, 0x01, 0xFC, 0x00, 0x78,
  0x70, 0x01, 0xFC, 0x00, 0x78, 0x70, 0x01, 0xDC, 0x00, 0xF0, 0x70, 0x03,
  0xDC, 0x00, 0xF0, 0x70, 0x03, 0x9C, 0x00, 0xE0, 0x78, 0x07, 0x9C, 0x01,
  0xE0, 0x78, 0x07, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x1E, 0x03, 0x80, 0x78, 0x1E, 0x0E,
  0x07, 0x80, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0x78, 0x3C, 0x0E, 0x07, 0x00,
  0x78, 0x38, 0x0E, 0x0F, 0x00, 0x78, 0x78, 0x0E, 0x0E, 0x00, 0x38, 0x70,
  0x0E, 0x1E, 0x00, 0x38, 0x70, 0x0E, 0x1E, 0x00, 0x38, 0xF0, 0x0E, 0x1C,
  0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x00, 0x39, 0xE0, 0x0F, 0x38, 0x00, 0x39,
  0xC0, 0x0F, 0x78, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x38, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0x0F, 0xFE, 0x00, 0x07, 0x1F, 0xFF, 0x00, 0x07, 0x3E,
  0x0F, 0x80, 0x0F, 0x3C, 0x07, 0xC0, 0x0E, 0x78, 0x03, 0xE0, 0x0E, 0x70,
  0x01, 0xE0, 0x1E, 0x70, 0x01, 0xF8, 0x3C, 0xF0, 0x00, 0xFF, 0xF8, 0xE0,
  0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 51, 15, 2, -50 },
  { 78, 14, 16, 20, 7, -53 },
  { 106, 35, 50, 35, 2, -50 },
  { 325, 28, 65, 33, 3, -58 },
  { 553, 32, 52, 43, 7, -51 },
  { 761, 31, 52, 37, 2, -51 },
  { 963, 6, 15, 12, 7, -53 },
  { 975, 20, 72, 20, 3, -56 },
  { 1155, 20, 72, 20, -4, -56 },
  { 1335, 27, 28, 29, 4, -50 },
  { 1430, 28, 36, 34, 3, -41 },
  { 1556, 10, 16, 13, -3, -7 },
  { 1576, 14, 4, 18, 2, -24 },
  { 1583, 6, 6, 16, 2, -5 },
  { 1588, 30, 54, 24, -3, -50 },
  { 1791, 27, 52, 33, 4, -51 },
  { 1967, 16, 50, 33, 9, -50 },
  { 2067, 30, 51, 33, 1, -51 },
  { 2259, 29, 52, 33, 2, -51 },
  { 2448, 30, 50, 33, 1, -50 },
  { 2636, 30, 51, 33, 4, -50 },
  { 2828, 25, 51, 33, 4, -50 },
  { 2988, 29, 50, 33, 5, -50 },
  { 3170, 30, 52, 33, 2, -51 },
  { 3365, 26, 51, 33, 5, -51 },
  { 3531, 12, 38, 14, 1, -37 },
  { 3588, 15, 46, 13, -3, -37 },
  { 3675, 26, 29, 30, 3, -37 },
  { 3770, 26, 18, 33, 4, -32 },
  { 3829, 26, 29, 31, 2, -37 },
  { 3924, 22, 52, 27, 6, -51 },
  { 4067, 48, 64, 53, 2, -49 },
  { 4451, 34, 50, 37, -2, -50 },
  { 4664, 32, 50, 36, 2, -50 },
  { 4864, 33, 52, 38, 4, -51 },
  { 5079, 34, 50, 39, 2, -50 },
  { 5292, 34, 50, 34, 2, -50 },
  { 5505, 34, 50, 33, 2, -50 },
  { 5718, 34, 52, 40, 4, -51 },
  { 5939, 39, 50, 42, 2, -50 },
  { 6183, 12, 50, 17, 3, -50 },
  { 6258, 31, 51, 33, 1, -50 },
  { 6456, 38, 50, 37, 2, -50 },
  { 6694, 25, 50, 32, 2, -50 },
  { 6851, 48, 50, 51, 2, -50 },
  { 7151, 39, 50, 42, 2, -50 },
  { 7395, 34, 52, 40, 4, -51 },
  { 7616, 34, 50, 37, 2, -50 },
  { 7829, 34, 60, 40, 4, -51 },
  { 8084, 34, 50, 37, 2, -50 },
  { 8297, 33, 52, 35, 2, -51 },
  { 8512, 32, 50, 35, 6, -50 },
  { 8712, 35, 51, 39, 4, -50 },
  { 8936, 34, 50, 37, 6, -50 },
  { 9149, 48, 50, 52, 7, -50 },
  { 9449, 40, 50, 36, -1, -50 },
  { 9699, 33, 50, 36, 6, -50 },
  { 9906, 37, 50, 35, 0, -50 },
  { 10138, 20, 68, 15, 0, -57 },
  { 10308, 11, 54, 24, 7, -50 },
  { 10383, 20, 68, 15, -4, -57 },
  { 10553, 20, 25, 25, 3, -50 },
  { 10616, 25, 4, 26, -3, 0 },
  { 10629, 9, 10, 19, 9, -53 },
  { 10641, 27, 39, 32, 1, -38 },
  { 10773, 29, 54, 33, 1, -53 },
  { 10969, 27, 39, 31, 2, -38 },
  { 11101, 31, 54, 33, 3, -53 },
  { 11311, 27, 39, 31, 2, -38 },
  { 11443, 22, 54, 20, 4, -54 },
  { 11592, 31, 52, 33, 0, -38 },
  { 11794, 28, 53, 33, 1, -53 },
  { 11980, 13, 51, 14, 2, -51 },
  { 12063, 22, 65, 14, -8, -51 },
  { 12242, 29, 53, 29, 1, -53 },
  { 12435, 13, 53, 14, 2, -53 },
  { 12522, 47, 38, 52, 1, -38 },
  { 12746, 28, 38, 33, 1, -38 },
  { 12879, 27, 39, 33, 3, -38 },
  { 13011, 31, 52, 33, -1, -38 },
  { 13213, 28, 52, 33, 3, -38 },
  { 13395, 21, 38, 21, 1, -38 },
  { 13495, 27, 39, 30, 1, -38 },
  { 13627, 17, 47, 20, 3, -46 },
  { 13727, 28, 38, 33, 3, -37 },
  { 13860, 26, 37, 29, 4, -37 },
  { 13981, 40, 37, 44, 5, -37 },
  { 14166, 30, 37, 29, -1, -37 },
  { 14305, 33, 51, 28, -3, -37 },
  { 14516, 29, 37, 29, 0, -37 },
  { 14651, 22, 69, 20, 2, -55 },
  { 14841, 13, 59, 15, 1, -50 },
  { 14937, 22, 69, 20, -4, -55 },
  { 15127, 32, 13, 40, 4, -27 },
};

const GFXfont RobotoCondensed_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC70PT7B_H_
