#ifndef _ROBOTOCONDENSED_LIGHTITALIC35PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3,
  0x08, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x30, 0xC0, 0x65, 0x14, 0xF3, 0xCF,
  0x28, 0xA2, 0x00, 0x61, 0x80, 0x30, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C,
  0x20, 0x04, 0x30, 0x06, 0x18, 0x3F, 0xFF, 0x1F, 0xFF, 0x81, 0x86, 0x00,
  0xC2, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30, 0x80, 0x10, 0xC0, 0x18, 0x60,
  0xFF, 0xFE, 0x7F, 0xFF, 0x06, 0x18, 0x03, 0x08, 0x01, 0x0C, 0x01, 0x86,
  0x00, 0xC2, 0x00, 0x43, 0x00, 0x61, 0x80, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x0F, 0x80, 0x7F, 0x81, 0xC3, 0x83, 0x03, 0x0C, 0x06, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x10, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xE0, 0xC0, 0xFF, 0x00, 0x7C,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x61,
  0x00, 0x61, 0x02, 0x41, 0x86, 0xC1, 0x8C, 0xC1, 0x08, 0xC1, 0x18, 0xC3,
  0x30, 0x43, 0x20, 0x7E, 0x60, 0x3C, 0xC0, 0x01, 0x80, 0x01, 0x1C, 0x03,
  0x3E, 0x06, 0x63, 0x04, 0x41, 0x0C, 0xC1, 0x18, 0xC1, 0x10, 0xC1, 0x30,
  0xC3, 0x60, 0xC3, 0x00, 0xC2, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xF0, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C,
  0x30, 0x0C, 0x70, 0x06, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x19,
  0x83, 0x31, 0x82, 0x70, 0xC6, 0x60, 0xC6, 0xC0, 0x64, 0xC0, 0x6C, 0xC0,
  0x38, 0xC0, 0x38, 0x60, 0x38, 0x70, 0x7C, 0x3F, 0xCC, 0x1F, 0x06, 0x6D,
  0xB6, 0xB6, 0x00, 0x40, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x04, 0x30, 0xF9, 0x9C, 0xFF, 0xC1, 0xF0, 0x0F, 0x00, 0x68,
  0x06, 0x60, 0x61, 0x86, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFE,
  0xFF, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x33, 0x33, 0x66, 0xC8, 0xFF, 0xFC, 0xDF,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3, 0x86, 0x06, 0x30,
  0x18, 0xC0, 0x22, 0x00, 0x98, 0x02, 0x60, 0x09, 0x80, 0x66, 0x01, 0x90,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0, 0x33, 0x00, 0xCC,
  0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x06, 0x1C, 0x1F, 0xE0, 0x3E, 0x00,
  0x01, 0x83, 0x8F, 0xCE, 0x64, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03,
  0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x3F, 0xFE, 0xFF,
  0xF8, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0xC3, 0x01,
  0x8C, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x3F, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x03, 0x0C, 0x06, 0x1C, 0x18, 0x1F, 0xE0, 0x1F, 0x80,
  0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x0B, 0x00, 0x78, 0x03, 0x60, 0x09,
  0x80, 0x66, 0x03, 0x18, 0x18, 0x40, 0x63, 0x03, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0x03, 0x18, 0x08, 0x60, 0x63, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x6F, 0x80, 0xFF, 0x81, 0xC3, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x0C,
  0x0C, 0x18, 0x38, 0x1F, 0xE0, 0x1F, 0x00, 0x00, 0x70, 0x0F, 0x81, 0xE0,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x3E, 0x1B,
  0xF8, 0xF0, 0xEF, 0x03, 0x70, 0x1B, 0x00, 0x58, 0x03, 0xC0, 0x16, 0x01,
  0xB0, 0x0D, 0x80, 0x6C, 0x06, 0x30, 0x31, 0x83, 0x07, 0xF0, 0x1F, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xF0,
  0x38, 0x70, 0x60, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18,
  0x0C, 0x30, 0x18, 0x30, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0x0E, 0x0C, 0x0C,
  0x30, 0x0C, 0x60, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x8C,
  0x06, 0x1C, 0x18, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0x81, 0xFE, 0x38, 0x67,
  0x03, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x0F, 0x61, 0xE7, 0xF6, 0x3E, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x0F, 0xC0, 0xF0, 0x00, 0x19, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x30, 0x06, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x30, 0x40, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x80, 0x7F, 0xFB, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x20, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F,
  0x07, 0xF9, 0xC3, 0x30, 0x6C, 0x07, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x0F, 0x03, 0x18, 0x3F,
  0x83, 0x10, 0x30, 0xC3, 0x30, 0x60, 0xC3, 0x30, 0xC0, 0x83, 0x20, 0xC1,
  0x83, 0x61, 0x81, 0x83, 0x61, 0x81, 0x83, 0x41, 0x81, 0x02, 0x41, 0x03,
  0x02, 0xC1, 0x03, 0x06, 0xC3, 0x03, 0x06, 0xC3, 0x06, 0x04, 0xC3, 0x06,
  0x0C, 0xC1, 0x0B, 0x18, 0xC1, 0xFB, 0xB0, 0xC0, 0xE1, 0xE0, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x40, 0x03, 0x20, 0x01,
  0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0,
  0x30, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x06, 0x0F, 0xFF, 0x0F, 0xFF,
  0x86, 0x00, 0xC3, 0x00, 0x23, 0x00, 0x11, 0x80, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x0C, 0x06, 0x0C, 0x03,
  0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06,
  0x18, 0x0C, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x1C, 0x30, 0x0C, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C,
  0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81,
  0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x04, 0x60, 0x03, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x30, 0x01, 0x18, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0xC1, 0xC0, 0xC0, 0x7F, 0xC0, 0x0F, 0x80, 0x00,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0xC0, 0x30, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x03,
  0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xC3, 0x01,
  0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81,
  0xC1, 0x80, 0x61, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0xFB,
  0x03, 0xFD, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x9C, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x70, 0xC0, 0xF0, 0x3F, 0xF0, 0x0F, 0xC0, 0x00,
  0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x06, 0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x40, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x63, 0x00,
  0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x38, 0x70, 0x3F, 0xC0, 0x3F, 0x00,
  0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0xE0,
  0x30, 0x38, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x03, 0x18, 0x00,
  0x66, 0x00, 0x19, 0xC0, 0x03, 0x78, 0x00, 0x7B, 0x80, 0x0E, 0x30, 0x01,
  0x87, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0E, 0x0B, 0x00, 0x1A, 0x1B, 0x00, 0x1E, 0x1B, 0x00, 0x36, 0x1B,
  0x00, 0x36, 0x1B, 0x00, 0x66, 0x19, 0x00, 0x64, 0x11, 0x80, 0xCC, 0x31,
  0x80, 0xCC, 0x31, 0x81, 0x8C, 0x31, 0x81, 0x8C, 0x31, 0x83, 0x0C, 0x30,
  0x83, 0x18, 0x20, 0xC6, 0x18, 0x60, 0xC6, 0x18, 0x60, 0xCC, 0x18, 0x60,
  0xCC, 0x18, 0x60, 0xD8, 0x18, 0x60, 0x58, 0x30, 0xC0, 0x70, 0x30, 0xC0,
  0x60, 0x30, 0xC0, 0x60, 0x30, 0x0C, 0x00, 0x30, 0xE0, 0x06, 0x0E, 0x00,
  0x60, 0xF0, 0x06, 0x0F, 0x00, 0x61, 0xB0, 0x06, 0x19, 0x80, 0x61, 0x98,
  0x0C, 0x19, 0x80, 0xC1, 0x8C, 0x0C, 0x18, 0xC0, 0xC3, 0x04, 0x0C, 0x30,
  0x60, 0x83, 0x06, 0x18, 0x30, 0x31, 0x83, 0x03, 0x18, 0x30, 0x31, 0x86,
  0x01, 0x98, 0x60, 0x1B, 0x06, 0x01, 0xB0, 0x60, 0x0F, 0x06, 0x00, 0xF0,
  0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0x81, 0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0xCE, 0x00, 0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0x7F, 0xC0, 0x0F,
  0xC0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0x01, 0xC1, 0x80, 0x70, 0xC0,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0xC6, 0x00, 0xE3, 0x00, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0x81, 0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0x7F, 0xC0, 0x0F,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0x01, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0xC3,
  0x00, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xE3, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0x81, 0x81, 0x80,
  0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x46, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xC7, 0x00, 0xC1, 0xC1,
  0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00,
  0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x38, 0x60,
  0x18, 0x30, 0x0C, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x31, 0x80, 0x08, 0xC0, 0x06, 0x60, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x03, 0x40, 0x18, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x3C, 0x06,
  0x60, 0x3C, 0x06, 0x60, 0x6C, 0x06, 0x60, 0x6C, 0x0C, 0x60, 0x4C, 0x0C,
  0x60, 0xCC, 0x18, 0x60, 0xCC, 0x18, 0x61, 0x84, 0x18, 0x61, 0x84, 0x30,
  0x61, 0x04, 0x30, 0x63, 0x04, 0x30, 0x63, 0x04, 0x60, 0x62, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x80,
  0x28, 0x07, 0x80, 0x38, 0x07, 0x80, 0x38, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xE0, 0x30,
  0x1C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x01, 0x87, 0x00, 0x0C, 0x60, 0x00,
  0xCC, 0x00, 0x0D, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x03, 0x98, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x07,
  0x07, 0x00, 0x30, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x30, 0x03, 0x98, 0x01,
  0x8C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x18,
  0x60, 0x0C, 0x70, 0x06, 0x30, 0x01, 0x30, 0x00, 0xD8, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x07, 0xC1, 0xF0,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0xE0, 0xF8, 0x00, 0x84, 0x31, 0x8C, 0x63, 0x08, 0x43, 0x18, 0xC6, 0x30,
  0x84, 0x31, 0x8C, 0x63, 0x08, 0x43, 0x18, 0xC6, 0x07, 0xC1, 0xF0, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x83, 0xE0,
  0xF8, 0x00, 0x02, 0x03, 0x81, 0xC1, 0xE0, 0x90, 0xC8, 0x44, 0x63, 0x21,
  0xB0, 0xF0, 0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x63, 0x0C, 0x61, 0x80,
  0x03, 0xE0, 0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x0F, 0xF1, 0xFF, 0x9C, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x01,
  0x98, 0x3C, 0x7F, 0x61, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x19, 0xE0, 0x5F, 0xE3,
  0xC1, 0x8E, 0x07, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x60, 0x0D,
  0x80, 0x36, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0xEE, 0x03, 0x3C, 0x18,
  0xDF, 0xE3, 0x3E, 0x00, 0x07, 0xE0, 0x7F, 0x86, 0x0C, 0x60, 0x33, 0x01,
  0xB0, 0x0D, 0x80, 0x6C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x03, 0x60, 0x19, 0x81, 0x8C, 0x1C, 0x3F, 0xC0, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x07, 0xCC, 0x0F, 0xEC, 0x18, 0x3C, 0x30, 0x1C, 0x30, 0x0C,
  0x60, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x40, 0x18, 0xC0, 0x18,
  0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x30, 0x60, 0xF0, 0x3F, 0xB0,
  0x1F, 0x20, 0x07, 0xE0, 0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0xB0, 0x0D,
  0x80, 0x6F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x8E, 0x0C, 0x3F, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x38,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x7F, 0x1F, 0xE0, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x03, 0xE2, 0x07, 0xF6,
  0x0C, 0x1E, 0x18, 0x0E, 0x18, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x18, 0x60, 0x18,
  0x30, 0x18, 0x30, 0x78, 0x1F, 0xD8, 0x0F, 0x90, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x40, 0x60, 0xE0, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x19,
  0xE0, 0xBF, 0x8F, 0x06, 0x70, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0x64, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x06, 0xC0, 0x26, 0x03, 0x00, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18,
  0x63, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC0,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x38, 0x3E, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x1C,
  0x40, 0xE3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x0B, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0x30, 0x18, 0xC0, 0x61, 0x83, 0x06, 0x0C, 0x0C,
  0x30, 0x30, 0xC0, 0x63, 0x01, 0x80, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86,
  0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x8C, 0x30,
  0xC3, 0x00, 0x19, 0xE0, 0xF8, 0x2F, 0xE3, 0xF8, 0xF0, 0xEC, 0x31, 0xC0,
  0xF0, 0x33, 0x01, 0xC0, 0x66, 0x03, 0x80, 0xCC, 0x06, 0x01, 0xB0, 0x0C,
  0x03, 0x60, 0x18, 0x04, 0xC0, 0x30, 0x19, 0x80, 0x40, 0x33, 0x01, 0x80,
  0x66, 0x03, 0x00, 0xD8, 0x06, 0x01, 0xB0, 0x0C, 0x06, 0x60, 0x18, 0x0C,
  0xC0, 0x60, 0x19, 0x80, 0xC0, 0x30, 0x19, 0xE0, 0xBF, 0x8F, 0x06, 0x70,
  0x33, 0x81, 0x98, 0x0C, 0xC0, 0x64, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x26, 0x03, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x8E, 0x06, 0x30, 0x0D, 0x80, 0x36, 0x00,
  0xD8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x19, 0x80,
  0x66, 0x03, 0x1C, 0x18, 0x3F, 0xC0, 0x7E, 0x00, 0x06, 0x78, 0x05, 0xFE,
  0x0F, 0x06, 0x0E, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03,
  0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x0C,
  0x38, 0x0C, 0x3C, 0x18, 0x37, 0xF8, 0x33, 0xE0, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x07, 0xC4,
  0x1F, 0xD8, 0x60, 0xF1, 0x80, 0xE3, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0x80, 0x33, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x06,
  0x18, 0x0C, 0x30, 0x78, 0x3F, 0xB0, 0x3E, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x1B, 0xC5, 0xF3,
  0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xC0, 0xFF, 0x86,
  0x0C, 0x60, 0x33, 0x01, 0x98, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x60, 0x33, 0x01, 0x9C, 0x1C, 0x7F, 0xC0,
  0xF8, 0x00, 0x08, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x60, 0x78,
  0x78, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x19, 0x80,
  0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x03, 0x9C, 0x3C, 0x7F, 0x41, 0xF6, 0x00, 0xC0, 0x1E, 0x01, 0x90, 0x0C,
  0xC0, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x61, 0x81, 0x08, 0x08,
  0xC0, 0x64, 0x03, 0x60, 0x1B, 0x00, 0xF0, 0x07, 0x80, 0x18, 0x00, 0xC0,
  0x00, 0x80, 0xC0, 0x78, 0x18, 0x0F, 0x07, 0x03, 0x60, 0xF0, 0x6C, 0x16,
  0x0D, 0x86, 0xC3, 0x30, 0xD8, 0x66, 0x33, 0x18, 0xC6, 0x63, 0x19, 0x8C,
  0x43, 0x31, 0x98, 0x64, 0x13, 0x0D, 0x82, 0xC1, 0xA0, 0x58, 0x1C, 0x0A,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x0C, 0x0E,
  0x06, 0x0C, 0x06, 0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x60, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x60,
  0x18, 0x20, 0x30, 0x30, 0x70, 0x30, 0x60, 0x18, 0x18, 0x03, 0x18, 0x06,
  0x08, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30,
  0x0C, 0x30, 0x04, 0x60, 0x04, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x60, 0x1C, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0xF0, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x18,
  0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3,
  0x0C, 0x30, 0xC2, 0x00, 0x04, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0xE0, 0x18, 0x00, 0x1E, 0x01, 0x7F, 0x03, 0x63, 0x83, 0xC1, 0xC6, 0xC0,
  0xFE, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 7, 1, -25 },
  { 20, 6, 8, 10, 4, -26 },
  { 26, 17, 25, 17, 1, -25 },
  { 80, 15, 31, 17, 1, -28 },
  { 139, 16, 25, 22, 3, -25 },
  { 189, 16, 25, 18, 1, -25 },
  { 239, 3, 8, 6, 3, -26 },
  { 242, 10, 36, 10, 2, -28 },
  { 287, 10, 36, 10, -2, -28 },
  { 332, 13, 14, 14, 2, -25 },
  { 355, 15, 18, 17, 1, -21 },
  { 389, 4, 8, 7, -1, -3 },
  { 393, 7, 2, 9, 1, -12 },
  { 395, 3, 3, 8, 1, -3 },
  { 397, 15, 27, 12, -2, -25 },
  { 448, 14, 25, 17, 2, -25 },
  { 492, 9, 25, 17, 4, -25 },
  { 521, 14, 25, 17, 1, -25 },
  { 565, 15, 25, 17, 1, -25 },
  { 612, 14, 25, 17, 1, -25 },
  { 656, 15, 25, 17, 2, -25 },
  { 703, 13, 25, 17, 2, -25 },
  { 744, 14, 25, 17, 3, -25 },
  { 788, 15, 25, 17, 1, -25 },
  { 835, 12, 25, 17, 3, -25 },
  { 873, 5, 19, 7, 1, -19 },
  { 885, 7, 24, 7, -1, -19 },
  { 906, 13, 15, 15, 1, -19 },
  { 931, 13, 9, 16, 2, -16 },
  { 946, 13, 15, 15, 1, -19 },
  { 971, 11, 25, 14, 3, -25 },
  { 1006, 24, 32, 27, 1, -24 },
  { 1102, 17, 25, 19, -1, -25 },
  { 1156, 16, 25, 18, 1, -25 },
  { 1206, 17, 25, 19, 2, -25 },
  { 1260, 17, 25, 19, 1, -25 },
  { 1314, 17, 25, 17, 1, -25 },
  { 1368, 17, 25, 17, 1, -25 },
  { 1422, 17, 25, 20, 2, -25 },
  { 1476, 20, 25, 21, 1, -25 },
  { 1539, 7, 25, 8, 1, -25 },
  { 1561, 15, 25, 16, 1, -25 },
  { 1608, 19, 25, 19, 1, -25 },
  { 1668, 12, 25, 16, 1, -25 },
  { 1706, 24, 25, 25, 1, -25 },
  { 1781, 20, 25, 21, 1, -25 },
  { 1844, 17, 25, 20, 2, -25 },
  { 1898, 17, 25, 18, 1, -25 },
  { 1952, 17, 29, 20, 2, -25 },
  { 2014, 17, 25, 19, 1, -25 },
  { 2068, 17, 25, 18, 1, -25 },
  { 2122, 16, 25, 18, 3, -25 },
  { 2172, 17, 25, 19, 2, -25 },
  { 2226, 17, 25, 18, 3, -25 },
  { 2280, 24, 25, 26, 3, -25 },
  { 2355, 20, 25, 18, -1, -25 },
  { 2418, 17, 25, 18, 3, -25 },
  { 2472, 18, 25, 18, 0, -25 },
  { 2529, 10, 33, 8, 0, -28 },
  { 2571, 5, 27, 12, 4, -25 },
  { 2588, 10, 33, 8, -2, -28 },
  { 2630, 9, 12, 13, 2, -25 },
  { 2644, 13, 2, 13, -2, 0 },
  { 2648, 5, 5, 10, 4, -26 },
  { 2652, 13, 18, 16, 1, -18 },
  { 2682, 14, 26, 17, 1, -26 },
  { 2728, 13, 18, 15, 1, -18 },
  { 2758, 16, 26, 17, 1, -26 },
  { 2810, 13, 18, 16, 1, -18 },
  { 2840, 11, 26, 10, 2, -26 },
  { 2876, 16, 25, 17, 0, -18 },
  { 2926, 13, 26, 16, 1, -26 },
  { 2969, 6, 25, 7, 1, -25 },
  { 2988, 11, 32, 7, -4, -25 },
  { 3032, 14, 26, 15, 1, -26 },
  { 3078, 6, 26, 7, 1, -26 },
  { 3098, 23, 18, 26, 1, -18 },
  { 3150, 13, 18, 16, 1, -18 },
  { 3180, 14, 18, 17, 1, -18 },
  { 3212, 16, 25, 17, -1, -18 },
  { 3262, 15, 25, 17, 1, -18 },
  { 3309, 10, 18, 10, 1, -18 },
  { 3332, 13, 18, 15, 1, -18 },
  { 3362, 8, 23, 10, 2, -23 },
  { 3385, 13, 18, 16, 2, -18 },
  { 3415, 13, 18, 14, 2, -18 },
  { 3445, 19, 18, 22, 3, -18 },
  { 3488, 16, 18, 15, -1, -18 },
  { 3524, 16, 25, 14, -1, -18 },
  { 3574, 14, 18, 15, 0, -18 },
  { 3606, 11, 34, 10, 1, -27 },
  { 3653, 6, 30, 8, 1, -25 },
  { 3676, 11, 34, 10, -2, -27 },
  { 3723, 16, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC35PT7B_H_
