#ifndef _ROBOTOCONDENSED_LIGHTITALIC62PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x04, 0x00, 0x1C, 0x31, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x38, 0xE1, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xC1, 0x86, 0x0C,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0xC6, 0x00, 0xC0, 0x1C, 0xE0, 0x0C, 0x01, 0xCE, 0x00, 0xC0,
  0x38, 0xE0, 0x0C, 0x07, 0x0E, 0x00, 0xC0, 0xE0, 0xE0, 0x1C, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0xE0, 0x1C, 0x38, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0x38,
  0x70, 0x07, 0x07, 0x8E, 0x00, 0x78, 0xF0, 0xE0, 0x03, 0xFE, 0x1C, 0x00,
  0x1F, 0xC3, 0x80, 0x00, 0x20, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC3, 0xF8, 0x00, 0x38, 0x7F,
  0xC0, 0x07, 0x0F, 0x1E, 0x00, 0x70, 0xE0, 0xE0, 0x0E, 0x1C, 0x07, 0x01,
  0xC1, 0x80, 0x70, 0x1C, 0x38, 0x07, 0x03, 0x83, 0x80, 0x70, 0x70, 0x38,
  0x07, 0x07, 0x03, 0x00, 0x70, 0xE0, 0x30, 0x07, 0x1C, 0x03, 0x00, 0x73,
  0xC0, 0x30, 0x07, 0x38, 0x03, 0x00, 0x67, 0x00, 0x38, 0x0E, 0x30, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE1, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF1, 0xE0, 0x1C, 0x3C,
  0x3C, 0x03, 0x8F, 0x03, 0xC0, 0x73, 0xC0, 0x38, 0x0E, 0xF0, 0x07, 0x83,
  0xDE, 0x00, 0x70, 0x73, 0x80, 0x0F, 0x0E, 0xF0, 0x00, 0xE3, 0xDE, 0x00,
  0x1E, 0x73, 0xC0, 0x01, 0xFE, 0x78, 0x00, 0x3F, 0x8F, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x7F, 0x07, 0x80, 0x3E, 0xE0, 0x7F, 0x3F, 0x9E, 0x07, 0xFF, 0xC1, 0xC0,
  0x7F, 0xE0, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x39, 0xCE, 0x77, 0x39, 0xCE,
  0x73, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x1C, 0x07, 0x7E, 0x1C, 0x3F, 0xFF, 0x9C,
  0xFF, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x87,
  0x00, 0x07, 0x83, 0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01,
  0xE0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xE7, 0xDE, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03,
  0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x1E, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFF, 0xFE, 0xEF, 0xC3, 0xBC, 0x0E, 0x80, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x03, 0xC0,
  0x0E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x3F, 0x00, 0x03, 0xBF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70,
  0x3C, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x07,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x1F,
  0xC0, 0x1C, 0xFF, 0xE0, 0x7B, 0xFF, 0xE0, 0xEF, 0x87, 0xE1, 0xFC, 0x03,
  0xC3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x1D, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0x70, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8,
  0x0F, 0x81, 0xF0, 0x7C, 0x01, 0xC1, 0xE0, 0x07, 0x8F, 0x00, 0x0E, 0x38,
  0x00, 0x39, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80,
  0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0x78, 0x01, 0xF9, 0xF0, 0x1F,
  0xE3, 0xE1, 0xF7, 0x07, 0xFF, 0x9C, 0x0F, 0xFC, 0x70, 0x0F, 0xC3, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x08, 0x00,
  0x00, 0x20, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF0, 0x3C, 0x7C, 0x03,
  0x8F, 0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x00, 0xF8,
  0x00, 0x70, 0x38, 0x00, 0xFF, 0x80, 0x1C, 0x1C, 0x00, 0xFF, 0xF0, 0x07,
  0x07, 0x00, 0x7C, 0x1E, 0x01, 0xC3, 0x80, 0x1C, 0x03, 0x80, 0x30, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x70, 0x07, 0x80, 0x38, 0x03, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xC7, 0x00, 0xE0, 0x07, 0x00, 0x73, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xCC,
  0x01, 0xC0, 0x0E, 0x00, 0x77, 0x00, 0xF0, 0x03, 0x80, 0x1D, 0xC0, 0x38,
  0x00, 0xE0, 0x06, 0x70, 0x0E, 0x00, 0x38, 0x01, 0x9C, 0x03, 0x80, 0x0C,
  0x00, 0xE6, 0x00, 0xE0, 0x07, 0x00, 0x3B, 0x80, 0x70, 0x01, 0xC0, 0x0E,
  0xE0, 0x1C, 0x00, 0x70, 0x03, 0x38, 0x07, 0x00, 0x38, 0x01, 0xCE, 0x01,
  0xC0, 0x0E, 0x00, 0x73, 0x80, 0x70, 0x03, 0x80, 0x18, 0xE0, 0x1C, 0x01,
  0xE0, 0x0E, 0x38, 0x07, 0x00, 0xF8, 0x03, 0x0E, 0x01, 0xC0, 0x3E, 0x01,
  0xC3, 0x80, 0x78, 0x19, 0xC0, 0xE0, 0xE0, 0x0F, 0x1E, 0x70, 0x70, 0x38,
  0x03, 0xFF, 0x1F, 0xF8, 0x06, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xFC, 0x01,
  0xC0, 0x03, 0xE0, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x1C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0xE0, 0xF0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x07, 0xF0, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x81, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x3F, 0x00,
  0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xF1, 0xC0, 0x07, 0xFF, 0x8F, 0x00,
  0x3F, 0xFE, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x0F,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F,
  0x80, 0x38, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1C, 0x07,
  0xC0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xE7,
  0xE0, 0x00, 0x00, 0x73, 0xF8, 0x00, 0x00, 0x3B, 0xFC, 0x00, 0x00, 0x3F,
  0xCF, 0x00, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xB8, 0x00,
  0x00, 0x7B, 0x80, 0xEF, 0x00, 0x00, 0x1E, 0xE0, 0x3B, 0xC0, 0x00, 0x0F,
  0x78, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x01,
  0xC7, 0x00, 0x00, 0x71, 0xC0, 0x71, 0xC0, 0x00, 0x3C, 0x70, 0x1C, 0x70,
  0x00, 0x0E, 0x3C, 0x07, 0x1E, 0x00, 0x07, 0x8F, 0x03, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x3C, 0x38, 0x00, 0x38, 0x38,
  0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x03, 0x83, 0x80, 0x07, 0x07, 0x80, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x00,
  0x78, 0x1C, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0x03,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F,
  0x00, 0xE0, 0x70, 0x0E, 0x03, 0xC0, 0x38, 0x3C, 0x03, 0x80, 0xF0, 0x0E,
  0x0E, 0x01, 0xE0, 0x38, 0x03, 0x87, 0x80, 0x78, 0x0E, 0x00, 0xE1, 0xC0,
  0x1E, 0x03, 0x80, 0x3C, 0xF0, 0x07, 0x01, 0xE0, 0x07, 0x38, 0x01, 0xC0,
  0x78, 0x01, 0xDE, 0x00, 0x70, 0x1C, 0x00, 0x77, 0x00, 0x3C, 0x07, 0x00,
  0x1F, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xF8,
  0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x07, 0x80, 0xFE, 0x00, 0x00,
  0xE0, 0x1F, 0xE0, 0x00, 0x1C, 0x03, 0xDC, 0x00, 0x03, 0x80, 0x73, 0x80,
  0x00, 0xF0, 0x0E, 0x78, 0x00, 0x1E, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x78,
  0xE0, 0x00, 0x70, 0x0F, 0x1E, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x01, 0xC0,
  0x38, 0x3C, 0x00, 0x78, 0x07, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0x80,
  0x70, 0x01, 0xE0, 0xF0, 0x0E, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x03, 0x83,
  0xC0, 0x78, 0x00, 0x78, 0x70, 0x0F, 0x00, 0x07, 0x0E, 0x01, 0xE0, 0x00,
  0xE1, 0xC0, 0x38, 0x00, 0x1E, 0x78, 0x07, 0x00, 0x01, 0xCF, 0x00, 0xE0,
  0x00, 0x39, 0xE0, 0x3C, 0x00, 0x07, 0xB8, 0x07, 0x80, 0x00, 0x77, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x70, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1F, 0x80, 0xE0,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x03, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x07,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x1F, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x3B, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xCF,
  0x00, 0x03, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x3C, 0x00,
  0x1D, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xB8, 0x00, 0x78, 0x70, 0x00, 0x77,
  0x00, 0x0F, 0x0E, 0x00, 0x1C, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x9C, 0x00,
  0x78, 0x38, 0x00, 0xE3, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x8E, 0x00, 0x78, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x87, 0x00, 0x78, 0x0E, 0x00, 0xE0,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x01, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x3C, 0x07, 0x03, 0xC0,
  0x1E, 0x07, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0,
  0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0xC0,
  0x01, 0xCF, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00, 0x07,
  0x38, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x00,
  0xE1, 0x80, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x3C, 0x0E,
  0x1C, 0x07, 0x1E, 0x01, 0x8E, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x70,
  0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xC0, 0x1C, 0x1F, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0x70, 0x00, 0xF8, 0x78, 0x03, 0xF8,
  0x7C, 0x0F, 0xF8, 0x3F, 0xFF, 0x78, 0x1F, 0xFC, 0x78, 0x0F, 0xF8, 0x78,
  0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x3F, 0xE0, 0x07, 0x3F, 0xF8, 0x07, 0xBF, 0xFE, 0x03, 0xF8, 0x0F, 0x81,
  0xF8, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0x8F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1C, 0x3E,
  0x00, 0x1E, 0x1D, 0x80, 0x1E, 0x0E, 0xF0, 0x1F, 0x07, 0x3F, 0xFF, 0x07,
  0x8F, 0xFF, 0x03, 0x83, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1,
  0xF0, 0x03, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x71,
  0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x0F,
  0x80, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0x83, 0x80, 0x1F, 0xFE, 0x38, 0x03, 0xFF,
  0xF3, 0x80, 0x7C, 0x07, 0x38, 0x0F, 0x80, 0x3F, 0x80, 0xF0, 0x01, 0xF8,
  0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x80, 0x38, 0x01, 0xF8, 0x03, 0xE0, 0x7F, 0x00,
  0x1F, 0xFF, 0x70, 0x01, 0xFF, 0xE7, 0x00, 0x07, 0xFC, 0x70, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x0F, 0x00,
  0x0F, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x02, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFC, 0x1C, 0x01, 0xFF, 0xE3, 0x80, 0x7F, 0xFE, 0x70, 0x1F, 0x01, 0xCE,
  0x07, 0xC0, 0x1F, 0xC0, 0xF0, 0x01, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0xFC,
  0x03, 0xE0, 0x7F, 0x00, 0x3F, 0xFE, 0xE0, 0x07, 0xFF, 0x9C, 0x00, 0x3F,
  0xE3, 0x80, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x20, 0x00,
  0xF0, 0x0E, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x87, 0xF8, 0x03, 0x9F, 0xFC, 0x07, 0xBF,
  0xFE, 0x07, 0xF8, 0x1E, 0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x00, 0xC0, 0x3C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x8F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x0E,
  0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x70, 0x07, 0xC0,
  0x1C, 0x03, 0xE0, 0x07, 0x01, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0xF0, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x0E, 0x1F, 0x00, 0x03, 0x8F, 0x80, 0x00, 0xE7,
  0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7E, 0xF0, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01,
  0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xF0,
  0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC7, 0xFC, 0x03, 0xFE, 0x01, 0xE7,
  0xFF, 0x03, 0xFF, 0x80, 0xF7, 0xFF, 0xC3, 0xFF, 0xE0, 0x77, 0x01, 0xE3,
  0xC0, 0xF0, 0x3F, 0x00, 0x7B, 0x80, 0x3C, 0x1F, 0x00, 0x3F, 0x80, 0x1E,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0x87, 0x80,
  0x03, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x00, 0x03, 0x87, 0x00, 0x03, 0x80,
  0x01, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x80, 0x03, 0xC7,
  0x00, 0x03, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xC0, 0x00, 0xE1, 0xC0, 0x00,
  0xE0, 0x00, 0x71, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87,
  0xF8, 0x03, 0x9F, 0xFC, 0x07, 0xBF, 0xFE, 0x07, 0xF8, 0x1E, 0x07, 0xE0,
  0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00,
  0x39, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x7F, 0xC0, 0x03, 0x9F,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x07, 0x80,
  0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x07, 0x70, 0x0F, 0x80,
  0xE7, 0xFF, 0xE0, 0x3C, 0x7F, 0xF8, 0x07, 0x87, 0xFC, 0x00, 0xE0, 0x08,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xC1,
  0xC0, 0x7F, 0xF8, 0xE0, 0x7F, 0xFE, 0x70, 0x7C, 0x07, 0x38, 0x7C, 0x00,
  0xFC, 0x3C, 0x00, 0x7E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38,
  0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x81, 0xC0, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x3F, 0xFE, 0xE0, 0x1F, 0xFE,
  0x70, 0x03, 0xFE, 0x38, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80,
  0xE3, 0xF0, 0x3B, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x70,
  0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x0F, 0xE0, 0x3F, 0xFE, 0xE0, 0x3F, 0xFC,
  0xE0, 0x0F, 0xF1, 0xE0, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x71, 0xC0, 0x03, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x80,
  0x3C, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x07,
  0x0F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xDC, 0x00, 0x3C, 0x00, 0x3B, 0x80,
  0x0F, 0x80, 0x0F, 0x70, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x3E, 0x00, 0x79,
  0xC0, 0x0F, 0xC0, 0x0E, 0x38, 0x01, 0xF8, 0x01, 0xC7, 0x00, 0x77, 0x00,
  0x78, 0xE0, 0x0E, 0xE0, 0x0E, 0x1C, 0x03, 0xDC, 0x03, 0xC3, 0x80, 0x73,
  0x80, 0x70, 0x70, 0x0E, 0x70, 0x0E, 0x0F, 0x03, 0x86, 0x03, 0xC1, 0xE0,
  0x70, 0xE0, 0x70, 0x1C, 0x1C, 0x1C, 0x1E, 0x03, 0x83, 0x83, 0x83, 0x80,
  0x70, 0x70, 0x70, 0x70, 0x0E, 0x1C, 0x0E, 0x1E, 0x01, 0xC3, 0x81, 0xC3,
  0x80, 0x38, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x07, 0x1C, 0x00, 0xE7, 0x00,
  0xE3, 0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x03, 0x9C, 0x01, 0x9C, 0x00, 0x77,
  0x00, 0x33, 0x80, 0x0E, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x03,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x20,
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC7, 0xFF, 0x00, 0x0E, 0x3E,
  0x7C, 0x00, 0x73, 0xC0, 0xF0, 0x07, 0x1C, 0x03, 0xC0, 0x39, 0xC0, 0x0F,
  0x03, 0xCE, 0x00, 0x7E, 0x7C, 0x70, 0x01, 0xFF, 0xC7, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 45, 13, 2, -44 },
  { 63, 13, 14, 17, 6, -47 },
  { 86, 31, 44, 31, 2, -44 },
  { 257, 26, 58, 29, 2, -51 },
  { 446, 28, 46, 38, 6, -45 },
  { 607, 27, 46, 32, 2, -45 },
  { 763, 5, 14, 10, 6, -47 },
  { 772, 18, 63, 18, 3, -49 },
  { 914, 17, 63, 18, -3, -49 },
  { 1048, 24, 25, 26, 3, -44 },
  { 1123, 25, 32, 30, 3, -36 },
  { 1223, 8, 14, 12, -2, -6 },
  { 1237, 12, 3, 16, 2, -21 },
  { 1242, 6, 6, 14, 1, -5 },
  { 1247, 27, 48, 21, -3, -44 },
  { 1409, 25, 46, 29, 3, -45 },
  { 1553, 14, 44, 29, 8, -44 },
  { 1630, 26, 45, 29, 1, -45 },
  { 1777, 25, 46, 29, 2, -45 },
  { 1921, 26, 44, 29, 1, -44 },
  { 2064, 26, 45, 29, 4, -44 },
  { 2211, 23, 45, 29, 3, -44 },
  { 2341, 25, 44, 29, 5, -44 },
  { 2479, 26, 46, 29, 2, -45 },
  { 2629, 22, 45, 29, 5, -45 },
  { 2753, 10, 34, 12, 1, -33 },
  { 2796, 13, 41, 12, -2, -33 },
  { 2863, 23, 26, 27, 2, -33 },
  { 2938, 24, 15, 29, 3, -28 },
  { 2983, 23, 26, 27, 2, -33 },
  { 3058, 19, 46, 24, 5, -45 },
  { 3168, 42, 57, 47, 2, -43 },
  { 3468, 30, 44, 33, -2, -44 },
  { 3633, 28, 44, 32, 2, -44 },
  { 3787, 29, 46, 34, 4, -45 },
  { 3954, 30, 44, 34, 2, -44 },
  { 4119, 30, 44, 30, 2, -44 },
  { 4284, 30, 44, 30, 2, -44 },
  { 4449, 30, 46, 36, 4, -45 },
  { 4622, 34, 44, 37, 2, -44 },
  { 4809, 11, 44, 15, 3, -44 },
  { 4870, 28, 45, 29, 1, -44 },
  { 5028, 33, 44, 33, 2, -44 },
  { 5210, 22, 44, 28, 2, -44 },
  { 5331, 42, 44, 45, 2, -44 },
  { 5562, 35, 44, 37, 2, -44 },
  { 5755, 30, 46, 35, 3, -45 },
  { 5928, 30, 44, 32, 2, -44 },
  { 6093, 30, 53, 35, 3, -45 },
  { 6292, 30, 44, 33, 2, -44 },
  { 6457, 29, 46, 31, 2, -45 },
  { 6624, 28, 44, 31, 6, -44 },
  { 6778, 31, 45, 34, 3, -44 },
  { 6953, 30, 44, 33, 5, -44 },
  { 7118, 43, 44, 46, 6, -44 },
  { 7355, 35, 44, 32, -1, -44 },
  { 7548, 29, 44, 31, 6, -44 },
  { 7708, 32, 44, 31, 0, -44 },
  { 7884, 18, 59, 14, 0, -50 },
  { 8017, 10, 48, 21, 6, -44 },
  { 8077, 18, 59, 14, -4, -50 },
  { 8210, 17, 22, 22, 3, -44 },
  { 8257, 22, 3, 23, -3, 0 },
  { 8266, 8, 8, 17, 8, -46 },
  { 8274, 24, 35, 28, 1, -34 },
  { 8379, 25, 48, 29, 1, -47 },
  { 8529, 23, 35, 27, 2, -34 },
  { 8630, 28, 48, 29, 2, -47 },
  { 8798, 23, 35, 28, 2, -34 },
  { 8899, 20, 48, 18, 3, -48 },
  { 9019, 27, 47, 29, 0, -34 },
  { 9178, 24, 47, 29, 1, -47 },
  { 9319, 11, 45, 13, 2, -45 },
  { 9381, 20, 58, 13, -7, -45 },
  { 9526, 26, 47, 26, 1, -47 },
  { 9679, 11, 47, 13, 2, -47 },
  { 9744, 41, 34, 46, 1, -34 },
  { 9919, 24, 34, 29, 1, -34 },
  { 10021, 25, 35, 30, 2, -34 },
  { 10131, 27, 47, 29, -1, -34 },
  { 10290, 25, 47, 29, 2, -34 },
  { 10437, 18, 34, 18, 1, -34 },
  { 10514, 24, 35, 27, 1, -34 },
  { 10619, 14, 42, 17, 3, -41 },
  { 10693, 24, 34, 29, 3, -33 },
  { 10795, 22, 33, 26, 4, -33 },
  { 10886, 35, 33, 39, 5, -33 },
  { 11031, 27, 33, 26, -1, -33 },
  { 11143, 29, 46, 25, -2, -33 },
  { 11310, 25, 33, 26, 0, -33 },
  { 11414, 19, 60, 18, 2, -48 },
  { 11557, 11, 52, 13, 1, -44 },
  { 11629, 19, 60, 18, -3, -48 },
  { 11772, 29, 11, 36, 3, -24 },
};

const GFXfont RobotoCondensed_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC62PT7B_H_
