#ifndef _ROBOTOCONDENSED_LIGHTITALIC13PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x80, 0x80, 0x76, 0x80, 0x12, 0x29, 0xF9, 0x22, 0x85,
  0x3F, 0x28, 0x50, 0x08, 0xE2, 0x51, 0x20, 0x40, 0xA2, 0x49, 0xC2, 0x00,
  0x62, 0x9A, 0x9C, 0x10, 0xB5, 0x65, 0x1C, 0x18, 0xA2, 0x8C, 0x21, 0x58,
  0xE2, 0x74, 0xE0, 0x25, 0x49, 0x24, 0x92, 0x44, 0x21, 0x11, 0x11, 0x11,
  0x12, 0x24, 0x80, 0x21, 0x7C, 0xC9, 0x00, 0x21, 0x09, 0xF4, 0x21, 0x00,
  0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41, 0x00, 0x72,
  0x63, 0x18, 0xC6, 0x52, 0xE0, 0x75, 0x24, 0x92, 0x80, 0x39, 0x14, 0x42,
  0x08, 0x42, 0x10, 0xF8, 0x38, 0x94, 0x41, 0x38, 0x28, 0xA2, 0x70, 0x0C,
  0x21, 0x8A, 0x29, 0x2F, 0xC4, 0x10, 0x7A, 0x10, 0xE1, 0x06, 0x52, 0x60,
  0x34, 0x8F, 0x99, 0x99, 0xE0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x80, 0x38,
  0x94, 0x51, 0x39, 0x28, 0xA2, 0x70, 0x74, 0x63, 0x19, 0x38, 0x44, 0xC0,
  0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x12, 0xC8, 0x61, 0xF8, 0x01, 0xE0,
  0x41, 0x82, 0x36, 0x40, 0x79, 0x12, 0x44, 0x00, 0x80, 0x0F, 0x08, 0x48,
  0x29, 0xD5, 0x2A, 0x96, 0x53, 0x29, 0x9B, 0x40, 0x10, 0x07, 0x80, 0x08,
  0x61, 0x8A, 0x25, 0xE4, 0x61, 0x84, 0x3C, 0x94, 0x51, 0x79, 0x14, 0x51,
  0xF8, 0x39, 0x18, 0x60, 0x82, 0x08, 0xA2, 0x70, 0x3C, 0x45, 0x0A, 0x14,
  0x28, 0x91, 0x22, 0xF8, 0x3E, 0x41, 0x02, 0x07, 0x88, 0x10, 0x20, 0xF8,
  0x3E, 0x41, 0x02, 0x07, 0x88, 0x10, 0x20, 0x80, 0x39, 0x18, 0x60, 0x9E,
  0x18, 0xA2, 0x70, 0x21, 0x22, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x44, 0x84,
  0x56, 0xAA, 0x80, 0x04, 0x10, 0x41, 0x08, 0x28, 0xA2, 0x70, 0x22, 0x49,
  0x22, 0x87, 0x0A, 0x12, 0x24, 0x84, 0x21, 0x10, 0x84, 0x21, 0x08, 0xF8,
  0x20, 0x90, 0x58, 0x6A, 0x55, 0x2A, 0xA9, 0x54, 0x92, 0x89, 0x00, 0x21,
  0x21, 0x52, 0x52, 0x4A, 0x4A, 0x4A, 0x44, 0x84, 0x39, 0x18, 0x61, 0x86,
  0x18, 0xA2, 0x70, 0x3C, 0x45, 0x0A, 0x27, 0xC8, 0x10, 0x20, 0x80, 0x39,
  0x18, 0x61, 0x86, 0x18, 0xA2, 0x70, 0x40, 0x80, 0x3C, 0x45, 0x0A, 0x27,
  0x89, 0x12, 0x24, 0x84, 0x3C, 0x89, 0x09, 0x01, 0x80, 0xA1, 0x42, 0x78,
  0xFC, 0x82, 0x08, 0x20, 0x82, 0x10, 0x40, 0x46, 0x18, 0x61, 0x86, 0x28,
  0xA2, 0xF0, 0x86, 0x18, 0x92, 0x51, 0x46, 0x18, 0x40, 0x88, 0xC4, 0x66,
  0x52, 0xAA, 0x55, 0x32, 0x98, 0x88, 0x44, 0x00, 0x42, 0x48, 0xA0, 0xC1,
  0x06, 0x0A, 0x24, 0x84, 0x85, 0x24, 0x94, 0x60, 0x82, 0x10, 0x40, 0x3E,
  0x08, 0x20, 0x41, 0x04, 0x10, 0x20, 0xF8, 0x32, 0x44, 0x44, 0x44, 0x48,
  0x88, 0xC0, 0xA9, 0x55, 0x50, 0x31, 0x11, 0x22, 0x22, 0x22, 0x24, 0xC0,
  0x2D, 0xD8, 0xF8, 0xC0, 0x3A, 0x42, 0xF8, 0xC5, 0xE0, 0x20, 0x84, 0x1E,
  0x45, 0x14, 0x62, 0x8B, 0xC0, 0x3A, 0x51, 0x08, 0x45, 0xC0, 0x08, 0x42,
  0xF8, 0xCA, 0x52, 0x97, 0x80, 0x3A, 0x52, 0xF8, 0x41, 0xC0, 0x34, 0x4E,
  0x88, 0x88, 0x88, 0x3D, 0x14, 0xA2, 0x8A, 0x27, 0x82, 0x11, 0xC0, 0x21,
  0x10, 0xF4, 0xA5, 0x29, 0x8C, 0x40, 0x21, 0x24, 0x94, 0x80, 0x10, 0x22,
  0x22, 0x24, 0x44, 0x48, 0x20, 0x84, 0x12, 0x51, 0x86, 0x24, 0x92, 0x20,
  0x25, 0x24, 0x92, 0x90, 0x7B, 0x22, 0x52, 0x29, 0x18, 0x8C, 0x4A, 0x24,
  0x7A, 0x52, 0x94, 0xC6, 0x20, 0x39, 0x14, 0x61, 0x89, 0x27, 0x00, 0x79,
  0x14, 0x51, 0x8A, 0x2F, 0x20, 0x82, 0x00, 0x3D, 0x14, 0xA2, 0x8A, 0x27,
  0x82, 0x10, 0x40, 0x74, 0x44, 0x48, 0x80, 0x3A, 0x50, 0x60, 0xC5, 0xC0,
  0x4B, 0xC9, 0x24, 0xC0, 0x8C, 0x65, 0x29, 0x4B, 0xC0, 0x94, 0xA5, 0x4A,
  0x21, 0x00, 0x93, 0x26, 0xD5, 0xAD, 0x59, 0x22, 0x00, 0x4A, 0x8C, 0x45,
  0x2A, 0x40, 0x24, 0x48, 0x91, 0x42, 0x82, 0x04, 0x10, 0x20, 0x80, 0x78,
  0x44, 0x44, 0x23, 0xC0, 0x12, 0x22, 0x22, 0xC4, 0x44, 0x44, 0x20, 0x25,
  0x24, 0x92, 0x92, 0x00, 0x21, 0x11, 0x11, 0x12, 0x22, 0x24, 0x80, 0xE6,
  0x60,
};

const GFXglyph RobotoCondensed_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -10 },
  { 7, 7, 9, 6, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 6, 9, 8, 1, -9 },
  { 31, 6, 9, 7, 0, -9 },
  { 38, 1, 3, 2, 1, -10 },
  { 39, 3, 13, 4, 1, -10 },
  { 44, 4, 13, 4, -1, -10 },
  { 51, 5, 5, 5, 1, -9 },
  { 55, 5, 7, 6, 1, -8 },
  { 60, 2, 3, 2, -1, -1 },
  { 61, 3, 1, 3, 0, -5 },
  { 62, 1, 1, 3, 0, -1 },
  { 63, 6, 10, 4, -1, -9 },
  { 71, 5, 9, 6, 1, -9 },
  { 77, 3, 9, 6, 2, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 6, 9, 6, 0, -9 },
  { 95, 6, 9, 6, 0, -9 },
  { 102, 5, 9, 6, 1, -9 },
  { 108, 4, 9, 6, 1, -9 },
  { 113, 5, 9, 6, 1, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 5, 9, 6, 1, -9 },
  { 132, 2, 7, 3, 0, -7 },
  { 134, 3, 9, 2, -1, -7 },
  { 138, 4, 6, 6, 1, -7 },
  { 141, 5, 4, 6, 1, -6 },
  { 144, 5, 6, 6, 0, -7 },
  { 148, 4, 9, 5, 1, -9 },
  { 153, 9, 12, 10, 0, -9 },
  { 167, 6, 9, 7, 0, -9 },
  { 174, 6, 9, 7, 0, -9 },
  { 181, 6, 9, 7, 1, -9 },
  { 188, 7, 9, 7, 0, -9 },
  { 196, 7, 9, 6, 0, -9 },
  { 204, 7, 9, 6, 0, -9 },
  { 212, 6, 9, 7, 1, -9 },
  { 219, 8, 9, 8, 0, -9 },
  { 228, 2, 9, 3, 1, -9 },
  { 231, 6, 9, 6, 0, -9 },
  { 238, 7, 9, 7, 0, -9 },
  { 246, 5, 9, 6, 0, -9 },
  { 252, 9, 9, 9, 0, -9 },
  { 263, 8, 9, 8, 0, -9 },
  { 272, 6, 9, 7, 1, -9 },
  { 279, 7, 9, 7, 0, -9 },
  { 287, 6, 11, 7, 1, -9 },
  { 296, 7, 9, 7, 0, -9 },
  { 304, 7, 9, 7, 0, -9 },
  { 312, 6, 9, 7, 1, -9 },
  { 319, 6, 9, 7, 1, -9 },
  { 326, 6, 9, 7, 1, -9 },
  { 333, 9, 9, 10, 1, -9 },
  { 344, 7, 9, 7, 0, -9 },
  { 352, 6, 9, 7, 1, -9 },
  { 359, 7, 9, 7, 0, -9 },
  { 367, 4, 13, 3, 0, -11 },
  { 374, 2, 10, 4, 1, -9 },
  { 377, 4, 13, 3, -1, -11 },
  { 384, 3, 5, 5, 1, -9 },
  { 386, 5, 1, 5, -1, 0 },
  { 387, 1, 2, 4, 2, -10 },
  { 388, 5, 7, 6, 0, -7 },
  { 393, 6, 10, 6, 0, -10 },
  { 401, 5, 7, 6, 0, -7 },
  { 406, 5, 10, 6, 1, -10 },
  { 413, 5, 7, 6, 0, -7 },
  { 418, 4, 10, 4, 1, -10 },
  { 423, 6, 10, 6, 0, -7 },
  { 431, 5, 10, 6, 0, -10 },
  { 438, 3, 9, 3, 0, -9 },
  { 442, 4, 12, 3, -1, -9 },
  { 448, 6, 10, 5, 0, -10 },
  { 456, 3, 10, 3, 0, -10 },
  { 460, 9, 7, 10, 0, -7 },
  { 468, 5, 7, 6, 0, -7 },
  { 473, 6, 7, 6, 0, -7 },
  { 479, 6, 10, 6, 0, -7 },
  { 487, 6, 10, 6, 0, -7 },
  { 495, 4, 7, 4, 0, -7 },
  { 499, 5, 7, 6, 0, -7 },
  { 504, 3, 9, 4, 1, -9 },
  { 508, 5, 7, 6, 1, -7 },
  { 513, 5, 7, 5, 1, -7 },
  { 518, 7, 7, 8, 1, -7 },
  { 525, 5, 7, 5, 0, -7 },
  { 530, 7, 10, 5, -1, -7 },
  { 539, 5, 7, 5, 0, -7 },
  { 544, 4, 13, 4, 0, -10 },
  { 551, 3, 11, 3, 0, -9 },
  { 556, 4, 13, 4, -1, -10 },
  { 563, 6, 2, 7, 1, -5 },
};

const GFXfont RobotoCondensed_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC13PT7B_H_
