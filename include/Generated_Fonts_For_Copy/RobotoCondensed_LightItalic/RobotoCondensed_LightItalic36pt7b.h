#ifndef _ROBOTOCONDENSED_LIGHTITALIC36PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x0C, 0x21, 0x86, 0x00, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x66, 0xCD, 0x16,
  0x6C, 0xD9, 0xB3, 0x44, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x08, 0x60, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC0, 0x41, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x02, 0x08, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x10, 0x40, 0x0C, 0x30, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x61,
  0x80, 0x18, 0x60, 0x04, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x80,
  0x08, 0x60, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x1F,
  0x00, 0x7F, 0x81, 0x83, 0x06, 0x07, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x30, 0x06, 0x60, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0xC1, 0x83, 0x83, 0xFE, 0x01, 0xF0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x18, 0x40, 0x0C,
  0x30, 0x44, 0x18, 0x22, 0x0C, 0x33, 0x06, 0x31, 0x83, 0x10, 0x41, 0x18,
  0x21, 0x98, 0x1F, 0x98, 0x07, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x78, 0x06, 0x7E, 0x06, 0x61, 0x02, 0x30, 0xC3, 0x10, 0x63, 0x18, 0x31,
  0x0C, 0x19, 0x86, 0x0D, 0x83, 0x04, 0x00, 0x86, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0x18, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0xE0, 0x07, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0D, 0x80, 0x19, 0x83, 0x30, 0xC3, 0x60, 0xC3, 0x60,
  0x66, 0xC0, 0x66, 0xC0, 0x34, 0xC0, 0x3C, 0xC0, 0x18, 0x60, 0x3C, 0x70,
  0x7C, 0x3F, 0xCE, 0x1F, 0x86, 0x2D, 0xB6, 0x96, 0x00, 0x40, 0x30, 0x18,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x10, 0x00, 0x02, 0x00, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x43, 0x0F, 0xCC, 0xF3, 0xFF, 0x01, 0xE0, 0x07, 0x00, 0x36, 0x01,
  0x98, 0x0C, 0x30, 0x60, 0xE0, 0x81, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFE,
  0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x33, 0x33, 0x66, 0xC8, 0xFF, 0xFC, 0xDF,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0xC1, 0x86, 0x06, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60,
  0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C,
  0x06, 0x18, 0x30, 0x7F, 0x80, 0x7C, 0x00, 0x03, 0x0F, 0x3F, 0xF6, 0xC6,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x01, 0xF0, 0x0F,
  0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0x63, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x01, 0xF0,
  0x0F, 0xF0, 0x38, 0x70, 0x60, 0x61, 0x80, 0x63, 0x00, 0xCC, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x18, 0x0C, 0x38, 0x30, 0x3F, 0xC0, 0x1F, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x06, 0xC0, 0x19, 0x80, 0x36,
  0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0x60, 0xC1, 0xC3, 0x03,
  0x06, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x67, 0x80, 0xFF, 0x81, 0xC3, 0x81, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x66,
  0x00, 0xCC, 0x03, 0x18, 0x06, 0x18, 0x1C, 0x38, 0x70, 0x3F, 0xC0, 0x3E,
  0x00, 0x00, 0x78, 0x0F, 0xC0, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x3E, 0x1B, 0xF8, 0xF0, 0xE7, 0x03, 0x70, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60,
  0x19, 0x81, 0x8E, 0x1C, 0x3F, 0xC0, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xF8,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x07,
  0xF8, 0x18, 0x30, 0x60, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0x60, 0xC0, 0x7F, 0x01, 0xFC, 0x06,
  0x0C, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x13, 0x00, 0x36, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x18, 0x0C, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0x30, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x39, 0x83, 0xCF, 0xF6,
  0x1E, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0xFC, 0x07, 0x80, 0x00, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC7, 0x30, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC1, 0x86, 0x0C,
  0x30, 0x40, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x18, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0x80, 0x02, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x20,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x0F, 0x87, 0xF9, 0xC3, 0x30, 0x3E, 0x07, 0x80, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x38, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18, 0x18, 0x00, 0x04,
  0x18, 0x00, 0x02, 0x18, 0x0F, 0x81, 0x0C, 0x0F, 0xE0, 0xCC, 0x0C, 0x10,
  0x66, 0x0C, 0x18, 0x32, 0x04, 0x0C, 0x1B, 0x06, 0x06, 0x0D, 0x82, 0x02,
  0x04, 0xC3, 0x03, 0x02, 0x41, 0x81, 0x81, 0x20, 0xC0, 0xC1, 0xB0, 0x40,
  0x40, 0xD8, 0x20, 0x60, 0x4C, 0x10, 0x30, 0x66, 0x08, 0x38, 0x23, 0x06,
  0x3C, 0x31, 0x83, 0xF3, 0xF0, 0xC0, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x10, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x30, 0x80, 0x18, 0x20, 0x06,
  0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03,
  0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x60, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x20, 0x0F, 0xF8, 0x07,
  0xFF, 0x03, 0x01, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x60, 0x0E,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x03, 0x83, 0xFF, 0x03, 0xFF,
  0x81, 0x80, 0xE0, 0xC0, 0x38, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x70,
  0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1,
  0x80, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0x60, 0x70, 0x3F, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xC0, 0x70, 0x30, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x02, 0x18, 0x00, 0xC6, 0x00, 0x71,
  0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06,
  0x18, 0x03, 0x86, 0x01, 0xC1, 0x81, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x70, 0x70, 0x30, 0x0E, 0x18, 0x01, 0x86, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x1F, 0xC6, 0x07, 0xF3, 0x80, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0x60, 0x06, 0x18, 0x01, 0x87,
  0x00, 0xE0, 0xE0, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x00, 0xC3, 0x00,
  0x1C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xE0,
  0xC0, 0x7F, 0x80, 0x1F, 0x00, 0x0C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x06,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x07, 0x00, 0xC1, 0xC0,
  0x18, 0x70, 0x03, 0x1C, 0x00, 0x67, 0x00, 0x0D, 0xC0, 0x03, 0x78, 0x00,
  0x7F, 0x80, 0x0F, 0x30, 0x01, 0xC7, 0x00, 0x30, 0x60, 0x06, 0x0E, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x58, 0x00, 0xD8, 0x6C, 0x00, 0x6C,
  0x36, 0x00, 0x66, 0x19, 0x00, 0x36, 0x0C, 0xC0, 0x33, 0x06, 0x60, 0x19,
  0x83, 0x30, 0x18, 0xC3, 0x18, 0x0C, 0x61, 0x8C, 0x0C, 0x70, 0xC2, 0x06,
  0x30, 0x61, 0x86, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x63, 0x06, 0x18, 0x31,
  0x83, 0x0C, 0x19, 0x83, 0x06, 0x04, 0xC1, 0x83, 0x03, 0xC0, 0xC1, 0x81,
  0xE0, 0x60, 0xC0, 0xE0, 0x30, 0xC0, 0x70, 0x18, 0x60, 0x30, 0x18, 0x00,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xF0, 0x03, 0x0F, 0x00,
  0x60, 0xD0, 0x06, 0x19, 0x80, 0x61, 0x98, 0x06, 0x18, 0xC0, 0x61, 0x8C,
  0x06, 0x18, 0xC0, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30,
  0x30, 0xC3, 0x03, 0x0C, 0x30, 0x31, 0x83, 0x01, 0x98, 0x60, 0x19, 0x86,
  0x00, 0x98, 0x60, 0x0D, 0x86, 0x00, 0xD8, 0x60, 0x07, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x30, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1,
  0x80, 0x61, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC,
  0x00, 0x63, 0x00, 0x61, 0x80, 0x70, 0x60, 0x70, 0x3F, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x71, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x38, 0x60, 0x0C, 0x30, 0x0E, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x03, 0xC1, 0xC1, 0x80, 0x61, 0x80, 0x19, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x61, 0x80,
  0x70, 0xE0, 0x70, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x40, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0x01, 0xC1, 0x80,
  0x70, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC3, 0x00, 0xE3, 0x00, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x38, 0x1C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0E, 0x60, 0x03, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x61, 0x80,
  0x70, 0xE0, 0x70, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x01, 0x81, 0xC0, 0xE0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x07, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x0C, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC3, 0x80, 0x10, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x06, 0xC0,
  0x38, 0x06, 0xC0, 0x78, 0x06, 0xC0, 0x68, 0x0C, 0xC0, 0xC8, 0x0C, 0xC0,
  0xC8, 0x0C, 0xC0, 0xC8, 0x18, 0xC1, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC1,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC6,
  0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x04, 0xC0, 0x58,
  0x05, 0x80, 0x58, 0x05, 0x80, 0x50, 0x05, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x38,
  0x03, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x38, 0x1C, 0x00, 0xC0, 0xC0,
  0x06, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18,
  0x00, 0xE0, 0x60, 0x06, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x60, 0x70,
  0x03, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x01, 0xCC,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x70, 0x18, 0x30,
  0x0C, 0x30, 0x06, 0x38, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xF8, 0x3E, 0x00, 0xC6, 0x31,
  0x8C, 0x61, 0x08, 0x63, 0x18, 0xC6, 0x10, 0x86, 0x31, 0x8C, 0x61, 0x08,
  0x63, 0x18, 0xC6, 0x30, 0x07, 0xC1, 0xF0, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0xF8, 0x3E, 0x00, 0x03,
  0x01, 0xC0, 0x70, 0x34, 0x0D, 0x06, 0x61, 0x98, 0xC6, 0x31, 0x98, 0x66,
  0x0B, 0x02, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x63, 0x8C, 0x31, 0x80,
  0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0x98, 0x0C, 0x00, 0x60,
  0x03, 0x0F, 0xF9, 0xFF, 0xDC, 0x04, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x0E, 0xE1, 0xB3, 0xFB, 0x8F, 0x8C, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x19, 0xF0, 0x7F,
  0xE1, 0xC1, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x20,
  0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x19, 0x80, 0x6E, 0x01, 0xB8,
  0x0C, 0xF0, 0x73, 0x7F, 0x8C, 0x78, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC3,
  0x8C, 0x06, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x4C, 0x03, 0x18, 0x0C, 0x70,
  0x60, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xC6, 0x0F,
  0xE6, 0x1C, 0x36, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x08, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0x60, 0x10, 0x60, 0x30, 0x70, 0xF0, 0x3F, 0xB0, 0x1F, 0x30, 0x03,
  0xE0, 0x3F, 0xC1, 0xC3, 0x8C, 0x06, 0x30, 0x09, 0x80, 0x36, 0x00, 0xD8,
  0x03, 0x7F, 0xFF, 0xFF, 0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x08, 0x70, 0x70, 0xFF, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0xFC,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x7F, 0x9F, 0xF0, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x03,
  0xE3, 0x07, 0xF3, 0x0E, 0x1B, 0x1C, 0x0E, 0x18, 0x06, 0x38, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x38, 0x78, 0x1F, 0xD8, 0x0F,
  0x98, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x40, 0x70, 0xE0, 0xE0, 0x7F,
  0xC0, 0x1F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x19, 0xF0, 0x6F, 0xE1, 0xE1, 0x8F, 0x07,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x20, 0x19, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x03, 0x00, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x61, 0x8C,
  0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x00, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x07, 0x07, 0xC0, 0xF0, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x0C, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x0C, 0x06, 0x30, 0x0C,
  0xC0, 0x1B, 0x00, 0x2E, 0x00, 0xFC, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x18,
  0x0C, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0xC0,
  0x04, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x00,
  0x19, 0xE0, 0x78, 0x1F, 0xF9, 0xFE, 0x34, 0x1B, 0x06, 0x38, 0x1A, 0x06,
  0x38, 0x0E, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x0C, 0x03, 0x30, 0x18, 0x06,
  0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06,
  0x60, 0x18, 0x06, 0x60, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C,
  0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0x19, 0xF0, 0x6F,
  0xE1, 0x61, 0x8F, 0x07, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x20,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0xCC, 0x03, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1,
  0x86, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x66, 0x01, 0x98, 0x0C, 0x70,
  0x70, 0xFF, 0x80, 0xF8, 0x00, 0x06, 0x7C, 0x07, 0xFE, 0x07, 0x07, 0x0E,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x38,
  0x0C, 0x3C, 0x1C, 0x37, 0xF8, 0x33, 0xE0, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x07, 0xC6, 0x1F,
  0xCC, 0x70, 0xD9, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x08, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x18,
  0x0C, 0x30, 0x18, 0x70, 0xF0, 0x7F, 0xE0, 0x7C, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x19, 0xC7,
  0xF1, 0xE0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x07, 0xC0,
  0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x60, 0x1B, 0x00, 0xD8, 0x0C,
  0x60, 0xE3, 0xFE, 0x07, 0xC0, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x40, 0x40, 0x60, 0x78, 0x38, 0x30, 0x0C, 0xC0, 0x36, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0xC0, 0x33, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30, 0x38, 0xE1, 0xE1, 0xFD,
  0x83, 0xE6, 0x00, 0xC0, 0x1E, 0x00, 0xD0, 0x0C, 0xC0, 0x66, 0x06, 0x30,
  0x31, 0x83, 0x0C, 0x18, 0x61, 0x81, 0x0C, 0x0C, 0x60, 0x66, 0x03, 0x30,
  0x1B, 0x00, 0xD8, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x60,
  0x3C, 0x0E, 0x06, 0xC0, 0xE0, 0x6C, 0x1E, 0x06, 0xC1, 0xE0, 0xCC, 0x16,
  0x0C, 0xC3, 0x61, 0x8C, 0x32, 0x18, 0xC6, 0x21, 0x8C, 0x62, 0x30, 0xCC,
  0x33, 0x0C, 0xC3, 0x60, 0xC8, 0x36, 0x05, 0x83, 0x40, 0x50, 0x3C, 0x07,
  0x03, 0xC0, 0x70, 0x38, 0x06, 0x03, 0x80, 0x60, 0x10, 0x00, 0x0C, 0x07,
  0x0C, 0x06, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x70,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x30, 0x30, 0x70, 0x18, 0x60, 0x18,
  0x18, 0x03, 0x18, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x07, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x20, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x38, 0x1E, 0x03, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18,
  0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x86, 0x18, 0x43,
  0x0C, 0x30, 0xC3, 0x08, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x1C, 0x03, 0x00, 0x00, 0x1E, 0x01, 0x9F, 0x80, 0x98, 0xE0,
  0x48, 0x38, 0x6C, 0x0C, 0x66, 0x03, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 8, 1, -26 },
  { 21, 7, 8, 10, 4, -27 },
  { 28, 18, 26, 18, 1, -26 },
  { 87, 15, 33, 17, 1, -30 },
  { 149, 17, 26, 22, 3, -26 },
  { 205, 16, 26, 19, 1, -26 },
  { 257, 3, 8, 6, 3, -27 },
  { 260, 10, 37, 10, 2, -29 },
  { 307, 10, 37, 10, -2, -29 },
  { 354, 14, 14, 15, 2, -26 },
  { 379, 15, 18, 17, 1, -21 },
  { 413, 4, 8, 7, -1, -3 },
  { 417, 7, 2, 9, 1, -12 },
  { 419, 3, 3, 8, 1, -3 },
  { 421, 16, 28, 12, -2, -26 },
  { 477, 14, 26, 17, 2, -26 },
  { 523, 8, 26, 17, 5, -26 },
  { 549, 15, 26, 17, 1, -26 },
  { 598, 15, 26, 17, 1, -26 },
  { 647, 15, 26, 17, 1, -26 },
  { 696, 15, 26, 17, 2, -26 },
  { 745, 13, 26, 17, 2, -26 },
  { 788, 15, 26, 17, 3, -26 },
  { 837, 15, 26, 17, 1, -26 },
  { 886, 13, 26, 17, 3, -26 },
  { 929, 5, 19, 7, 1, -19 },
  { 941, 7, 24, 7, -1, -19 },
  { 962, 14, 15, 16, 1, -19 },
  { 989, 14, 10, 17, 2, -17 },
  { 1007, 14, 15, 16, 1, -19 },
  { 1034, 11, 26, 14, 3, -26 },
  { 1070, 25, 33, 27, 1, -25 },
  { 1174, 18, 26, 19, -1, -26 },
  { 1233, 17, 26, 19, 1, -26 },
  { 1289, 17, 26, 20, 2, -26 },
  { 1345, 18, 26, 20, 1, -26 },
  { 1404, 18, 26, 17, 1, -26 },
  { 1463, 18, 26, 17, 1, -26 },
  { 1522, 18, 26, 21, 2, -26 },
  { 1581, 20, 26, 21, 1, -26 },
  { 1646, 7, 26, 9, 1, -26 },
  { 1669, 16, 26, 17, 1, -26 },
  { 1721, 19, 26, 19, 1, -26 },
  { 1783, 13, 26, 16, 1, -26 },
  { 1826, 25, 26, 26, 1, -26 },
  { 1908, 20, 26, 22, 1, -26 },
  { 1973, 17, 26, 21, 2, -26 },
  { 2029, 18, 26, 19, 1, -26 },
  { 2088, 17, 30, 21, 2, -26 },
  { 2152, 17, 26, 19, 1, -26 },
  { 2208, 17, 26, 18, 1, -26 },
  { 2264, 17, 26, 18, 3, -26 },
  { 2320, 18, 26, 20, 2, -26 },
  { 2379, 18, 26, 19, 3, -26 },
  { 2438, 24, 26, 27, 4, -26 },
  { 2516, 21, 26, 19, -1, -26 },
  { 2585, 17, 26, 18, 3, -26 },
  { 2641, 19, 26, 18, 0, -26 },
  { 2703, 10, 34, 8, 0, -29 },
  { 2746, 5, 28, 12, 4, -26 },
  { 2764, 10, 34, 8, -2, -29 },
  { 2807, 10, 13, 13, 2, -26 },
  { 2824, 13, 2, 13, -2, 0 },
  { 2828, 5, 5, 10, 4, -27 },
  { 2832, 13, 19, 16, 1, -19 },
  { 2863, 14, 27, 17, 1, -27 },
  { 2911, 14, 19, 16, 1, -19 },
  { 2945, 16, 27, 17, 1, -27 },
  { 2999, 14, 19, 16, 1, -19 },
  { 3033, 11, 27, 11, 2, -27 },
  { 3071, 16, 26, 17, 0, -19 },
  { 3123, 14, 27, 17, 1, -27 },
  { 3171, 6, 26, 7, 1, -26 },
  { 3191, 11, 33, 7, -4, -26 },
  { 3237, 15, 27, 15, 1, -27 },
  { 3288, 7, 27, 7, 1, -27 },
  { 3312, 24, 19, 27, 1, -19 },
  { 3369, 14, 19, 17, 1, -19 },
  { 3403, 14, 19, 17, 1, -19 },
  { 3437, 16, 26, 17, -1, -19 },
  { 3489, 15, 26, 17, 1, -19 },
  { 3538, 10, 19, 11, 1, -19 },
  { 3562, 13, 19, 16, 1, -19 },
  { 3593, 8, 24, 10, 2, -24 },
  { 3617, 14, 19, 17, 2, -19 },
  { 3651, 13, 19, 15, 2, -19 },
  { 3682, 20, 19, 23, 3, -19 },
  { 3730, 16, 19, 15, -1, -19 },
  { 3768, 16, 26, 15, -1, -19 },
  { 3820, 15, 19, 15, 0, -19 },
  { 3856, 11, 35, 10, 1, -28 },
  { 3905, 6, 31, 8, 1, -26 },
  { 3929, 11, 35, 10, -2, -28 },
  { 3978, 17, 7, 21, 2, -14 },
};

const GFXfont RobotoCondensed_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC36PT7B_H_
