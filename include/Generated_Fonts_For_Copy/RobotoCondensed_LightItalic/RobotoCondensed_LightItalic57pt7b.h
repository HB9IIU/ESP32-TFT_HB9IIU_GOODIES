#ifndef _ROBOTOCONDENSED_LIGHTITALIC57PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x70, 0x00, 0x00, 0x38,
  0xE7, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0x73, 0x0E, 0x61, 0xDC,
  0x33, 0x86, 0x70, 0xCC, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x80, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x39, 0x80, 0x70,
  0x0C, 0x60, 0x1C, 0x07, 0x18, 0x07, 0x03, 0x86, 0x01, 0xC1, 0xC3, 0x80,
  0x70, 0x70, 0xE0, 0x18, 0x38, 0x18, 0x0E, 0x1C, 0x06, 0x03, 0x87, 0x01,
  0xC1, 0xC3, 0x80, 0x78, 0xF1, 0xC0, 0x0F, 0xF8, 0x70, 0x01, 0xFC, 0x38,
  0x00, 0x08, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x1C, 0x3F, 0xE0,
  0x06, 0x1C, 0x38, 0x03, 0x86, 0x07, 0x01, 0xC3, 0x80, 0xC0, 0x60, 0xC0,
  0x30, 0x38, 0x70, 0x0C, 0x1C, 0x1C, 0x03, 0x06, 0x07, 0x00, 0xC3, 0x81,
  0xC0, 0x31, 0xC0, 0x70, 0x0C, 0x60, 0x1C, 0x07, 0x38, 0x07, 0x01, 0xCC,
  0x01, 0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x8F, 0x80, 0x01, 0xCF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1E,
  0x03, 0x9E, 0x07, 0x01, 0xCE, 0x03, 0xC0, 0xEF, 0x00, 0xE0, 0x67, 0x00,
  0x78, 0x77, 0x80, 0x1C, 0x3B, 0x80, 0x0F, 0x39, 0xC0, 0x03, 0x9C, 0xE0,
  0x01, 0xFC, 0x70, 0x00, 0x7E, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x0F, 0xE1, 0xF0, 0x0F, 0x70, 0x7F, 0x3F, 0x3C,
  0x1F, 0xFF, 0x0E, 0x03, 0xFE, 0x07, 0x80, 0x30, 0x00, 0x00, 0x39, 0xCE,
  0x73, 0x19, 0xCE, 0x73, 0x19, 0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x0E, 0x03, 0x78, 0x38, 0x7F, 0xFC,
  0xE7, 0xF3, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xF7, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x38, 0x01,
  0xE0, 0xF0, 0x07, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x1E,
  0x38, 0xF3, 0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFE,
  0xF2, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7E,
  0x7C, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x80,
  0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x3F, 0xF9, 0xF8, 0xE7,
  0x87, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0xFC, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3E, 0x03, 0xC0, 0x70, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x0F, 0x01, 0xF0, 0x1F,
  0xCF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03,
  0x80, 0x70, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x3F, 0x00, 0x0E, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x83, 0xE0, 0x1E,
  0x00, 0xF0, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0x9F, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x71, 0xF8, 0x07,
  0x3F, 0xF0, 0x3B, 0xFF, 0xC1, 0xFC, 0x1F, 0x1F, 0x80, 0x38, 0xF8, 0x01,
  0xE7, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x80,
  0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x83, 0x80, 0x3C, 0x1E, 0x03, 0xC0,
  0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFC, 0xFC, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x78, 0x03, 0xC0, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0x83, 0xC0, 0x1E,
  0x00, 0xE0, 0x3C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0x78, 0x70,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x3F,
  0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0xF0, 0x1E,
  0x07, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0xF9, 0xE0, 0x07, 0xC7,
  0x00, 0xFE, 0x3E, 0x0F, 0xE0, 0xFF, 0xF7, 0x03, 0xFE, 0x38, 0x07, 0xC1,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x87, 0x80,
  0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3C, 0x07, 0x0E, 0x01, 0xE7, 0x80, 0x39, 0xC0,
  0x0E, 0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0xF8, 0x00, 0xC0,
  0xE0, 0x07, 0xFC, 0x01, 0x81, 0xC0, 0x1F, 0xFC, 0x03, 0x07, 0x00, 0x70,
  0x3C, 0x06, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x38, 0x07, 0x00, 0x60, 0x1C,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0xC0, 0x38, 0x03, 0x80, 0x73, 0x80, 0x60,
  0x07, 0x00, 0xC7, 0x01, 0xC0, 0x0C, 0x01, 0x8C, 0x03, 0x80, 0x38, 0x03,
  0x38, 0x06, 0x00, 0x70, 0x06, 0x70, 0x1C, 0x00, 0xE0, 0x0C, 0xC0, 0x38,
  0x01, 0x80, 0x19, 0x80, 0x70, 0x07, 0x00, 0x73, 0x00, 0xC0, 0x0E, 0x00,
  0xEE, 0x03, 0x80, 0x1C, 0x01, 0x9C, 0x07, 0x00, 0x30, 0x03, 0x38, 0x0E,
  0x00, 0x60, 0x0E, 0x70, 0x1C, 0x01, 0xC0, 0x18, 0xE0, 0x38, 0x03, 0x80,
  0x31, 0xC0, 0x70, 0x0F, 0x00, 0xE3, 0x80, 0xE0, 0x1E, 0x01, 0x87, 0x01,
  0xC0, 0x7C, 0x07, 0x0E, 0x03, 0x81, 0xB8, 0x1C, 0x1C, 0x03, 0xCF, 0x38,
  0x70, 0x38, 0x07, 0xFC, 0x7F, 0xC0, 0x70, 0x07, 0xE0, 0x7F, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0,
  0x38, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0E, 0x00, 0x7C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03, 0x80,
  0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0x00, 0x1F, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xF0, 0x03, 0x80, 0x07,
  0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x07,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0xC7, 0x00, 0x3F, 0xFC, 0x70, 0x03, 0xFF,
  0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1F, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x70, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x0E,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x3E, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x3C,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x1D, 0xFC, 0x00, 0x00, 0x7F,
  0x78, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xB8, 0x00, 0x00, 0xEE,
  0x07, 0x70, 0x00, 0x03, 0xF8, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x1C, 0xE0,
  0x00, 0x1E, 0xE0, 0x39, 0xC0, 0x00, 0x39, 0xC0, 0x73, 0x80, 0x00, 0xF3,
  0x81, 0xC7, 0x00, 0x01, 0xCF, 0x03, 0x8E, 0x00, 0x07, 0x9C, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x0E, 0x18, 0x00, 0x3C, 0x70, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0xF0, 0xE0, 0x03, 0x87, 0x81, 0xC1,
  0xC0, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x07, 0x03, 0x00, 0x70,
  0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0xE0, 0x1C, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x0E,
  0x01, 0xC7, 0x00, 0xF0, 0x3C, 0x03, 0x8E, 0x01, 0xC0, 0x70, 0x07, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x70, 0x07, 0x01, 0xC0, 0x0D, 0xC0, 0x0E, 0x03,
  0x80, 0x1F, 0x80, 0x1C, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x7C,
  0x00, 0xE0, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x0E, 0x03, 0xE0, 0x00,
  0x0E, 0x03, 0xF0, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x1C, 0x07, 0xF8, 0x00,
  0x1C, 0x07, 0xB8, 0x00, 0x1C, 0x07, 0x38, 0x00, 0x1C, 0x07, 0x1C, 0x00,
  0x1C, 0x07, 0x1C, 0x00, 0x3C, 0x07, 0x1C, 0x00, 0x38, 0x0F, 0x0E, 0x00,
  0x38, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x07, 0x00,
  0x38, 0x0E, 0x07, 0x00, 0x78, 0x0E, 0x07, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xC0, 0xF0, 0x1C, 0x00, 0xE0, 0xE0, 0x3C, 0x00, 0xE0,
  0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x38, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x70,
  0xE0, 0x38, 0x00, 0x71, 0xE0, 0x38, 0x00, 0x39, 0xC0, 0x78, 0x00, 0x39,
  0xC0, 0x70, 0x00, 0x3D, 0xC0, 0x70, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x1D,
  0xC0, 0x70, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x03, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x03, 0x80,
  0x03, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3F, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x31, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xC0,
  0x07, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70,
  0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xC0, 0x07, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0,
  0x70, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x80,
  0x01, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x80,
  0x03, 0x9C, 0x00, 0x1F, 0x00, 0x07, 0x38, 0x00, 0x76, 0x00, 0x1C, 0x70,
  0x00, 0xEC, 0x00, 0x38, 0xE0, 0x03, 0x98, 0x00, 0xF1, 0xC0, 0x07, 0x30,
  0x01, 0xC3, 0x80, 0x0E, 0x60, 0x03, 0x87, 0x00, 0x38, 0xC0, 0x0F, 0x0E,
  0x00, 0x71, 0xC0, 0x1C, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x38, 0x03, 0x87,
  0x00, 0xF0, 0x70, 0x07, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x38, 0x0E, 0x01, 0xC0, 0x60, 0x70, 0x1C, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x0E, 0x0E, 0x01, 0x81, 0xC0,
  0x1C, 0x1C, 0x03, 0x03, 0x80, 0x38, 0x38, 0x06, 0x0E, 0x00, 0x70, 0xE0,
  0x0C, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x0E, 0x70,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF8,
  0x00, 0x1B, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xD8, 0x01,
  0xD8, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x0E,
  0x0C, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0xF0,
  0x06, 0xE0, 0x06, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFC, 0xFC, 0x07, 0xC0, 0x78, 0x1C, 0x00, 0xE0,
  0xF0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0x00, 0x70, 0xF8, 0x01, 0xC3, 0x80, 0x07, 0x1E,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x00, 0x7E, 0x1E, 0x03, 0xB8,
  0x3F, 0xFC, 0xE0, 0xFF, 0xE3, 0x81, 0xFF, 0x0E, 0x00, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x10,
  0x00, 0xE3, 0xFC, 0x01, 0xCF, 0xFE, 0x03, 0xBE, 0xFC, 0x07, 0xE0, 0x3C,
  0x1F, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E,
  0x1F, 0x00, 0x3C, 0x3F, 0x00, 0xF0, 0x67, 0xEF, 0xC1, 0xC7, 0xFF, 0x03,
  0x87, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0xF8, 0x0F, 0x07, 0x00, 0x3C, 0x70, 0x00,
  0xE7, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE3,
  0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0xF3, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x80, 0xE0, 0x07,
  0xF8, 0x70, 0x0F, 0xFE, 0x38, 0x0F, 0xEF, 0x9C, 0x0F, 0x80, 0xEE, 0x07,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x87, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x3F,
  0x3F, 0xC0, 0x0F, 0xFE, 0xE0, 0x03, 0xFC, 0x70, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0xF0,
  0x0F, 0x07, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x78,
  0x07, 0x83, 0xF9, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xE1, 0xC0, 0x3F, 0xF8,
  0xE0, 0x3F, 0xBE, 0x70, 0x3E, 0x03, 0xB8, 0x1E, 0x00, 0xFC, 0x1E, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C,
  0x07, 0x80, 0x3E, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0xFF, 0x80, 0x3F, 0xFB,
  0x80, 0x0F, 0xF1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x00,
  0x0E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x7F, 0x80, 0x73, 0xFF, 0x01,
  0xDF, 0x7E, 0x07, 0xE0, 0x3C, 0x3F, 0x00, 0xF0, 0xF8, 0x01, 0xC3, 0xC0,
  0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x07,
  0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E,
  0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0xF0, 0x00, 0x1D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x3E,
  0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x7F,
  0x80, 0x7F, 0x80, 0x73, 0xFF, 0x07, 0xFF, 0x01, 0xDE, 0x7E, 0x3E, 0x7E,
  0x07, 0xE0, 0x39, 0xE0, 0x78, 0x3E, 0x00, 0xF6, 0x00, 0xE0, 0xF8, 0x01,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0xC0, 0x07, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x80, 0x07, 0x8E,
  0x00, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xC0,
  0x01, 0xC7, 0x80, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0x00, 0xF1, 0xC0, 0x01, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x7F, 0x80, 0x73, 0xFF, 0x01, 0xDF, 0x7E, 0x07, 0xE0, 0x3C, 0x1F,
  0x00, 0xF0, 0xF8, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x78,
  0x07, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0,
  0x01, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x01, 0xF9, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE3,
  0xFC, 0x00, 0x77, 0xFF, 0x80, 0x3F, 0xEF, 0xC0, 0x1F, 0x80, 0xF0, 0x0F,
  0x00, 0x38, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x87, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0E, 0x07, 0xC0, 0x0F, 0x03, 0xF0, 0x0F, 0x01, 0xDF,
  0x3F, 0x01, 0xC7, 0xFF, 0x00, 0xE1, 0xFF, 0x00, 0x70, 0x08, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xFE, 0x1C, 0x0F, 0xFE, 0x38, 0x3F, 0x3E, 0x70, 0xF8, 0x0E,
  0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x03, 0xF3, 0xFE, 0x03, 0xFF, 0xB8,
  0x03, 0xFE, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xC1, 0xDF, 0xE0, 0xFF, 0xE0, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x07, 0x80, 0xF0, 0x3C, 0x01,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xF0, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1E, 0x01,
  0xF0, 0x3F, 0x3F, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0x10, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03,
  0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0xF0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0xC3, 0xC0, 0x1F, 0x07, 0x81, 0xF8, 0x1F, 0xBF, 0xE0, 0x3F, 0xFB, 0x80,
  0x7F, 0x8E, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0,
  0x70, 0x1C, 0x03, 0x01, 0xC0, 0x30, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0x9C,
  0x00, 0x1D, 0xC0, 0x01, 0xD8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0,
  0x0E, 0x60, 0x07, 0xC0, 0x1E, 0x70, 0x07, 0xC0, 0x1C, 0x70, 0x0F, 0xC0,
  0x1C, 0x70, 0x0F, 0xC0, 0x38, 0x70, 0x1C, 0xC0, 0x38, 0x70, 0x1C, 0xC0,
  0x78, 0x70, 0x38, 0xC0, 0x70, 0x70, 0x38, 0xE0, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0x70, 0x70, 0xE0, 0xE0, 0x70, 0x70, 0xE1, 0xC0, 0x70, 0xE0, 0xE1,
  0xC0, 0x70, 0xE0, 0xE1, 0xC0, 0x71, 0xC0, 0xE3, 0x80, 0x71, 0xC0, 0xE3,
  0x80, 0x73, 0x80, 0x63, 0x00, 0x33, 0x80, 0x67, 0x00, 0x33, 0x00, 0x67,
  0x00, 0x37, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07,
  0x81, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x71,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x07, 0x80, 0x07, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x7F, 0xE0,
  0x03, 0x1E, 0x1E, 0x00, 0xE7, 0x81, 0xE0, 0x1C, 0xE0, 0x1E, 0x07, 0x1C,
  0x01, 0xE1, 0xE7, 0x00, 0x1F, 0xF8, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0x80,
};

const GFXglyph RobotoCondensed_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 42, 12, 1, -41 },
  { 59, 11, 13, 16, 6, -43 },
  { 77, 28, 41, 28, 2, -41 },
  { 221, 24, 54, 27, 2, -48 },
  { 383, 26, 43, 35, 5, -42 },
  { 523, 25, 43, 30, 2, -42 },
  { 658, 5, 12, 9, 5, -43 },
  { 666, 16, 58, 16, 3, -45 },
  { 782, 16, 58, 16, -3, -45 },
  { 898, 22, 23, 23, 3, -41 },
  { 962, 24, 29, 27, 2, -33 },
  { 1049, 7, 13, 11, -2, -5 },
  { 1061, 11, 3, 14, 2, -19 },
  { 1066, 5, 5, 13, 1, -4 },
  { 1070, 24, 44, 20, -2, -41 },
  { 1202, 22, 43, 27, 3, -42 },
  { 1321, 14, 41, 27, 7, -41 },
  { 1393, 24, 42, 27, 1, -42 },
  { 1519, 23, 43, 27, 2, -42 },
  { 1643, 24, 41, 27, 1, -41 },
  { 1766, 24, 42, 27, 3, -41 },
  { 1892, 21, 42, 27, 3, -41 },
  { 2003, 24, 41, 27, 4, -41 },
  { 2126, 24, 43, 27, 2, -42 },
  { 2255, 21, 42, 27, 4, -42 },
  { 2366, 9, 31, 11, 1, -30 },
  { 2401, 12, 38, 11, -2, -30 },
  { 2458, 21, 24, 25, 2, -30 },
  { 2521, 22, 14, 27, 3, -26 },
  { 2560, 21, 24, 25, 2, -30 },
  { 2623, 18, 43, 22, 5, -42 },
  { 2720, 39, 53, 43, 2, -40 },
  { 2979, 28, 41, 30, -2, -41 },
  { 3123, 26, 41, 30, 2, -41 },
  { 3257, 27, 43, 31, 3, -42 },
  { 3403, 28, 41, 32, 2, -41 },
  { 3547, 27, 41, 28, 2, -41 },
  { 3686, 27, 41, 27, 2, -41 },
  { 3825, 28, 43, 33, 3, -42 },
  { 3976, 31, 41, 34, 2, -41 },
  { 4135, 11, 41, 14, 2, -41 },
  { 4192, 25, 42, 27, 1, -41 },
  { 4324, 30, 41, 30, 2, -41 },
  { 4478, 20, 41, 26, 2, -41 },
  { 4581, 39, 41, 41, 2, -41 },
  { 4781, 32, 41, 34, 2, -41 },
  { 4945, 28, 43, 33, 3, -42 },
  { 5096, 28, 41, 30, 2, -41 },
  { 5240, 28, 49, 33, 3, -42 },
  { 5412, 27, 41, 30, 2, -41 },
  { 5551, 28, 43, 29, 1, -42 },
  { 5702, 26, 41, 29, 5, -41 },
  { 5836, 29, 42, 32, 3, -41 },
  { 5989, 28, 41, 30, 5, -41 },
  { 6133, 39, 41, 43, 6, -41 },
  { 6333, 32, 41, 30, -1, -41 },
  { 6497, 27, 41, 29, 5, -41 },
  { 6636, 30, 41, 29, 0, -41 },
  { 6790, 17, 55, 12, 0, -46 },
  { 6907, 9, 44, 20, 6, -41 },
  { 6957, 16, 55, 12, -3, -46 },
  { 7067, 16, 20, 20, 3, -41 },
  { 7107, 21, 3, 21, -3, 0 },
  { 7115, 8, 8, 16, 7, -43 },
  { 7123, 22, 32, 26, 1, -31 },
  { 7211, 23, 44, 27, 1, -43 },
  { 7338, 21, 32, 25, 2, -31 },
  { 7422, 25, 44, 27, 2, -43 },
  { 7560, 21, 32, 25, 2, -31 },
  { 7644, 18, 44, 17, 3, -44 },
  { 7743, 25, 43, 27, 0, -31 },
  { 7878, 22, 43, 27, 1, -43 },
  { 7997, 11, 41, 12, 1, -41 },
  { 8054, 19, 53, 12, -7, -41 },
  { 8180, 24, 43, 24, 1, -43 },
  { 8309, 11, 43, 12, 1, -43 },
  { 8369, 38, 31, 42, 1, -31 },
  { 8517, 22, 31, 27, 1, -31 },
  { 8603, 23, 32, 27, 2, -31 },
  { 8695, 25, 43, 27, -1, -31 },
  { 8830, 23, 43, 27, 2, -31 },
  { 8954, 17, 31, 17, 1, -31 },
  { 9020, 22, 32, 25, 1, -31 },
  { 9108, 13, 39, 16, 3, -38 },
  { 9172, 22, 31, 27, 3, -30 },
  { 9258, 20, 30, 23, 4, -30 },
  { 9333, 32, 30, 36, 4, -30 },
  { 9453, 25, 30, 24, -1, -30 },
  { 9547, 26, 42, 23, -2, -30 },
  { 9684, 23, 30, 24, 0, -30 },
  { 9771, 18, 56, 17, 2, -45 },
  { 9897, 10, 49, 12, 1, -41 },
  { 9959, 18, 55, 17, -3, -44 },
  { 10083, 27, 10, 33, 3, -22 },
};

const GFXfont RobotoCondensed_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC57PT7B_H_
