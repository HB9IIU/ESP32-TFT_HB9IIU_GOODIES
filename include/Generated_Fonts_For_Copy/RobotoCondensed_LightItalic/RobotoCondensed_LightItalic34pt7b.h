#ifndef _ROBOTOCONDENSED_LIGHTITALIC34PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0x82,
  0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x30, 0x4D, 0x3C, 0xF3, 0xCA, 0x28,
  0xA6, 0x00, 0x43, 0x00, 0x21, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x08, 0x60,
  0x0C, 0x20, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0x08, 0x01, 0x84, 0x00, 0x86,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x21, 0x80, 0x30, 0x80, 0x18, 0x40, 0xFF,
  0xFC, 0x7F, 0xFE, 0x06, 0x10, 0x02, 0x18, 0x03, 0x08, 0x01, 0x84, 0x00,
  0x86, 0x00, 0xC2, 0x00, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x7C, 0x07,
  0xF8, 0x38, 0x60, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0xC0, 0x1B, 0x00, 0x44, 0x03, 0x18, 0x0C, 0x70, 0xE0,
  0xFF, 0x01, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x63, 0x00, 0x41, 0x06, 0xC1, 0x04, 0xC1, 0x08, 0xC1, 0x18, 0xC3,
  0x30, 0x42, 0x20, 0x7E, 0x60, 0x3C, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x3C, 0x06, 0x7E, 0x04, 0x42, 0x0C, 0xC3, 0x18, 0x83, 0x30, 0x83, 0x20,
  0x83, 0x60, 0x82, 0x00, 0xC6, 0x00, 0xEC, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0xE0, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x0C, 0x06, 0x38,
  0x0C, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x30, 0xDC,
  0x61, 0xB0, 0x63, 0xC0, 0xC5, 0x80, 0xDB, 0x01, 0xA6, 0x01, 0xCC, 0x03,
  0x8C, 0x0F, 0x0F, 0xF3, 0x0F, 0x86, 0x6D, 0xA5, 0xB0, 0x00, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x00, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0xF9, 0x3D, 0xFF, 0xC1, 0xF0, 0x0F, 0x00,
  0xD8, 0x06, 0x60, 0x63, 0x06, 0x0C, 0x20, 0x40, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x7F, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x33, 0x33, 0x66, 0xC8, 0xFF, 0xFC, 0x5F, 0x00,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xC0,
  0x7F, 0x87, 0x0C, 0x30, 0x33, 0x01, 0x98, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x1B, 0x00, 0xD0, 0x07, 0x80, 0x3C, 0x01, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0xC0, 0x36, 0x01, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x30, 0xE1, 0xFE, 0x07,
  0xC0, 0x01, 0x0F, 0x3F, 0x73, 0xC2, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x03, 0xE0, 0x1F, 0xE0, 0xC1, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0xC1,
  0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0x60, 0x31, 0x83, 0x83, 0xFC, 0x07,
  0xC0, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0xD8, 0x03, 0x60,
  0x19, 0x80, 0xC4, 0x03, 0x30, 0x18, 0xC0, 0xC3, 0x06, 0x0C, 0x18, 0x30,
  0xC1, 0x86, 0x06, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x37, 0xC0, 0xFF,
  0x83, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x33, 0x00, 0xCC, 0x03, 0x30, 0x18, 0x40, 0x61, 0x83, 0x03, 0xF8, 0x07,
  0xC0, 0x00, 0xF0, 0x3F, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x67, 0x87, 0xFE, 0x70, 0x6E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x66, 0x0C, 0x3F, 0x81,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1,
  0xC3, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x18, 0x0C, 0x60,
  0x60, 0xC3, 0x83, 0xF8, 0x0F, 0xC0, 0xE1, 0x87, 0x03, 0x18, 0x06, 0xC0,
  0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x81, 0x83, 0xFC, 0x07,
  0xC0, 0x0F, 0x81, 0xFC, 0x30, 0x66, 0x06, 0x60, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x06, 0xC0, 0xEE, 0x1E, 0x7F, 0x63,
  0xE4, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0xE0, 0xFC, 0x0F,
  0x00, 0x19, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC6,
  0x00, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x20, 0x00, 0x00, 0x08,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x10, 0x7F, 0xFB, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x20, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x1F,
  0x0F, 0xE7, 0x0D, 0x83, 0xC0, 0xF0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x06, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0x80, 0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x83, 0x00,
  0x01, 0x84, 0x07, 0x81, 0x18, 0x3F, 0x82, 0x20, 0xC1, 0x04, 0xC1, 0x06,
  0x09, 0x06, 0x0C, 0x16, 0x08, 0x18, 0x2C, 0x30, 0x20, 0x50, 0x60, 0xC1,
  0xA0, 0x81, 0x83, 0x43, 0x03, 0x07, 0x86, 0x04, 0x0B, 0x0C, 0x18, 0x16,
  0x18, 0x30, 0x6C, 0x30, 0xE0, 0x98, 0x61, 0x43, 0x30, 0x7C, 0xDC, 0x60,
  0xF0, 0xE0, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0,
  0x03, 0x60, 0x03, 0x10, 0x01, 0x88, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1,
  0x80, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x30, 0x18, 0x08, 0x1F, 0xFC, 0x0F,
  0xFF, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x05, 0x80, 0x03, 0x0F, 0xF8, 0x0F, 0xFC, 0x0C, 0x0E, 0x0C, 0x06,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x10, 0x1C,
  0x3F, 0xF8, 0x3F, 0xF0, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0xC0, 0x38,
  0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0x70, 0x70,
  0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0x03, 0x81, 0x80,
  0xE1, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x04, 0x30, 0x02, 0x18, 0x01, 0x08,
  0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C,
  0x40, 0x04, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01,
  0x86, 0x03, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E,
  0x06, 0x1C, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0xFE, 0xC0, 0xFE, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x30, 0x38, 0x3F, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x00, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x60, 0x03, 0x0C, 0x00, 0x41, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x30, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x61,
  0x84, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86, 0x30, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x31, 0x80, 0x63, 0x01, 0x86, 0x03, 0x0C,
  0x0E, 0x1C, 0x38, 0x1F, 0xE0, 0x1F, 0x80, 0x0C, 0x01, 0xC3, 0x00, 0xE0,
  0xC0, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x18, 0xC0, 0x04, 0x60, 0x03, 0x30, 0x00, 0xDE, 0x00, 0x3D, 0x80,
  0x0E, 0x70, 0x03, 0x0C, 0x00, 0x83, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0xF1, 0xA0, 0x01, 0x63, 0x60, 0x06, 0x86, 0xC0, 0x1B, 0x0D, 0x80, 0x36,
  0x1B, 0x00, 0xCC, 0x26, 0x01, 0x98, 0xC4, 0x06, 0x31, 0x8C, 0x0C, 0xC3,
  0x18, 0x31, 0x86, 0x30, 0x63, 0x0C, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x60,
  0x8C, 0x10, 0xC1, 0x98, 0x61, 0x83, 0x60, 0xC3, 0x06, 0xC1, 0x86, 0x0F,
  0x03, 0x18, 0x1E, 0x06, 0x30, 0x18, 0x08, 0x60, 0x30, 0x30, 0x0C, 0x00,
  0x61, 0xC0, 0x0C, 0x38, 0x01, 0x87, 0x00, 0x21, 0xB0, 0x0C, 0x36, 0x01,
  0x86, 0x40, 0x30, 0xCC, 0x06, 0x19, 0x80, 0xC2, 0x18, 0x30, 0xC3, 0x06,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x0C, 0x08, 0x61, 0x01, 0x98,
  0x60, 0x33, 0x0C, 0x02, 0x61, 0x80, 0x6C, 0x30, 0x0D, 0x86, 0x00, 0xE1,
  0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xFC, 0x0E,
  0x0E, 0x18, 0x07, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x60,
  0x18, 0x70, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0x01, 0xC1, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02,
  0x18, 0x03, 0x08, 0x01, 0x8C, 0x01, 0x86, 0x01, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C,
  0xC0, 0x0C, 0x60, 0x18, 0x70, 0x70, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x10, 0x0F, 0xF8, 0x0F, 0xFE, 0x0C, 0x06,
  0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x06, 0x30, 0x06, 0x30, 0x1C, 0x3F, 0xF8, 0x3F, 0xE0, 0x30, 0x60,
  0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x18, 0x60, 0x18,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E,
  0x1C, 0x06, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xE0, 0x18,
  0x70, 0x30, 0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00,
  0x46, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x60,
  0x02, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x33,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03,
  0x0E, 0x03, 0x83, 0x03, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x30, 0x60, 0x30, 0x20, 0x30, 0x20, 0x60, 0x30, 0x60, 0x30,
  0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x13, 0x00, 0x13, 0x00, 0x1A,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0x40, 0x28, 0x0C, 0x40, 0x68, 0x0C,
  0x40, 0x68, 0x0C, 0x60, 0x48, 0x18, 0x60, 0xC8, 0x18, 0x60, 0xCC, 0x18,
  0x61, 0x8C, 0x30, 0x61, 0x8C, 0x30, 0x61, 0x0C, 0x30, 0x63, 0x0C, 0x60,
  0x63, 0x0C, 0x60, 0x66, 0x0C, 0x40, 0x66, 0x0C, 0xC0, 0x64, 0x04, 0xC0,
  0x6C, 0x05, 0x80, 0x6C, 0x05, 0x80, 0x68, 0x05, 0x80, 0x78, 0x05, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x60, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x80, 0x18, 0x30,
  0x01, 0x86, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x39,
  0x80, 0x03, 0x18, 0x00, 0x61, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x18,
  0x06, 0x03, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x60,
  0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x38, 0x30, 0x30, 0x30,
  0x60, 0x18, 0x60, 0x18, 0xC0, 0x19, 0x80, 0x09, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0xE0, 0xF8, 0x00, 0x41, 0x06, 0x18,
  0x61, 0x86, 0x08, 0x20, 0x83, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x61, 0x86,
  0x18, 0x60, 0x82, 0x0C, 0x30, 0x07, 0xC1, 0xF0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x83, 0xE0, 0xF8, 0x00, 0x02,
  0x03, 0x03, 0xC1, 0xE1, 0xB0, 0xD8, 0xC4, 0x62, 0x61, 0xB0, 0xF0, 0x78,
  0x30, 0x7F, 0xFF, 0xFF, 0x80, 0xE3, 0x0C, 0x61, 0x80, 0x07, 0xC0, 0x7F,
  0x86, 0x0C, 0x60, 0x23, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x0F, 0xF1,
  0xFF, 0x9C, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x03, 0x98, 0x3C, 0x7F,
  0x61, 0xE3, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x13, 0xE1, 0xBF, 0x8F, 0x0E, 0x70, 0x33, 0x01,
  0x98, 0x04, 0x80, 0x2C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x34,
  0x01, 0x60, 0x1B, 0x80, 0xDE, 0x0C, 0xDF, 0xC4, 0x7C, 0x00, 0x07, 0xC0,
  0x7F, 0x86, 0x0C, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0x60, 0x11, 0x81, 0x8C, 0x18,
  0x3F, 0x80, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x07, 0xCC, 0x3F, 0xD8, 0x60,
  0xB1, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0x80, 0x23, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x18, 0x1C, 0x30,
  0x70, 0x3F, 0xE0, 0x3C, 0xC0, 0x07, 0xC0, 0x7F, 0x86, 0x0C, 0x60, 0x36,
  0x01, 0xB0, 0x0D, 0x80, 0x6F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x0C, 0x3F, 0xC0, 0xF8, 0x00, 0x03,
  0xC1, 0xF0, 0xE0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x3F, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x03, 0xE6, 0x1F, 0xEC,
  0x30, 0x58, 0xC0, 0x71, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x40, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x0C, 0x0E,
  0x18, 0x38, 0x1F, 0xF0, 0x1E, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x38, 0x30, 0x3F, 0xE0, 0x1F, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x11, 0xE1, 0xBF, 0x8F,
  0x0C, 0x70, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01,
  0x98, 0x0C, 0xC0, 0x64, 0x03, 0x60, 0x1B, 0x00, 0x98, 0x0C, 0xC0, 0x66,
  0x03, 0x00, 0x08, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x43, 0x0C, 0x30,
  0xC3, 0x08, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC0, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x38, 0x3E, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x18, 0xC0, 0xC3, 0x06,
  0x0C, 0x30, 0x31, 0x80, 0xCC, 0x02, 0x60, 0x1B, 0x00, 0x7E, 0x01, 0xD8,
  0x06, 0x30, 0x18, 0xC0, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0,
  0xC3, 0x01, 0x80, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x00, 0x13,
  0xE0, 0xF0, 0xDF, 0xCF, 0xE3, 0xC3, 0x60, 0xCE, 0x07, 0x03, 0x30, 0x1C,
  0x0C, 0xC0, 0x60, 0x32, 0x01, 0x80, 0xD8, 0x06, 0x03, 0x60, 0x10, 0x0D,
  0x80, 0xC0, 0x36, 0x03, 0x00, 0x98, 0x0C, 0x06, 0x40, 0x30, 0x1B, 0x00,
  0xC0, 0x6C, 0x02, 0x01, 0xB0, 0x18, 0x06, 0xC0, 0x60, 0x13, 0x01, 0x80,
  0xC0, 0x11, 0xE1, 0xBF, 0x8F, 0x0C, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0x6C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x03, 0x60, 0x1B,
  0x00, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0x83,
  0x8C, 0x06, 0x30, 0x19, 0x80, 0x26, 0x00, 0xD8, 0x02, 0x40, 0x0B, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x19, 0x00, 0xC6, 0x03, 0x1C, 0x38, 0x3F,
  0xC0, 0x7C, 0x00, 0x04, 0xF8, 0x1B, 0xF8, 0x3C, 0x38, 0x70, 0x30, 0xC0,
  0x61, 0x80, 0x42, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x00, 0x46, 0x01, 0x8E, 0x03, 0x1E, 0x0C, 0x37, 0xF0, 0x67,
  0xC0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x07, 0xCC, 0x7F, 0xB1, 0x83, 0xCC, 0x06, 0x30, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0,
  0x33, 0x00, 0xC6, 0x07, 0x18, 0x38, 0x3F, 0xE0, 0x7D, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x13, 0xCD,
  0xE3, 0xC0, 0xE0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xC1, 0xFE,
  0x38, 0x33, 0x03, 0x30, 0x13, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x6C, 0x06, 0xC0, 0x6E, 0x0C, 0x7F, 0x83, 0xF0,
  0x18, 0x30, 0x60, 0xC1, 0x9F, 0xFF, 0x98, 0x30, 0x60, 0xC1, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x0F, 0x1E, 0x00, 0x20, 0x1B, 0x00,
  0xD8, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0, 0x26,
  0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x38, 0x7F,
  0xC1, 0xE6, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x64, 0x06, 0x60, 0xC6, 0x0C,
  0x60, 0x86, 0x18, 0x61, 0x86, 0x30, 0x23, 0x02, 0x60, 0x36, 0x03, 0x40,
  0x3C, 0x03, 0x80, 0x18, 0x01, 0x00, 0x80, 0xC0, 0x70, 0x18, 0x1A, 0x07,
  0x03, 0x60, 0xE0, 0xCC, 0x34, 0x19, 0x86, 0x83, 0x31, 0x90, 0xC6, 0x32,
  0x18, 0xC4, 0x66, 0x19, 0x8C, 0xC3, 0x21, 0x90, 0x6C, 0x36, 0x0D, 0x86,
  0xC1, 0xE0, 0xD0, 0x3C, 0x0E, 0x07, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x00, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x70, 0x30, 0xC0, 0x63, 0x00, 0x6C,
  0x00, 0xD8, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x36, 0x00,
  0xC4, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x18, 0x70, 0x30, 0xC0, 0x60, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x0C, 0x08, 0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x0C,
  0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x04, 0x60, 0x04, 0xC0, 0x06,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x40, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0xF0, 0x1C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0x80, 0x0C, 0x30, 0x86, 0x18,
  0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x18, 0x41,
  0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0xE0, 0x18, 0x00, 0x3C, 0x03, 0x7F, 0x02, 0x63, 0x86, 0xC1, 0xC6,
  0xC0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 6, 8, 9, 4, -26 },
  { 25, 17, 24, 17, 1, -24 },
  { 76, 14, 30, 16, 1, -27 },
  { 129, 16, 24, 21, 3, -24 },
  { 177, 15, 24, 18, 1, -24 },
  { 222, 3, 7, 6, 3, -26 },
  { 225, 9, 35, 10, 2, -27 },
  { 265, 10, 35, 10, -2, -27 },
  { 309, 13, 14, 14, 2, -24 },
  { 332, 14, 18, 16, 1, -20 },
  { 364, 4, 8, 6, -1, -3 },
  { 368, 7, 2, 9, 1, -12 },
  { 370, 3, 3, 8, 1, -3 },
  { 372, 14, 26, 12, -1, -24 },
  { 418, 13, 24, 16, 2, -24 },
  { 457, 8, 24, 16, 4, -24 },
  { 481, 14, 24, 16, 1, -24 },
  { 523, 14, 24, 16, 1, -24 },
  { 565, 14, 24, 16, 1, -24 },
  { 607, 14, 24, 16, 2, -24 },
  { 649, 12, 24, 16, 2, -24 },
  { 685, 14, 24, 16, 3, -24 },
  { 727, 14, 24, 16, 1, -24 },
  { 769, 12, 24, 16, 3, -24 },
  { 805, 5, 18, 7, 1, -18 },
  { 817, 7, 23, 6, -1, -18 },
  { 838, 13, 14, 15, 1, -18 },
  { 861, 13, 9, 16, 2, -16 },
  { 876, 13, 14, 15, 1, -18 },
  { 899, 10, 24, 13, 3, -24 },
  { 929, 23, 32, 26, 1, -24 },
  { 1021, 17, 24, 18, -1, -24 },
  { 1072, 16, 24, 18, 1, -24 },
  { 1120, 16, 24, 19, 2, -24 },
  { 1168, 17, 24, 19, 1, -24 },
  { 1219, 16, 24, 16, 1, -24 },
  { 1267, 16, 24, 16, 1, -24 },
  { 1315, 16, 24, 20, 2, -24 },
  { 1363, 19, 24, 20, 1, -24 },
  { 1420, 6, 24, 8, 1, -24 },
  { 1438, 15, 24, 16, 1, -24 },
  { 1483, 18, 24, 18, 1, -24 },
  { 1537, 12, 24, 15, 1, -24 },
  { 1573, 23, 24, 25, 1, -24 },
  { 1642, 19, 24, 20, 1, -24 },
  { 1699, 16, 24, 19, 2, -24 },
  { 1747, 17, 24, 18, 1, -24 },
  { 1798, 16, 28, 19, 2, -24 },
  { 1854, 16, 24, 18, 1, -24 },
  { 1902, 16, 24, 17, 1, -24 },
  { 1950, 16, 24, 17, 3, -24 },
  { 1998, 17, 24, 19, 2, -24 },
  { 2049, 16, 24, 18, 3, -24 },
  { 2097, 24, 24, 25, 3, -24 },
  { 2169, 20, 24, 18, -1, -24 },
  { 2229, 16, 24, 17, 3, -24 },
  { 2277, 18, 24, 17, 0, -24 },
  { 2331, 10, 33, 7, 0, -28 },
  { 2373, 6, 26, 12, 3, -24 },
  { 2393, 10, 33, 7, -2, -28 },
  { 2435, 9, 12, 12, 2, -24 },
  { 2449, 13, 2, 13, -2, 0 },
  { 2453, 5, 5, 9, 4, -26 },
  { 2457, 13, 18, 16, 1, -18 },
  { 2487, 13, 26, 16, 1, -26 },
  { 2530, 13, 18, 15, 1, -18 },
  { 2560, 15, 26, 16, 1, -26 },
  { 2609, 13, 18, 15, 1, -18 },
  { 2639, 10, 26, 10, 2, -26 },
  { 2672, 15, 25, 16, 0, -18 },
  { 2719, 13, 26, 16, 1, -26 },
  { 2762, 6, 25, 7, 1, -25 },
  { 2781, 11, 32, 7, -4, -25 },
  { 2825, 14, 26, 14, 1, -26 },
  { 2871, 6, 26, 7, 1, -26 },
  { 2891, 22, 18, 25, 1, -18 },
  { 2941, 13, 18, 16, 1, -18 },
  { 2971, 14, 18, 16, 1, -18 },
  { 3003, 15, 25, 16, -1, -18 },
  { 3050, 14, 25, 16, 1, -18 },
  { 3094, 10, 18, 10, 1, -18 },
  { 3117, 12, 18, 15, 1, -18 },
  { 3144, 7, 23, 10, 2, -23 },
  { 3165, 13, 18, 16, 2, -18 },
  { 3195, 12, 18, 14, 2, -18 },
  { 3222, 19, 18, 22, 3, -18 },
  { 3265, 15, 18, 14, -1, -18 },
  { 3299, 16, 25, 14, -1, -18 },
  { 3349, 14, 18, 14, 0, -18 },
  { 3381, 11, 34, 10, 1, -27 },
  { 3428, 6, 28, 7, 1, -24 },
  { 3449, 11, 34, 10, -2, -27 },
  { 3496, 16, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC34PT7B_H_
