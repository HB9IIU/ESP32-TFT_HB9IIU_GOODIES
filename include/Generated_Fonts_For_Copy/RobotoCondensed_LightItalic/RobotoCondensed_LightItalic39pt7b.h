#ifndef _ROBOTOCONDENSED_LIGHTITALIC39PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x86, 0x00, 0x63, 0x62, 0x66, 0x66, 0x66, 0x46, 0xC6, 0xC4, 0xCC, 0x00,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x01, 0x82, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C,
  0x00, 0x20, 0xC0, 0x06, 0x08, 0x00, 0x61, 0x80, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x10,
  0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x1C, 0x38,
  0x0C, 0x0E, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x61, 0xC0,
  0x30, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x60, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x87, 0x01, 0x81, 0xC3,
  0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x06, 0x30, 0x03, 0x06, 0x04, 0xC1,
  0x83, 0x30, 0x60, 0x8C, 0x18, 0x62, 0x06, 0x30, 0x81, 0x08, 0x30, 0xC6,
  0x0C, 0x33, 0x01, 0xF9, 0x80, 0x3C, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x78, 0x03, 0x3F, 0x01, 0x9C, 0x60, 0xC6, 0x08, 0x31, 0x02, 0x18,
  0xC0, 0x8C, 0x30, 0x23, 0x0C, 0x09, 0x83, 0x06, 0x40, 0x41, 0x80, 0x18,
  0xC0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x38, 0xC0,
  0x1C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x30, 0x06,
  0x1C, 0x01, 0x8E, 0x00, 0x67, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x73, 0x02, 0x38, 0xE1, 0x9C, 0x18, 0x66, 0x07, 0x19,
  0x80, 0xCC, 0xE0, 0x3B, 0x30, 0x07, 0x8E, 0x01, 0xE1, 0x80, 0x30, 0x60,
  0x1E, 0x1E, 0x1D, 0x83, 0xFE, 0x30, 0x3E, 0x0C, 0x6D, 0xAD, 0xB6, 0x80,
  0x00, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x0C,
  0x30, 0xFE, 0x6F, 0x9F, 0xFC, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x66,
  0x01, 0x8E, 0x06, 0x0C, 0x1C, 0x1C, 0x10, 0x10, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x1C, 0x71, 0x86, 0x38, 0xC7, 0x18, 0x40, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0x60, 0x71, 0x80,
  0x63, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0xF0, 0x06, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x18,
  0x60, 0x70, 0xE1, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0x83, 0xC7, 0xFF,
  0x6E, 0x34, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0C, 0x07,
  0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x07, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xE0, 0x0C, 0x60, 0x1C,
  0x70, 0x18, 0x38, 0x70, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x36, 0x00, 0x66, 0x00, 0xCE,
  0x00, 0xCC, 0x01, 0x8C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0xF8, 0x03, 0xFE, 0x03, 0xC3, 0x81, 0xC0, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x38, 0x18, 0x38, 0x07,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x3E, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x3E, 0x1B,
  0xFC, 0x7C, 0x39, 0xE0, 0x77, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0x98, 0x0E, 0x60, 0x30,
  0xC3, 0x83, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC3, 0x80, 0xC0, 0xE0, 0xC0, 0x30,
  0x60, 0x18, 0x70, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x87, 0x01,
  0xC1, 0x80, 0xC0, 0xE1, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x38, 0x70, 0x38,
  0x0C, 0x38, 0x06, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73,
  0x00, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x38, 0x3C, 0x0F, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x1D, 0x80, 0x36,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7E, 0x03, 0x98, 0x1E, 0x70, 0xF8, 0xFF, 0x61, 0xF3, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x0F, 0xE0,
  0x3C, 0x00, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x38, 0xC0, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x60, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x18, 0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF,
  0xF0, 0x10, 0x00, 0x30, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x07, 0xC1, 0xFE,
  0x38, 0x73, 0x03, 0x60, 0x36, 0x03, 0xE0, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x02, 0x0C, 0x07, 0xC0, 0x41, 0x81, 0xFC,
  0x0C, 0x60, 0x60, 0xC1, 0x8C, 0x18, 0x18, 0x33, 0x03, 0x02, 0x06, 0x60,
  0xC0, 0xC0, 0xCC, 0x18, 0x18, 0x1B, 0x06, 0x03, 0x03, 0x60, 0xC0, 0x60,
  0x4C, 0x18, 0x18, 0x09, 0x82, 0x03, 0x03, 0x20, 0xC0, 0x60, 0x6C, 0x18,
  0x0C, 0x09, 0x83, 0x03, 0x03, 0x30, 0x60, 0x60, 0x66, 0x0C, 0x14, 0x18,
  0xC1, 0xC6, 0xC6, 0x18, 0x1F, 0x9F, 0xC1, 0x01, 0xE1, 0xE0, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x01, 0x98,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x18,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31,
  0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x30,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x60, 0x38, 0x38, 0x06, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x71, 0x80,
  0x18, 0x60, 0x0E, 0x18, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0x38,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x70, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x0E, 0x18, 0x07, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x07, 0x00,
  0xE0, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x39, 0xC0, 0x07, 0x30, 0x00,
  0xE6, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0xCE, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30,
  0x70, 0x0E, 0x07, 0x07, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x18, 0x1E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC7, 0x00, 0x18,
  0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x0E, 0x0C, 0x07, 0x83,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x81,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1E, 0x0F, 0x03, 0x00, 0x60, 0xC0, 0x0E, 0x38, 0x00, 0xC6, 0x00, 0x19,
  0xC0, 0x03, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x01, 0xFE, 0x60, 0x3F, 0xCC,
  0x00, 0x33, 0x80, 0x06, 0x70, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0xE3, 0x80, 0x18, 0x30, 0x07, 0x07, 0x83, 0xC0, 0x7F, 0xF0, 0x03,
  0xF0, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x83, 0x80,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E,
  0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x07, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x60, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x86, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xE0,
  0x70, 0x38, 0x70, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x38, 0x30,
  0x03, 0x81, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xC0, 0x38, 0x06, 0x03, 0x80,
  0x30, 0x38, 0x01, 0x83, 0x80, 0x0C, 0x38, 0x00, 0xE1, 0x80, 0x06, 0x18,
  0x00, 0x31, 0xC0, 0x01, 0x9C, 0x00, 0x0D, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xDC, 0x00, 0x3C, 0x60, 0x01, 0xC3, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x70,
  0x07, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x38, 0x38, 0x00, 0xC1, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3C, 0x1B, 0x00, 0x0F, 0x83, 0x60, 0x01, 0xB0, 0x6C,
  0x00, 0x66, 0x0D, 0x80, 0x0D, 0x83, 0x30, 0x03, 0x30, 0x66, 0x00, 0x66,
  0x0C, 0x60, 0x18, 0xC1, 0x8C, 0x03, 0x18, 0x31, 0x80, 0xC7, 0x06, 0x30,
  0x18, 0xC1, 0xC6, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x06, 0x0C, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x31, 0x83, 0x87, 0x06, 0x30, 0x60, 0xC0, 0xCC,
  0x0C, 0x18, 0x19, 0x81, 0x83, 0x01, 0xE0, 0x30, 0x60, 0x3C, 0x06, 0x0C,
  0x07, 0x01, 0xC3, 0x80, 0xE0, 0x30, 0x60, 0x18, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC3, 0xC0, 0x06, 0x0D, 0x80, 0x18,
  0x36, 0x00, 0x60, 0xD8, 0x01, 0x83, 0x30, 0x06, 0x0C, 0xC0, 0x38, 0x73,
  0x80, 0xC1, 0x86, 0x03, 0x06, 0x18, 0x0C, 0x18, 0x70, 0x30, 0x60, 0xC1,
  0xC1, 0x83, 0x06, 0x0E, 0x06, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x61, 0x83,
  0x00, 0xC6, 0x0C, 0x03, 0x38, 0x70, 0x0E, 0xC1, 0xC0, 0x1B, 0x06, 0x00,
  0x6C, 0x18, 0x01, 0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0F, 0x0E, 0x00, 0x18,
  0x30, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x07, 0x00,
  0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0E, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x38,
  0x70, 0x0E, 0x07, 0x07, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x18, 0x0F, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x03,
  0x8C, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x07, 0x06, 0x01, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x0E,
  0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x3B,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x30, 0x70, 0x0E, 0x07, 0x07, 0x80, 0x7F, 0xE0, 0x03, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x18, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C,
  0x18, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x0E, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x07,
  0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C,
  0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1E, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x07, 0x07, 0x80, 0x7F, 0xE0, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xE0, 0x06, 0x06,
  0x00, 0x60, 0x70, 0x0C, 0x03, 0x83, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18,
  0xC0, 0x07, 0x1C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x06, 0x0E, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xD8, 0x01,
  0x80, 0x1B, 0x00, 0x70, 0x07, 0x60, 0x0E, 0x00, 0xCC, 0x01, 0x60, 0x19,
  0x80, 0x6C, 0x07, 0x30, 0x0D, 0x80, 0xC6, 0x03, 0x30, 0x18, 0xC0, 0x66,
  0x07, 0x18, 0x0C, 0xC0, 0xC3, 0x03, 0x18, 0x18, 0x70, 0x63, 0x07, 0x0E,
  0x18, 0x60, 0xC0, 0xC3, 0x0C, 0x18, 0x18, 0x61, 0x86, 0x03, 0x18, 0x10,
  0xC0, 0x63, 0x02, 0x18, 0x0C, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0xC0, 0x33,
  0x01, 0x98, 0x06, 0xC0, 0x36, 0x00, 0xD8, 0x06, 0xC0, 0x1A, 0x00, 0xD8,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x60,
  0x30, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x07, 0x03, 0x80, 0x0C,
  0x1C, 0x00, 0x30, 0x60, 0x00, 0xE3, 0x80, 0x01, 0x9C, 0x00, 0x06, 0x60,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0xE1,
  0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x30, 0x07, 0x00, 0xE0,
  0x18, 0x01, 0x80, 0xE0, 0x06, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0xF0, 0x00, 0xEE, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03,
  0x07, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x00,
  0x63, 0x80, 0x18, 0xC0, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x03, 0xE0, 0x7C, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0F, 0xC1, 0xF8, 0x00, 0xC3, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x20, 0xC3, 0x0C, 0x30, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x19, 0x03, 0x20, 0xC6, 0x18, 0xC6, 0x18, 0xC3,
  0x30, 0x66, 0x05, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x1C, 0x61,
  0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xC0, 0x63, 0x80, 0xC6, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8, 0x7F, 0xF1, 0xC0, 0xE6,
  0x01, 0x9C, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0xF3, 0x87,
  0xE3, 0xFD, 0xC3, 0xE3, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0xF8, 0x1B,
  0xFC, 0x1E, 0x0E, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xF0, 0x18, 0xD8, 0x78, 0xCF,
  0xF0, 0xC7, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x78, 0x70, 0xC0, 0x63, 0x00,
  0x66, 0x00, 0xDC, 0x01, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x03, 0x70, 0x0C, 0x60, 0x18, 0xC0,
  0x61, 0xC1, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x07, 0xC6, 0x0F, 0xF3, 0x0F, 0x0D, 0x86, 0x03, 0xC7, 0x00, 0xE3, 0x00,
  0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x38,
  0x60, 0x38, 0x38, 0x3C, 0x0F, 0xF6, 0x03, 0xE3, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x38, 0x70, 0xC0, 0x63, 0x00, 0xE6, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x20, 0xE1, 0xE1, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x3F, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x7F, 0xC7, 0xF8, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xF1, 0x83,
  0xFC, 0xC3, 0xC3, 0x61, 0x80, 0xF1, 0xC0, 0x38, 0xC0, 0x18, 0x60, 0x0C,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x0E, 0x0E,
  0x0F, 0x03, 0xFD, 0x80, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x20, 0x18, 0x1C, 0x3C, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0xF8, 0x37, 0xF8, 0x7C, 0x30, 0xE0, 0x71, 0x80, 0x67,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x33, 0x80,
  0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x60, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x00, 0xCC, 0x01, 0x80, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xF8, 0x0F,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x07, 0x18, 0x0E, 0x18, 0x1C, 0x18,
  0x38, 0x18, 0x70, 0x38, 0xE0, 0x31, 0xC0, 0x33, 0x80, 0x37, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7B, 0x80, 0x71, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x60,
  0xC0, 0x60, 0x60, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0x06,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C,
  0x00, 0x18, 0xF0, 0x3E, 0x06, 0xFF, 0x1F, 0xC1, 0xE1, 0xCC, 0x38, 0x70,
  0x3E, 0x06, 0x38, 0x07, 0x01, 0xCE, 0x01, 0xC0, 0x73, 0x00, 0x60, 0x1C,
  0xC0, 0x18, 0x07, 0x30, 0x0E, 0x01, 0x8C, 0x03, 0x00, 0x67, 0x00, 0xC0,
  0x19, 0x80, 0x30, 0x06, 0x60, 0x0C, 0x01, 0x98, 0x03, 0x00, 0xE6, 0x01,
  0xC0, 0x31, 0x80, 0x60, 0x0C, 0xE0, 0x18, 0x03, 0x30, 0x06, 0x00, 0xCC,
  0x01, 0x80, 0x33, 0x00, 0x60, 0x1C, 0xC0, 0x38, 0x06, 0x00, 0x18, 0xF8,
  0x37, 0xF8, 0x7C, 0x30, 0xE0, 0x71, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x1C, 0x1C, 0x0E, 0x38, 0x06,
  0x30, 0x06, 0x30, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x1C,
  0x70, 0x18, 0x38, 0x70, 0x1F, 0xE0, 0x0F, 0xC0, 0x06, 0x3E, 0x03, 0x7F,
  0x81, 0xE0, 0xE0, 0xE0, 0x30, 0x60, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x38, 0x07, 0x1E, 0x03, 0x0D, 0x87,
  0x86, 0x7F, 0x83, 0x1F, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE3,
  0x0F, 0xF3, 0x1E, 0x1B, 0x18, 0x0F, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x38, 0x70, 0x78,
  0x3F, 0xD8, 0x1F, 0x98, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x19, 0xE3, 0x7C, 0x7C,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x33,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xB0, 0x06, 0xC0, 0x3B, 0x80, 0xC7, 0x0F, 0x0F, 0xF8,
  0x1F, 0x80, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC7, 0xFF, 0xFE, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7C, 0x1E, 0x00, 0x30, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x77, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x18, 0xC0, 0x31, 0xC0, 0xE1, 0xC7, 0xC3, 0xFD, 0x83, 0xE3, 0x00,
  0xE0, 0x0C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18,
  0x0C, 0x30, 0x30, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18,
  0x06, 0x70, 0x0C, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0, 0x6C, 0x07, 0x01,
  0xB0, 0x3C, 0x0E, 0xC0, 0xF0, 0x33, 0x03, 0xC0, 0xCC, 0x1B, 0x06, 0x30,
  0x64, 0x18, 0xC3, 0x10, 0xE3, 0x0C, 0x63, 0x06, 0x61, 0x8C, 0x19, 0x86,
  0x60, 0x66, 0x19, 0x81, 0xB0, 0x66, 0x06, 0xC1, 0xB0, 0x1E, 0x06, 0xC0,
  0x78, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x03, 0x87, 0x01, 0x81, 0x81, 0xC0, 0xC1, 0xC0, 0x30,
  0xC0, 0x18, 0xE0, 0x0C, 0xE0, 0x03, 0x60, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x18, 0xC0, 0x1C, 0x60,
  0x1C, 0x38, 0x0C, 0x0C, 0x0E, 0x06, 0x0E, 0x03, 0x86, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x18, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x01, 0x81, 0xC0, 0x38, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x10, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x06,
  0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x02, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x0F, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x1E, 0x00, 0xCF, 0xE0, 0x37, 0x1C, 0x0D, 0x83, 0x86, 0xC0, 0x71,
  0xB0, 0x0F, 0xC0, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 8, 1, -28 },
  { 26, 8, 9, 11, 4, -29 },
  { 35, 20, 28, 19, 1, -28 },
  { 105, 17, 36, 18, 1, -32 },
  { 182, 18, 28, 24, 4, -28 },
  { 245, 18, 28, 20, 1, -28 },
  { 308, 3, 9, 6, 4, -29 },
  { 312, 11, 40, 11, 2, -31 },
  { 367, 11, 40, 11, -2, -31 },
  { 422, 15, 16, 16, 2, -28 },
  { 452, 16, 20, 19, 2, -23 },
  { 492, 6, 9, 7, -2, -4 },
  { 499, 8, 2, 10, 1, -13 },
  { 501, 3, 3, 9, 1, -3 },
  { 503, 17, 30, 13, -2, -28 },
  { 567, 15, 28, 18, 2, -28 },
  { 620, 9, 28, 18, 5, -28 },
  { 652, 16, 28, 18, 1, -28 },
  { 708, 16, 28, 18, 1, -28 },
  { 764, 16, 28, 18, 1, -28 },
  { 820, 17, 28, 18, 2, -28 },
  { 880, 14, 28, 18, 2, -28 },
  { 929, 16, 28, 18, 3, -28 },
  { 985, 17, 28, 18, 1, -28 },
  { 1045, 14, 28, 18, 3, -28 },
  { 1094, 6, 21, 8, 1, -21 },
  { 1110, 9, 26, 7, -2, -21 },
  { 1140, 14, 17, 17, 2, -21 },
  { 1170, 15, 10, 18, 2, -18 },
  { 1189, 15, 17, 17, 1, -21 },
  { 1221, 12, 28, 15, 3, -28 },
  { 1263, 27, 36, 30, 1, -27 },
  { 1385, 19, 28, 21, -1, -28 },
  { 1452, 18, 28, 20, 1, -28 },
  { 1515, 19, 28, 21, 2, -28 },
  { 1582, 19, 28, 22, 1, -28 },
  { 1649, 19, 28, 19, 1, -28 },
  { 1716, 19, 28, 19, 1, -28 },
  { 1783, 19, 28, 22, 2, -28 },
  { 1850, 22, 28, 23, 1, -28 },
  { 1927, 7, 28, 9, 2, -28 },
  { 1952, 17, 28, 18, 1, -28 },
  { 2012, 21, 28, 21, 1, -28 },
  { 2086, 14, 28, 18, 1, -28 },
  { 2135, 27, 28, 28, 1, -28 },
  { 2230, 22, 28, 23, 1, -28 },
  { 2307, 19, 28, 22, 2, -28 },
  { 2374, 19, 28, 20, 1, -28 },
  { 2441, 19, 33, 22, 2, -28 },
  { 2520, 19, 28, 21, 1, -28 },
  { 2587, 19, 28, 20, 1, -28 },
  { 2654, 17, 28, 20, 4, -28 },
  { 2714, 20, 28, 22, 2, -28 },
  { 2784, 19, 28, 20, 3, -28 },
  { 2851, 27, 28, 29, 4, -28 },
  { 2946, 22, 28, 20, -1, -28 },
  { 3023, 18, 28, 20, 4, -28 },
  { 3086, 20, 28, 20, 0, -28 },
  { 3156, 11, 38, 9, 0, -32 },
  { 3209, 6, 30, 13, 4, -28 },
  { 3232, 11, 38, 9, -2, -32 },
  { 3285, 11, 14, 14, 2, -28 },
  { 3305, 14, 2, 15, -2, 0 },
  { 3309, 5, 5, 11, 5, -29 },
  { 3313, 15, 21, 18, 1, -21 },
  { 3353, 16, 29, 18, 1, -29 },
  { 3411, 15, 21, 17, 1, -21 },
  { 3451, 17, 29, 18, 2, -29 },
  { 3513, 15, 21, 17, 1, -21 },
  { 3553, 12, 29, 11, 2, -29 },
  { 3597, 17, 29, 18, 0, -21 },
  { 3659, 15, 29, 18, 1, -29 },
  { 3714, 7, 28, 8, 1, -28 },
  { 3739, 12, 36, 8, -4, -28 },
  { 3793, 16, 29, 16, 1, -29 },
  { 3851, 7, 29, 8, 1, -29 },
  { 3877, 26, 21, 29, 1, -21 },
  { 3946, 15, 21, 18, 1, -21 },
  { 3986, 16, 21, 19, 1, -21 },
  { 4028, 17, 29, 18, -1, -21 },
  { 4090, 16, 29, 19, 1, -21 },
  { 4148, 11, 21, 11, 1, -21 },
  { 4177, 14, 21, 17, 1, -21 },
  { 4214, 9, 26, 11, 2, -26 },
  { 4244, 15, 21, 18, 2, -21 },
  { 4284, 15, 21, 16, 2, -21 },
  { 4324, 22, 21, 25, 3, -21 },
  { 4382, 17, 21, 16, -1, -21 },
  { 4427, 19, 29, 16, -2, -21 },
  { 4496, 16, 21, 16, 0, -21 },
  { 4538, 12, 38, 11, 1, -30 },
  { 4595, 7, 33, 8, 1, -28 },
  { 4624, 12, 38, 11, -2, -30 },
  { 4681, 18, 7, 22, 2, -15 },
};

const GFXfont RobotoCondensed_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC39PT7B_H_
