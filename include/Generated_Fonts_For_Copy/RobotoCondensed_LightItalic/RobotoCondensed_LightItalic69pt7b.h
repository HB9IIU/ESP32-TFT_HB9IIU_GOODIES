#ifndef _ROBOTOCONDENSED_LIGHTITALIC69PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x06, 0x00, 0x1C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E, 0x0E, 0x38,
  0x38, 0xE1, 0xE3, 0x87, 0x9E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x38, 0x60, 0xE3, 0x83, 0x8E, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x08,
  0x78, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x80, 0x3C, 0x70, 0x03, 0x80, 0x38,
  0x70, 0x03, 0x80, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x70, 0x03, 0x80, 0xE0,
  0x70, 0x07, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x07, 0x07, 0x80,
  0x70, 0x07, 0x07, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x78, 0x1E, 0x1E, 0x00,
  0x38, 0x3C, 0x1C, 0x00, 0x3F, 0xF8, 0x38, 0x00, 0x1F, 0xF0, 0x78, 0x00,
  0x0F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x1E, 0x1F, 0xFC,
  0x00, 0x1C, 0x3C, 0x1E, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x78, 0x70, 0x0F,
  0x00, 0xF0, 0x70, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x07,
  0x0F, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x0E,
  0x3C, 0x00, 0xE0, 0x0E, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x03, 0xCF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x01,
  0xE1, 0xF0, 0x78, 0x03, 0xC7, 0xC0, 0x78, 0x07, 0x0F, 0x00, 0xF0, 0x0E,
  0x3C, 0x00, 0xF0, 0x3C, 0xF8, 0x01, 0xF0, 0x79, 0xE0, 0x01, 0xE0, 0xE3,
  0xC0, 0x03, 0xE3, 0xC7, 0x00, 0x03, 0xC7, 0x9E, 0x00, 0x07, 0xDE, 0x3C,
  0x00, 0x07, 0xBC, 0x78, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x0F, 0xC0, 0xE0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xFC, 0x07, 0xC0, 0x07, 0xFC, 0x07, 0xC0, 0x3F, 0x7C, 0x0F, 0xFF,
  0xF8, 0x78, 0x0F, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0x8E, 0x39, 0xE7, 0x1C, 0x71,
  0xC7, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x40, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x7F, 0xE0, 0xE0, 0xFF, 0xFE, 0x39,
  0xFF, 0x3F, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x70, 0x00,
  0x0F, 0x9E, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x7C, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x77, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x1F, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7E,
  0x01, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF, 0x9E, 0xFC, 0x1E, 0xF0, 0x1C,
  0x80, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC3, 0xF0, 0x00, 0x1E, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x0F, 0xE0, 0x0F, 0x1F, 0xFC, 0x07, 0xBF, 0xFF, 0x03,
  0xBF, 0xFF, 0xC1, 0xFE, 0x01, 0xF1, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0x3C,
  0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1D, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00,
  0x0F, 0xCF, 0x80, 0x0F, 0xE3, 0xC0, 0x0F, 0xE1, 0xF0, 0x0F, 0x70, 0x7F,
  0xFF, 0x78, 0x1F, 0xFF, 0x3C, 0x07, 0xFF, 0x1C, 0x00, 0xFE, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xF8, 0x3E, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x3F, 0x80, 0x03, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x0E, 0x07, 0x00, 0x1F, 0x87, 0xC0,
  0x1C, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x70, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xE1, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x8F, 0x00, 0x78, 0x00, 0xE0, 0x07,
  0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0xF0, 0x07, 0x00, 0x0E, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x73,
  0x80, 0x3C, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xDE,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x70,
  0x07, 0x80, 0x07, 0x00, 0x1C, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x39, 0xC0,
  0x1C, 0x00, 0x38, 0x00, 0x63, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC7, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x3C, 0x01,
  0xC0, 0x07, 0x80, 0x1C, 0x78, 0x03, 0x80, 0x1E, 0x00, 0x38, 0xF0, 0x07,
  0x00, 0x3C, 0x00, 0x61, 0xE0, 0x0E, 0x00, 0xF8, 0x01, 0xC3, 0xC0, 0x1C,
  0x01, 0xF0, 0x07, 0x03, 0x80, 0x38, 0x07, 0xF0, 0x0E, 0x07, 0x00, 0x78,
  0x1C, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0xF1, 0xE1, 0xE0, 0x1C, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x38, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x70, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0x8F, 0x00, 0x0F, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0xE3, 0xC0, 0x07, 0xFF,
  0xF1, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0x1E, 0x7E, 0x00, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xDE, 0x00, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x00,
  0x1F, 0xC3, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x78,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xEE, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x07, 0x38, 0x00, 0x00,
  0x1E, 0xF0, 0x0E, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x3C, 0xF0, 0x00, 0x00,
  0xF3, 0x80, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x03, 0x87, 0x00, 0x00, 0x3C,
  0x78, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xC0, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C,
  0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0xF0, 0x07, 0x80, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x01, 0xE0,
  0x07, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x39, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x73, 0x80, 0x07, 0x00, 0xF0, 0x00,
  0xEF, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xDC, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xF8, 0x00, 0x78, 0x07, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x00, 0x1C,
  0x01, 0xEE, 0x00, 0x00, 0x78, 0x03, 0xDE, 0x00, 0x00, 0xF0, 0x07, 0xBC,
  0x00, 0x01, 0xE0, 0x0E, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xE0,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x1E, 0x01,
  0xE0, 0x00, 0x1C, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0xF0, 0x07, 0x80, 0x00,
  0x79, 0xE0, 0x0F, 0x00, 0x00, 0x73, 0xC0, 0x1E, 0x00, 0x00, 0xF7, 0x80,
  0x38, 0x00, 0x01, 0xEF, 0x00, 0xF0, 0x00, 0x01, 0xDC, 0x01, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x7B, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xCE, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x1E, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x80, 0xE0, 0x03,
  0x83, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x1E,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x1C, 0x01,
  0xC0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0xE0, 0x07,
  0x03, 0xC0, 0x07, 0x81, 0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1C,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE3,
  0xC0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0x80, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0x01, 0xC1, 0xE0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x1E,
  0x78, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xF0, 0x7C,
  0x01, 0xFE, 0x07, 0xC0, 0xFB, 0xC0, 0xFF, 0xFE, 0x78, 0x0F, 0xFF, 0x8F,
  0x00, 0xFF, 0xE1, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x0F, 0x80, 0x03, 0xC3, 0xFF, 0x00, 0x3C, 0xFF, 0xF8, 0x03,
  0xDF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0xE0, 0x00,
  0x78, 0x7E, 0x00, 0x0F, 0x07, 0xF0, 0x01, 0xF0, 0x7B, 0xC0, 0x7E, 0x07,
  0x1F, 0xFF, 0xC0, 0x70, 0xFF, 0xF8, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x7F, 0xE0, 0xE0, 0x07, 0xFF,
  0xC7, 0x80, 0x3F, 0xFF, 0x9E, 0x01, 0xF8, 0x0F, 0x78, 0x0F, 0x80, 0x1D,
  0xE0, 0x3C, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0xFF, 0xFE,
  0xF0, 0x01, 0xFF, 0xF3, 0xC0, 0x03, 0xFF, 0x8E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x3E, 0x00, 0x3C,
  0x07, 0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8,
  0x70, 0x03, 0xFF, 0xF8, 0xE0, 0x0F, 0xC0, 0x7B, 0xC0, 0x3E, 0x00, 0x77,
  0x80, 0x78, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF,
  0x00, 0x1F, 0xFF, 0xDE, 0x00, 0x1F, 0xFF, 0x3C, 0x00, 0x1F, 0xFC, 0x70,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x01,
  0x00, 0x01, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x03, 0xC3, 0xFF, 0x00, 0x79, 0xFF, 0xF0, 0x0F, 0x7F, 0xFF, 0x01,
  0xFF, 0x03, 0xE0, 0x3B, 0x80, 0x3C, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x0F, 0x80, 0x38, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xC0, 0xF8, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0E, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x1E, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x7C,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3C, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xF7,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xC7, 0x80, 0xF8, 0x0F, 0xE0,
  0x0F, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xC1, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x38, 0x7F, 0xE0, 0x0F, 0x3F, 0xFE,
  0x01, 0xEF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xF0, 0x07, 0x80, 0xFC,
  0x00, 0x78, 0x3F, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xC7, 0xFF, 0x00,
  0x0F, 0x3F, 0xFE, 0x00, 0x3D, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x7B, 0xC0, 0x7E, 0x01,
  0xE7, 0xFF, 0xF0, 0x07, 0x0F, 0xFF, 0x80, 0x3C, 0x1F, 0xF8, 0x00, 0xF0,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x0E, 0x01,
  0xFF, 0xF0, 0xE0, 0x3F, 0xFF, 0x8E, 0x07, 0xE0, 0x3D, 0xE0, 0xF8, 0x00,
  0xDE, 0x0F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xBC, 0x01, 0xFF, 0xF3, 0xC0, 0x0F, 0xFE,
  0x38, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x3F, 0xC0, 0xF3, 0xFC, 0x07,
  0xBF, 0xE0, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x01,
  0xE0, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF8,
  0x1E, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0x3E, 0x07, 0xFC, 0x07, 0xFF,
  0xF7, 0x00, 0x7F, 0xFC, 0xE0, 0x07, 0xFE, 0x3C, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x01,
  0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x03,
  0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0x80, 0x07, 0x9E, 0x00, 0x3F, 0x80, 0x0F, 0x1C, 0x00,
  0x7F, 0x00, 0x1C, 0x38, 0x00, 0xFE, 0x00, 0x78, 0x70, 0x03, 0xFC, 0x00,
  0xF0, 0xE0, 0x07, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x70, 0x07, 0x83, 0x80,
  0x38, 0xE0, 0x0E, 0x07, 0x00, 0xF1, 0xC0, 0x3C, 0x0F, 0x01, 0xC3, 0x80,
  0x78, 0x1E, 0x03, 0x87, 0x01, 0xE0, 0x3C, 0x0F, 0x0E, 0x03, 0xC0, 0x78,
  0x1C, 0x1C, 0x07, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x78,
  0x38, 0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x0F,
  0x0E, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0x1C, 0x70, 0x07,
  0x1C, 0x00, 0x39, 0xE0, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x1C, 0xF0, 0x00,
  0xEF, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x1F, 0xFE,
  0x00, 0x07, 0x1F, 0xFF, 0x00, 0x0E, 0x3C, 0x0F, 0x80, 0x0E, 0x78, 0x07,
  0xC0, 0x1E, 0x78, 0x03, 0xE0, 0x1C, 0x70, 0x01, 0xF0, 0x3C, 0xF0, 0x00,
  0xFF, 0xF8, 0xE0, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0x80,
};

const GFXglyph RobotoCondensed_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 50, 14, 2, -49 },
  { 76, 14, 15, 19, 7, -52 },
  { 103, 34, 49, 34, 2, -49 },
  { 312, 28, 64, 33, 3, -57 },
  { 536, 32, 51, 43, 6, -50 },
  { 740, 31, 51, 36, 2, -50 },
  { 938, 6, 15, 11, 6, -52 },
  { 950, 20, 71, 20, 3, -55 },
  { 1128, 20, 71, 20, -4, -55 },
  { 1306, 26, 28, 28, 4, -49 },
  { 1397, 28, 36, 33, 3, -41 },
  { 1523, 10, 16, 13, -3, -6 },
  { 1543, 14, 4, 17, 2, -24 },
  { 1550, 5, 6, 16, 2, -5 },
  { 1554, 29, 53, 24, -3, -49 },
  { 1747, 28, 51, 33, 3, -50 },
  { 1926, 16, 49, 33, 9, -49 },
  { 2024, 30, 50, 33, 1, -50 },
  { 2212, 29, 51, 33, 2, -50 },
  { 2397, 29, 49, 33, 1, -49 },
  { 2575, 29, 50, 33, 4, -49 },
  { 2757, 25, 50, 33, 4, -49 },
  { 2914, 29, 49, 33, 5, -49 },
  { 3092, 29, 51, 33, 2, -50 },
  { 3277, 25, 50, 33, 5, -50 },
  { 3434, 11, 37, 14, 1, -36 },
  { 3485, 15, 46, 13, -3, -36 },
  { 3572, 25, 29, 30, 3, -37 },
  { 3663, 26, 18, 32, 4, -32 },
  { 3722, 26, 29, 31, 2, -37 },
  { 3817, 21, 51, 27, 6, -50 },
  { 3951, 47, 63, 52, 2, -48 },
  { 4322, 34, 49, 37, -2, -49 },
  { 4531, 32, 49, 36, 2, -49 },
  { 4727, 33, 51, 38, 4, -50 },
  { 4938, 34, 49, 38, 2, -49 },
  { 5147, 33, 49, 33, 2, -49 },
  { 5350, 33, 49, 33, 2, -49 },
  { 5553, 33, 51, 40, 4, -50 },
  { 5764, 39, 49, 41, 2, -49 },
  { 6003, 12, 49, 16, 3, -49 },
  { 6077, 31, 50, 32, 1, -49 },
  { 6271, 37, 49, 37, 2, -49 },
  { 6498, 24, 49, 31, 2, -49 },
  { 6645, 47, 49, 50, 2, -49 },
  { 6933, 39, 49, 41, 2, -49 },
  { 7172, 33, 51, 39, 4, -50 },
  { 7383, 34, 49, 36, 2, -49 },
  { 7592, 33, 59, 39, 4, -50 },
  { 7836, 33, 49, 37, 2, -49 },
  { 8039, 33, 51, 35, 2, -50 },
  { 8250, 32, 49, 35, 6, -49 },
  { 8446, 34, 50, 38, 4, -49 },
  { 8659, 33, 49, 36, 6, -49 },
  { 8862, 47, 49, 52, 7, -49 },
  { 9150, 39, 49, 36, -1, -49 },
  { 9389, 33, 49, 35, 6, -49 },
  { 9592, 36, 49, 35, 0, -49 },
  { 9813, 20, 67, 15, 0, -56 },
  { 9981, 11, 53, 24, 7, -49 },
  { 10054, 20, 67, 15, -4, -56 },
  { 10222, 19, 25, 25, 3, -49 },
  { 10282, 25, 4, 26, -3, 0 },
  { 10295, 10, 9, 19, 8, -51 },
  { 10307, 27, 38, 32, 1, -37 },
  { 10436, 28, 53, 33, 1, -52 },
  { 10622, 26, 38, 30, 2, -37 },
  { 10746, 30, 53, 33, 3, -52 },
  { 10945, 26, 38, 31, 2, -37 },
  { 11069, 21, 53, 20, 4, -53 },
  { 11209, 31, 51, 33, 0, -37 },
  { 11407, 27, 52, 32, 1, -52 },
  { 11583, 12, 50, 14, 2, -50 },
  { 11658, 22, 64, 14, -8, -50 },
  { 11834, 29, 52, 29, 1, -52 },
  { 12023, 12, 52, 14, 2, -52 },
  { 12101, 46, 37, 51, 1, -37 },
  { 12314, 27, 37, 32, 1, -37 },
  { 12439, 27, 38, 33, 3, -37 },
  { 12568, 30, 51, 33, -1, -37 },
  { 12760, 28, 51, 33, 3, -37 },
  { 12939, 21, 37, 20, 1, -37 },
  { 13037, 26, 38, 30, 1, -37 },
  { 13161, 16, 47, 19, 3, -46 },
  { 13255, 27, 37, 32, 3, -36 },
  { 13380, 25, 36, 28, 4, -36 },
  { 13493, 39, 36, 44, 5, -36 },
  { 13669, 30, 36, 29, -1, -36 },
  { 13804, 33, 50, 28, -3, -36 },
  { 14011, 28, 36, 29, 0, -36 },
  { 14137, 22, 68, 20, 2, -54 },
  { 14324, 13, 58, 15, 1, -49 },
  { 14419, 22, 68, 20, -4, -54 },
  { 14606, 32, 12, 40, 4, -26 },
};

const GFXfont RobotoCondensed_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC69PT7B_H_
