#ifndef _ROBOTOCONDENSED_LIGHTITALIC51PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x78, 0x3C, 0x0C, 0x00, 0x38, 0xCC, 0x33, 0x1C, 0xC7, 0x71,
  0xDC, 0x66, 0x19, 0x86, 0x63, 0x98, 0xCC, 0x30, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xC0,
  0xF0, 0x3C, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00,
  0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x07, 0x07,
  0x00, 0x78, 0x1C, 0x07, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x83,
  0x00, 0x06, 0x07, 0x00, 0x1C, 0x06, 0x03, 0xB0, 0x0C, 0x0E, 0x60, 0x18,
  0x18, 0xC0, 0x70, 0x71, 0x80, 0xE1, 0xC3, 0x01, 0x83, 0x06, 0x03, 0x0C,
  0x0C, 0x0E, 0x38, 0x1C, 0x18, 0xE0, 0x1C, 0x71, 0x80, 0x1F, 0xC7, 0x00,
  0x1F, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x87, 0x80,
  0x0E, 0x3F, 0x80, 0x18, 0xE3, 0x80, 0x71, 0x83, 0x81, 0xC6, 0x03, 0x03,
  0x0C, 0x06, 0x0C, 0x38, 0x0C, 0x38, 0x70, 0x18, 0xE0, 0xC0, 0x31, 0x81,
  0x80, 0x67, 0x03, 0x01, 0xDC, 0x06, 0x03, 0x30, 0x0E, 0x06, 0x00, 0x0C,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x70, 0x03, 0x80, 0xE0,
  0x0E, 0x03, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x78,
  0x00, 0x3B, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xDC, 0x00, 0x1E, 0x38, 0x0C, 0xF0, 0xE0, 0x77, 0x81,
  0xC1, 0xDC, 0x07, 0x07, 0xE0, 0x0E, 0x1B, 0x80, 0x38, 0xEE, 0x00, 0x73,
  0x38, 0x01, 0xFC, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38,
  0x00, 0xF8, 0x70, 0x07, 0xE1, 0xF0, 0x79, 0xC3, 0xFF, 0xC7, 0x03, 0xFC,
  0x0E, 0x01, 0x00, 0x00, 0x37, 0x77, 0x66, 0x6E, 0xEC, 0xC0, 0x00, 0x04,
  0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x40, 0x60, 0x6F, 0x86, 0x1E, 0xFE, 0x6F, 0xF1, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x73, 0x00, 0x0E, 0x38,
  0x01, 0xE1, 0x80, 0x3C, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x02, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x8F, 0x1C, 0x78, 0xE3, 0x82, 0x00, 0x7F,
  0xEF, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1C, 0x0F,
  0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x38, 0x00, 0x63,
  0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x06,
  0x70, 0x00, 0x67, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0,
  0x03, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1,
  0xFF, 0x7F, 0x77, 0x86, 0x60, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1C,
  0x03, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x18, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC3, 0x80,
  0x06, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x18, 0x03, 0x81, 0xC0,
  0x18, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x18, 0x0E, 0x00,
  0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x73, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1E, 0x07,
  0x80, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E,
  0x06, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x38, 0x1E, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0xFC, 0x0C, 0xFF,
  0x87, 0x7F, 0xF1, 0xF8, 0x1E, 0x7C, 0x03, 0x9E, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0x38, 0x78, 0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x03, 0x80, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x3C, 0x0E, 0x03, 0xC0, 0x38, 0x3C, 0x00, 0xE1, 0xC0,
  0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x30, 0x00, 0x39,
  0x80, 0x03, 0x8C, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x0E, 0x00,
  0xF0, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x1C, 0x03, 0x8E,
  0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x79, 0xC0, 0x3E, 0x78, 0x1F, 0x8F,
  0xFE, 0xE1, 0xFF, 0x30, 0x3F, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x0F, 0x0F,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0x60,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00,
  0x20, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E,
  0x38, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x0C, 0x38, 0x01, 0xF0, 0x03, 0x0E, 0x01, 0xFF, 0x00, 0xC7,
  0x00, 0xF9, 0xE0, 0x31, 0xC0, 0x78, 0x18, 0x0C, 0x60, 0x1C, 0x06, 0x03,
  0x38, 0x0E, 0x03, 0x80, 0xCC, 0x03, 0x00, 0xE0, 0x33, 0x01, 0xC0, 0x30,
  0x0D, 0xC0, 0x60, 0x0C, 0x03, 0x60, 0x38, 0x03, 0x00, 0xD8, 0x0C, 0x01,
  0xC0, 0x3E, 0x03, 0x00, 0x60, 0x0F, 0x81, 0xC0, 0x18, 0x06, 0xC0, 0x70,
  0x06, 0x01, 0xB0, 0x1C, 0x03, 0x80, 0x6C, 0x06, 0x00, 0xC0, 0x1B, 0x01,
  0x80, 0x30, 0x0C, 0xC0, 0x60, 0x1C, 0x03, 0x30, 0x18, 0x07, 0x01, 0xCC,
  0x06, 0x03, 0xC0, 0x63, 0x01, 0xC1, 0xB0, 0x30, 0xC0, 0x70, 0xEE, 0x1C,
  0x30, 0x0F, 0xF3, 0xFE, 0x0C, 0x03, 0xF0, 0x7F, 0x03, 0x80, 0x10, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xC0, 0x0F, 0x03, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00,
  0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0xE0, 0x03, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0x00, 0x7C, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x07, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x03, 0xC0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0x8E, 0x01, 0xFF, 0xC7,
  0x00, 0xFF, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x1E, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x60, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x70,
  0x01, 0xE0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x30, 0x07, 0x80,
  0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x6E, 0xE0,
  0x00, 0x1F, 0x9C, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x18, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xFC, 0x0D, 0x80, 0x00, 0x1F, 0x81, 0xB8, 0x00, 0x07, 0x60, 0x37,
  0x00, 0x00, 0xEC, 0x0E, 0xE0, 0x00, 0x3B, 0x81, 0xDC, 0x00, 0x07, 0x70,
  0x39, 0x80, 0x01, 0xCE, 0x07, 0x30, 0x00, 0x39, 0xC0, 0xC7, 0x00, 0x0E,
  0x30, 0x38, 0xE0, 0x01, 0xCE, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0xE3, 0x80,
  0x0E, 0x38, 0x1C, 0x30, 0x03, 0x87, 0x03, 0x86, 0x00, 0x70, 0xE0, 0x60,
  0xE0, 0x1C, 0x18, 0x1C, 0x1C, 0x03, 0x87, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x38, 0x1C, 0x0E, 0x03, 0x87, 0x03, 0x81, 0xC0, 0x71,
  0xC0, 0x70, 0x38, 0x0E, 0x30, 0x0E, 0x07, 0x00, 0xCE, 0x01, 0xC0, 0xE0,
  0x19, 0x80, 0x30, 0x18, 0x03, 0x70, 0x0E, 0x07, 0x00, 0x7C, 0x01, 0xC0,
  0xE0, 0x0F, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x60, 0x03, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x70, 0x7C, 0x00, 0x06, 0x07, 0xC0, 0x00, 0xE0,
  0x7E, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0xE0, 0x66, 0x00, 0x0E, 0x0E, 0x70,
  0x00, 0xE0, 0xE7, 0x00, 0x0C, 0x0E, 0x30, 0x01, 0xC0, 0xE3, 0x80, 0x1C,
  0x0E, 0x38, 0x01, 0xC1, 0xC1, 0xC0, 0x1C, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0xC0, 0x18, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x18, 0x06, 0x03,
  0x83, 0x80, 0x70, 0x38, 0x38, 0x07, 0x03, 0x03, 0x80, 0x30, 0x70, 0x38,
  0x03, 0x87, 0x03, 0x80, 0x38, 0x70, 0x30, 0x01, 0xC7, 0x07, 0x00, 0x1C,
  0x70, 0x70, 0x00, 0xC6, 0x07, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0xEE, 0x07,
  0x00, 0x06, 0xE0, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0x3C, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x3E,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0x60, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x06, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x70, 0x00,
  0x30, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0x70, 0x00, 0xF0,
  0x00, 0xEE, 0x00, 0x3E, 0x00, 0x39, 0xC0, 0x07, 0xC0, 0x07, 0x38, 0x00,
  0xD8, 0x00, 0xE7, 0x00, 0x3B, 0x00, 0x38, 0xE0, 0x07, 0x60, 0x07, 0x0C,
  0x01, 0xCE, 0x00, 0xE1, 0x80, 0x39, 0xC0, 0x38, 0x30, 0x06, 0x38, 0x07,
  0x06, 0x01, 0xC7, 0x00, 0xC0, 0xC0, 0x38, 0xE0, 0x38, 0x18, 0x06, 0x0C,
  0x07, 0x03, 0x81, 0xC1, 0x80, 0xC0, 0x70, 0x30, 0x30, 0x38, 0x0E, 0x0E,
  0x06, 0x07, 0x01, 0xC1, 0xC0, 0xC1, 0xC0, 0x38, 0x30, 0x18, 0x38, 0x07,
  0x0E, 0x03, 0x07, 0x00, 0xE1, 0x80, 0x61, 0xC0, 0x1C, 0x70, 0x0E, 0x38,
  0x03, 0x8E, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x07,
  0x38, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x03, 0x70,
  0x01, 0xB8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0x18, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xE0, 0xE0, 0x60, 0x60, 0x60,
  0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x03, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x37, 0x00, 0xEE, 0x01, 0x8C, 0x07, 0x18, 0x0C,
  0x30, 0x38, 0x60, 0x60, 0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x03, 0x18, 0x06,
  0x70, 0x0C, 0xC0, 0x1C, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00,
  0x61, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0x0C, 0x3E, 0x01, 0xC3, 0x80, 0x1C, 0x70,
  0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E,
  0x00, 0x78, 0xE0, 0x0F, 0x87, 0x03, 0xF8, 0x7F, 0xFB, 0x83, 0xFE, 0x38,
  0x0F, 0x83, 0x80, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x3E, 0x00, 0xE7,
  0xFC, 0x07, 0x7F, 0xF0, 0x3F, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x70,
  0x60, 0x01, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x1B, 0x01, 0xE1, 0xCF,
  0xFE, 0x0E, 0x3F, 0xE0, 0x70, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0x01, 0xE1, 0xC0, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x1C,
  0x03, 0xC3, 0xC0, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xC1, 0xC0, 0x3F,
  0xE3, 0x01, 0xFF, 0xEE, 0x03, 0xC0, 0xFC, 0x0E, 0x00, 0xF8, 0x3C, 0x00,
  0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x1C,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0,
  0x0F, 0x01, 0xE0, 0x7C, 0x01, 0xFF, 0xD8, 0x01, 0xFF, 0x70, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x01, 0xE1,
  0xC0, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xB8,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x83, 0xC0, 0x78, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x7E, 0x0E, 0x01, 0xFF, 0x18, 0x0F, 0xFF, 0x70, 0x1E, 0x07,
  0xE0, 0x70, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x0C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1,
  0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x78, 0x0F, 0x03, 0xF0, 0x0F, 0xFE,
  0xC0, 0x0F, 0xFB, 0x80, 0x0F, 0xC7, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x61, 0xF8, 0x0E, 0x7F, 0xC0, 0xEF, 0xFE, 0x0F,
  0xC0, 0xE0, 0xF8, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x63, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x60, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0xF0, 0x38, 0x0F, 0x01,
  0xC0, 0xF0, 0x0C, 0x0F, 0x00, 0x60, 0xF0, 0x07, 0x0F, 0x00, 0x38, 0xF0,
  0x01, 0xCF, 0x00, 0x0E, 0xF0, 0x00, 0x6F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xF7, 0x00, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x03, 0x80,
  0x38, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00,
  0x0E, 0x1F, 0x00, 0x7C, 0x03, 0x9F, 0xF0, 0x7F, 0xC0, 0xEF, 0xFE, 0x3F,
  0xF8, 0x3F, 0x03, 0x9C, 0x0E, 0x0F, 0x00, 0xEC, 0x03, 0x83, 0x80, 0x1F,
  0x00, 0x71, 0xE0, 0x07, 0x80, 0x1C, 0x70, 0x01, 0xE0, 0x07, 0x1C, 0x00,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x1C, 0x60,
  0x01, 0x80, 0x06, 0x38, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x30, 0x00, 0xC0, 0x03,
  0x9C, 0x00, 0x30, 0x00, 0xC7, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x00,
  0x1C, 0x70, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x01, 0xC6, 0x00, 0x18,
  0x00, 0x73, 0x80, 0x0E, 0x00, 0x18, 0xE0, 0x03, 0x80, 0x0E, 0x38, 0x00,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x1F, 0x80, 0xE7, 0xFC,
  0x0E, 0xFF, 0xE0, 0xFC, 0x0E, 0x0F, 0x80, 0xE0, 0xF0, 0x07, 0x0E, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80,
  0x06, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF0,
  0x1C, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0x63, 0x80, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x07,
  0x03, 0x80, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01,
  0x87, 0xE0, 0x07, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x3C,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x0E, 0x07, 0x80, 0x3C, 0x0D, 0x80, 0xF0, 0x3B, 0xFF, 0xC0, 0x73,
  0xFF, 0x00, 0xE1, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x38, 0x1F, 0xF1, 0x83, 0xFF, 0xDC, 0x1E, 0x07, 0xE1, 0xC0, 0x1F, 0x1E,
  0x00, 0x78, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x03,
  0xE0, 0x3F, 0xFB, 0x00, 0xFF, 0xB8, 0x03, 0xF1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x3E, 0x1C, 0xFC, 0x3B, 0xF8, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0x80,
  0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01, 0xC3, 0xC0, 0x78,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xE1, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1C, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x38, 0x00, 0x67, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x30, 0x00, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x18,
  0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x71, 0xC0, 0x1E, 0x38,
  0x07, 0x87, 0x81, 0xF0, 0x7F, 0xFE, 0x07, 0xFD, 0xC0, 0x7E, 0x00, 0x00,
  0xE0, 0x00, 0xDC, 0x00, 0x39, 0x80, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x38,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x06, 0x01, 0x80,
  0xC0, 0x70, 0x18, 0x0C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01,
  0xD8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x37, 0x00, 0x70, 0x03,
  0xB8, 0x03, 0x80, 0x1D, 0xC0, 0x3E, 0x01, 0xCE, 0x01, 0xF0, 0x0E, 0x70,
  0x0F, 0x80, 0x63, 0x80, 0xFC, 0x07, 0x1C, 0x06, 0xE0, 0x38, 0xE0, 0x73,
  0x03, 0x87, 0x03, 0x18, 0x1C, 0x38, 0x38, 0xC0, 0xC0, 0xC1, 0xC6, 0x0E,
  0x06, 0x0C, 0x30, 0x70, 0x30, 0xE1, 0x87, 0x01, 0x86, 0x0E, 0x38, 0x0C,
  0x70, 0x71, 0x80, 0x63, 0x03, 0x9C, 0x03, 0x38, 0x1C, 0xC0, 0x19, 0x80,
  0xEE, 0x00, 0xEC, 0x03, 0x70, 0x07, 0xE0, 0x1B, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x07, 0x80,
  0x1C, 0x1C, 0x00, 0x30, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x01,
  0xE1, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x00,
  0xE0, 0x38, 0x03, 0x81, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x70, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1,
  0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x02, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x06, 0x3F, 0xF0, 0x06,
  0x70, 0x78, 0x06, 0x60, 0x3C, 0x0E, 0xE0, 0x1E, 0x1C, 0xE0, 0x0F, 0xF8,
  0xC0, 0x07, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 36, 11, 1, -36 },
  { 42, 10, 11, 14, 5, -38 },
  { 56, 25, 36, 25, 2, -36 },
  { 169, 21, 46, 24, 2, -41 },
  { 290, 23, 36, 32, 5, -36 },
  { 394, 22, 37, 27, 2, -36 },
  { 496, 4, 11, 8, 5, -38 },
  { 502, 14, 53, 14, 3, -41 },
  { 595, 15, 53, 15, -3, -41 },
  { 695, 20, 20, 21, 3, -36 },
  { 745, 21, 27, 24, 2, -31 },
  { 816, 7, 12, 9, -2, -5 },
  { 827, 11, 3, 13, 1, -18 },
  { 832, 4, 4, 12, 1, -4 },
  { 834, 21, 39, 18, -2, -36 },
  { 937, 20, 36, 24, 3, -36 },
  { 1027, 12, 36, 24, 6, -36 },
  { 1081, 22, 36, 24, 1, -36 },
  { 1180, 21, 36, 24, 2, -36 },
  { 1275, 21, 36, 24, 1, -36 },
  { 1370, 22, 36, 24, 3, -36 },
  { 1469, 18, 36, 24, 3, -36 },
  { 1550, 21, 36, 24, 4, -36 },
  { 1645, 21, 36, 24, 2, -36 },
  { 1740, 18, 36, 24, 4, -36 },
  { 1821, 8, 27, 10, 1, -27 },
  { 1848, 11, 34, 9, -2, -27 },
  { 1895, 19, 21, 22, 2, -27 },
  { 1945, 19, 14, 24, 3, -24 },
  { 1979, 20, 21, 23, 1, -27 },
  { 2032, 16, 36, 20, 4, -36 },
  { 2104, 34, 46, 39, 2, -35 },
  { 2300, 25, 36, 27, -2, -36 },
  { 2413, 23, 36, 27, 2, -36 },
  { 2517, 24, 36, 28, 3, -36 },
  { 2625, 24, 36, 28, 2, -36 },
  { 2733, 24, 36, 25, 2, -36 },
  { 2841, 24, 36, 24, 2, -36 },
  { 2949, 25, 36, 29, 3, -36 },
  { 3062, 28, 36, 30, 2, -36 },
  { 3188, 9, 36, 12, 2, -36 },
  { 3229, 23, 36, 24, 1, -36 },
  { 3333, 27, 36, 27, 2, -36 },
  { 3455, 17, 36, 23, 2, -36 },
  { 3532, 35, 36, 37, 2, -36 },
  { 3690, 28, 36, 31, 2, -36 },
  { 3816, 25, 36, 29, 3, -36 },
  { 3929, 25, 36, 27, 2, -36 },
  { 4042, 24, 42, 29, 3, -36 },
  { 4168, 25, 36, 27, 1, -36 },
  { 4281, 25, 36, 26, 1, -36 },
  { 4394, 23, 36, 26, 5, -36 },
  { 4498, 25, 36, 28, 3, -36 },
  { 4611, 25, 36, 27, 4, -36 },
  { 4724, 35, 36, 38, 5, -36 },
  { 4882, 29, 36, 27, -1, -36 },
  { 5013, 24, 36, 26, 5, -36 },
  { 5121, 27, 36, 26, 0, -36 },
  { 5243, 15, 49, 11, 0, -41 },
  { 5335, 8, 39, 17, 5, -36 },
  { 5374, 15, 49, 11, -3, -41 },
  { 5466, 15, 18, 18, 2, -36 },
  { 5500, 19, 3, 19, -3, 0 },
  { 5508, 7, 7, 14, 6, -38 },
  { 5515, 20, 27, 23, 1, -27 },
  { 5583, 21, 38, 24, 1, -38 },
  { 5683, 19, 27, 22, 2, -27 },
  { 5748, 23, 38, 24, 2, -38 },
  { 5858, 19, 27, 23, 2, -27 },
  { 5923, 16, 39, 15, 3, -39 },
  { 6001, 23, 37, 24, 0, -27 },
  { 6108, 20, 38, 24, 1, -38 },
  { 6203, 10, 37, 10, 1, -37 },
  { 6250, 16, 47, 11, -6, -37 },
  { 6344, 21, 38, 21, 1, -38 },
  { 6444, 10, 38, 10, 1, -38 },
  { 6492, 34, 27, 38, 1, -27 },
  { 6607, 20, 27, 24, 1, -27 },
  { 6675, 20, 27, 24, 2, -27 },
  { 6743, 23, 37, 24, -1, -27 },
  { 6850, 21, 37, 24, 2, -27 },
  { 6948, 15, 27, 15, 1, -27 },
  { 6999, 19, 27, 22, 1, -27 },
  { 7064, 11, 34, 14, 3, -34 },
  { 7111, 19, 27, 24, 3, -27 },
  { 7176, 19, 27, 21, 3, -27 },
  { 7241, 29, 27, 32, 4, -27 },
  { 7339, 22, 27, 21, -1, -27 },
  { 7414, 24, 37, 21, -2, -27 },
  { 7525, 21, 27, 21, 0, -27 },
  { 7596, 15, 50, 15, 2, -40 },
  { 7690, 9, 43, 11, 1, -36 },
  { 7739, 16, 50, 15, -3, -40 },
  { 7839, 24, 9, 29, 3, -19 },
};

const GFXfont RobotoCondensed_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC51PT7B_H_
