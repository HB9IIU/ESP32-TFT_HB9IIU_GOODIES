#ifndef _ROBOTOCONDENSED_LIGHTITALIC50PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x78, 0x3C, 0x0C, 0x00, 0x31, 0xCC, 0x73, 0x1D, 0xC6, 0x71,
  0x98, 0x66, 0x19, 0x8E, 0x63, 0x38, 0xCC, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x38, 0x00,
  0x30, 0x30, 0x00, 0x70, 0x30, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00,
  0xE0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01,
  0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x06,
  0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xC0, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xE3, 0x00, 0x03,
  0x83, 0x00, 0x06, 0x06, 0x01, 0x1C, 0x0C, 0x03, 0x30, 0x18, 0x0C, 0x60,
  0x30, 0x38, 0xC0, 0x60, 0x61, 0x80, 0xC1, 0x83, 0x01, 0x87, 0x06, 0x03,
  0x1C, 0x0C, 0x0E, 0x30, 0x1C, 0x18, 0xE0, 0x1C, 0xE3, 0x80, 0x3F, 0xC6,
  0x00, 0x1E, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x0F,
  0x80, 0x0E, 0x3F, 0x80, 0x38, 0xE3, 0x80, 0x63, 0x83, 0x01, 0xC6, 0x06,
  0x07, 0x1C, 0x0C, 0x0C, 0x30, 0x18, 0x30, 0x60, 0x38, 0xE0, 0xC0, 0x61,
  0x81, 0x80, 0xC6, 0x03, 0x01, 0x9C, 0x06, 0x03, 0x30, 0x0C, 0x0E, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x70, 0x03, 0x81,
  0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x03, 0x0F, 0x00, 0x0E,
  0x78, 0x00, 0x3B, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x1C, 0xE0, 0xE0, 0x77,
  0x83, 0x81, 0x9C, 0x07, 0x06, 0xE0, 0x0E, 0x3B, 0x80, 0x38, 0xCE, 0x00,
  0x77, 0x30, 0x01, 0xDC, 0xC0, 0x03, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0x70, 0x07, 0xE1, 0xF0, 0x7B, 0x83, 0xFF, 0xC7, 0x03,
  0xFC, 0x1C, 0x01, 0x00, 0x00, 0x77, 0x76, 0x66, 0xEE, 0xCC, 0xC0, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x10, 0x18, 0x1F, 0xC3, 0x1F, 0xFE, 0xEF, 0xE3, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x03, 0x8E,
  0x00, 0xE1, 0xC0, 0x3C, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x38, 0x10, 0x04,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8E,
  0x1C, 0x71, 0xC1, 0x00, 0x7F, 0xDF, 0xFF, 0xFC, 0x7F, 0xF6, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x0C, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x1B,
  0x80, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x76,
  0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x01, 0x8C,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x3C, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1,
  0xFE, 0x7E, 0x67, 0x8E, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x07, 0x00,
  0xE0, 0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xE0, 0x01,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x70, 0x78, 0x0E, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D,
  0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00,
  0x61, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x07, 0x00, 0x38, 0x38,
  0x03, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x7C, 0x00, 0x6F, 0xF8, 0x03, 0xFF, 0xE0, 0x1E,
  0x07, 0x81, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC1,
  0x80, 0x1C, 0x0E, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0xF8, 0x0C, 0xFF, 0x87,
  0x7F, 0xF1, 0xF8, 0x1C, 0x78, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0x71, 0xC0, 0x38, 0x78, 0x1C, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x78, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x0F,
  0x00, 0xE0, 0x78, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xC1, 0xE0, 0x1E, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x38,
  0x60, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1C, 0x1C, 0x03, 0x8E, 0x00, 0xE7,
  0x00, 0x19, 0xC0, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x79, 0xC0, 0x3E, 0x78, 0x1F, 0x8F, 0xFE, 0xC1,
  0xFF, 0x70, 0x3F, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x0E, 0x0F, 0x0F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x20, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C,
  0x1E, 0x38, 0x0E, 0x70, 0x06, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60,
  0x70, 0x07, 0xC0, 0x18, 0x38, 0x07, 0xFC, 0x06, 0x0C, 0x03, 0xC7, 0x81,
  0x87, 0x01, 0xC0, 0xE0, 0x61, 0x80, 0xE0, 0x38, 0x0C, 0xE0, 0x30, 0x0C,
  0x03, 0x38, 0x1C, 0x03, 0x00, 0xCC, 0x06, 0x00, 0xC0, 0x77, 0x01, 0x80,
  0x70, 0x19, 0xC0, 0xE0, 0x18, 0x06, 0x60, 0x30, 0x06, 0x01, 0x98, 0x0C,
  0x01, 0x80, 0x6E, 0x07, 0x00, 0xE0, 0x1B, 0x81, 0xC0, 0x38, 0x06, 0xC0,
  0x60, 0x0C, 0x03, 0xB0, 0x18, 0x03, 0x00, 0xCC, 0x06, 0x00, 0xC0, 0x33,
  0x01, 0x80, 0x70, 0x0C, 0xC0, 0x60, 0x1C, 0x06, 0x30, 0x18, 0x0E, 0x01,
  0x8C, 0x06, 0x03, 0x80, 0xC3, 0x01, 0x81, 0xF0, 0x30, 0xC0, 0x70, 0xCC,
  0x18, 0x30, 0x1F, 0xE3, 0xFC, 0x0C, 0x03, 0xF0, 0x7E, 0x03, 0x80, 0x30,
  0x04, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x18, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x38,
  0x03, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00,
  0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x78,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xC0, 0x0F, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x70,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x07,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x00,
  0x3C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x60, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x1E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x0F, 0xFC, 0x70, 0x0F, 0xFC, 0x60, 0x0F,
  0xFC, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x3C, 0x03,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x78, 0x1E, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x03, 0xC1,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x01,
  0xE0, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0C,
  0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x73, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x06, 0x7C, 0x00, 0x01, 0xBF, 0x80, 0x00, 0xFC, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xC0,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xB0, 0x00, 0x07, 0xE0,
  0x6C, 0x00, 0x01, 0xF8, 0x3B, 0x00, 0x00, 0xEE, 0x0E, 0xE0, 0x00, 0x3B,
  0x03, 0xB8, 0x00, 0x1C, 0xC0, 0xEE, 0x00, 0x07, 0x70, 0x31, 0x80, 0x03,
  0x9C, 0x0C, 0x60, 0x00, 0xE7, 0x07, 0x18, 0x00, 0x71, 0xC1, 0xC7, 0x00,
  0x1C, 0x60, 0x71, 0xC0, 0x0E, 0x38, 0x1C, 0x70, 0x03, 0x8E, 0x06, 0x0C,
  0x01, 0xC3, 0x81, 0x83, 0x00, 0x70, 0xE0, 0xE0, 0xC0, 0x38, 0x30, 0x38,
  0x38, 0x0E, 0x0C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x18, 0x38, 0x1C, 0x1C, 0x06, 0x1C, 0x06,
  0x07, 0x01, 0xC7, 0x01, 0x81, 0xC0, 0x73, 0x80, 0xE0, 0x70, 0x1C, 0xE0,
  0x38, 0x18, 0x03, 0x70, 0x0E, 0x0E, 0x00, 0xDC, 0x03, 0x83, 0x80, 0x3E,
  0x00, 0xC0, 0xE0, 0x0F, 0x80, 0x70, 0x38, 0x03, 0xC0, 0x1C, 0x0E, 0x00,
  0xF0, 0x07, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0xF0,
  0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x0E,
  0x0F, 0x80, 0x01, 0xC1, 0xB8, 0x00, 0x30, 0x77, 0x00, 0x0E, 0x0E, 0x60,
  0x01, 0xC1, 0xCE, 0x00, 0x38, 0x39, 0xC0, 0x07, 0x07, 0x1C, 0x00, 0xE0,
  0xC3, 0x80, 0x18, 0x38, 0x30, 0x07, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0xE0,
  0x1C, 0x1C, 0x0C, 0x03, 0x83, 0x81, 0xC0, 0x60, 0xE0, 0x38, 0x0C, 0x1C,
  0x03, 0x03, 0x83, 0x80, 0x70, 0x70, 0x70, 0x0E, 0x0E, 0x0E, 0x00, 0xC1,
  0xC1, 0x80, 0x1C, 0x30, 0x70, 0x03, 0x8E, 0x0E, 0x00, 0x39, 0xC1, 0xC0,
  0x07, 0x38, 0x38, 0x00, 0x67, 0x07, 0x00, 0x0E, 0xE0, 0xC0, 0x01, 0xD8,
  0x38, 0x00, 0x1F, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7C, 0x1C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x18, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x07, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0x80, 0x1E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x0C, 0x00, 0x78, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x3C, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x30, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x70, 0x00, 0x18,
  0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x0E, 0xE0, 0x03, 0xE0,
  0x03, 0xB8, 0x00, 0xF8, 0x01, 0xCE, 0x00, 0x76, 0x00, 0x73, 0x80, 0x19,
  0x80, 0x1C, 0xE0, 0x06, 0x60, 0x0E, 0x38, 0x03, 0x98, 0x03, 0x8E, 0x00,
  0xC6, 0x00, 0xE1, 0x80, 0x71, 0x80, 0x70, 0x60, 0x1C, 0x60, 0x1C, 0x18,
  0x06, 0x18, 0x06, 0x06, 0x03, 0x86, 0x03, 0x81, 0x80, 0xC1, 0xC0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x18, 0x1C, 0x1C, 0x1C, 0x07, 0x06, 0x07, 0x07,
  0x01, 0xC3, 0x81, 0xC1, 0x80, 0x70, 0xC0, 0x30, 0xE0, 0x1C, 0x30, 0x0C,
  0x38, 0x07, 0x1C, 0x03, 0x0C, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0x73, 0x80,
  0x31, 0xC0, 0x1C, 0xC0, 0x0C, 0xE0, 0x07, 0x30, 0x03, 0x38, 0x01, 0xDC,
  0x00, 0xCC, 0x00, 0x76, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF3, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0xE0, 0x01, 0x83, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30,
  0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x06,
  0x06, 0x07, 0x07, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x00, 0xCE, 0x07, 0x38, 0x18, 0x60,
  0xE1, 0x83, 0x06, 0x1C, 0x18, 0x60, 0x73, 0x81, 0xCC, 0x07, 0x70, 0x0D,
  0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF0, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03,
  0x80, 0xE0, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0x83, 0x8F, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x1F, 0x1C, 0x0F, 0xC3, 0xFF,
  0xD8, 0x3F, 0xE3, 0x03, 0xF0, 0x60, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x3F, 0x00, 0xE7, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x0E, 0x0F, 0x00,
  0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80,
  0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38,
  0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x80, 0x38, 0x6C, 0x07, 0x8E, 0xFF, 0xF0,
  0xE7, 0xFE, 0x0E, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x0F, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x33, 0x80, 0x06,
  0x70, 0x00, 0xCC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x73,
  0x00, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x1C, 0x07, 0x81,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x01, 0xF8, 0x70, 0x1F, 0xF9, 0xC0, 0xFF, 0xF7,
  0x07, 0x80, 0xD8, 0x1C, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x60,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x01, 0xC0, 0x1C, 0x07, 0x01, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF7,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x38,
  0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x0D, 0xC0, 0x03, 0x70, 0x00,
  0xD8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0x87, 0x80, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x08, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x0C, 0x07, 0xFE, 0x70, 0x3F,
  0xFD, 0xC1, 0xE0, 0x37, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x06,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x18, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x7C, 0x03, 0xFF, 0xF0, 0x0F,
  0xFD, 0xC0, 0x0F, 0xC7, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xF0, 0x1E, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE1, 0xF0, 0x1C, 0xFF, 0x83, 0xBF, 0xF0, 0x7E, 0x0F, 0x0F, 0x00,
  0xE3, 0xC0, 0x1C, 0x78, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x00,
  0xC6, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03,
  0x18, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E,
  0x70, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x06, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x07,
  0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0x67, 0x00, 0x07, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x00,
  0x0F, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x70, 0x18, 0x03, 0x81,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x00, 0x0E, 0x3F, 0x00, 0xFC, 0x07, 0x3F, 0xC1, 0xFF, 0x03,
  0xBF, 0xF1, 0xFF, 0xC1, 0xF0, 0x3D, 0xC0, 0xE0, 0xF0, 0x0E, 0xC0, 0x38,
  0xF0, 0x07, 0xC0, 0x1C, 0x78, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0xE0, 0x07,
  0x1C, 0x00, 0x70, 0x03, 0x8E, 0x00, 0x70, 0x01, 0xC6, 0x00, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x00, 0x31, 0xC0, 0x07, 0x00,
  0x18, 0xE0, 0x03, 0x00, 0x1C, 0x60, 0x03, 0x80, 0x0E, 0x30, 0x01, 0xC0,
  0x07, 0x38, 0x00, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0x01, 0x8E, 0x00, 0x30,
  0x00, 0xC7, 0x00, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x00, 0x73, 0x80, 0x0E,
  0x00, 0x39, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0x03, 0x80, 0x0C, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x0E, 0x1F, 0x01, 0xCF, 0xF8, 0x3B, 0xFF, 0x07, 0xE0,
  0xF0, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00,
  0x63, 0x80, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0x81, 0xE1, 0xC0, 0x1C, 0x78, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x07,
  0x70, 0x00, 0x6E, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x01, 0xC6, 0x00, 0x38, 0xE0, 0x0E, 0x1E, 0x03, 0x81,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x8F, 0xC0, 0x0E, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xF8, 0x0E, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60,
  0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x78, 0x03, 0x81, 0xB0, 0x1E, 0x0E, 0xFF,
  0xF0, 0x39, 0xFF, 0x80, 0xE1, 0xF8, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8,
  0x70, 0x7F, 0xE7, 0x0F, 0xFF, 0x71, 0xE0, 0x37, 0x1C, 0x01, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x60,
  0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x87, 0x00, 0x70, 0x70, 0x1F, 0x03, 0xFF, 0xF0, 0x3F, 0xF7,
  0x00, 0xFC, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x3E, 0x1D, 0xFC, 0x3F, 0xF0, 0x7E, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E, 0x1E, 0x03, 0x81,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x07, 0xFF, 0x7F, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x1C, 0x30, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x86, 0x00, 0x70, 0x60,
  0x07, 0x07, 0x00, 0xF0, 0x78, 0x1F, 0x03, 0xFF, 0xF0, 0x3F, 0xE6, 0x00,
  0xFC, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x39, 0x80, 0x0E, 0x60,
  0x07, 0x18, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00,
  0xE3, 0x80, 0x18, 0xE0, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0xC0, 0x1E, 0x00, 0xEE,
  0x01, 0xE0, 0x0E, 0xE0, 0x1E, 0x01, 0xCE, 0x03, 0xE0, 0x1C, 0xE0, 0x36,
  0x01, 0x8E, 0x07, 0x70, 0x38, 0xE0, 0x67, 0x03, 0x0E, 0x0E, 0x70, 0x70,
  0xE0, 0xE7, 0x07, 0x0E, 0x0C, 0x30, 0x60, 0x61, 0xC3, 0x0E, 0x06, 0x18,
  0x30, 0xC0, 0x63, 0x83, 0x1C, 0x06, 0x30, 0x31, 0xC0, 0x67, 0x03, 0x18,
  0x06, 0x60, 0x33, 0x80, 0x6E, 0x03, 0x30, 0x06, 0xE0, 0x3F, 0x00, 0x6C,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x3C, 0x1C,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x07, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x31, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0,
  0x01, 0xC1, 0x80, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0xE0, 0x70, 0x01, 0x83, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0xC0, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x01, 0x9C, 0x00,
  0x03, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x0C, 0xFF, 0x80, 0x3B, 0x83, 0x80, 0x66, 0x03, 0x80, 0xDC, 0x03,
  0x83, 0xB0, 0x07, 0xFE, 0x60, 0x07, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 36, 10, 1, -36 },
  { 42, 10, 11, 14, 5, -38 },
  { 56, 24, 36, 25, 2, -36 },
  { 164, 20, 46, 24, 2, -41 },
  { 279, 23, 36, 31, 5, -36 },
  { 383, 22, 37, 26, 2, -36 },
  { 485, 4, 11, 8, 5, -38 },
  { 491, 15, 51, 14, 2, -40 },
  { 587, 15, 52, 14, -3, -40 },
  { 685, 19, 20, 21, 3, -36 },
  { 733, 20, 26, 24, 2, -29 },
  { 798, 7, 11, 9, -2, -5 },
  { 808, 10, 3, 13, 1, -17 },
  { 812, 4, 4, 12, 1, -4 },
  { 814, 21, 39, 17, -2, -36 },
  { 917, 19, 36, 24, 3, -36 },
  { 1003, 12, 36, 24, 6, -36 },
  { 1057, 21, 36, 24, 1, -36 },
  { 1152, 20, 36, 24, 2, -36 },
  { 1242, 21, 36, 24, 1, -36 },
  { 1337, 21, 36, 24, 3, -36 },
  { 1432, 18, 36, 24, 3, -36 },
  { 1513, 20, 36, 24, 4, -36 },
  { 1603, 22, 36, 24, 1, -36 },
  { 1702, 18, 36, 24, 4, -36 },
  { 1783, 8, 27, 10, 1, -27 },
  { 1810, 11, 33, 9, -2, -27 },
  { 1856, 19, 21, 22, 2, -27 },
  { 1906, 19, 13, 23, 3, -23 },
  { 1937, 19, 20, 22, 1, -26 },
  { 1985, 16, 36, 20, 4, -36 },
  { 2057, 34, 46, 38, 2, -35 },
  { 2253, 25, 36, 27, -2, -36 },
  { 2366, 23, 36, 26, 2, -36 },
  { 2470, 24, 36, 27, 3, -36 },
  { 2578, 24, 36, 28, 2, -36 },
  { 2686, 24, 36, 24, 2, -36 },
  { 2794, 24, 36, 24, 2, -36 },
  { 2902, 24, 36, 29, 3, -36 },
  { 3010, 27, 36, 30, 2, -36 },
  { 3132, 9, 36, 12, 2, -36 },
  { 3173, 22, 36, 23, 1, -36 },
  { 3272, 26, 36, 27, 2, -36 },
  { 3389, 17, 36, 23, 2, -36 },
  { 3466, 34, 36, 36, 2, -36 },
  { 3619, 27, 36, 30, 2, -36 },
  { 3741, 24, 36, 29, 3, -36 },
  { 3849, 24, 36, 26, 2, -36 },
  { 3957, 24, 42, 29, 3, -36 },
  { 4083, 24, 36, 27, 1, -36 },
  { 4191, 24, 36, 25, 1, -36 },
  { 4299, 22, 36, 25, 5, -36 },
  { 4398, 25, 36, 28, 3, -36 },
  { 4511, 25, 36, 26, 4, -36 },
  { 4624, 34, 36, 37, 5, -36 },
  { 4777, 29, 36, 26, -1, -36 },
  { 4908, 23, 36, 25, 5, -36 },
  { 5012, 26, 36, 25, 0, -36 },
  { 5129, 15, 49, 11, 0, -41 },
  { 5221, 8, 39, 17, 5, -36 },
  { 5260, 14, 49, 11, -3, -41 },
  { 5346, 14, 18, 18, 2, -36 },
  { 5378, 18, 3, 19, -2, 0 },
  { 5385, 7, 7, 14, 6, -38 },
  { 5392, 19, 26, 23, 1, -26 },
  { 5454, 20, 38, 24, 1, -38 },
  { 5549, 19, 26, 22, 2, -26 },
  { 5611, 22, 38, 24, 2, -38 },
  { 5716, 18, 26, 22, 2, -26 },
  { 5775, 15, 39, 15, 3, -39 },
  { 5849, 22, 36, 24, 0, -26 },
  { 5948, 19, 38, 23, 1, -38 },
  { 6039, 9, 36, 10, 1, -36 },
  { 6080, 16, 46, 10, -6, -36 },
  { 6172, 21, 38, 21, 1, -38 },
  { 6272, 9, 38, 10, 1, -38 },
  { 6315, 33, 26, 37, 1, -26 },
  { 6423, 19, 26, 23, 1, -26 },
  { 6485, 19, 26, 24, 2, -26 },
  { 6547, 22, 36, 24, -1, -26 },
  { 6646, 20, 36, 24, 2, -26 },
  { 6736, 15, 26, 15, 1, -26 },
  { 6785, 19, 26, 22, 1, -26 },
  { 6847, 12, 33, 14, 2, -33 },
  { 6897, 20, 26, 23, 2, -26 },
  { 6962, 18, 26, 21, 3, -26 },
  { 7021, 28, 26, 32, 4, -26 },
  { 7112, 22, 26, 21, -1, -26 },
  { 7184, 23, 36, 20, -2, -26 },
  { 7288, 20, 26, 21, 0, -26 },
  { 7353, 15, 49, 14, 2, -39 },
  { 7445, 9, 43, 11, 1, -36 },
  { 7494, 16, 49, 14, -3, -39 },
  { 7592, 23, 9, 29, 3, -19 },
};

const GFXfont RobotoCondensed_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC50PT7B_H_
