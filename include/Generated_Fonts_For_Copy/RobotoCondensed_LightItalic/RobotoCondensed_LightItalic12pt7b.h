#ifndef _ROBOTOCONDENSED_LIGHTITALIC12PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x54, 0x80, 0xB6, 0x00, 0x14, 0x57, 0xCA, 0x28, 0xAF, 0x94,
  0x50, 0x11, 0xD2, 0x94, 0x18, 0x31, 0x8B, 0x88, 0x62, 0xAA, 0xB4, 0x20,
  0xE5, 0x65, 0x18, 0x38, 0xA2, 0x8C, 0x21, 0x59, 0xA2, 0x78, 0xE0, 0x29,
  0x49, 0x24, 0x92, 0x48, 0x21, 0x11, 0x11, 0x11, 0x22, 0x24, 0x80, 0x22,
  0xF6, 0xA0, 0x10, 0x84, 0xF2, 0x10, 0x80, 0xE0, 0xE0, 0x80, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x10, 0x41, 0x00, 0x79, 0x99, 0x99, 0x99, 0xE0, 0x75,
  0x5A, 0x80, 0x3A, 0x52, 0x11, 0x08, 0x88, 0xF8, 0x3A, 0x42, 0x13, 0x04,
  0x31, 0x70, 0x08, 0x46, 0x54, 0xAB, 0xE2, 0x10, 0x7A, 0x21, 0xC1, 0x08,
  0x52, 0xE0, 0x34, 0x8E, 0x99, 0x99, 0xE0, 0xF8, 0x84, 0x42, 0x21, 0x10,
  0x80, 0x3A, 0x52, 0x93, 0x26, 0x31, 0x70, 0x79, 0x99, 0x9F, 0x12, 0xC0,
  0x40, 0x20, 0x40, 0x2A, 0x09, 0xB0, 0xC1, 0x00, 0xF0, 0x0F, 0x41, 0x82,
  0x6C, 0x00, 0x69, 0x11, 0x24, 0x40, 0x80, 0x1E, 0x10, 0x90, 0x29, 0x95,
  0x4D, 0x26, 0x95, 0x3C, 0x80, 0x20, 0x0E, 0x00, 0x10, 0x62, 0x8A, 0x29,
  0xE4, 0xA1, 0x84, 0x39, 0x14, 0x51, 0x79, 0x24, 0x62, 0xF0, 0x3A, 0x63,
  0x08, 0x42, 0x32, 0xE0, 0x39, 0x14, 0x51, 0x45, 0x14, 0x62, 0xF0, 0x3D,
  0x04, 0x10, 0x79, 0x04, 0x20, 0xF8, 0x3D, 0x04, 0x10, 0x79, 0x04, 0x20,
  0x80, 0x39, 0x28, 0x60, 0x9A, 0x28, 0xA2, 0x70, 0x22, 0x85, 0x0A, 0x17,
  0xC8, 0x91, 0x42, 0x84, 0x25, 0x24, 0x92, 0x80, 0x04, 0x20, 0x82, 0x08,
  0x20, 0xA4, 0x60, 0x24, 0x89, 0x22, 0x86, 0x0A, 0x14, 0x44, 0x88, 0x22,
  0x10, 0x84, 0x21, 0x10, 0xF8, 0x21, 0x90, 0x98, 0xCC, 0x65, 0x52, 0xA9,
  0x65, 0x32, 0x92, 0x00, 0x22, 0x45, 0x4A, 0x95, 0x49, 0x93, 0x46, 0x84,
  0x3A, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x3D, 0x14, 0x51, 0x79, 0x04, 0x20,
  0x80, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0xF0, 0x84, 0x39, 0x14, 0x51, 0x79,
  0x24, 0xA2, 0x88, 0x39, 0x14, 0x50, 0x30, 0x28, 0xA2, 0x70, 0xFC, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x40, 0x86, 0x18, 0xA2, 0x8A, 0x28, 0xA4, 0xE0,
  0x86, 0x28, 0xA4, 0x91, 0x46, 0x18, 0x40, 0x89, 0x99, 0x99, 0xAA, 0xAA,
  0xAA, 0xCC, 0x44, 0x84, 0x44, 0x48, 0xA1, 0x81, 0x06, 0x12, 0x24, 0x88,
  0x86, 0x25, 0x14, 0x60, 0x84, 0x10, 0x40, 0x7C, 0x10, 0x84, 0x10, 0x84,
  0x10, 0xF8, 0x29, 0x24, 0x92, 0x92, 0x60, 0xAA, 0x55, 0x50, 0x31, 0x12,
  0x22, 0x22, 0x24, 0x4C, 0x4A, 0xD0, 0xF8, 0x50, 0x32, 0x42, 0xF8, 0xC9,
  0xC0, 0x22, 0x1E, 0x94, 0xA6, 0x31, 0xF0, 0x32, 0x61, 0x08, 0x45, 0xC0,
  0x04, 0x13, 0x52, 0x4A, 0x28, 0xA4, 0x70, 0x32, 0x63, 0xF8, 0x41, 0xC0,
  0x6B, 0xC9, 0x24, 0x80, 0x3A, 0x53, 0x18, 0xC9, 0xC2, 0xE0, 0x22, 0x1E,
  0x94, 0xA6, 0x31, 0x90, 0x05, 0x56, 0x80, 0x00, 0x92, 0x52, 0x4A, 0x00,
  0x22, 0x12, 0xA6, 0x32, 0x92, 0x90, 0x29, 0x24, 0x94, 0x80, 0x7F, 0x49,
  0x49, 0x49, 0x89, 0x89, 0x91, 0x7A, 0x52, 0x98, 0xC6, 0x40, 0x32, 0x53,
  0x18, 0xC5, 0xC0, 0x7A, 0x53, 0x18, 0xC7, 0xD0, 0x80, 0x3A, 0x53, 0x18,
  0xC9, 0xC2, 0x10, 0x74, 0x44, 0x88, 0x80, 0x32, 0x50, 0x41, 0x49, 0xC0,
  0x7A, 0xAA, 0x99, 0x99, 0x9A, 0xE0, 0x99, 0xAA, 0xCC, 0x80, 0x93, 0x6A,
  0xD6, 0xAD, 0x93, 0x24, 0x00, 0x4A, 0x88, 0x46, 0x2A, 0x40, 0x4A, 0x54,
  0xA6, 0x31, 0x08, 0x80, 0x78, 0x84, 0x44, 0x23, 0xC0, 0x12, 0x22, 0x4C,
  0x44, 0x44, 0x40, 0x55, 0x56, 0xA8, 0x21, 0x12, 0x21, 0x22, 0x24, 0x80,
  0xCD, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 0, -9 },
  { 4, 3, 3, 3, 1, -9 },
  { 6, 6, 9, 6, 0, -9 },
  { 13, 5, 11, 6, 0, -10 },
  { 20, 6, 9, 7, 1, -9 },
  { 27, 6, 9, 6, 0, -9 },
  { 34, 1, 3, 2, 1, -9 },
  { 35, 3, 13, 3, 1, -10 },
  { 40, 4, 13, 3, -1, -10 },
  { 47, 4, 5, 5, 1, -9 },
  { 50, 5, 7, 6, 0, -8 },
  { 55, 1, 3, 2, 0, -1 },
  { 56, 3, 1, 3, 0, -4 },
  { 57, 1, 1, 3, 0, -1 },
  { 58, 6, 10, 4, -1, -9 },
  { 66, 4, 9, 6, 1, -9 },
  { 71, 2, 9, 6, 2, -9 },
  { 74, 5, 9, 6, 0, -9 },
  { 80, 5, 9, 6, 0, -9 },
  { 86, 5, 9, 6, 0, -9 },
  { 92, 5, 9, 6, 1, -9 },
  { 98, 4, 9, 6, 1, -9 },
  { 103, 5, 9, 6, 1, -9 },
  { 109, 5, 9, 6, 0, -9 },
  { 115, 4, 9, 6, 1, -9 },
  { 120, 2, 6, 2, 0, -6 },
  { 122, 2, 8, 2, 0, -6 },
  { 124, 5, 5, 5, 0, -6 },
  { 128, 4, 4, 6, 1, -6 },
  { 130, 5, 5, 5, 0, -6 },
  { 134, 4, 9, 5, 1, -9 },
  { 139, 9, 11, 9, 0, -8 },
  { 152, 6, 9, 6, 0, -9 },
  { 159, 6, 9, 6, 0, -9 },
  { 166, 5, 9, 7, 1, -9 },
  { 172, 6, 9, 7, 0, -9 },
  { 179, 6, 9, 6, 0, -9 },
  { 186, 6, 9, 6, 0, -9 },
  { 193, 6, 9, 7, 1, -9 },
  { 200, 7, 9, 7, 0, -9 },
  { 208, 3, 9, 3, 0, -9 },
  { 212, 6, 9, 6, 0, -9 },
  { 219, 7, 9, 6, 0, -9 },
  { 227, 5, 9, 5, 0, -9 },
  { 233, 9, 9, 9, 0, -9 },
  { 244, 7, 9, 7, 0, -9 },
  { 252, 5, 9, 7, 1, -9 },
  { 258, 6, 9, 6, 0, -9 },
  { 265, 5, 11, 7, 1, -9 },
  { 272, 6, 9, 6, 0, -9 },
  { 279, 6, 9, 6, 0, -9 },
  { 286, 6, 9, 6, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 6, 9, 6, 1, -9 },
  { 307, 8, 9, 9, 1, -9 },
  { 316, 7, 9, 6, 0, -9 },
  { 324, 6, 9, 6, 1, -9 },
  { 331, 6, 9, 6, 0, -9 },
  { 338, 3, 12, 3, 0, -10 },
  { 343, 2, 10, 4, 1, -9 },
  { 346, 4, 12, 3, -1, -10 },
  { 352, 3, 4, 4, 1, -9 },
  { 354, 5, 1, 4, -1, 0 },
  { 355, 2, 2, 3, 1, -9 },
  { 356, 5, 7, 5, 0, -7 },
  { 361, 5, 9, 6, 0, -9 },
  { 367, 5, 7, 5, 0, -7 },
  { 372, 6, 9, 6, 0, -9 },
  { 379, 5, 7, 5, 0, -7 },
  { 384, 3, 9, 4, 1, -9 },
  { 388, 5, 9, 6, 0, -7 },
  { 394, 5, 9, 6, 0, -9 },
  { 400, 2, 9, 2, 0, -9 },
  { 403, 3, 11, 2, -1, -9 },
  { 408, 5, 9, 5, 0, -9 },
  { 414, 3, 9, 2, 0, -9 },
  { 418, 8, 7, 9, 0, -7 },
  { 425, 5, 7, 6, 0, -7 },
  { 430, 5, 7, 6, 0, -7 },
  { 435, 5, 9, 6, 0, -7 },
  { 441, 5, 9, 6, 0, -7 },
  { 447, 4, 7, 4, 0, -7 },
  { 451, 5, 7, 5, 0, -7 },
  { 456, 2, 8, 3, 1, -8 },
  { 458, 4, 7, 6, 1, -7 },
  { 462, 4, 7, 5, 1, -7 },
  { 466, 7, 7, 8, 1, -7 },
  { 473, 5, 7, 5, 0, -7 },
  { 478, 5, 9, 5, 0, -7 },
  { 484, 5, 7, 5, 0, -7 },
  { 489, 4, 11, 3, 0, -9 },
  { 495, 2, 11, 3, 0, -9 },
  { 498, 4, 11, 3, -1, -9 },
  { 504, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC12PT7B_H_
