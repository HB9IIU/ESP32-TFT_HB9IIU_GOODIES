#ifndef _ROBOTOCONDENSED_LIGHTITALIC43PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x31, 0x98, 0xCC, 0xEE,
  0x66, 0x33, 0x19, 0x8C, 0xC6, 0x66, 0x23, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x01, 0x81, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x40, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1E,
  0x3C, 0x1C, 0x06, 0x0C, 0x03, 0x8E, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x73, 0x80, 0x70, 0xE0, 0x78, 0x78, 0xF8, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0x31, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x4C, 0x0C, 0x0C,
  0xC0, 0xC1, 0x8C, 0x0C, 0x30, 0xC0, 0xC3, 0x0C, 0x0C, 0x60, 0xC1, 0x8C,
  0x06, 0x38, 0xC0, 0x7F, 0x18, 0x03, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x78, 0x01, 0x8F, 0xC0, 0x31, 0x86, 0x06,
  0x38, 0x60, 0x63, 0x03, 0x0C, 0x30, 0x31, 0x83, 0x03, 0x18, 0x30, 0x33,
  0x02, 0x06, 0x60, 0x30, 0x62, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0x1C, 0x01, 0xC1,
  0x80, 0x30, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x06, 0x07,
  0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x01, 0x9C, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x03, 0x8C, 0x0C, 0xE1, 0xC1,
  0x98, 0x18, 0x37, 0x03, 0x8E, 0xC0, 0x39, 0x98, 0x07, 0x37, 0x00, 0x7C,
  0xE0, 0x07, 0x8C, 0x00, 0xE1, 0x80, 0x1C, 0x38, 0x07, 0xC3, 0xC3, 0xD8,
  0x3F, 0xE3, 0x81, 0xF0, 0x30, 0x37, 0x66, 0x66, 0xCC, 0xC0, 0x00, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x03, 0x06, 0x0D, 0xE3,
  0x1E, 0xFD, 0xFE, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0xE6, 0x00, 0xE1, 0x80, 0xE0, 0xE0, 0xE0, 0x30, 0x20, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x71,
  0xC7, 0x18, 0xE3, 0x1C, 0x61, 0x00, 0xFF, 0xFF, 0xC0, 0x4E, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0,
  0x60, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x06, 0x30, 0x03, 0x38, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x37, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0xEE, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0xE0, 0x0C, 0x70, 0x06, 0x18,
  0x06, 0x0E, 0x07, 0x03, 0x87, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x40,
  0x78, 0x3F, 0x1F, 0x67, 0x9C, 0xC3, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x78, 0x78,
  0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x18,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x38, 0x78, 0x1C, 0x0E,
  0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x0C, 0x60, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07, 0x18,
  0x01, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x3C, 0x38, 0x07, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x06, 0xE0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x0C, 0x70, 0x06, 0x1C, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x83, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xCF, 0x80, 0x3F, 0xF8, 0x0F, 0x9F, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x0E, 0x01, 0x81,
  0x80, 0xE0, 0x78, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x31, 0xF0, 0x37, 0xFC, 0x7E,
  0x1C, 0x7C, 0x0E, 0x78, 0x06, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0x60, 0x0E, 0x60,
  0x0C, 0x70, 0x1C, 0x30, 0x18, 0x3C, 0x78, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x3C, 0x78, 0x1C, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06,
  0x0E, 0x03, 0x01, 0xC3, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0x1E, 0x0E,
  0x01, 0x83, 0x00, 0x71, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x0C, 0xE0, 0x07, 0x18, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x70,
  0x3C, 0x3C, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x0E,
  0x1C, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x70, 0x07, 0x60, 0x07, 0x60,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0,
  0x06, 0x60, 0x0E, 0x60, 0x1E, 0x70, 0x3E, 0x38, 0xFC, 0x1F, 0xEC, 0x0F,
  0x8C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x0E, 0x1C, 0x38, 0x00, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C,
  0x0C, 0x04, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x08, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFF,
  0x00, 0x10, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x07, 0xC0, 0xFF, 0x0F, 0x3C, 0xE0, 0x66, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x18, 0x18, 0x07, 0xC0, 0x20, 0xC0, 0x7F, 0x80, 0x83, 0x03, 0x87,
  0x03, 0x18, 0x0C, 0x0C, 0x0C, 0x60, 0x60, 0x30, 0x33, 0x83, 0x81, 0x80,
  0xCC, 0x0C, 0x06, 0x03, 0x30, 0x30, 0x18, 0x08, 0xC1, 0x80, 0x60, 0x26,
  0x06, 0x01, 0x81, 0x98, 0x18, 0x0C, 0x06, 0x60, 0xE0, 0x30, 0x19, 0x83,
  0x00, 0xC0, 0x66, 0x0C, 0x03, 0x03, 0x18, 0x30, 0x18, 0x0C, 0x40, 0xC0,
  0x60, 0x21, 0x03, 0x03, 0x81, 0x84, 0x0C, 0x1E, 0x0C, 0x10, 0x38, 0xCC,
  0x70, 0x60, 0x7E, 0x3F, 0x81, 0x80, 0xF0, 0x78, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x07,
  0x03, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18,
  0x0E, 0x00, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x30, 0x01, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66,
  0x00, 0x03, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0x03, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x70, 0x60, 0x07, 0x0E,
  0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60,
  0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x18, 0x03, 0x81, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x60, 0x03, 0x86, 0x00, 0x70, 0x60, 0x1F, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x78, 0x0F, 0x00,
  0xE0, 0x60, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x18,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x71,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00,
  0xE0, 0x70, 0x0E, 0x01, 0xE1, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xC0, 0xF8, 0x0C, 0x01, 0xC0, 0x60,
  0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE1, 0xC0, 0x03, 0x0E, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E,
  0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0xE0, 0xC0,
  0x1E, 0x06, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xC3, 0xC0, 0xF0, 0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x33,
  0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x3F,
  0xEE, 0x03, 0xFE, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0x60,
  0x03, 0x87, 0x00, 0x78, 0x3C, 0x3F, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x06, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x38,
  0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C,
  0x18, 0x01, 0x83, 0x80, 0x70, 0x38, 0x1C, 0x07, 0x8F, 0x00, 0x7F, 0xC0,
  0x03, 0xE0, 0x00, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x80, 0xE0, 0x07,
  0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x61,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0D, 0xF0,
  0x00, 0x1F, 0x70, 0x00, 0x3C, 0x60, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0xC0,
  0x03, 0x81, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x18, 0x03, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0x60, 0x7C, 0x00, 0x1F, 0x83, 0xB0,
  0x00, 0x6E, 0x0C, 0xC0, 0x03, 0xB0, 0x33, 0x00, 0x0C, 0xC0, 0xCC, 0x00,
  0x73, 0x03, 0x38, 0x01, 0x8C, 0x1C, 0xE0, 0x0E, 0x70, 0x71, 0x80, 0x31,
  0xC1, 0x86, 0x01, 0xC6, 0x06, 0x18, 0x06, 0x18, 0x18, 0x60, 0x38, 0x60,
  0x61, 0x80, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x0C, 0x18, 0x38, 0x38,
  0x30, 0xE0, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x03, 0x1C, 0x0C, 0x0C, 0x0C,
  0x60, 0x70, 0x70, 0x3B, 0x81, 0xC1, 0xC0, 0x6C, 0x06, 0x06, 0x01, 0xF0,
  0x18, 0x18, 0x07, 0x80, 0x60, 0x60, 0x1E, 0x01, 0x81, 0x80, 0x70, 0x0E,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x07,
  0x80, 0x03, 0x07, 0x80, 0x07, 0x07, 0xC0, 0x07, 0x06, 0xC0, 0x06, 0x0E,
  0xC0, 0x06, 0x0E, 0xE0, 0x06, 0x0E, 0x60, 0x0E, 0x0C, 0x60, 0x0E, 0x0C,
  0x70, 0x0E, 0x0C, 0x30, 0x0C, 0x1C, 0x30, 0x0C, 0x1C, 0x38, 0x0C, 0x1C,
  0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x1C, 0x18, 0x0C, 0x18, 0x38,
  0x0E, 0x18, 0x38, 0x06, 0x18, 0x38, 0x06, 0x38, 0x30, 0x07, 0x38, 0x30,
  0x03, 0x38, 0x30, 0x03, 0x30, 0x70, 0x03, 0xB0, 0x70, 0x01, 0xB0, 0x60,
  0x01, 0xF0, 0x60, 0x01, 0xF0, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0,
  0x00, 0x60, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x78, 0x0F, 0x00,
  0xE0, 0x60, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x18,
  0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0xE0, 0x70, 0x0E, 0x01, 0xE1, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xC0, 0x7C, 0x0C, 0x00, 0xE0, 0x60,
  0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00,
  0x38, 0x70, 0x03, 0x83, 0x00, 0x78, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x18, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x38, 0x00, 0x19, 0xC0, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x33, 0x80, 0x03, 0x8C, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x01,
  0xE1, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xC0, 0x78, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x07,
  0x03, 0x00, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0E, 0x03, 0x00, 0x70,
  0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0xE0,
  0x70, 0x03, 0x03, 0x80, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE,
  0x00, 0xF8, 0x78, 0x0F, 0x01, 0xC0, 0x60, 0x07, 0x07, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x30, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC3, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0xF0, 0x0E, 0x03, 0xE1, 0xE0, 0x0F,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00,
  0x18, 0x70, 0x00, 0x61, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30,
  0x60, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xC0,
  0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0xC0, 0x01,
  0x86, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0E,
  0x00, 0x0C, 0x38, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x07, 0x00,
  0x38, 0x1E, 0x01, 0xC0, 0x3E, 0x3E, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x03,
  0x83, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0C, 0x03, 0x00, 0xE0, 0x18,
  0x06, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x80, 0x30, 0x18, 0x01, 0xC1, 0xC0,
  0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63,
  0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x6E, 0x00, 0x70, 0x03, 0xB8, 0x01,
  0xC0, 0x0E, 0xE0, 0x0F, 0x00, 0x31, 0x80, 0x34, 0x01, 0xC6, 0x01, 0xD8,
  0x06, 0x18, 0x06, 0x60, 0x18, 0x60, 0x19, 0x80, 0xE1, 0x80, 0xC6, 0x03,
  0x06, 0x03, 0x18, 0x0C, 0x18, 0x1C, 0x60, 0x70, 0x60, 0x61, 0x81, 0x81,
  0x81, 0x86, 0x06, 0x06, 0x0C, 0x18, 0x38, 0x18, 0x30, 0x60, 0xC0, 0x60,
  0xC1, 0x83, 0x01, 0x86, 0x06, 0x1C, 0x06, 0x18, 0x18, 0x60, 0x18, 0xE0,
  0x33, 0x80, 0x63, 0x00, 0xCC, 0x01, 0xCC, 0x03, 0x30, 0x07, 0x60, 0x0D,
  0xC0, 0x1D, 0x80, 0x36, 0x00, 0x7E, 0x00, 0xD8, 0x00, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x06, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0x60, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0x83, 0x00, 0x38,
  0x30, 0x07, 0x03, 0x80, 0x60, 0x38, 0x0E, 0x01, 0x81, 0xC0, 0x18, 0x1C,
  0x01, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0xE0, 0x00, 0xEC,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xFC, 0x0F, 0xC0, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83,
  0x06, 0x0C, 0x01, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x0E, 0x60, 0xC6, 0x1C,
  0x61, 0x86, 0x38, 0x63, 0x06, 0x70, 0x36, 0x03, 0xE0, 0x30, 0xFF, 0xFE,
  0xFF, 0xFE, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0x0E, 0x1C, 0x07, 0x18, 0x03, 0x38, 0x03, 0x38, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x03, 0xFE, 0x1F, 0xFE, 0x3C, 0x06, 0x70, 0x06, 0x60,
  0x0E, 0xE0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xE0, 0x1C, 0xE0, 0x3C, 0x71,
  0xEC, 0x7F, 0xCC, 0x1F, 0x0C, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x3E, 0x03, 0x7F, 0x83, 0xF1, 0xE1, 0xE0, 0x38, 0xE0, 0x1C, 0x60,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x03,
  0x98, 0x01, 0x8E, 0x01, 0xCF, 0x80, 0xE7, 0xE1, 0xE3, 0x3F, 0xE1, 0x87,
  0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0x83, 0x80, 0xE1, 0x80, 0x31,
  0xC0, 0x18, 0xC0, 0x0E, 0x60, 0x07, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x07, 0x18, 0x03, 0x0E, 0x03, 0x83, 0x87, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x7C, 0x30, 0x3F, 0xE6, 0x0F, 0x0D, 0xC3, 0x80, 0xF8, 0x60, 0x0E, 0x1C,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x70, 0x0E, 0x0E, 0x03, 0xC0, 0xF1,
  0xF8, 0x0F, 0xF6, 0x00, 0xF8, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xC3,
  0x83, 0x80, 0xE1, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0xE0, 0x06, 0x70,
  0x03, 0x30, 0x01, 0x9F, 0xFF, 0xCF, 0xFF, 0xE6, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x01,
  0x83, 0xC3, 0xC0, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x60, 0x7F, 0xCC, 0x1E, 0x1B, 0x87, 0x01,
  0xE0, 0xE0, 0x1C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07,
  0x0C, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xE0, 0x1C,
  0x1C, 0x07, 0x81, 0xE3, 0xF0, 0x1F, 0xEC, 0x01, 0xF1, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x20, 0x0E, 0x0E, 0x03, 0x80,
  0xF0, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x3E, 0x03, 0x7F, 0x83, 0xF1, 0xE1, 0xE0, 0x70, 0xE0,
  0x18, 0x70, 0x0C, 0x30, 0x07, 0x18, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x18, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x02, 0x78, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0xC0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x06, 0x0E, 0x01, 0x87, 0x00, 0x63, 0x80, 0x19, 0xC0, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xDE, 0x00, 0x3F, 0x80, 0x0E, 0x60, 0x07, 0x1C, 0x01,
  0xC3, 0x00, 0x60, 0xE0, 0x18, 0x18, 0x06, 0x07, 0x01, 0x80, 0xC0, 0xE0,
  0x38, 0x38, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0x03, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60,
  0x60, 0x60, 0xE0, 0xC0, 0x0C, 0x7C, 0x0F, 0xC1, 0xDF, 0xE1, 0xFE, 0x1F,
  0x8F, 0x38, 0xF1, 0xE0, 0x76, 0x07, 0x1C, 0x03, 0xC0, 0x31, 0xC0, 0x3C,
  0x03, 0x18, 0x03, 0x80, 0x33, 0x80, 0x38, 0x03, 0x38, 0x03, 0x00, 0x33,
  0x00, 0x30, 0x03, 0x30, 0x03, 0x00, 0x73, 0x00, 0x70, 0x07, 0x30, 0x07,
  0x00, 0x77, 0x00, 0x70, 0x06, 0x70, 0x06, 0x00, 0x66, 0x00, 0x60, 0x06,
  0x60, 0x06, 0x00, 0xE6, 0x00, 0xE0, 0x0E, 0xE0, 0x0E, 0x00, 0xEE, 0x00,
  0xC0, 0x0C, 0xE0, 0x0C, 0x00, 0xCC, 0x00, 0xC0, 0x0C, 0xC0, 0x0C, 0x01,
  0xC0, 0x0C, 0x7C, 0x06, 0xFF, 0x07, 0xE3, 0xC3, 0xC0, 0xE1, 0xC0, 0x30,
  0xE0, 0x18, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x03, 0x18, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x30, 0x03, 0xF0, 0x07, 0xFC, 0x0E, 0x1E, 0x1C, 0x06, 0x38, 0x07,
  0x30, 0x03, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0E, 0xE0, 0x1C, 0x60, 0x38, 0x78, 0x78, 0x3F, 0xE0, 0x0F, 0xC0,
  0x03, 0x1F, 0x00, 0xEF, 0xF0, 0x1F, 0x8F, 0x03, 0xC0, 0x70, 0x70, 0x0E,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x1E, 0x01, 0x83,
  0xF0, 0xF0, 0x67, 0xFC, 0x0C, 0x3E, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xE1, 0x87, 0xFC, 0xC7, 0x86, 0xE7, 0x01,
  0xE3, 0x80, 0x73, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x39,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x38, 0x07, 0x1C, 0x07, 0x87, 0x0F,
  0xC1, 0xFE, 0xC0, 0x7C, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x0C, 0xF0, 0xDF, 0x1F, 0xD1, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x06, 0x18, 0x07, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xE0,
  0x1C, 0x60, 0x18, 0x78, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x0F, 0xFF, 0xFF, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xF0, 0x3C, 0x00, 0x18, 0x03,
  0x9C, 0x01, 0xCE, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x0E,
  0x38, 0x0F, 0x0C, 0x07, 0x87, 0x8F, 0x81, 0xFE, 0xC0, 0x7C, 0x60, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x18, 0x0C,
  0x30, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x83, 0x83, 0x06, 0x07, 0x1C, 0x06,
  0x30, 0x0C, 0xE0, 0x19, 0x80, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x70, 0x0C,
  0x03, 0xB8, 0x0E, 0x01, 0xDC, 0x07, 0x80, 0xCE, 0x07, 0xC0, 0xE3, 0x03,
  0x60, 0x61, 0x83, 0xB0, 0x30, 0xC1, 0x98, 0x30, 0x60, 0xCC, 0x18, 0x30,
  0xC6, 0x1C, 0x18, 0x63, 0x0C, 0x0C, 0x71, 0x86, 0x06, 0x30, 0xC6, 0x03,
  0x18, 0x63, 0x01, 0x98, 0x33, 0x80, 0xCC, 0x0D, 0x80, 0x6C, 0x06, 0xC0,
  0x36, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70,
  0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0xC0, 0x38,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0x30, 0x70, 0x07, 0x1C, 0x00, 0x63, 0x80,
  0x0C, 0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x39, 0xC0, 0x06, 0x18, 0x01,
  0xC3, 0x00, 0x70, 0x70, 0x0C, 0x06, 0x03, 0x80, 0xE0, 0xE0, 0x0C, 0x38,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x70, 0x0E,
  0x07, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x01, 0x80, 0x30, 0x38, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x07, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x18,
  0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01,
  0xB0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x0F,
  0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x08, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x20, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x03, 0x39, 0xE0, 0x37, 0x0E,
  0x03, 0x60, 0x70, 0x66, 0x03, 0xCE, 0xC0, 0x1F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 10, 12, 4, -32 },
  { 44, 22, 31, 21, 1, -31 },
  { 130, 17, 39, 20, 2, -35 },
  { 213, 20, 31, 27, 4, -31 },
  { 291, 19, 31, 22, 1, -31 },
  { 365, 4, 9, 7, 4, -32 },
  { 370, 12, 44, 12, 2, -34 },
  { 436, 12, 44, 12, -2, -34 },
  { 502, 17, 17, 18, 2, -31 },
  { 539, 17, 22, 21, 2, -25 },
  { 586, 6, 10, 8, -2, -4 },
  { 594, 9, 2, 11, 1, -14 },
  { 597, 4, 4, 10, 1, -4 },
  { 599, 18, 34, 15, -2, -31 },
  { 676, 17, 31, 20, 2, -31 },
  { 742, 11, 31, 20, 5, -31 },
  { 785, 18, 31, 20, 1, -31 },
  { 855, 18, 31, 20, 1, -31 },
  { 925, 18, 31, 20, 1, -31 },
  { 995, 18, 31, 20, 3, -31 },
  { 1065, 16, 31, 20, 2, -31 },
  { 1127, 18, 31, 20, 3, -31 },
  { 1197, 18, 31, 20, 1, -31 },
  { 1267, 16, 31, 20, 3, -31 },
  { 1329, 7, 23, 9, 1, -23 },
  { 1350, 9, 29, 8, -2, -23 },
  { 1383, 16, 18, 19, 2, -23 },
  { 1419, 17, 10, 20, 2, -19 },
  { 1441, 16, 18, 19, 1, -23 },
  { 1477, 13, 31, 17, 4, -31 },
  { 1528, 30, 40, 33, 1, -30 },
  { 1678, 21, 31, 23, -1, -31 },
  { 1760, 20, 31, 22, 1, -31 },
  { 1838, 21, 31, 24, 2, -31 },
  { 1920, 21, 31, 24, 1, -31 },
  { 2002, 21, 31, 21, 1, -31 },
  { 2084, 21, 31, 20, 1, -31 },
  { 2166, 20, 31, 25, 3, -31 },
  { 2244, 24, 31, 26, 1, -31 },
  { 2337, 7, 31, 10, 2, -31 },
  { 2365, 19, 31, 20, 1, -31 },
  { 2439, 23, 31, 23, 1, -31 },
  { 2529, 15, 31, 19, 1, -31 },
  { 2588, 30, 31, 31, 1, -31 },
  { 2705, 24, 31, 26, 1, -31 },
  { 2798, 21, 31, 25, 2, -31 },
  { 2880, 21, 31, 22, 1, -31 },
  { 2962, 21, 36, 25, 2, -31 },
  { 3057, 21, 31, 23, 1, -31 },
  { 3139, 21, 31, 22, 1, -31 },
  { 3221, 20, 31, 22, 4, -31 },
  { 3299, 22, 31, 24, 2, -31 },
  { 3385, 21, 31, 23, 4, -31 },
  { 3467, 30, 31, 32, 4, -31 },
  { 3584, 25, 31, 22, -1, -31 },
  { 3681, 20, 31, 22, 4, -31 },
  { 3759, 22, 31, 22, 0, -31 },
  { 3845, 12, 42, 9, 0, -35 },
  { 3908, 7, 34, 15, 4, -31 },
  { 3938, 13, 42, 9, -3, -35 },
  { 4007, 12, 15, 15, 2, -31 },
  { 4030, 16, 2, 16, -2, 0 },
  { 4034, 6, 6, 12, 5, -32 },
  { 4039, 16, 23, 20, 1, -23 },
  { 4085, 17, 32, 20, 1, -32 },
  { 4153, 17, 23, 19, 1, -23 },
  { 4202, 19, 32, 20, 2, -32 },
  { 4278, 17, 23, 19, 1, -23 },
  { 4327, 14, 32, 13, 2, -32 },
  { 4383, 19, 32, 20, 0, -23 },
  { 4459, 17, 32, 20, 1, -32 },
  { 4527, 8, 31, 9, 1, -31 },
  { 4558, 14, 40, 9, -5, -31 },
  { 4628, 18, 32, 18, 1, -32 },
  { 4700, 8, 32, 9, 1, -32 },
  { 4732, 28, 23, 32, 1, -23 },
  { 4813, 17, 23, 20, 1, -23 },
  { 4862, 16, 23, 20, 2, -23 },
  { 4908, 19, 32, 20, -1, -23 },
  { 4984, 17, 32, 20, 2, -23 },
  { 5052, 12, 23, 13, 1, -23 },
  { 5087, 16, 23, 19, 1, -23 },
  { 5133, 10, 29, 12, 2, -29 },
  { 5170, 17, 23, 20, 2, -23 },
  { 5219, 15, 23, 18, 3, -23 },
  { 5263, 25, 23, 27, 3, -23 },
  { 5335, 19, 23, 18, -1, -23 },
  { 5390, 20, 32, 17, -2, -23 },
  { 5470, 18, 23, 18, 0, -23 },
  { 5522, 14, 42, 12, 1, -34 },
  { 5596, 8, 37, 9, 1, -31 },
  { 5633, 13, 43, 12, -2, -34 },
  { 5703, 20, 8, 25, 2, -17 },
};

const GFXfont RobotoCondensed_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC43PT7B_H_
