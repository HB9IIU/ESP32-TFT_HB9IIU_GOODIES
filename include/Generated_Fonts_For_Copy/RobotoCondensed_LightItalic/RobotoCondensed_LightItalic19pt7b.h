#ifndef _ROBOTOCONDENSED_LIGHTITALIC19PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x00, 0x4C, 0x5A, 0xAA, 0x08, 0x84,
  0x82, 0x42, 0x27, 0xF8, 0x90, 0x48, 0x48, 0x24, 0x7F, 0x92, 0x09, 0x04,
  0x84, 0x80, 0x04, 0x08, 0x1C, 0x22, 0x42, 0x42, 0x40, 0x60, 0x30, 0x0C,
  0x04, 0x02, 0x82, 0x84, 0xCC, 0x78, 0x20, 0x20, 0x70, 0x48, 0x24, 0x52,
  0x49, 0x47, 0x20, 0x20, 0x20, 0x17, 0x14, 0x92, 0x29, 0x20, 0x90, 0x30,
  0x1C, 0x22, 0x22, 0x22, 0x24, 0x28, 0x30, 0x70, 0xC9, 0x89, 0x86, 0x86,
  0x86, 0x7A, 0xF0, 0x08, 0xC4, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x42, 0x08, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x44, 0x22, 0x20, 0x08, 0x12, 0x47, 0xF1, 0x05, 0x12, 0x22, 0x08, 0x08,
  0x18, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x20, 0x2D, 0x40, 0xE0, 0x70, 0x01,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0x60, 0xC1, 0x83, 0x06, 0x14,
  0x2C, 0x8F, 0x00, 0x1B, 0xE4, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x10,
  0x0E, 0x11, 0x21, 0x21, 0x01, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0xFE, 0x1C, 0x45, 0x0A, 0x10, 0x20, 0xCE, 0x02, 0x04, 0x06, 0x14,
  0x28, 0xCF, 0x00, 0x01, 0x03, 0x05, 0x05, 0x0A, 0x12, 0x22, 0x22, 0x42,
  0xFF, 0x04, 0x04, 0x04, 0x04, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x7C, 0x46,
  0x02, 0x02, 0x02, 0x82, 0x84, 0x44, 0x78, 0x0E, 0x20, 0x83, 0x04, 0x0F,
  0xB1, 0x61, 0x83, 0x06, 0x0C, 0x24, 0xCF, 0x00, 0x7F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x1C, 0x22,
  0x42, 0x43, 0x42, 0x66, 0x38, 0x44, 0x86, 0x82, 0x82, 0x84, 0x8C, 0x78,
  0x1C, 0x45, 0x0A, 0x1C, 0x30, 0x50, 0xA3, 0x3A, 0x08, 0x10, 0x41, 0x8C,
  0x00, 0x24, 0x00, 0x00, 0x0B, 0x00, 0x11, 0x00, 0x00, 0x00, 0x02, 0x64,
  0x80, 0x02, 0x18, 0xC6, 0x0C, 0x0C, 0x06, 0x02, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x40, 0xC0, 0x60, 0x30, 0xC6, 0x30, 0x40, 0x73, 0x28, 0x82, 0x08,
  0x61, 0x08, 0x41, 0x00, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x41, 0x04, 0x04,
  0x40, 0x24, 0x38, 0xA2, 0x46, 0x22, 0x31, 0x11, 0x91, 0x14, 0x88, 0xA4,
  0x45, 0x26, 0x49, 0xDC, 0x40, 0x02, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x01,
  0x00, 0xC0, 0x30, 0x14, 0x04, 0x82, 0x20, 0x88, 0x62, 0x10, 0x87, 0xE2,
  0x08, 0x82, 0x40, 0x50, 0x10, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x42, 0x7C,
  0x42, 0xC2, 0x81, 0x82, 0x82, 0x86, 0xF8, 0x0F, 0x18, 0xC8, 0x28, 0x14,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x50, 0x24, 0x21, 0xE0, 0x3E,
  0x10, 0x88, 0x48, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x40, 0xA0, 0x50,
  0x48, 0x47, 0xC0, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x07, 0xF0, 0x3F, 0x90, 0x08, 0x08, 0x04,
  0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F,
  0x18, 0xC8, 0x28, 0x14, 0x02, 0x01, 0x01, 0x8F, 0x81, 0x40, 0xA0, 0x58,
  0x24, 0x31, 0xE0, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x90, 0x27, 0xF9,
  0x02, 0x40, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x24, 0x94, 0x92,
  0x4A, 0x49, 0x00, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x20, 0x98, 0x44, 0x41, 0xC0, 0x20, 0x88, 0x42, 0x31, 0x18,
  0x4C, 0x16, 0x05, 0x01, 0xA0, 0x48, 0x23, 0x08, 0x42, 0x18, 0x82, 0x20,
  0xC0, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0xF0,
  0x20, 0x19, 0x81, 0x94, 0x0C, 0xA0, 0xE5, 0x05, 0x28, 0x29, 0x42, 0xCA,
  0x14, 0x49, 0x24, 0x49, 0x22, 0x89, 0x14, 0x48, 0xC6, 0x46, 0x20, 0x20,
  0x48, 0x13, 0x05, 0x41, 0x48, 0x92, 0x24, 0x89, 0x12, 0xC4, 0xA1, 0x28,
  0x32, 0x0C, 0x83, 0x20, 0x40, 0x0F, 0x18, 0xC8, 0x28, 0x14, 0x0A, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x24, 0x21, 0xE0, 0x3E, 0x10, 0x88,
  0x28, 0x14, 0x0A, 0x09, 0x0C, 0xFC, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x1F, 0x18, 0x88, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xA0, 0x50, 0x24, 0x21, 0xE0, 0x18, 0x04, 0x3E, 0x10, 0x98, 0x68, 0x14,
  0x1A, 0x09, 0x0C, 0xF8, 0xC4, 0x42, 0x21, 0x10, 0x48, 0x24, 0x10, 0x0F,
  0x04, 0x22, 0x08, 0x82, 0x20, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x00, 0x44,
  0x11, 0x04, 0x63, 0x0F, 0x00, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x98, 0x24, 0x09, 0x02,
  0x40, 0x90, 0x24, 0x13, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x46, 0x1F,
  0x00, 0x81, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x98, 0x48, 0x24,
  0x14, 0x0A, 0x06, 0x01, 0x00, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x0C, 0x28,
  0xA2, 0x45, 0x12, 0x48, 0x92, 0x48, 0x91, 0x45, 0x0A, 0x28, 0x61, 0x43,
  0x0C, 0x18, 0x20, 0x80, 0x20, 0x44, 0x21, 0x08, 0x44, 0x0A, 0x02, 0x80,
  0xC0, 0x30, 0x1C, 0x04, 0x82, 0x21, 0x88, 0x41, 0x20, 0x40, 0x81, 0x40,
  0xB0, 0x88, 0xC4, 0x42, 0x40, 0xA0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x00, 0x3F, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x3F, 0xC0, 0x18, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x83, 0x80, 0x92, 0x44,
  0x92, 0x49, 0x22, 0x48, 0x18, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42,
  0x10, 0x84, 0x27, 0x00, 0x10, 0x8A, 0x54, 0xA6, 0x20, 0xFE, 0x48, 0x80,
  0x1E, 0x22, 0x21, 0x02, 0x3E, 0x42, 0x42, 0x82, 0x46, 0x7A, 0x10, 0x10,
  0x20, 0x20, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x62, 0x9C,
  0x3C, 0x8A, 0x0C, 0x18, 0x10, 0x20, 0x42, 0x8C, 0xF0, 0x01, 0x01, 0x01,
  0x01, 0x3A, 0x46, 0xC2, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0x74, 0x3C,
  0x8A, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x84, 0xF0, 0x1C, 0xC2, 0x08, 0xF8,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x00, 0x1D, 0x23, 0x61, 0x41, 0x41,
  0x42, 0x42, 0x42, 0x46, 0x3A, 0x02, 0x04, 0x84, 0x78, 0x10, 0x10, 0x20,
  0x20, 0x2E, 0x33, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x01,
  0x00, 0x22, 0x22, 0x44, 0x44, 0x44, 0x00, 0x10, 0x00, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x23, 0x00, 0x10, 0x10, 0x20, 0x20,
  0x23, 0x26, 0x2C, 0x38, 0x50, 0x68, 0x48, 0x4C, 0x44, 0x86, 0x11, 0x12,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x2E, 0x71, 0x9C, 0x48, 0x42, 0x82, 0x14,
  0x30, 0xA1, 0x05, 0x08, 0x48, 0x42, 0x42, 0x14, 0x10, 0x80, 0x2E, 0x33,
  0x21, 0x61, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x3C, 0x8D, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x8C, 0xF0, 0x2E, 0x33, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x42, 0x46, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3A, 0x8F, 0x0C, 0x18, 0x30,
  0xA1, 0x42, 0x8C, 0xE8, 0x10, 0x40, 0x81, 0x00, 0x2C, 0xC2, 0x18, 0x41,
  0x04, 0x10, 0x42, 0x00, 0x1C, 0x22, 0x22, 0x20, 0x30, 0x0C, 0x06, 0x82,
  0x44, 0x38, 0x22, 0x2F, 0x44, 0x44, 0x48, 0x88, 0x60, 0x42, 0x85, 0x0C,
  0x18, 0x30, 0xA1, 0x42, 0x8C, 0xE8, 0x83, 0x09, 0x12, 0x44, 0x89, 0x14,
  0x28, 0x60, 0x40, 0x84, 0x30, 0x8D, 0x31, 0x25, 0x25, 0x28, 0xA5, 0x18,
  0xC3, 0x18, 0x63, 0x08, 0x40, 0x23, 0x22, 0x24, 0x18, 0x18, 0x18, 0x28,
  0x68, 0x44, 0x84, 0x20, 0x90, 0x84, 0x42, 0x41, 0x20, 0xB0, 0x50, 0x28,
  0x18, 0x0C, 0x04, 0x02, 0x02, 0x06, 0x00, 0x3F, 0x02, 0x04, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0xC0, 0xFC, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x42,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x02, 0x00, 0x11, 0x22, 0x22, 0x22,
  0x24, 0x44, 0x44, 0x44, 0x80, 0x10, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x31, 0x04, 0x10, 0x82, 0x08, 0x21, 0x08, 0x00, 0x70, 0xE4, 0xA1, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 4, 5, 2, -14 },
  { 10, 9, 14, 9, 1, -14 },
  { 26, 8, 18, 9, 1, -16 },
  { 44, 9, 14, 12, 2, -14 },
  { 60, 8, 14, 10, 1, -14 },
  { 74, 1, 4, 3, 2, -14 },
  { 75, 5, 19, 5, 1, -15 },
  { 87, 5, 19, 5, -1, -15 },
  { 99, 7, 8, 8, 1, -14 },
  { 106, 8, 9, 9, 1, -11 },
  { 115, 3, 4, 4, -1, -2 },
  { 117, 3, 1, 5, 1, -6 },
  { 118, 2, 2, 4, 0, -2 },
  { 119, 8, 15, 7, -1, -14 },
  { 134, 7, 14, 9, 1, -14 },
  { 147, 5, 14, 9, 2, -14 },
  { 156, 8, 14, 9, 0, -14 },
  { 170, 7, 14, 9, 1, -14 },
  { 183, 8, 14, 9, 0, -14 },
  { 197, 8, 14, 9, 1, -14 },
  { 211, 7, 14, 9, 1, -14 },
  { 224, 8, 14, 9, 1, -14 },
  { 238, 8, 14, 9, 1, -14 },
  { 252, 7, 14, 9, 1, -14 },
  { 265, 3, 11, 4, 0, -11 },
  { 270, 4, 13, 4, -1, -11 },
  { 277, 7, 8, 8, 1, -10 },
  { 284, 7, 5, 9, 1, -9 },
  { 289, 7, 8, 8, 1, -10 },
  { 296, 6, 14, 7, 2, -14 },
  { 307, 13, 17, 14, 1, -13 },
  { 335, 10, 14, 10, -1, -14 },
  { 353, 8, 14, 10, 1, -14 },
  { 367, 9, 14, 10, 1, -14 },
  { 383, 9, 14, 11, 1, -14 },
  { 399, 9, 14, 9, 1, -14 },
  { 415, 9, 14, 9, 1, -14 },
  { 431, 9, 14, 11, 1, -14 },
  { 447, 10, 14, 11, 1, -14 },
  { 465, 3, 14, 5, 1, -14 },
  { 471, 9, 14, 9, 0, -14 },
  { 487, 10, 14, 10, 1, -14 },
  { 505, 6, 14, 9, 1, -14 },
  { 516, 13, 14, 14, 1, -14 },
  { 539, 10, 14, 11, 1, -14 },
  { 557, 9, 14, 11, 1, -14 },
  { 573, 9, 14, 10, 1, -14 },
  { 589, 9, 16, 11, 1, -14 },
  { 607, 9, 14, 10, 1, -14 },
  { 623, 10, 14, 10, 0, -14 },
  { 641, 8, 14, 10, 2, -14 },
  { 655, 10, 14, 11, 1, -14 },
  { 673, 9, 14, 10, 2, -14 },
  { 689, 13, 14, 14, 2, -14 },
  { 712, 10, 14, 10, 0, -14 },
  { 730, 9, 14, 10, 2, -14 },
  { 746, 10, 14, 10, 0, -14 },
  { 764, 6, 18, 4, 0, -15 },
  { 778, 3, 15, 7, 2, -14 },
  { 784, 5, 18, 4, -1, -15 },
  { 796, 5, 7, 7, 1, -14 },
  { 801, 7, 1, 7, -1, 0 },
  { 802, 3, 3, 5, 2, -15 },
  { 804, 8, 10, 9, 0, -10 },
  { 814, 8, 14, 9, 0, -14 },
  { 828, 7, 10, 8, 1, -10 },
  { 837, 8, 14, 9, 1, -14 },
  { 851, 7, 10, 8, 1, -10 },
  { 860, 6, 14, 6, 1, -14 },
  { 871, 8, 14, 9, 0, -10 },
  { 885, 8, 14, 9, 0, -14 },
  { 899, 4, 14, 4, 0, -14 },
  { 906, 6, 18, 4, -2, -14 },
  { 920, 8, 14, 8, 0, -14 },
  { 934, 4, 14, 4, 0, -14 },
  { 941, 13, 10, 14, 0, -10 },
  { 958, 8, 10, 9, 0, -10 },
  { 968, 7, 10, 9, 1, -10 },
  { 977, 8, 14, 9, 0, -10 },
  { 991, 7, 14, 9, 1, -10 },
  { 1004, 6, 10, 6, 0, -10 },
  { 1012, 8, 10, 8, 0, -10 },
  { 1022, 4, 13, 5, 1, -13 },
  { 1029, 7, 10, 9, 1, -10 },
  { 1038, 7, 10, 8, 1, -10 },
  { 1047, 11, 10, 12, 1, -10 },
  { 1061, 8, 10, 8, 0, -10 },
  { 1071, 9, 14, 8, -1, -10 },
  { 1087, 8, 10, 8, 0, -10 },
  { 1097, 6, 19, 6, 1, -15 },
  { 1112, 4, 17, 4, 0, -14 },
  { 1121, 6, 19, 6, -1, -15 },
  { 1136, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC19PT7B_H_
