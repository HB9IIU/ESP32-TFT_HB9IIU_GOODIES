#ifndef _ROBOTOCONDENSED_LIGHTITALIC72PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00,
  0xC0, 0x00, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE3, 0xC3, 0xC7,
  0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xE1, 0xE3, 0x83,
  0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x38, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x20, 0xE0, 0x0F, 0x00, 0x18, 0x70, 0x03,
  0x80, 0x1C, 0x78, 0x01, 0xC0, 0x1E, 0x38, 0x00, 0xE0, 0x0E, 0x1C, 0x00,
  0x70, 0x0E, 0x0E, 0x00, 0x78, 0x0F, 0x07, 0x00, 0x38, 0x0F, 0x03, 0x80,
  0x1C, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0xE0, 0x07, 0x07, 0x80, 0x70,
  0x07, 0x83, 0x80, 0x3C, 0x03, 0x83, 0x80, 0x0E, 0x03, 0xC3, 0xC0, 0x07,
  0x83, 0xC1, 0xC0, 0x01, 0xFF, 0xC1, 0xC0, 0x00, 0x7F, 0xC1, 0xE0, 0x00,
  0x1F, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0x38, 0x3F, 0xF0, 0x00, 0x3C, 0x3F,
  0xFC, 0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x1C, 0x1E, 0x07, 0x80, 0x1E, 0x1E,
  0x01, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07,
  0x80, 0x3C, 0x0F, 0x03, 0x80, 0x0E, 0x07, 0x01, 0xC0, 0x0F, 0x07, 0x00,
  0xE0, 0x07, 0x87, 0x80, 0x70, 0x03, 0x87, 0x80, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x00, 0x73, 0xC0, 0x07, 0x00, 0x78, 0xC0,
  0x03, 0x80, 0x38, 0x20, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x70, 0x0F, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x07, 0xC3, 0xE0, 0x07, 0x0F, 0x81, 0xE0, 0x07, 0x0F, 0x01, 0xF0, 0x0F,
  0x1F, 0x00, 0xF0, 0x0F, 0x3E, 0x00, 0xF8, 0x0E, 0x3C, 0x00, 0x78, 0x1E,
  0x7C, 0x00, 0x3C, 0x1E, 0x78, 0x00, 0x3C, 0x1C, 0x78, 0x00, 0x1E, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0xF0, 0x00, 0x0F, 0xF8,
  0xF0, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xF0,
  0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x78, 0x0F, 0xFF, 0xF8, 0x78,
  0x07, 0xFF, 0xF0, 0x3C, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xF3, 0x8E, 0x38,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x70, 0x06, 0x7C, 0x07, 0x03, 0xFF, 0xF8, 0x70, 0xFF,
  0x7F, 0xEF, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x01, 0x80, 0x03, 0x80, 0x08, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x00, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFF, 0xF9, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF, 0x3C, 0xFE,
  0x1E, 0xF8, 0x0E, 0x70, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x00, 0x39, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x70, 0xFF, 0xE0, 0x3C,
  0xFF, 0xFC, 0x0F, 0x7F, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0xFE, 0x00, 0x7C,
  0x7F, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x3C,
  0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC3, 0xC0, 0x03, 0xF8, 0x7C,
  0x00, 0xFF, 0x07, 0xC0, 0x7D, 0xC0, 0xFF, 0xFF, 0x78, 0x0F, 0xFF, 0xCF,
  0x00, 0xFF, 0xE1, 0xE0, 0x07, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C,
  0x03, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC1,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x7C, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xE0, 0x70, 0x01,
  0xF0, 0x0F, 0x00, 0x70, 0x78, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x38, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x8F, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE3, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x73, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x39, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x70,
  0x03, 0x80, 0x03, 0x80, 0x0F, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x3C,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x9C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xCE,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE3,
  0x80, 0x3C, 0x00, 0x3C, 0x00, 0x71, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x18, 0x70, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x38, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x1C, 0x01, 0xE0, 0x07, 0xC0, 0x0E,
  0x0E, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x03, 0x70, 0x07,
  0x03, 0x80, 0x1C, 0x03, 0xB8, 0x07, 0x81, 0xC0, 0x0F, 0x07, 0x9E, 0x07,
  0x80, 0xE0, 0x07, 0xFF, 0x8F, 0x8F, 0x80, 0x70, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x38, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x73,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0xFC, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3F, 0x03,
  0xC0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0xF8, 0xF0, 0x00, 0xFF, 0xFE, 0x1E, 0x00,
  0x1F, 0xFF, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x07, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x00,
  0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x00, 0x3C,
  0x3F, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x03, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x00, 0x0F,
  0x7F, 0xC0, 0x00, 0x00, 0x3D, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0x80,
  0x00, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xEF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x1C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x3C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0x70, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x9C,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3B,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x70,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x78, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x1E, 0x00,
  0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x3C,
  0x00, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x00,
  0x7F, 0x80, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xF8, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0xB8, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x00,
  0x78, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x07,
  0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00,
  0x78, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xCE, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xB8, 0x00, 0x7B, 0xC0, 0x07, 0x1C, 0x00, 0xF1,
  0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xE0, 0x38,
  0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x78, 0x00, 0x77,
  0x80, 0x07, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0x78, 0x3F, 0x80, 0x0F, 0x0F, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0xC7, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0xC3,
  0xE0, 0x07, 0xF8, 0x3F, 0x07, 0xEF, 0x07, 0xFF, 0xF9, 0xE0, 0x7F, 0xFE,
  0x3C, 0x03, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE3, 0xFF, 0x80, 0x0F, 0x3F,
  0xFE, 0x00, 0x73, 0xFF, 0xF8, 0x07, 0xBE, 0x07, 0xE0, 0x3F, 0xC0, 0x1F,
  0x01, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0xF8, 0x7F, 0x00, 0x0F, 0x83, 0xDC, 0x00, 0xF8, 0x1E, 0xF8, 0x1F,
  0xC0, 0xF3, 0xFF, 0xFC, 0x07, 0x0F, 0xFF, 0xC0, 0x78, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0xFF, 0xF8, 0x78,
  0x01, 0xFF, 0xFC, 0x70, 0x03, 0xF0, 0x3E, 0xF0, 0x07, 0xC0, 0x0E, 0xF0,
  0x0F, 0x80, 0x07, 0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0xDE, 0x00, 0x1F, 0xFF, 0x9E, 0x00, 0x07, 0xFE, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x04, 0x07, 0xC0, 0x01, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x04, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00,
  0x1F, 0xFF, 0x0F, 0x00, 0x7F, 0xFF, 0x8F, 0x00, 0x7E, 0x07, 0xCE, 0x00,
  0xF8, 0x01, 0xDE, 0x01, 0xF0, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x7F, 0xC0, 0x07, 0xFF, 0xFB, 0xC0, 0x03, 0xFF, 0xF3, 0xC0, 0x00,
  0xFF, 0xC3, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE1, 0xFF, 0x80, 0x1E, 0x7F, 0xFC, 0x01, 0xCF, 0xFF, 0xE0, 0x3D, 0xF0,
  0x3E, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0x03, 0xF0, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x20, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0x7C, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFB, 0xC0, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x7E, 0x1E, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x70, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xC7, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0xCF, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xDE, 0x07, 0xE3, 0xE0, 0x7E, 0x03,
  0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x03, 0xF0, 0x01, 0xF7, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x1E, 0x1F, 0xF8, 0x01, 0xC7, 0xFF, 0xC0, 0x1C, 0xFF,
  0xFE, 0x03, 0xDF, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x03, 0xF8, 0x00, 0xF0,
  0x3F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xFF, 0xC0, 0x01, 0xC7, 0xFF, 0xC0,
  0x03, 0xBF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x80, 0x07, 0xC0,
  0x7B, 0x80, 0x1F, 0x00, 0xF7, 0xC0, 0xFE, 0x01, 0xE7, 0xFF, 0xF8, 0x03,
  0xC7, 0xFF, 0xE0, 0x07, 0x07, 0xFF, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0x83, 0xC0, 0x3F, 0xFE, 0x1E, 0x07, 0xFF, 0xF8, 0xE0, 0x3F, 0x01, 0xE7,
  0x03, 0xE0, 0x07, 0x78, 0x3E, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x3F,
  0x80, 0x7E, 0x07, 0xFC, 0x03, 0xFF, 0xFD, 0xE0, 0x0F, 0xFF, 0xCF, 0x00,
  0x1F, 0xF8, 0x70, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0x8F, 0xE0, 0x1E, 0xFF, 0x80, 0x77, 0xFE, 0x03, 0xDF, 0x88,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x07, 0xC0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0x7E, 0x0F, 0xFC,
  0x03, 0xFF, 0xFB, 0x80, 0x3F, 0xFF, 0x78, 0x01, 0xFF, 0xC7, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0xE0,
  0x01, 0xE3, 0x80, 0x07, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0xF8, 0x00, 0xF0,
  0xF0, 0x01, 0xFC, 0x00, 0x78, 0x78, 0x01, 0xFE, 0x00, 0x3C, 0x3C, 0x00,
  0xE7, 0x00, 0x3C, 0x1E, 0x00, 0xF3, 0x80, 0x1E, 0x0F, 0x00, 0x79, 0xC0,
  0x1E, 0x07, 0x80, 0x78, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x70, 0x07, 0x81,
  0xE0, 0x1C, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x0E, 0x07, 0x83, 0xC0,
  0xE0, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x01,
  0xC1, 0xC0, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x07, 0x1E, 0x00, 0x1E, 0x70, 0x03, 0x8F,
  0x00, 0x0F, 0x78, 0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x03,
  0xDC, 0x00, 0x7B, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x07,
  0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xC3, 0xFF, 0xC0, 0x00, 0xE3,
  0xFF, 0xF0, 0x00, 0x73, 0xE0, 0xFC, 0x00, 0x79, 0xE0, 0x3E, 0x00, 0x39,
  0xE0, 0x0F, 0x80, 0x3C, 0xF0, 0x03, 0xE0, 0x1E, 0x70, 0x00, 0xF8, 0x3E,
  0x78, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x0F, 0xFF, 0x1C, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 52, 15, 2, -51 },
  { 86, 15, 16, 20, 7, -54 },
  { 116, 36, 51, 36, 2, -51 },
  { 346, 29, 67, 34, 3, -59 },
  { 589, 33, 53, 45, 7, -52 },
  { 808, 32, 53, 38, 2, -52 },
  { 1020, 6, 16, 12, 7, -54 },
  { 1032, 20, 73, 20, 4, -57 },
  { 1215, 21, 74, 21, -4, -57 },
  { 1410, 28, 29, 30, 4, -51 },
  { 1512, 29, 37, 35, 3, -42 },
  { 1647, 10, 16, 13, -3, -7 },
  { 1667, 14, 4, 18, 2, -25 },
  { 1674, 6, 6, 17, 2, -5 },
  { 1679, 30, 55, 25, -3, -51 },
  { 1886, 28, 53, 34, 4, -52 },
  { 2072, 17, 51, 34, 9, -51 },
  { 2181, 31, 52, 34, 1, -52 },
  { 2383, 30, 53, 34, 2, -52 },
  { 2582, 31, 51, 34, 1, -51 },
  { 2780, 31, 52, 34, 4, -51 },
  { 2982, 26, 52, 34, 4, -51 },
  { 3151, 30, 51, 34, 5, -51 },
  { 3343, 31, 53, 34, 2, -52 },
  { 3549, 27, 52, 34, 5, -52 },
  { 3725, 12, 38, 14, 1, -37 },
  { 3782, 16, 46, 13, -3, -37 },
  { 3874, 27, 30, 31, 3, -38 },
  { 3976, 27, 18, 34, 4, -33 },
  { 4037, 27, 30, 32, 2, -38 },
  { 4139, 22, 53, 28, 6, -52 },
  { 4285, 49, 66, 55, 2, -50 },
  { 4690, 35, 51, 38, -2, -51 },
  { 4914, 33, 51, 37, 2, -51 },
  { 5125, 34, 53, 39, 4, -52 },
  { 5351, 35, 51, 40, 2, -51 },
  { 5575, 35, 51, 35, 2, -51 },
  { 5799, 35, 51, 34, 2, -51 },
  { 6023, 35, 53, 41, 4, -52 },
  { 6255, 40, 51, 43, 2, -51 },
  { 6510, 13, 51, 17, 3, -51 },
  { 6593, 32, 52, 34, 1, -51 },
  { 6801, 39, 51, 38, 2, -51 },
  { 7050, 25, 51, 32, 2, -51 },
  { 7210, 50, 51, 52, 2, -51 },
  { 7529, 40, 51, 43, 2, -51 },
  { 7784, 35, 53, 41, 4, -52 },
  { 8016, 35, 51, 38, 2, -51 },
  { 8240, 35, 61, 41, 4, -52 },
  { 8507, 35, 51, 38, 2, -51 },
  { 8731, 34, 53, 36, 2, -52 },
  { 8957, 33, 51, 36, 7, -51 },
  { 9168, 36, 52, 40, 4, -51 },
  { 9402, 35, 51, 38, 6, -51 },
  { 9626, 50, 51, 54, 7, -51 },
  { 9945, 41, 51, 37, -1, -51 },
  { 10207, 34, 51, 37, 7, -51 },
  { 10424, 38, 51, 37, 0, -51 },
  { 10667, 21, 70, 16, 0, -59 },
  { 10851, 12, 55, 25, 7, -51 },
  { 10934, 20, 70, 16, -4, -59 },
  { 11109, 20, 26, 26, 3, -51 },
  { 11174, 27, 4, 27, -4, 0 },
  { 11188, 10, 10, 20, 9, -54 },
  { 11201, 27, 40, 33, 2, -39 },
  { 11336, 29, 55, 34, 1, -54 },
  { 11536, 28, 40, 32, 2, -39 },
  { 11676, 32, 55, 34, 3, -54 },
  { 11896, 27, 40, 32, 2, -39 },
  { 12031, 22, 55, 21, 4, -55 },
  { 12183, 32, 54, 34, 0, -39 },
  { 12399, 28, 54, 34, 1, -54 },
  { 12588, 13, 52, 15, 2, -52 },
  { 12673, 23, 67, 15, -8, -52 },
  { 12866, 30, 54, 30, 1, -54 },
  { 13069, 13, 54, 15, 2, -54 },
  { 13157, 48, 39, 53, 1, -39 },
  { 13391, 28, 39, 34, 1, -39 },
  { 13528, 28, 40, 34, 3, -39 },
  { 13668, 31, 54, 34, -1, -39 },
  { 13878, 29, 54, 34, 3, -39 },
  { 14074, 22, 39, 21, 1, -39 },
  { 14182, 26, 40, 31, 2, -39 },
  { 14312, 16, 49, 20, 4, -48 },
  { 14410, 28, 39, 34, 4, -38 },
  { 14547, 27, 38, 30, 4, -38 },
  { 14676, 41, 38, 46, 5, -38 },
  { 14871, 31, 38, 30, -1, -38 },
  { 15019, 34, 53, 29, -3, -38 },
  { 15245, 29, 38, 30, 0, -38 },
  { 15383, 23, 70, 21, 2, -56 },
  { 15585, 13, 61, 15, 1, -51 },
  { 15685, 23, 70, 21, -4, -56 },
  { 15887, 33, 13, 41, 4, -28 },
};

const GFXfont RobotoCondensed_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC72PT7B_H_
