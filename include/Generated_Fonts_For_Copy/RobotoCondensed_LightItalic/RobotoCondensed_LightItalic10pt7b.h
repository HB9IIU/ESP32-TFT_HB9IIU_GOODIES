#ifndef _ROBOTOCONDENSED_LIGHTITALIC10PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x09, 0x4C, 0x65, 0x30, 0x80, 0x01, 0x92, 0x82,
  0x0A, 0x4C, 0x00, 0xC5, 0xB8, 0x47, 0x94, 0xC0, 0x32, 0x94, 0xCA, 0xC9,
  0xC0, 0x80, 0x25, 0x29, 0x24, 0x88, 0x24, 0x92, 0x49, 0x50, 0x5D, 0x50,
  0x21, 0x1C, 0x42, 0x00, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x88, 0x35,
  0x59, 0x99, 0x60, 0x65, 0x24, 0x90, 0x35, 0x11, 0x24, 0xF0, 0x35, 0x13,
  0x19, 0x60, 0x13, 0x35, 0xF1, 0x20, 0x78, 0xE2, 0x2A, 0xC0, 0x73, 0xDB,
  0x70, 0xF2, 0x24, 0x48, 0x80, 0x32, 0x52, 0xE9, 0x49, 0x80, 0x76, 0xDE,
  0x70, 0x40, 0x20, 0x40, 0x28, 0x16, 0x42, 0xE3, 0x80, 0x43, 0x2C, 0xF4,
  0xA8, 0x20, 0x1C, 0x45, 0x4D, 0x1A, 0xB5, 0x6F, 0x40, 0x70, 0x11, 0x8C,
  0xA7, 0x46, 0x20, 0x72, 0x52, 0xE4, 0xC7, 0xC0, 0x79, 0x88, 0x89, 0xE0,
  0x72, 0x52, 0x94, 0xC7, 0xC0, 0x7A, 0x10, 0xE4, 0x43, 0xC0, 0x7A, 0x10,
  0xE4, 0x42, 0x00, 0x79, 0x8B, 0x99, 0xE0, 0x45, 0x14, 0x5E, 0x4A, 0x28,
  0x80, 0x55, 0x68, 0x08, 0x44, 0x21, 0x49, 0x80, 0x49, 0x46, 0x18, 0x52,
  0x48, 0x80, 0x44, 0x44, 0x48, 0xF0, 0x42, 0x85, 0x9B, 0x56, 0xB6, 0xA5,
  0x00, 0x45, 0x96, 0x56, 0x5A, 0x28, 0x80, 0x79, 0x99, 0x99, 0xE0, 0x7A,
  0x52, 0xE4, 0x42, 0x00, 0x79, 0x99, 0x99, 0xE2, 0x7A, 0x52, 0xE5, 0x4A,
  0x40, 0x32, 0x50, 0x60, 0xC5, 0xC0, 0xF2, 0x10, 0x84, 0x21, 0x00, 0x8C,
  0x65, 0x29, 0x4B, 0x80, 0x8C, 0xA5, 0x4A, 0x61, 0x00, 0x93, 0x26, 0xD5,
  0xAD, 0x91, 0x20, 0x00, 0x49, 0x23, 0x08, 0x51, 0x49, 0x00, 0x94, 0xA8,
  0x84, 0x21, 0x00, 0x78, 0x44, 0x44, 0x23, 0xC0, 0x69, 0x25, 0x24, 0x90,
  0xAA, 0xA5, 0x24, 0x92, 0x4A, 0x58, 0x25, 0xC0, 0x70, 0x90, 0x71, 0x59,
  0xE0, 0x44, 0x47, 0x59, 0x9E, 0x79, 0x89, 0x60, 0x08, 0x42, 0xE9, 0x4A,
  0x4E, 0x79, 0xF8, 0x60, 0x72, 0x49, 0x24, 0x79, 0x99, 0x71, 0xE0, 0x44,
  0x47, 0x59, 0x99, 0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44, 0x45, 0x64,
  0xA9, 0x55, 0x6A, 0x7E, 0xA6, 0x4C, 0x99, 0x20, 0x75, 0x99, 0x90, 0x79,
  0x99, 0x60, 0x75, 0x99, 0xE8, 0x80, 0x79, 0x99, 0x71, 0x20, 0x6A, 0x48,
  0x75, 0x29, 0x60, 0x49, 0x25, 0x10, 0x55, 0x99, 0x70, 0xB7, 0x68, 0xAD,
  0x7B, 0x28, 0x00, 0x56, 0x26, 0xA0, 0x95, 0x66, 0x44, 0x80, 0x72, 0x44,
  0xE0, 0x25, 0x28, 0x92, 0x48, 0x55, 0xAA, 0x22, 0x22, 0x12, 0x24, 0x48,
  0xC3,
};

const GFXglyph RobotoCondensed_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 6, 1, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -8 },
  { 26, 3, 10, 3, 0, -8 },
  { 30, 3, 10, 3, -1, -8 },
  { 34, 3, 4, 4, 1, -7 },
  { 36, 5, 5, 5, 0, -6 },
  { 40, 1, 2, 2, 0, -1 },
  { 41, 2, 1, 3, 0, -4 },
  { 42, 1, 1, 2, 0, -1 },
  { 43, 4, 8, 3, 0, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 3, 7, 5, 1, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 4, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 0, -7 },
  { 66, 4, 7, 5, 1, -7 },
  { 70, 3, 7, 5, 1, -7 },
  { 73, 4, 7, 5, 1, -7 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 3, 7, 5, 1, -7 },
  { 85, 2, 6, 2, 0, -6 },
  { 87, 2, 7, 2, 0, -6 },
  { 89, 4, 4, 4, 0, -5 },
  { 91, 3, 3, 5, 1, -5 },
  { 93, 4, 4, 4, 0, -5 },
  { 95, 3, 7, 4, 1, -7 },
  { 98, 7, 9, 8, 0, -7 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 4, 7, 5, 1, -7 },
  { 120, 5, 7, 6, 0, -7 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 5, 7, 5, 0, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 6, 7, 6, 0, -7 },
  { 145, 2, 7, 2, 0, -7 },
  { 147, 5, 7, 5, 0, -7 },
  { 152, 6, 7, 5, 0, -7 },
  { 158, 4, 7, 5, 0, -7 },
  { 162, 7, 7, 7, 0, -7 },
  { 169, 6, 7, 6, 0, -7 },
  { 175, 4, 7, 6, 1, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 4, 8, 6, 1, -7 },
  { 188, 5, 7, 5, 0, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 5, 7, 5, 1, -7 },
  { 203, 5, 7, 6, 1, -7 },
  { 208, 5, 7, 5, 1, -7 },
  { 213, 7, 7, 7, 1, -7 },
  { 220, 6, 7, 5, 0, -7 },
  { 226, 5, 7, 5, 1, -7 },
  { 231, 5, 7, 5, 0, -7 },
  { 236, 3, 10, 2, 0, -8 },
  { 240, 2, 8, 3, 1, -7 },
  { 242, 3, 10, 2, -1, -8 },
  { 246, 3, 4, 4, 0, -7 },
  { 248, 4, 1, 4, -1, 0 },
  { 249, 2, 2, 3, 1, -8 },
  { 250, 4, 5, 5, 0, -5 },
  { 253, 4, 8, 5, 0, -8 },
  { 257, 4, 5, 4, 0, -5 },
  { 260, 5, 8, 5, 0, -8 },
  { 265, 4, 5, 4, 0, -5 },
  { 268, 3, 8, 3, 1, -8 },
  { 271, 4, 7, 5, 0, -5 },
  { 275, 4, 8, 5, 0, -8 },
  { 279, 2, 7, 2, 0, -7 },
  { 281, 3, 9, 2, -1, -7 },
  { 285, 4, 8, 4, 0, -8 },
  { 289, 2, 8, 2, 0, -8 },
  { 291, 7, 5, 7, 0, -5 },
  { 296, 4, 5, 5, 0, -5 },
  { 299, 4, 5, 5, 0, -5 },
  { 302, 4, 7, 5, 0, -5 },
  { 306, 4, 7, 5, 0, -5 },
  { 310, 3, 5, 3, 0, -5 },
  { 312, 4, 5, 4, 0, -5 },
  { 315, 3, 7, 3, 0, -7 },
  { 318, 4, 5, 5, 0, -5 },
  { 321, 3, 5, 4, 1, -5 },
  { 323, 5, 5, 6, 1, -5 },
  { 327, 4, 5, 4, 0, -5 },
  { 330, 4, 7, 4, 0, -5 },
  { 334, 4, 5, 4, 0, -5 },
  { 337, 3, 10, 3, 0, -8 },
  { 341, 2, 8, 2, 0, -7 },
  { 343, 4, 10, 3, -1, -8 },
  { 348, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC10PT7B_H_
