#ifndef _ROBOTOCONDENSED_LIGHTITALIC61PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x8E, 0x30, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xC6, 0x0C, 0x61, 0xCE, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x80, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00,
  0x71, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x01, 0x8E, 0x01,
  0xC0, 0x1C, 0xE0, 0x1C, 0x03, 0x8E, 0x01, 0xC0, 0x70, 0xE0, 0x1C, 0x07,
  0x0E, 0x01, 0xC0, 0xE0, 0xC0, 0x1C, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0xE0,
  0x38, 0x38, 0x0E, 0x03, 0x87, 0x00, 0x60, 0x70, 0xE0, 0x07, 0x8F, 0x0E,
  0x00, 0x3F, 0xE1, 0xC0, 0x01, 0xFC, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x70, 0x7F, 0xC0, 0x07, 0x0F, 0x1C,
  0x00, 0xE1, 0xC0, 0xE0, 0x1C, 0x18, 0x0E, 0x01, 0xC3, 0x80, 0x60, 0x38,
  0x38, 0x07, 0x07, 0x03, 0x00, 0x70, 0x70, 0x70, 0x07, 0x0E, 0x07, 0x00,
  0x61, 0xC0, 0x70, 0x06, 0x38, 0x07, 0x00, 0x63, 0x80, 0x70, 0x0E, 0x70,
  0x07, 0x00, 0xE2, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x03, 0x80,
  0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE3, 0xE0, 0x00, 0x1C, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE1, 0xE0, 0x1C, 0x78, 0x1C, 0x03, 0x9E, 0x03, 0xC0, 0x73, 0x80,
  0x38, 0x1C, 0xF0, 0x07, 0x83, 0x9C, 0x00, 0x70, 0x77, 0x80, 0x0F, 0x1C,
  0xF0, 0x00, 0xE3, 0x9E, 0x00, 0x1E, 0xE3, 0x80, 0x01, 0xFC, 0x70, 0x00,
  0x3F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x83,
  0xC0, 0x03, 0xF0, 0x3C, 0x01, 0xEF, 0x07, 0xF1, 0xF8, 0xE0, 0x7F, 0xFE,
  0x1E, 0x03, 0xFF, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x39, 0xCE, 0xE7, 0x39,
  0xCE, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x1C, 0x03, 0x78, 0x1C, 0x0F,
  0x7F, 0x1C, 0x7F, 0x3F, 0xDF, 0xFE, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xCE, 0x00,
  0x03, 0x87, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x03, 0x80, 0x1E, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x11, 0xE7, 0xBE, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x3C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1,
  0xFE, 0x3F, 0xFB, 0xFC, 0xEF, 0xC3, 0xB8, 0x1E, 0x80, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xF8, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF0,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x38,
  0x1C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x7E, 0x00, 0x1D, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x0F,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x0F, 0xE0, 0x1C, 0xFF, 0xC0, 0xE7, 0xFF, 0xC3, 0xBC, 0x1F,
  0x0F, 0xC0, 0x1E, 0x3E, 0x00, 0x39, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0x83, 0xC0, 0x1E, 0x07, 0x81, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0E,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x07, 0x83, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0E,
  0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0x81, 0xF0, 0x78, 0x03, 0xC1, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x7B, 0x80, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0x78, 0x03, 0xF1,
  0xE0, 0x1F, 0xC3, 0xE1, 0xF7, 0x07, 0xFF, 0xBC, 0x0F, 0xF8, 0xE0, 0x1F,
  0xC3, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0x01, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0x20, 0x00, 0x00, 0x20,
  0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF0, 0x7C, 0x78,
  0x07, 0x8E, 0x00, 0x73, 0xC0, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x1F, 0xC0,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x3F, 0x00, 0x1C, 0x1E, 0x00,
  0x7F, 0xE0, 0x06, 0x0E, 0x00, 0x7F, 0xF8, 0x03, 0x07, 0x00, 0x78, 0x1E,
  0x01, 0x87, 0x00, 0x78, 0x07, 0x00, 0xC3, 0x80, 0x38, 0x03, 0x00, 0x63,
  0x80, 0x38, 0x03, 0x80, 0x31, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0xC0, 0x1C,
  0x00, 0xE0, 0x0C, 0xE0, 0x1C, 0x00, 0x60, 0x06, 0x70, 0x0E, 0x00, 0x70,
  0x03, 0x30, 0x07, 0x00, 0x38, 0x03, 0xB8, 0x07, 0x00, 0x1C, 0x01, 0xDC,
  0x03, 0x80, 0x0C, 0x00, 0xEE, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0x00, 0xE0,
  0x07, 0x00, 0x33, 0x00, 0xE0, 0x03, 0x80, 0x1B, 0x80, 0x70, 0x01, 0xC0,
  0x1D, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0xE0, 0x1C, 0x00, 0xE0, 0x06, 0x70,
  0x0E, 0x00, 0x70, 0x07, 0x38, 0x07, 0x00, 0x78, 0x03, 0x9C, 0x03, 0x80,
  0x3C, 0x01, 0x8E, 0x01, 0xC0, 0x3E, 0x01, 0xC7, 0x00, 0xE0, 0x3F, 0x01,
  0xC3, 0x80, 0x78, 0x3B, 0x81, 0xC1, 0xC0, 0x1E, 0x39, 0xE1, 0xE0, 0xE0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x30, 0x03, 0xF8, 0x1F, 0xC0, 0x18, 0x00, 0x70,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0F,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x07, 0xF0, 0x01, 0xC0, 0x03,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1F,
  0x01, 0xC0, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0xC0, 0x3C, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xE7, 0x80, 0x1F, 0xFF, 0x3C, 0x00,
  0xFF, 0xF9, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x07, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x3E, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x0F,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0xE0, 0x0F,
  0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x38, 0x0F,
  0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC7,
  0xC0, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0x77, 0xF8, 0x00, 0x00, 0x7F,
  0xBC, 0x00, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x3B, 0x80, 0x00, 0x03, 0xF8, 0x0E, 0xE0, 0x00, 0x01,
  0xFC, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0,
  0x3B, 0x80, 0x00, 0x0E, 0x70, 0x1E, 0xF0, 0x00, 0x07, 0x9C, 0x07, 0x1C,
  0x00, 0x01, 0xCF, 0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x1C, 0x70, 0x00, 0x1E, 0x38, 0x0F, 0x1C, 0x00, 0x07, 0x0E,
  0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x38,
  0x38, 0x00, 0x78, 0x70, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x38,
  0x07, 0x00, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x87, 0x00, 0x70,
  0x0E, 0x00, 0xE3, 0x80, 0x3C, 0x07, 0x80, 0x38, 0xE0, 0x0F, 0x01, 0xE0,
  0x07, 0x70, 0x03, 0xC0, 0x70, 0x01, 0xFC, 0x00, 0xE0, 0x1C, 0x00, 0x7E,
  0x00, 0x38, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0xFE, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0x00, 0x78, 0x0F,
  0xE0, 0x00, 0x1E, 0x03, 0x9C, 0x00, 0x07, 0x00, 0xE7, 0x00, 0x01, 0xC0,
  0x39, 0xE0, 0x00, 0x70, 0x1E, 0x38, 0x00, 0x1C, 0x07, 0x8E, 0x00, 0x0F,
  0x01, 0xC3, 0xC0, 0x03, 0xC0, 0x70, 0x70, 0x00, 0xE0, 0x1C, 0x1C, 0x00,
  0x38, 0x0F, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xF0, 0x38,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xF0, 0x1E,
  0x00, 0xF0, 0x3C, 0x07, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x70, 0x01, 0xE0, 0xE0, 0x3C, 0x00, 0x38, 0x38, 0x0F, 0x00, 0x0F, 0x1E,
  0x03, 0x80, 0x01, 0xC7, 0x80, 0xE0, 0x00, 0x71, 0xC0, 0x38, 0x00, 0x1E,
  0x70, 0x1E, 0x00, 0x03, 0x9C, 0x07, 0x80, 0x00, 0xE7, 0x01, 0xE0, 0x00,
  0x3F, 0xC0, 0x70, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x7E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xF8,
  0x01, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78,
  0x0E, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x18, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF8, 0x07, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x3C, 0x00, 0x1F, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xF8, 0x00, 0x38,
  0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x1C, 0x00, 0x3B, 0x80, 0x07, 0x07, 0x00,
  0x1C, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x38, 0x00, 0xF0, 0x70, 0x03, 0xC6,
  0x00, 0x38, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x70, 0x07,
  0x81, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x1C,
  0x03, 0xC1, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x1C, 0x07, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00,
  0x70, 0x38, 0x03, 0x03, 0x80, 0x1E, 0x1C, 0x00, 0xC1, 0xE0, 0x07, 0x87,
  0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x39, 0xE0,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x0E,
  0xE0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00,
  0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xE0,
  0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x60, 0x03, 0xB0, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0xE1, 0xC0, 0x70, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x67, 0x00, 0x3F, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x1C,
  0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0x70, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0x7C, 0x0F, 0x70,
  0x3F, 0xFE, 0x70, 0x1F, 0xFC, 0x70, 0x0F, 0xF0, 0x70, 0x01, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x3F, 0xE0, 0x0F,
  0x3F, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x70, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x1D,
  0xC0, 0x3C, 0x0E, 0x7F, 0xFE, 0x0F, 0x1F, 0xFC, 0x07, 0x07, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x0F,
  0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x78, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x08, 0x07, 0x00, 0x3F, 0xE0, 0xE0, 0x0F, 0xFF, 0x3C, 0x03,
  0xFF, 0xE7, 0x80, 0xF8, 0x0E, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0x80, 0x0F,
  0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x3E, 0x00, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xB8, 0x01, 0xFF, 0xE7,
  0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0x81, 0xE0,
  0x07, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x78, 0x00,
  0x1C, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x02, 0x07, 0x80, 0x0E, 0x07, 0xC0, 0x7C, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xB0, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x1C, 0x01, 0xFF, 0xE3,
  0x80, 0x7F, 0xFC, 0xF0, 0x1F, 0x01, 0xDC, 0x07, 0x80, 0x1F, 0x80, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x03, 0xF8, 0x03, 0xFF, 0xF7, 0x00, 0x3F,
  0xFD, 0xE0, 0x03, 0xFE, 0x3C, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x03, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x8F, 0xF8, 0x07, 0x9F, 0xFC, 0x07, 0xBF,
  0xFE, 0x07, 0x70, 0x1E, 0x07, 0xE0, 0x0E, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0x00, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x08, 0x78, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x07,
  0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x1D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x7C,
  0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x07, 0x00,
  0x1E, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xC7, 0xFC,
  0x03, 0xFC, 0x01, 0xE7, 0xFF, 0x07, 0xFF, 0x00, 0xEF, 0xFF, 0x87, 0xFF,
  0xC0, 0x77, 0x01, 0xE7, 0x81, 0xF0, 0x3E, 0x00, 0xF7, 0x00, 0x78, 0x1F,
  0x00, 0x3F, 0x80, 0x1C, 0x1F, 0x00, 0x1F, 0x80, 0x0E, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x87, 0x80, 0x07, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC0, 0x01,
  0xE1, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x87, 0x00, 0x07, 0x80, 0x03, 0x87, 0x80, 0x03, 0x80, 0x01, 0xC3, 0xC0,
  0x01, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x87, 0x00, 0x03, 0x80, 0x03, 0xC3, 0x80, 0x03, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xF8,
  0x07, 0x9F, 0xFC, 0x07, 0xBF, 0xFE, 0x07, 0x70, 0x1E, 0x07, 0xE0, 0x0E,
  0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x3C,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x3C, 0x00, 0xF0,
  0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0xC0, 0x07, 0xBF,
  0xFC, 0x00, 0xEF, 0xFF, 0xC0, 0x1F, 0xC0, 0x78, 0x03, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xF0,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x80,
  0x07, 0x81, 0xF8, 0x01, 0xE0, 0x3B, 0x80, 0xF8, 0x07, 0x3F, 0xFE, 0x01,
  0xE7, 0xFF, 0x80, 0x3C, 0x3F, 0xE0, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xC1, 0xC0, 0x7F, 0xF8, 0xE0, 0x7F, 0xFC, 0xF0,
  0x7C, 0x07, 0x70, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x1F, 0x80, 0xFF, 0xFD, 0xC0,
  0x3F, 0xFD, 0xE0, 0x07, 0xF8, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0xE3,
  0xF0, 0x7B, 0xFC, 0x1F, 0xFF, 0x07, 0x78, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3C,
  0x07, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x80,
  0x7C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x04,
  0x00, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0x70, 0x07,
  0xE0, 0x78, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFD, 0xC0, 0x1F, 0xF1,
  0xC0, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07,
  0xB8, 0x00, 0x1C, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1E, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x37, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x0F, 0x00,
  0x1E, 0xE0, 0x07, 0xC0, 0x07, 0x38, 0x01, 0xF8, 0x03, 0xCE, 0x00, 0xFE,
  0x00, 0xE3, 0x80, 0x3B, 0x80, 0x38, 0xE0, 0x0E, 0xE0, 0x1E, 0x38, 0x07,
  0x38, 0x07, 0x0E, 0x01, 0xCE, 0x03, 0xC3, 0x80, 0xE3, 0x80, 0xE0, 0xE0,
  0x38, 0xE0, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x0F, 0x07, 0x0E, 0x07, 0x01,
  0xC1, 0xC3, 0x83, 0xC0, 0x70, 0xE0, 0x60, 0xE0, 0x1C, 0x38, 0x1C, 0x38,
  0x07, 0x1C, 0x07, 0x1C, 0x01, 0xC7, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x73,
  0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x78, 0x07, 0x38, 0x01, 0xDC, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x1D, 0x80, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01,
  0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC7, 0xFF, 0x00, 0x0C, 0x3C, 0xFC,
  0x00, 0xE3, 0xC1, 0xF0, 0x07, 0x3C, 0x07, 0xC0, 0x79, 0xC0, 0x1F, 0x03,
  0x8E, 0x00, 0x7C, 0x7C, 0x70, 0x01, 0xFF, 0xC7, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 44, 13, 2, -43 },
  { 56, 12, 14, 17, 6, -46 },
  { 77, 30, 43, 30, 2, -43 },
  { 239, 25, 57, 29, 2, -50 },
  { 418, 28, 45, 38, 6, -44 },
  { 576, 27, 45, 32, 2, -44 },
  { 728, 5, 13, 10, 6, -46 },
  { 737, 17, 63, 17, 3, -49 },
  { 871, 17, 63, 18, -3, -49 },
  { 1005, 24, 24, 25, 3, -43 },
  { 1077, 24, 31, 29, 3, -36 },
  { 1170, 8, 14, 11, -2, -6 },
  { 1184, 12, 3, 15, 2, -21 },
  { 1189, 6, 6, 14, 1, -5 },
  { 1194, 26, 47, 21, -3, -43 },
  { 1347, 24, 45, 29, 3, -44 },
  { 1482, 14, 43, 29, 8, -43 },
  { 1558, 26, 44, 29, 1, -44 },
  { 1701, 25, 45, 29, 2, -44 },
  { 1842, 26, 43, 29, 1, -43 },
  { 1982, 25, 44, 29, 4, -43 },
  { 2120, 22, 44, 29, 3, -43 },
  { 2241, 25, 43, 29, 5, -43 },
  { 2376, 26, 45, 29, 2, -44 },
  { 2523, 22, 44, 29, 5, -44 },
  { 2644, 10, 33, 12, 1, -32 },
  { 2686, 13, 40, 11, -2, -32 },
  { 2751, 23, 25, 27, 2, -32 },
  { 2823, 23, 15, 29, 3, -28 },
  { 2867, 23, 25, 27, 2, -32 },
  { 2939, 19, 45, 24, 5, -44 },
  { 3046, 41, 56, 46, 2, -42 },
  { 3333, 30, 43, 32, -2, -43 },
  { 3495, 28, 43, 32, 2, -43 },
  { 3646, 29, 45, 33, 3, -44 },
  { 3810, 30, 43, 34, 2, -43 },
  { 3972, 29, 43, 29, 2, -43 },
  { 4128, 29, 43, 29, 2, -43 },
  { 4284, 29, 45, 35, 4, -44 },
  { 4448, 34, 43, 36, 2, -43 },
  { 4631, 11, 43, 14, 2, -43 },
  { 4691, 27, 44, 29, 1, -43 },
  { 4840, 33, 43, 32, 2, -43 },
  { 5018, 21, 43, 27, 2, -43 },
  { 5131, 42, 43, 44, 2, -43 },
  { 5357, 34, 43, 36, 2, -43 },
  { 5540, 30, 45, 35, 3, -44 },
  { 5709, 30, 43, 32, 2, -43 },
  { 5871, 30, 52, 35, 3, -44 },
  { 6066, 29, 43, 33, 2, -43 },
  { 6222, 29, 45, 31, 2, -44 },
  { 6386, 28, 43, 31, 6, -43 },
  { 6537, 31, 44, 34, 3, -43 },
  { 6708, 30, 43, 32, 5, -43 },
  { 6870, 42, 43, 46, 6, -43 },
  { 7096, 35, 43, 32, -1, -43 },
  { 7285, 28, 43, 31, 6, -43 },
  { 7436, 32, 43, 31, 0, -43 },
  { 7608, 18, 59, 13, 0, -50 },
  { 7741, 10, 47, 21, 6, -43 },
  { 7800, 18, 59, 13, -4, -50 },
  { 7933, 17, 22, 22, 3, -43 },
  { 7980, 22, 3, 23, -3, 0 },
  { 7989, 9, 8, 17, 7, -45 },
  { 7998, 24, 34, 28, 1, -33 },
  { 8100, 25, 47, 29, 1, -46 },
  { 8247, 23, 34, 27, 2, -33 },
  { 8345, 27, 47, 29, 2, -46 },
  { 8504, 23, 34, 27, 2, -33 },
  { 8602, 19, 47, 18, 3, -47 },
  { 8714, 27, 45, 29, 0, -33 },
  { 8866, 24, 46, 28, 1, -46 },
  { 9004, 11, 44, 13, 2, -44 },
  { 9065, 19, 56, 13, -7, -44 },
  { 9198, 26, 46, 26, 1, -46 },
  { 9348, 11, 46, 13, 2, -46 },
  { 9412, 41, 33, 45, 1, -33 },
  { 9582, 24, 33, 29, 1, -33 },
  { 9681, 24, 34, 29, 2, -33 },
  { 9783, 27, 45, 29, -1, -33 },
  { 9935, 25, 45, 29, 2, -33 },
  { 10076, 18, 33, 18, 1, -33 },
  { 10151, 23, 34, 26, 1, -33 },
  { 10249, 14, 41, 17, 3, -40 },
  { 10321, 24, 33, 28, 3, -32 },
  { 10420, 22, 32, 25, 4, -32 },
  { 10508, 34, 32, 39, 5, -32 },
  { 10644, 27, 32, 25, -1, -32 },
  { 10752, 28, 44, 25, -2, -32 },
  { 10906, 25, 32, 25, 0, -32 },
  { 11006, 19, 60, 18, 2, -48 },
  { 11149, 11, 51, 13, 1, -43 },
  { 11220, 19, 60, 18, -3, -48 },
  { 11363, 29, 11, 35, 3, -24 },
};

const GFXfont RobotoCondensed_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC61PT7B_H_
