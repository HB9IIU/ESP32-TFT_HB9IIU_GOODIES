#ifndef _ROBOTOCONDENSED_LIGHTITALIC42PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x33, 0x99, 0x9C, 0xCC, 0x66,
  0x33, 0x19, 0x98, 0x8C, 0xC6, 0x00, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0x80,
  0x1F, 0xF0, 0x1E, 0x3C, 0x1C, 0x0E, 0x0C, 0x03, 0x0E, 0x01, 0xC6, 0x00,
  0xE3, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01,
  0xCC, 0x00, 0xC7, 0x00, 0xE1, 0x80, 0xE0, 0xF1, 0xF0, 0x3F, 0xE0, 0x07,
  0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x01, 0xC6, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x0D, 0x81, 0x83,
  0x30, 0x30, 0x66, 0x06, 0x18, 0xC0, 0xC6, 0x18, 0x31, 0x83, 0x06, 0x30,
  0x31, 0x8C, 0x07, 0xF3, 0x00, 0x78, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC7, 0x80, 0x33, 0xF8, 0x0C, 0x63, 0x03, 0x18, 0x30, 0x63, 0x06,
  0x18, 0x40, 0xC6, 0x18, 0x18, 0xC3, 0x03, 0x30, 0x60, 0x6C, 0x0C, 0x0D,
  0x80, 0x83, 0x00, 0x18, 0xE0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x07, 0x1C, 0x01, 0xC1, 0x80, 0x70, 0x30, 0x0E, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x38, 0x06, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x70,
  0x01, 0xBC, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x1C, 0xE0, 0x63, 0x0C, 0x0C, 0xE1, 0xC3, 0x38, 0x18, 0x66, 0x01, 0x8C,
  0xC0, 0x3B, 0x38, 0x03, 0x67, 0x00, 0x78, 0x60, 0x07, 0x0C, 0x00, 0xE1,
  0xC0, 0x3C, 0x1C, 0x1D, 0xC1, 0xFF, 0x18, 0x1F, 0x83, 0x80, 0x66, 0x66,
  0x66, 0xCC, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x02, 0x06, 0x09, 0xE3, 0x3C, 0xFD, 0x7E, 0x0F, 0xF8, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xDC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0xE0, 0xC0, 0xE0, 0x70,
  0x20, 0x10, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x1C, 0x61, 0x00, 0xFF, 0x7F,
  0x80, 0x0E, 0xEE, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC3,
  0x81, 0xC0, 0xE0, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x70, 0x07, 0x30,
  0x03, 0x98, 0x01, 0xCC, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x70, 0x03, 0xB8, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31, 0x80, 0x18, 0xE0, 0x1C, 0x30,
  0x0C, 0x18, 0x0E, 0x0F, 0x1E, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xC0,
  0xF0, 0xFD, 0xFF, 0x71, 0xB0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x78, 0x70, 0x18, 0x0E, 0x0E, 0x01, 0x87,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x78, 0x70, 0x18, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x87, 0x01, 0xC0, 0xF0, 0xE0, 0x1F,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x67, 0x00,
  0x63, 0x80, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x38, 0x38,
  0x38, 0x18, 0x18, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x67, 0xC0, 0x1F,
  0xF8, 0x07, 0x8F, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x8E, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x07, 0x01, 0xC0, 0xE1, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x31, 0xF0, 0x37, 0xF8, 0x3E, 0x1C, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x0E, 0xE0, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x38, 0x38, 0x70,
  0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x3C, 0x78, 0x1C, 0x0E, 0x06, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x0E, 0x0E,
  0x07, 0x01, 0xC3, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0x1C, 0x0E, 0x03,
  0x83, 0x00, 0x61, 0x80, 0x1C, 0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33,
  0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x78, 0xF0, 0xC0, 0x63,
  0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xB0, 0x0F, 0x70, 0x3C,
  0x71, 0xD8, 0xFF, 0x30, 0x7C, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x18, 0x00, 0x10, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x10,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0x80, 0xFF,
  0x0E, 0x38, 0xE0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0xE0, 0x01,
  0x80, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x10, 0x0E, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x70, 0x0F, 0x00, 0xC3, 0x01,
  0xFE, 0x06, 0x30, 0x1C, 0x38, 0x31, 0x81, 0xC1, 0x81, 0x9C, 0x0C, 0x0C,
  0x0C, 0xC0, 0xC0, 0x60, 0x66, 0x06, 0x03, 0x03, 0x30, 0x60, 0x30, 0x1B,
  0x03, 0x01, 0x80, 0xD8, 0x18, 0x0C, 0x04, 0xC1, 0x80, 0x60, 0x66, 0x0C,
  0x06, 0x03, 0x30, 0x60, 0x30, 0x19, 0x03, 0x01, 0x80, 0x88, 0x18, 0x1C,
  0x0C, 0xC0, 0xC0, 0xE0, 0x46, 0x06, 0x0F, 0x06, 0x10, 0x38, 0xD8, 0x60,
  0xC0, 0xFC, 0x7E, 0x06, 0x03, 0xC3, 0xE0, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0D, 0x80, 0x01, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x98,
  0x00, 0x31, 0x80, 0x03, 0x1C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x30,
  0x0E, 0x07, 0x00, 0x60, 0x60, 0x06, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1C,
  0x00, 0x61, 0x80, 0x06, 0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x36,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x07, 0xFE, 0x00, 0x7F, 0xF8,
  0x06, 0x03, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00,
  0x60, 0xE0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE1, 0xC0,
  0x0C, 0x1C, 0x01, 0xC1, 0x80, 0x78, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x18,
  0x07, 0x83, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x38,
  0x60, 0x07, 0x06, 0x01, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0,
  0x07, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03,
  0x87, 0x00, 0x30, 0x38, 0x07, 0x03, 0xC1, 0xE0, 0x1F, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0x80, 0xF0, 0x0C, 0x01, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0x38, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0,
  0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x03, 0xC0,
  0xC0, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xE1, 0x80,
  0x06, 0x38, 0x00, 0x63, 0x00, 0x07, 0x30, 0x00, 0x77, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x3F, 0xCC, 0x07, 0xFC, 0xC0, 0x00, 0xCC, 0x00, 0x1C,
  0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xE0, 0x01,
  0x86, 0x00, 0x38, 0x70, 0x07, 0x03, 0xC3, 0xE0, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x06, 0x0C, 0x38, 0x70, 0xC1,
  0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x30, 0x03, 0x8C,
  0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x38, 0x06, 0x06, 0x03, 0x81, 0xE3,
  0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70,
  0x18, 0x01, 0xE0, 0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x07, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x30,
  0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x06, 0xF8,
  0x00, 0x0F, 0xB0, 0x00, 0x1E, 0x70, 0x00, 0x78, 0x60, 0x00, 0xE0, 0xE0,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x06, 0xC1, 0xB8, 0x00, 0x76, 0x0C,
  0xC0, 0x03, 0x70, 0x66, 0x00, 0x3B, 0x03, 0x30, 0x01, 0x98, 0x39, 0x80,
  0x1C, 0xC1, 0xCC, 0x00, 0xC6, 0x0C, 0x70, 0x0E, 0x70, 0x61, 0x80, 0x63,
  0x83, 0x0C, 0x06, 0x18, 0x18, 0x60, 0x30, 0xC1, 0xC3, 0x03, 0x06, 0x0E,
  0x18, 0x18, 0x30, 0x60, 0xE1, 0x83, 0x83, 0x03, 0x0C, 0x1C, 0x18, 0x18,
  0xC0, 0xC0, 0xC0, 0xC6, 0x06, 0x0E, 0x06, 0x60, 0x30, 0x70, 0x33, 0x01,
  0x83, 0x00, 0xF0, 0x1C, 0x18, 0x07, 0x80, 0xE0, 0xC0, 0x38, 0x06, 0x06,
  0x01, 0xC0, 0x30, 0x70, 0x0C, 0x01, 0x80, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x06, 0x07, 0x80, 0x06, 0x07, 0x80, 0x06, 0x07, 0x80, 0x06, 0x0F, 0xC0,
  0x0E, 0x0E, 0xC0, 0x0E, 0x0E, 0xC0, 0x0C, 0x0C, 0x60, 0x0C, 0x0C, 0x60,
  0x0C, 0x0C, 0x70, 0x0C, 0x1C, 0x30, 0x1C, 0x1C, 0x30, 0x1C, 0x1C, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x18, 0x38, 0x0C,
  0x38, 0x38, 0x0C, 0x38, 0x30, 0x06, 0x30, 0x30, 0x06, 0x30, 0x30, 0x07,
  0x30, 0x30, 0x03, 0x30, 0x70, 0x03, 0x70, 0x70, 0x03, 0xF0, 0x60, 0x01,
  0xE0, 0x60, 0x01, 0xE0, 0x60, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0xF8, 0x0E, 0x01, 0xC0,
  0xE0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00,
  0x39, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x67, 0x00, 0x03, 0x38,
  0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x73, 0x00, 0x03,
  0x18, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80,
  0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x0E, 0x01, 0xC0,
  0x7C, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0x80, 0x78, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x07, 0x00, 0x18,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0x60, 0x07, 0x83,
  0x00, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0xF0, 0x0E,
  0x01, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06,
  0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00,
  0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x73,
  0x00, 0x03, 0x38, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x63, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x0E,
  0x01, 0xC0, 0x7C, 0x7C, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x06, 0x01, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x70,
  0xE0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x01,
  0xC1, 0x80, 0x78, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0E, 0x03, 0x00, 0x60, 0x30, 0x06, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x01, 0x8E,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E,
  0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x03, 0xC1, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x80,
  0x38, 0x1C, 0x03, 0xC0, 0x78, 0x7C, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01,
  0xCE, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00,
  0x70, 0x70, 0x06, 0x07, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x30,
  0x18, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x38, 0x70, 0x01,
  0x86, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x98, 0x00,
  0x1B, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xB8, 0x01,
  0xC0, 0x0D, 0xC0, 0x1E, 0x00, 0xEE, 0x00, 0xF0, 0x06, 0x70, 0x0D, 0x80,
  0x33, 0x80, 0x6C, 0x03, 0x8C, 0x03, 0x60, 0x18, 0x60, 0x33, 0x00, 0xC3,
  0x01, 0x98, 0x0E, 0x18, 0x1C, 0xC0, 0x60, 0xC0, 0xC2, 0x07, 0x06, 0x06,
  0x18, 0x30, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x1C, 0x0C, 0x38, 0x30,
  0xC0, 0x61, 0x81, 0x86, 0x03, 0x0C, 0x0C, 0x70, 0x18, 0xC0, 0x63, 0x00,
  0xC6, 0x03, 0x18, 0x06, 0x70, 0x19, 0xC0, 0x33, 0x00, 0xCC, 0x01, 0x98,
  0x06, 0x60, 0x0D, 0x80, 0x37, 0x00, 0x6C, 0x00, 0xB0, 0x03, 0x60, 0x05,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0x70, 0x00, 0xE0, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0xC7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x83, 0x00, 0x03, 0x03,
  0x80, 0x07, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x60, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00,
  0x70, 0x30, 0x07, 0x03, 0x00, 0xE0, 0x38, 0x0C, 0x01, 0x81, 0xC0, 0x18,
  0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFC, 0x0F, 0xC0,
  0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x83, 0x06, 0x01, 0xF0, 0x0F, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0x80,
  0x1C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xC4, 0x18, 0x61,
  0x86, 0x38, 0x63, 0x06, 0x70, 0x66, 0x06, 0xE0, 0x30, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE1, 0xC3, 0x0E, 0x18, 0x70, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x0E,
  0x1C, 0x06, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x03, 0xFE, 0x1F, 0xFE, 0x3C, 0x06, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xE0, 0x3C, 0x71, 0xFC, 0x7F, 0xDC,
  0x1F, 0x1C, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x3F, 0x03, 0xBF, 0xC1, 0xB8, 0xF0, 0xF0, 0x18, 0x70, 0x0C, 0x30, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x39, 0x80,
  0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01, 0x8E,
  0x01, 0xCF, 0x01, 0xC6, 0xE1, 0xE3, 0x3F, 0xE1, 0x87, 0xC0, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0x0E, 0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x70, 0x03, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x70, 0x18,
  0x38, 0x78, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x3E, 0x30, 0x3F, 0xCC, 0x1E, 0x3B, 0x0E,
  0x03, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x06, 0x18, 0x01, 0x8E, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x70, 0xE0, 0x38, 0x1C,
  0x3E, 0x07, 0xFD, 0x80, 0x7C, 0x60, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x0E,
  0x1C, 0x06, 0x18, 0x07, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x60, 0x03,
  0x7F, 0xFF, 0x7F, 0xFF, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x38, 0x38, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xF0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x1F, 0xF8, 0xFF, 0x80, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF8, 0xE0, 0x7F, 0x98, 0x1E,
  0x3B, 0x07, 0x01, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x86, 0x00, 0x70, 0xC0,
  0x0C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00,
  0x38, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0xE0, 0xE0, 0x38, 0x0E, 0x1F, 0x01, 0xFF, 0x60, 0x0F, 0x8C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x70, 0x30, 0x1C,
  0x07, 0x07, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1B, 0x8E, 0x1E, 0x07,
  0x1C, 0x03, 0x1C, 0x03, 0x38, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07,
  0x30, 0x07, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x0E,
  0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x9E, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0xE3, 0x80, 0xE1, 0x80, 0xE0, 0xC0, 0xE0, 0x60, 0xE0, 0x30,
  0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x06, 0xE0, 0x03, 0xF8, 0x01,
  0xEC, 0x01, 0xE6, 0x00, 0xE3, 0x80, 0x60, 0xC0, 0x30, 0x70, 0x18, 0x18,
  0x0C, 0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x38, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x1C, 0xF8, 0x0F, 0x81, 0xDF,
  0xE3, 0xFC, 0x1B, 0x0E, 0x70, 0xE1, 0xE0, 0x7E, 0x06, 0x1C, 0x03, 0xC0,
  0x71, 0x80, 0x38, 0x07, 0x38, 0x03, 0x80, 0x73, 0x80, 0x30, 0x07, 0x30,
  0x03, 0x00, 0x63, 0x00, 0x70, 0x06, 0x30, 0x07, 0x00, 0x63, 0x00, 0x60,
  0x06, 0x70, 0x06, 0x00, 0xE7, 0x00, 0x60, 0x0E, 0x60, 0x06, 0x00, 0xC6,
  0x00, 0xE0, 0x0C, 0x60, 0x0E, 0x00, 0xCE, 0x00, 0xC0, 0x0C, 0xE0, 0x0C,
  0x01, 0xCC, 0x00, 0xC0, 0x1C, 0xC0, 0x0C, 0x01, 0x8C, 0x01, 0xC0, 0x18,
  0x0C, 0x7C, 0x1D, 0xFE, 0x1B, 0x8E, 0x1E, 0x07, 0x1C, 0x03, 0x1C, 0x03,
  0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07, 0x30, 0x07, 0x30, 0x06,
  0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C,
  0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0x03, 0xF0, 0x0F, 0xFC,
  0x1E, 0x1C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x78, 0x70,
  0x3F, 0xE0, 0x1F, 0x80, 0x03, 0x3F, 0x00, 0xEF, 0xF0, 0x1B, 0x0F, 0x03,
  0xC0, 0xE0, 0x70, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x0C,
  0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x38,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x70, 0xF0,
  0x1C, 0x1F, 0x87, 0x83, 0x3F, 0xE0, 0x63, 0xF0, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE3, 0x87, 0xF9, 0x87, 0x86,
  0xC7, 0x01, 0xE3, 0x00, 0x73, 0x80, 0x39, 0x80, 0x18, 0xC0, 0x0C, 0xE0,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x38, 0x0E, 0x0E, 0x1F,
  0x07, 0xFD, 0x80, 0xF8, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x0C, 0xF1, 0xDF, 0x1B, 0x91, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0E, 0x1E, 0x1C, 0x0E, 0x18, 0x06, 0x38, 0x06, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x78,
  0x70, 0x3F, 0xE0, 0x0F, 0x80, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x0F, 0xFF, 0xFE, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0xC0, 0xF0, 0x38, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x07, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x0E,
  0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0xF8, 0x7F, 0xD8, 0x1F, 0x38,
  0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xCC, 0x03, 0x9C, 0x06, 0x18,
  0x0C, 0x30, 0x30, 0x60, 0x60, 0xC1, 0x81, 0x83, 0x03, 0x0E, 0x07, 0x18,
  0x06, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x07, 0xC0, 0x38, 0x06,
  0xC0, 0x38, 0x0E, 0xE0, 0x78, 0x0C, 0xE0, 0x78, 0x0C, 0xE0, 0x78, 0x1C,
  0x60, 0xD8, 0x18, 0x60, 0xCC, 0x18, 0x61, 0x8C, 0x30, 0x61, 0x8C, 0x30,
  0x63, 0x0C, 0x70, 0x63, 0x0C, 0x60, 0x67, 0x0C, 0x60, 0x66, 0x0C, 0xC0,
  0x66, 0x0C, 0xC0, 0x6C, 0x0D, 0x80, 0x6C, 0x0D, 0x80, 0x78, 0x0D, 0x80,
  0x78, 0x07, 0x00, 0x78, 0x07, 0x00, 0x70, 0x06, 0x00, 0x70, 0x06, 0x00,
  0x0E, 0x00, 0xC0, 0xC0, 0x38, 0x18, 0x0E, 0x03, 0x83, 0x80, 0x30, 0x60,
  0x07, 0x1C, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00,
  0x31, 0xC0, 0x0E, 0x18, 0x03, 0x83, 0x00, 0x60, 0x30, 0x1C, 0x06, 0x07,
  0x00, 0xE0, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00,
  0xE0, 0x60, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x03, 0x01, 0x80, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03,
  0x8C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x80, 0x01, 0xB0, 0x00,
  0x1B, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x08,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xE0, 0x02, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x3C, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xF8,
  0x03, 0x39, 0xC0, 0x37, 0x0E, 0x06, 0x60, 0x70, 0x66, 0x03, 0x8C, 0xC0,
  0x1F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 9, 9, 12, 4, -32 },
  { 42, 21, 30, 21, 1, -30 },
  { 121, 17, 38, 20, 2, -34 },
  { 202, 19, 30, 26, 4, -30 },
  { 274, 19, 30, 22, 1, -30 },
  { 346, 4, 9, 7, 4, -32 },
  { 351, 12, 44, 12, 2, -34 },
  { 417, 12, 43, 12, -2, -33 },
  { 482, 17, 17, 17, 2, -30 },
  { 519, 17, 22, 20, 2, -25 },
  { 566, 6, 10, 8, -2, -4 },
  { 574, 9, 2, 11, 1, -14 },
  { 577, 4, 4, 10, 1, -4 },
  { 579, 18, 33, 14, -2, -30 },
  { 654, 17, 30, 20, 2, -30 },
  { 718, 10, 30, 20, 5, -30 },
  { 756, 18, 30, 20, 1, -30 },
  { 824, 18, 30, 20, 1, -30 },
  { 892, 17, 30, 20, 1, -30 },
  { 956, 18, 30, 20, 2, -30 },
  { 1024, 16, 30, 20, 2, -30 },
  { 1084, 17, 30, 20, 3, -30 },
  { 1148, 18, 30, 20, 1, -30 },
  { 1216, 15, 30, 20, 3, -30 },
  { 1273, 7, 23, 8, 1, -23 },
  { 1294, 9, 29, 8, -2, -23 },
  { 1327, 15, 17, 18, 2, -22 },
  { 1359, 16, 10, 20, 2, -19 },
  { 1379, 16, 17, 19, 1, -22 },
  { 1413, 13, 30, 16, 4, -30 },
  { 1462, 29, 38, 32, 1, -29 },
  { 1600, 20, 30, 22, -1, -30 },
  { 1675, 20, 30, 22, 1, -30 },
  { 1750, 20, 30, 23, 2, -30 },
  { 1825, 21, 30, 23, 1, -30 },
  { 1904, 21, 30, 20, 1, -30 },
  { 1983, 21, 30, 20, 1, -30 },
  { 2062, 20, 30, 24, 3, -30 },
  { 2137, 24, 30, 25, 1, -30 },
  { 2227, 7, 30, 10, 2, -30 },
  { 2254, 18, 30, 20, 1, -30 },
  { 2322, 23, 30, 22, 1, -30 },
  { 2409, 15, 30, 19, 1, -30 },
  { 2466, 29, 30, 30, 1, -30 },
  { 2575, 24, 30, 25, 1, -30 },
  { 2665, 21, 30, 24, 2, -30 },
  { 2744, 21, 30, 22, 1, -30 },
  { 2823, 21, 35, 24, 2, -30 },
  { 2915, 20, 30, 22, 1, -30 },
  { 2990, 20, 30, 21, 1, -30 },
  { 3065, 19, 30, 21, 4, -30 },
  { 3137, 21, 30, 23, 2, -30 },
  { 3216, 20, 30, 22, 4, -30 },
  { 3291, 29, 30, 31, 4, -30 },
  { 3400, 24, 30, 22, -1, -30 },
  { 3490, 20, 30, 21, 4, -30 },
  { 3565, 22, 30, 21, 0, -30 },
  { 3648, 12, 40, 9, 0, -34 },
  { 3708, 7, 33, 14, 4, -30 },
  { 3737, 13, 40, 9, -3, -34 },
  { 3802, 12, 15, 15, 2, -30 },
  { 3825, 15, 2, 16, -2, 0 },
  { 3829, 6, 6, 12, 5, -32 },
  { 3834, 16, 22, 19, 1, -22 },
  { 3878, 17, 32, 20, 1, -32 },
  { 3946, 16, 22, 18, 1, -22 },
  { 3990, 18, 32, 20, 2, -32 },
  { 4062, 16, 22, 19, 1, -22 },
  { 4106, 13, 32, 12, 2, -32 },
  { 4158, 19, 31, 20, 0, -22 },
  { 4232, 16, 32, 20, 1, -32 },
  { 4296, 8, 30, 9, 1, -30 },
  { 4326, 14, 39, 9, -5, -30 },
  { 4395, 17, 32, 18, 1, -32 },
  { 4463, 8, 32, 9, 1, -32 },
  { 4495, 28, 22, 31, 1, -22 },
  { 4572, 16, 22, 20, 1, -22 },
  { 4616, 16, 22, 20, 2, -22 },
  { 4660, 19, 31, 20, -1, -22 },
  { 4734, 17, 31, 20, 2, -22 },
  { 4800, 12, 22, 12, 1, -22 },
  { 4833, 16, 22, 18, 1, -22 },
  { 4877, 10, 28, 12, 2, -28 },
  { 4912, 16, 22, 20, 2, -22 },
  { 4956, 15, 22, 17, 3, -22 },
  { 4998, 24, 22, 27, 3, -22 },
  { 5064, 19, 22, 18, -1, -22 },
  { 5117, 20, 31, 17, -2, -22 },
  { 5195, 17, 22, 18, 0, -22 },
  { 5242, 13, 41, 12, 1, -33 },
  { 5309, 7, 36, 9, 1, -30 },
  { 5341, 13, 41, 12, -2, -33 },
  { 5408, 20, 8, 24, 2, -17 },
};

const GFXfont RobotoCondensed_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC42PT7B_H_
