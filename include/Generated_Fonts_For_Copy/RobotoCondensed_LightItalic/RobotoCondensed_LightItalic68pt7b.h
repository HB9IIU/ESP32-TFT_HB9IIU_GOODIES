#ifndef _ROBOTOCONDENSED_LIGHTITALIC68PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x60, 0x00, 0x3C, 0x39, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9C,
  0x39, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x38, 0xE1, 0xCE, 0x0E,
  0x70, 0x73, 0x83, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x10, 0x70, 0x07, 0x00, 0x38, 0x70, 0x07, 0x00, 0x38, 0x70, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x00, 0xF0, 0x70, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x1E, 0x00, 0x70, 0x1E, 0x1C,
  0x00, 0x38, 0x3C, 0x38, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x1F, 0xF0, 0x70,
  0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x07,
  0xF0, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x1C, 0x3C,
  0x1C, 0x00, 0x38, 0x78, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0xF0, 0x70,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0xE0,
  0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x0E, 0x0F, 0x01, 0xE0,
  0x0E, 0x0E, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0xC0, 0x0E, 0x3C, 0x00, 0xE0,
  0x0E, 0x38, 0x00, 0xE0, 0x1C, 0x10, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF1,
  0xE0, 0x07, 0x0F, 0x83, 0xC0, 0x1C, 0x7C, 0x0F, 0x00, 0x71, 0xE0, 0x1E,
  0x03, 0xCF, 0x00, 0x78, 0x0E, 0x3C, 0x00, 0xF0, 0x39, 0xE0, 0x03, 0xE1,
  0xE7, 0x80, 0x07, 0x87, 0x9C, 0x00, 0x0F, 0x1C, 0xF0, 0x00, 0x3C, 0xF3,
  0xC0, 0x00, 0x7B, 0x8F, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xF0, 0x3C, 0x00, 0x3F, 0xE0, 0xFC, 0x03, 0xE7, 0x81, 0xFF, 0xFF,
  0x0F, 0x03, 0xFF, 0xF8, 0x3C, 0x03, 0xFF, 0x80, 0x78, 0x01, 0xF0, 0x00,
  0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xCE,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x00, 0xDE, 0x03, 0x81, 0xFF,
  0xE0, 0xE1, 0xFF, 0xFF, 0x3B, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0xF0,
  0x0E, 0x00, 0x38, 0x01, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0,
  0xF0, 0x78, 0x1C, 0x02, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x77,
  0xFF, 0xFF, 0xB0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x3C, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00,
  0x07, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x3F,
  0xDE, 0xFF, 0x1C, 0xFC, 0x1C, 0xE0, 0x3C, 0x80, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0xFE, 0x00, 0x03, 0xDF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x07, 0x8F, 0xFE, 0x03, 0xDF, 0xFF,
  0x81, 0xDF, 0xDF, 0xE1, 0xFF, 0x01, 0xF0, 0xFE, 0x00, 0x7C, 0x7E, 0x00,
  0x1E, 0x3E, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F,
  0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7E,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x3E, 0x70, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x87, 0x80,
  0x1F, 0xC3, 0xE0, 0x3F, 0xE0, 0xFF, 0xFE, 0xF0, 0x3F, 0xFE, 0x70, 0x0F,
  0xFC, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x78, 0x1F, 0x83, 0xF0, 0x7C, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF0, 0x3E,
  0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x77, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xFF, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0xFF, 0x80,
  0x1C, 0x0E, 0x00, 0x3E, 0x1F, 0x00, 0x70, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0xC1, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0C,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x30, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xC7,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xCE, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x38, 0x03, 0x80, 0x07, 0x00, 0x1C, 0xE0, 0x0E,
  0x00, 0x1C, 0x00, 0x77, 0x00, 0x78, 0x00, 0x70, 0x01, 0xDC, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x39, 0xC0, 0x1C, 0x00,
  0x38, 0x00, 0xE7, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x9C, 0x01, 0xC0, 0x07,
  0x80, 0x0C, 0x70, 0x0F, 0x00, 0x1C, 0x00, 0x73, 0xC0, 0x3C, 0x00, 0x70,
  0x01, 0xCE, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x38, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xC3, 0x80, 0x3C, 0x03, 0xF0, 0x07,
  0x0E, 0x00, 0x70, 0x1D, 0xC0, 0x38, 0x1C, 0x01, 0xE0, 0xE7, 0x81, 0xE0,
  0x70, 0x07, 0xFF, 0x8F, 0x1F, 0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x00,
  0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3F,
  0x03, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0F,
  0x80, 0x07, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0x8F, 0x00, 0x1F, 0xFF, 0xC7, 0x80, 0x0F, 0xFF, 0xC3, 0xC0, 0x07,
  0xFF, 0xE1, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x00, 0x1C,
  0xFE, 0x00, 0x00, 0x01, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0x7B, 0xC0, 0x00,
  0x00, 0x7F, 0x9E, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x83,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xDE,
  0x00, 0x00, 0x07, 0xB8, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0x70, 0x07, 0x78,
  0x00, 0x00, 0x3D, 0xE0, 0x1E, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x3C, 0xE0,
  0x00, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x03, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x0F, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x1E, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0xE0, 0x00,
  0xF0, 0x78, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0x80, 0x07,
  0x81, 0xC0, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0x83, 0xC0, 0x1E,
  0x01, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x70,
  0x07, 0x80, 0x1C, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0xF0, 0x03, 0xC0,
  0x1C, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x77, 0x80, 0x0F, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x03,
  0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x0E,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xE0,
  0x00, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x1E, 0x01, 0xEE, 0x00, 0x00, 0x78,
  0x07, 0xBC, 0x00, 0x01, 0xC0, 0x1C, 0xF0, 0x00, 0x0F, 0x00, 0xF1, 0xC0,
  0x00, 0x3C, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x03, 0x81, 0xC0,
  0x01, 0xE0, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x38, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x1E, 0x03, 0xC0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0xF0, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0xF0, 0x00, 0x0F, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0xE0, 0x0E, 0x00,
  0x00, 0x7F, 0x80, 0x78, 0x00, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0x03, 0xF8,
  0x07, 0x80, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xBC, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x70, 0x01,
  0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x3C,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80,
  0x70, 0x07, 0x81, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x78, 0x07,
  0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x78,
  0x0E, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xE0, 0x07, 0x81,
  0xC0, 0x0E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x3C,
  0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x87, 0x80,
  0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF7,
  0x80, 0x00, 0xE7, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07,
  0x8E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x01, 0xE0, 0xF0, 0x38,
  0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xE3, 0xC0,
  0x1E, 0x70, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0x1E, 0x0F, 0x80, 0x07,
  0x07, 0xC0, 0x01, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x01, 0xF8,
  0x7C, 0x01, 0xFE, 0x0F, 0x81, 0xF7, 0x83, 0xFF, 0xF9, 0xE0, 0x7F, 0xFC,
  0x78, 0x0F, 0xFC, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x3C, 0x7F, 0xE0, 0x03, 0xCF, 0xFF, 0x80, 0x3D, 0xFF, 0xF8, 0x03,
  0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0xF0, 0x7F, 0x00, 0x3E, 0x07, 0x3C, 0x07, 0xE0, 0x71, 0xFF, 0xFC, 0x07,
  0x0F, 0xFF, 0x80, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0xC0, 0x7C,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x3F,
  0xF8, 0x78, 0x01, 0xFF, 0xF1, 0xE0, 0x0F, 0xFF, 0xE7, 0x80, 0x7E, 0x03,
  0x9E, 0x03, 0xE0, 0x07, 0x70, 0x0F, 0x00, 0x0D, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0xB8, 0x00, 0x7F, 0xFC, 0xE0, 0x00, 0xFF, 0xC3,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x87, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x60, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x03, 0xFF,
  0xE3, 0xC0, 0x1F, 0xFF, 0xCF, 0x00, 0xFC, 0x07, 0x3C, 0x07, 0xC0, 0x0E,
  0xE0, 0x1E, 0x00, 0x1B, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0,
  0x03, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0x70, 0x00, 0xFF, 0xF9, 0xC0, 0x01, 0xFF, 0x8F, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x0F, 0x00, 0x60,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x3E, 0x00, 0x1E, 0x1F, 0xF0, 0x03, 0xCF, 0xFF, 0x00,
  0x7B, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0x01, 0xFC, 0x01, 0xE0, 0x3F, 0x00,
  0x3C, 0x0F, 0xC0, 0x03, 0x81, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x00, 0x3E, 0x00, 0x38, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C,
  0x03, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1E, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xF3, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xBF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x3B, 0xC0, 0xFC, 0xF8, 0x1F, 0x01, 0xF8, 0x01, 0xE7, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0x70, 0x01, 0xE0, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0x7C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x7F,
  0xC0, 0x0F, 0x3F, 0xFC, 0x01, 0xEF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7C, 0x07,
  0xF0, 0x07, 0x80, 0xFC, 0x00, 0xF0, 0x3F, 0x00, 0x0E, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x7C, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC7, 0xFE, 0x00, 0x0F,
  0x3F, 0xFE, 0x00, 0x3D, 0xFF, 0xF8, 0x00, 0xEF, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x7B, 0x80, 0x7E, 0x01, 0xCF,
  0xFF, 0xF0, 0x07, 0x1F, 0xFF, 0x80, 0x3C, 0x1F, 0xF8, 0x00, 0xF0, 0x1F,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x1C, 0x07, 0xFF,
  0xC7, 0x81, 0xFF, 0xFC, 0xF0, 0x7E, 0x03, 0xDE, 0x1F, 0x00, 0x3B, 0x83,
  0xC0, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0xFE,
  0xE0, 0x0F, 0xFF, 0xBC, 0x00, 0xFF, 0xC7, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x3C,
  0x7F, 0x03, 0xCF, 0xF0, 0x3D, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFD, 0xE0, 0x07, 0xFE, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x1C, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF0, 0x00,
  0x7B, 0xC0, 0x03, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x80, 0x07, 0x9E, 0x00, 0x3F, 0x00, 0x1E, 0x3C, 0x00, 0x7E, 0x00,
  0x3C, 0x38, 0x01, 0xFC, 0x00, 0x70, 0x70, 0x03, 0xB8, 0x01, 0xE0, 0xE0,
  0x0F, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0xF0, 0x07, 0x03, 0x80, 0x39, 0xE0,
  0x1E, 0x07, 0x00, 0xF1, 0xC0, 0x38, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0x1C,
  0x07, 0x87, 0x01, 0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0x78, 0x3C, 0x1C,
  0x0F, 0x00, 0xF0, 0x70, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x70, 0x78, 0x03,
  0xC3, 0xC0, 0xE0, 0xF0, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0x1E, 0x38, 0x07, 0x8E, 0x00, 0x1C, 0xF0, 0x07, 0x3C, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3E, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x7F, 0xF8, 0x00,
  0x39, 0xFF, 0xF8, 0x00, 0x73, 0xC0, 0xF8, 0x01, 0xEF, 0x00, 0xF8, 0x03,
  0x9C, 0x00, 0xF8, 0x0F, 0x78, 0x01, 0xF8, 0x3C, 0xF0, 0x01, 0xFF, 0xF9,
  0xC0, 0x01, 0xFF, 0xE3, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 49, 14, 2, -48 },
  { 75, 13, 15, 19, 7, -51 },
  { 100, 34, 48, 34, 2, -48 },
  { 304, 28, 63, 32, 3, -56 },
  { 525, 32, 50, 42, 6, -49 },
  { 725, 30, 50, 35, 2, -49 },
  { 913, 6, 15, 11, 6, -51 },
  { 925, 20, 70, 19, 3, -54 },
  { 1100, 20, 70, 20, -4, -54 },
  { 1275, 26, 27, 28, 4, -48 },
  { 1363, 28, 35, 33, 3, -40 },
  { 1486, 10, 15, 13, -3, -6 },
  { 1505, 14, 3, 17, 2, -23 },
  { 1511, 5, 6, 16, 2, -5 },
  { 1515, 29, 52, 23, -3, -48 },
  { 1704, 27, 50, 32, 3, -49 },
  { 1873, 16, 48, 32, 9, -48 },
  { 1969, 29, 49, 32, 1, -49 },
  { 2147, 28, 50, 32, 2, -49 },
  { 2322, 29, 48, 32, 1, -48 },
  { 2496, 29, 49, 32, 4, -48 },
  { 2674, 25, 49, 32, 3, -48 },
  { 2828, 28, 48, 32, 5, -48 },
  { 2996, 29, 50, 32, 2, -49 },
  { 3178, 25, 49, 32, 5, -49 },
  { 3332, 11, 37, 14, 1, -36 },
  { 3383, 15, 45, 13, -3, -36 },
  { 3468, 25, 28, 30, 3, -36 },
  { 3556, 25, 19, 32, 4, -32 },
  { 3616, 26, 28, 30, 2, -36 },
  { 3707, 21, 50, 27, 6, -49 },
  { 3839, 46, 62, 52, 2, -47 },
  { 4196, 33, 48, 36, -2, -48 },
  { 4394, 31, 48, 35, 2, -48 },
  { 4580, 32, 50, 37, 4, -49 },
  { 4780, 33, 48, 38, 2, -48 },
  { 4978, 33, 48, 33, 2, -48 },
  { 5176, 33, 48, 32, 2, -48 },
  { 5374, 33, 50, 39, 4, -49 },
  { 5581, 38, 48, 41, 2, -48 },
  { 5809, 12, 48, 16, 3, -48 },
  { 5881, 30, 49, 32, 1, -48 },
  { 6065, 37, 48, 36, 2, -48 },
  { 6287, 24, 48, 31, 2, -48 },
  { 6431, 47, 48, 49, 2, -48 },
  { 6713, 38, 48, 41, 2, -48 },
  { 6941, 33, 50, 39, 4, -49 },
  { 7148, 33, 48, 36, 2, -48 },
  { 7346, 33, 57, 39, 4, -49 },
  { 7582, 33, 48, 36, 2, -48 },
  { 7780, 32, 50, 34, 2, -49 },
  { 7980, 31, 48, 34, 6, -48 },
  { 8166, 34, 49, 38, 4, -48 },
  { 8375, 33, 48, 36, 6, -48 },
  { 8573, 46, 48, 51, 7, -48 },
  { 8849, 38, 48, 35, -1, -48 },
  { 9077, 32, 48, 35, 6, -48 },
  { 9269, 36, 48, 34, 0, -48 },
  { 9485, 20, 65, 15, 0, -55 },
  { 9648, 11, 52, 23, 7, -48 },
  { 9720, 19, 65, 15, -4, -55 },
  { 9875, 19, 24, 24, 3, -48 },
  { 9932, 24, 3, 25, -3, 0 },
  { 9941, 9, 9, 19, 8, -51 },
  { 9952, 26, 38, 31, 1, -37 },
  { 10076, 28, 52, 32, 1, -51 },
  { 10258, 26, 38, 30, 2, -37 },
  { 10382, 30, 52, 32, 3, -51 },
  { 10577, 26, 38, 30, 2, -37 },
  { 10701, 21, 52, 20, 4, -52 },
  { 10838, 30, 51, 32, 0, -37 },
  { 11030, 27, 51, 32, 1, -51 },
  { 11203, 12, 49, 14, 2, -49 },
  { 11277, 22, 63, 14, -8, -49 },
  { 11451, 29, 51, 29, 1, -51 },
  { 11636, 12, 51, 14, 2, -51 },
  { 11713, 45, 37, 50, 1, -37 },
  { 11922, 27, 37, 32, 1, -37 },
  { 12047, 26, 38, 32, 3, -37 },
  { 12171, 30, 51, 32, -1, -37 },
  { 12363, 27, 51, 32, 3, -37 },
  { 12536, 20, 37, 20, 1, -37 },
  { 12629, 26, 38, 29, 1, -37 },
  { 12753, 16, 46, 19, 3, -45 },
  { 12845, 27, 37, 32, 3, -36 },
  { 12970, 25, 36, 28, 4, -36 },
  { 13083, 39, 36, 43, 5, -36 },
  { 13259, 30, 36, 28, -1, -36 },
  { 13394, 32, 50, 28, -3, -36 },
  { 13594, 28, 36, 28, 0, -36 },
  { 13720, 21, 66, 20, 2, -53 },
  { 13894, 13, 57, 15, 1, -48 },
  { 13987, 21, 66, 20, -4, -53 },
  { 14161, 31, 12, 39, 4, -26 },
};

const GFXfont RobotoCondensed_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC68PT7B_H_
