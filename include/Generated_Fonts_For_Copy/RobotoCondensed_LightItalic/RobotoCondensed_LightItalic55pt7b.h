#ifndef _ROBOTOCONDENSED_LIGHTITALIC55PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x70, 0x3C,
  0x07, 0x00, 0x00, 0x30, 0xDC, 0x37, 0x1D, 0xC7, 0x71, 0xD8, 0x76, 0x1B,
  0x86, 0xE3, 0xB0, 0xEC, 0x33, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xC0, 0xF0, 0x0E,
  0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x11, 0x80, 0x60, 0x1C, 0xC0, 0x30, 0x1C, 0xE0, 0x18,
  0x0C, 0x70, 0x0C, 0x0E, 0x38, 0x06, 0x0E, 0x1C, 0x07, 0x06, 0x0E, 0x03,
  0x87, 0x07, 0x01, 0x87, 0x01, 0x81, 0xC3, 0x00, 0xE1, 0xC3, 0x80, 0x3F,
  0xC3, 0x80, 0x0F, 0xC3, 0x80, 0x01, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE1, 0xFC,
  0x00, 0x61, 0xFF, 0x00, 0x71, 0xC1, 0x80, 0x70, 0xC0, 0xE0, 0x30, 0xE0,
  0x30, 0x38, 0x60, 0x18, 0x38, 0x30, 0x0C, 0x18, 0x18, 0x06, 0x1C, 0x1C,
  0x03, 0x1C, 0x0E, 0x01, 0x9C, 0x07, 0x01, 0xCE, 0x03, 0x80, 0xE6, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xF0, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70,
  0x03, 0xC0, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x83, 0xC0,
  0x03, 0xC7, 0x80, 0x01, 0xCF, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xB8, 0x00,
  0x0F, 0x3C, 0x07, 0x1E, 0x1C, 0x07, 0x3C, 0x1E, 0x07, 0x78, 0x0E, 0x06,
  0x70, 0x0F, 0x0E, 0xF0, 0x07, 0x0E, 0xE0, 0x03, 0x8E, 0xE0, 0x03, 0x9C,
  0xE0, 0x01, 0xDC, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x70, 0x01, 0xF8, 0x78, 0x03, 0xB8, 0x3E, 0x1F, 0x3C,
  0x1F, 0xFE, 0x1C, 0x0F, 0xF8, 0x1E, 0x00, 0x80, 0x00, 0x39, 0xCE, 0x67,
  0x39, 0xCE, 0x63, 0x39, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x06, 0x07, 0xFC, 0x30, 0xFB, 0xFD, 0xBF,
  0xC3, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0E,
  0xE0, 0x00, 0xF3, 0x80, 0x0F, 0x1C, 0x00, 0xF0, 0x70, 0x07, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0x00, 0x70, 0x08, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x1C,
  0x78, 0xE3, 0x82, 0x00, 0x7F, 0xF7, 0xFE, 0x7F, 0xE0, 0x77, 0xFE, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC3,
  0xC0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x0E,
  0x07, 0x80, 0xF0, 0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFC, 0x1F, 0xE7, 0xFF, 0x7E, 0x3B,
  0xC1, 0xD0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0x07, 0xC7, 0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x03, 0x81,
  0xE0, 0x07, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x7C,
  0x03, 0xC0, 0x78, 0x1E, 0x00, 0xE0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8F, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0x80, 0xFC, 0x7C, 0x01, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x9F, 0x80, 0x06, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x3F, 0x07, 0x80, 0x78, 0x07, 0x80, 0x20, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xF1, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x7E, 0x03, 0x9F, 0xF8, 0x33, 0xFF,
  0xC7, 0x70, 0x3C, 0x7E, 0x01, 0xE7, 0xC0, 0x0E, 0x78, 0x00, 0xE7, 0x00,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x78, 0x03, 0x83, 0x80, 0xF0,
  0x3F, 0x3E, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC7, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x81, 0xE0, 0x07, 0x03,
  0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x07, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x1C, 0x00, 0x70,
  0x78, 0x00, 0xF0, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80,
  0x78, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0xFC, 0x0F,
  0x01, 0xC1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xEF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x3E, 0x78, 0x07, 0xE3, 0xC1,
  0xEE, 0x1F, 0xFD, 0xC0, 0xFF, 0x9C, 0x07, 0xE1, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC3, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x08,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0,
  0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x01, 0xF0, 0x01, 0x87, 0x00, 0x3F, 0xE0, 0x0C, 0x38, 0x03, 0xFF,
  0x80, 0x61, 0x80, 0x38, 0x0E, 0x03, 0x1C, 0x03, 0x80, 0x60, 0x18, 0xC0,
  0x38, 0x03, 0x00, 0xCE, 0x01, 0xC0, 0x38, 0x06, 0x70, 0x1C, 0x01, 0xC0,
  0x33, 0x00, 0xE0, 0x0C, 0x01, 0xB8, 0x06, 0x00, 0x60, 0x0D, 0xC0, 0x70,
  0x07, 0x00, 0xEC, 0x03, 0x80, 0x38, 0x07, 0x60, 0x18, 0x01, 0x80, 0x33,
  0x01, 0xC0, 0x0C, 0x01, 0xB8, 0x0E, 0x00, 0xE0, 0x0D, 0xC0, 0x70, 0x07,
  0x00, 0xEE, 0x03, 0x00, 0x30, 0x07, 0x70, 0x18, 0x03, 0x80, 0x33, 0x00,
  0xC0, 0x1C, 0x01, 0x98, 0x06, 0x01, 0xE0, 0x18, 0xC0, 0x30, 0x0F, 0x00,
  0xC6, 0x01, 0x80, 0xF8, 0x0C, 0x30, 0x0E, 0x0F, 0xC0, 0xE1, 0xC0, 0x78,
  0xE7, 0x0E, 0x0E, 0x01, 0xFE, 0x3F, 0xE0, 0x70, 0x0F, 0xE0, 0xFE, 0x01,
  0x80, 0x08, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x70, 0x03, 0xC0, 0x38, 0x00, 0xF0,
  0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xC0,
  0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x7C,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF1, 0xF8, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x01, 0xF0, 0x07, 0xE3,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xC0,
  0x1F, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x70, 0x03,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0x1C, 0x01, 0xFF, 0xE3, 0x80, 0x3F, 0xFC, 0x70,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x78, 0x0F,
  0x80, 0x3F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x3B, 0xF8,
  0x00, 0x01, 0xFD, 0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x7C, 0x38, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x1D, 0x80, 0x00, 0x0F, 0xC0, 0xEE, 0x00, 0x00, 0x7E, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x3B, 0x80, 0x00, 0x7B, 0x81, 0xDC, 0x00, 0x03, 0x9C, 0x1C,
  0xE0, 0x00, 0x3C, 0xC0, 0xE3, 0x00, 0x01, 0xCE, 0x07, 0x1C, 0x00, 0x1E,
  0x70, 0x38, 0xE0, 0x00, 0xE3, 0x81, 0xC7, 0x00, 0x0F, 0x1C, 0x0E, 0x38,
  0x00, 0x70, 0xE0, 0xE1, 0xC0, 0x07, 0x0E, 0x07, 0x06, 0x00, 0x38, 0x70,
  0x38, 0x38, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x1C, 0x1C, 0x0E, 0x0E, 0x01,
  0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x0F, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0x70, 0x1C, 0x38, 0x07, 0x07, 0x80, 0xE1, 0xC0, 0x70, 0x38, 0x07,
  0x1C, 0x03, 0x81, 0xC0, 0x18, 0xE0, 0x1C, 0x0E, 0x00, 0xCE, 0x00, 0xE0,
  0x70, 0x07, 0x70, 0x07, 0x03, 0x80, 0x3F, 0x00, 0x38, 0x3C, 0x01, 0xF8,
  0x03, 0x81, 0xC0, 0x0F, 0x80, 0x1C, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x1C, 0x1F, 0x80, 0x00, 0xE0, 0x77, 0x00, 0x03, 0x81,
  0xDC, 0x00, 0x0E, 0x07, 0x38, 0x00, 0x38, 0x1C, 0xE0, 0x00, 0xE0, 0x73,
  0x80, 0x03, 0x83, 0xC7, 0x00, 0x1C, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x70,
  0x01, 0xC0, 0xE0, 0xE0, 0x07, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x0E, 0x00,
  0xF0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x38,
  0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x0E,
  0x00, 0x70, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0xE0, 0x03, 0x87, 0x03, 0x80,
  0x0E, 0x1C, 0x0E, 0x00, 0x38, 0x70, 0x78, 0x00, 0x73, 0x81, 0xC0, 0x01,
  0xCE, 0x07, 0x00, 0x03, 0xB8, 0x1C, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x3B,
  0x81, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0xC0, 0x38, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x7C, 0x0E,
  0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x1F, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0E, 0x00, 0x7C, 0x03,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0,
  0x70, 0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x07, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x8F,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x01,
  0xE0, 0x00, 0xF7, 0x00, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x1E, 0x00, 0x0E,
  0x70, 0x00, 0xF8, 0x00, 0x79, 0xC0, 0x03, 0x60, 0x01, 0xC7, 0x00, 0x1D,
  0x80, 0x07, 0x1C, 0x00, 0x76, 0x00, 0x38, 0x70, 0x01, 0x98, 0x00, 0xE1,
  0xC0, 0x0E, 0x60, 0x03, 0x87, 0x00, 0x39, 0x80, 0x1C, 0x1C, 0x01, 0xC7,
  0x00, 0x70, 0x70, 0x07, 0x1C, 0x01, 0xC1, 0xC0, 0x18, 0x70, 0x0E, 0x07,
  0x00, 0xE1, 0xC0, 0x38, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x1C, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xC0, 0xE0, 0x1C,
  0x0E, 0x03, 0x03, 0x80, 0x70, 0x38, 0x0C, 0x0E, 0x00, 0xC1, 0xC0, 0x30,
  0x70, 0x03, 0x07, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x03, 0x07, 0x00, 0x38,
  0xE0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0xE3,
  0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x0E, 0x70, 0x00, 0xEE,
  0x00, 0x39, 0x80, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x0E, 0xC0, 0x01, 0xB8,
  0x00, 0x3F, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x03,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x18, 0x0E, 0x30, 0x38, 0x60, 0x70,
  0xE1, 0xC1, 0xC3, 0x83, 0x8E, 0x07, 0x1C, 0x06, 0x70, 0x0C, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xE1, 0xE1, 0xC3, 0x83, 0x83, 0x07, 0x00, 0x04, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xC7, 0xE0, 0x78, 0x07, 0x07, 0x80, 0x3C, 0x38,
  0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0x00, 0x71, 0xE0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x03,
  0xC3, 0x80, 0x3E, 0x1E, 0x03, 0xF0, 0xFC, 0xFB, 0x83, 0xFF, 0x9C, 0x0F,
  0xF0, 0xE0, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x1F, 0xE0, 0x1D, 0xFF, 0xC0, 0x7F, 0x9F, 0x83, 0xF0,
  0x1E, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xE1, 0xF8,
  0x0F, 0x0E, 0x78, 0xFC, 0x38, 0xFF, 0xE0, 0xE1, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x87, 0xC0,
  0xF0, 0x0E, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x33, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x73, 0x80,
  0x07, 0x1C, 0x00, 0x38, 0xF0, 0x01, 0xC3, 0x80, 0x1C, 0x1E, 0x01, 0xC0,
  0x7C, 0x3E, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x1F, 0xE1, 0xC0, 0x1F, 0xFC, 0xE0, 0x1F, 0x9F, 0x70, 0x1E, 0x01,
  0xB8, 0x1E, 0x00, 0x7C, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x30,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0xFF,
  0x00, 0x3F, 0xFB, 0x80, 0x0F, 0xF1, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x00, 0xE1,
  0xE0, 0x0F, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x18, 0x78, 0x03, 0x83, 0xF1, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0x30, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x83, 0x00, 0xFF, 0xE7, 0x01, 0xF9, 0xF7, 0x03,
  0xC0, 0x37, 0x07, 0x80, 0x1F, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0xCF, 0xF0, 0x07,
  0xFF, 0x70, 0x03, 0xFC, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x03, 0xC0, 0x70,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x71, 0xFE,
  0x03, 0xBF, 0xF8, 0x1F, 0xE7, 0xC1, 0xD8, 0x0F, 0x0F, 0x80, 0x38, 0x78,
  0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x00, 0x78,
  0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x70, 0x78, 0x00,
  0xE1, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x1D,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFB, 0x80, 0x03, 0xE7,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x38, 0xFF, 0x01, 0xFE, 0x01, 0xDF, 0xFC, 0x3F, 0xF8, 0x0D,
  0xE3, 0xE3, 0xE7, 0xC0, 0xFC, 0x07, 0xB8, 0x0F, 0x07, 0xC0, 0x1D, 0x80,
  0x38, 0x3C, 0x00, 0xF8, 0x01, 0xC1, 0xC0, 0x07, 0xC0, 0x0E, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x00, 0x3C, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xFF, 0x01, 0xDF, 0xFC,
  0x0F, 0xF3, 0xE0, 0xEC, 0x07, 0x87, 0xC0, 0x1C, 0x3C, 0x00, 0xE1, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xF8, 0xF8, 0x0F, 0x80,
  0xF0, 0x38, 0x01, 0xC1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xE0, 0x0F, 0x03, 0x80,
  0x78, 0x0F, 0xC7, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC7, 0xF8, 0x01, 0xDF, 0xFC, 0x01, 0xFC,
  0x7E, 0x03, 0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x39, 0xE3,
  0xF0, 0x38, 0xFF, 0xE0, 0x38, 0x7F, 0x80, 0x38, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x70, 0x3F, 0xF9,
  0xC1, 0xF0, 0xF7, 0x0F, 0x00, 0xDC, 0x78, 0x01, 0xF1, 0xC0, 0x07, 0x8F,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x0F, 0x8F, 0xF0, 0x1F, 0xFD, 0xC0,
  0x3F, 0xCE, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x02, 0x07,
  0x3F, 0x07, 0x7F, 0x07, 0xFF, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x07, 0x80,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38,
  0xF0, 0x01, 0xC3, 0x80, 0x1E, 0x1E, 0x01, 0xE0, 0x7C, 0x3E, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x79, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0x73, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x87, 0x80, 0xFC,
  0x1F, 0x3E, 0xE0, 0x7F, 0xEE, 0x01, 0xFE, 0x70, 0x01, 0x00, 0x00, 0xE0,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x03, 0x83, 0x00, 0x38, 0x30, 0x07, 0x03, 0x80, 0x70,
  0x38, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x18, 0x1C,
  0x01, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6,
  0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0x0D, 0xC0, 0x00, 0xDC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x77,
  0x00, 0x3C, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xF0, 0x07, 0x38,
  0x07, 0x60, 0x1E, 0x30, 0x0E, 0xC0, 0x38, 0x60, 0x19, 0xC0, 0x70, 0xE0,
  0x73, 0x81, 0xC1, 0xC0, 0xC7, 0x03, 0x83, 0x83, 0x8E, 0x06, 0x07, 0x07,
  0x1C, 0x1C, 0x0E, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x70, 0xE0, 0x38, 0x60,
  0x61, 0xC0, 0x71, 0xC0, 0xC3, 0x00, 0xE3, 0x01, 0x8E, 0x01, 0xCE, 0x03,
  0x1C, 0x03, 0x9C, 0x06, 0x70, 0x07, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x1D,
  0x80, 0x1D, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x06, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x1E, 0x03,
  0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0x77, 0x80, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xE6, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x83, 0x80, 0x07,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x73, 0xFF, 0x80, 0x18,
  0xE1, 0xE0, 0x06, 0x70, 0x3C, 0x03, 0x9C, 0x07, 0x81, 0xC6, 0x00, 0xF0,
  0xF3, 0x80, 0x1F, 0xF8, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 40, 11, 1, -39 },
  { 51, 10, 12, 15, 6, -41 },
  { 66, 27, 39, 27, 2, -39 },
  { 198, 23, 51, 26, 2, -45 },
  { 345, 25, 41, 34, 5, -40 },
  { 474, 24, 41, 29, 2, -40 },
  { 597, 5, 12, 9, 5, -41 },
  { 605, 15, 57, 16, 3, -44 },
  { 712, 16, 57, 16, -3, -44 },
  { 826, 21, 22, 23, 3, -39 },
  { 884, 23, 28, 26, 2, -32 },
  { 965, 7, 12, 10, -2, -5 },
  { 976, 12, 3, 14, 1, -19 },
  { 981, 5, 5, 13, 1, -4 },
  { 985, 23, 42, 19, -2, -39 },
  { 1106, 21, 41, 26, 3, -40 },
  { 1214, 13, 39, 26, 7, -39 },
  { 1278, 23, 40, 26, 1, -40 },
  { 1393, 22, 41, 26, 2, -40 },
  { 1506, 23, 39, 26, 1, -39 },
  { 1619, 23, 40, 26, 3, -39 },
  { 1734, 20, 40, 26, 3, -39 },
  { 1834, 23, 39, 26, 4, -39 },
  { 1947, 23, 41, 26, 2, -40 },
  { 2065, 20, 40, 26, 4, -40 },
  { 2165, 9, 30, 11, 1, -29 },
  { 2199, 12, 36, 10, -2, -29 },
  { 2253, 21, 23, 24, 2, -29 },
  { 2314, 21, 14, 26, 3, -25 },
  { 2351, 21, 23, 24, 1, -29 },
  { 2412, 17, 41, 22, 5, -40 },
  { 2500, 37, 50, 42, 2, -38 },
  { 2732, 27, 39, 29, -2, -39 },
  { 2864, 25, 39, 29, 2, -39 },
  { 2986, 26, 41, 30, 3, -40 },
  { 3120, 27, 39, 30, 2, -39 },
  { 3252, 26, 39, 27, 2, -39 },
  { 3379, 26, 39, 26, 2, -39 },
  { 3506, 27, 41, 32, 3, -40 },
  { 3645, 30, 39, 33, 2, -39 },
  { 3792, 10, 39, 13, 2, -39 },
  { 3841, 24, 40, 26, 1, -39 },
  { 3961, 29, 39, 29, 2, -39 },
  { 4103, 19, 39, 25, 2, -39 },
  { 4196, 37, 39, 40, 2, -39 },
  { 4377, 30, 39, 33, 2, -39 },
  { 4524, 27, 41, 31, 3, -40 },
  { 4663, 27, 39, 29, 2, -39 },
  { 4795, 27, 47, 31, 3, -40 },
  { 4954, 26, 39, 29, 2, -39 },
  { 5081, 27, 41, 28, 1, -40 },
  { 5220, 25, 39, 28, 5, -39 },
  { 5342, 28, 40, 30, 3, -39 },
  { 5482, 26, 39, 29, 5, -39 },
  { 5609, 38, 39, 41, 5, -39 },
  { 5795, 31, 39, 29, -1, -39 },
  { 5947, 26, 39, 28, 5, -39 },
  { 6074, 29, 39, 28, 0, -39 },
  { 6216, 16, 53, 12, 0, -45 },
  { 6322, 8, 42, 19, 6, -39 },
  { 6364, 16, 53, 12, -3, -45 },
  { 6470, 15, 20, 20, 3, -39 },
  { 6508, 20, 3, 21, -3, 0 },
  { 6516, 7, 8, 15, 7, -42 },
  { 6523, 21, 31, 25, 1, -30 },
  { 6605, 22, 42, 26, 1, -41 },
  { 6721, 21, 31, 24, 2, -30 },
  { 6803, 25, 42, 26, 2, -41 },
  { 6935, 20, 31, 24, 2, -30 },
  { 7013, 17, 42, 16, 3, -42 },
  { 7103, 24, 41, 26, 0, -30 },
  { 7226, 21, 41, 26, 1, -41 },
  { 7334, 10, 39, 11, 1, -39 },
  { 7383, 17, 50, 11, -6, -39 },
  { 7490, 23, 41, 23, 1, -41 },
  { 7608, 11, 41, 11, 1, -41 },
  { 7665, 37, 30, 41, 1, -30 },
  { 7804, 21, 30, 26, 1, -30 },
  { 7883, 22, 31, 26, 2, -30 },
  { 7969, 24, 41, 26, -1, -30 },
  { 8092, 22, 41, 26, 2, -30 },
  { 8205, 16, 30, 16, 1, -30 },
  { 8265, 21, 31, 24, 1, -30 },
  { 8347, 12, 38, 16, 3, -37 },
  { 8404, 21, 30, 26, 3, -29 },
  { 8483, 20, 29, 23, 3, -29 },
  { 8556, 31, 29, 35, 4, -29 },
  { 8669, 24, 29, 23, -1, -29 },
  { 8756, 26, 40, 22, -2, -29 },
  { 8886, 22, 29, 23, 0, -29 },
  { 8966, 17, 54, 16, 2, -43 },
  { 9081, 10, 46, 12, 1, -39 },
  { 9139, 17, 54, 16, -3, -43 },
  { 9254, 26, 10, 32, 3, -21 },
};

const GFXfont RobotoCondensed_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC55PT7B_H_
