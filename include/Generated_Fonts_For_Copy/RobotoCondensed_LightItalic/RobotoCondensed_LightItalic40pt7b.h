#ifndef _ROBOTOCONDENSED_LIGHTITALIC40PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x86, 0x00, 0x23, 0x63, 0x63, 0x62, 0x66, 0x66, 0x46, 0xC6, 0xC4, 0x00,
  0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x04,
  0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x80, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x10,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x0E, 0x0C,
  0x06, 0x1C, 0x07, 0x18, 0x03, 0x18, 0x03, 0x38, 0x03, 0x18, 0x03, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xE0, 0x38, 0x70, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x81, 0xB0, 0x60, 0xCC, 0x18,
  0x63, 0x06, 0x18, 0xC1, 0x8C, 0x30, 0x46, 0x0C, 0x33, 0x01, 0xF8, 0xC0,
  0x3C, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x3C, 0x03, 0x1F, 0x81,
  0x8C, 0x30, 0x66, 0x0C, 0x31, 0x83, 0x18, 0x60, 0xCE, 0x10, 0x33, 0x04,
  0x0D, 0x81, 0x03, 0x40, 0x61, 0x80, 0x18, 0x60, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x38, 0xE0, 0x1C, 0x18, 0x06, 0x06, 0x01,
  0x81, 0x80, 0x60, 0x60, 0x18, 0x38, 0x06, 0x0C, 0x01, 0x8E, 0x00, 0x77,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x73, 0x03,
  0x38, 0xE0, 0xCC, 0x18, 0x36, 0x03, 0x19, 0x80, 0xE6, 0xE0, 0x1B, 0x38,
  0x07, 0xCE, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x1E, 0x1E, 0x0F, 0xC3, 0xFF,
  0x30, 0x3F, 0x06, 0x6D, 0xB5, 0xB6, 0xC0, 0x00, 0x20, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x61,
  0x87, 0xF9, 0x9F, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0x80, 0x06, 0xC0, 0x0C,
  0xC0, 0x18, 0x60, 0x38, 0x60, 0x70, 0x30, 0x20, 0x20, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x1C, 0x71, 0x86, 0x18, 0xE7, 0x18, 0x40, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0x0E, 0x0C, 0x06,
  0x1C, 0x06, 0x18, 0x07, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03,
  0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06,
  0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18,
  0xC0, 0x18, 0xE0, 0x38, 0x60, 0x70, 0x70, 0xE0, 0x3F, 0xC0, 0x1F, 0x80,
  0x00, 0x83, 0xC7, 0xFF, 0xBE, 0x1C, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xC3, 0xC1, 0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x1C, 0x60, 0x0E, 0x30,
  0x06, 0x38, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xFF,
  0x01, 0xC3, 0x81, 0xC0, 0x60, 0xC0, 0x30, 0xE0, 0x1C, 0x60, 0x0E, 0x30,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x73, 0x80, 0x30, 0xC0, 0x18, 0x70,
  0x18, 0x1C, 0x3C, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0xC6, 0x00, 0xC7, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x60, 0xC0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x30, 0x18, 0x38, 0x0C, 0x18, 0x06,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x78, 0x03, 0xFF, 0x01, 0xE3, 0xC1,
  0xC0, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xCC, 0x00, 0xC7, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x70,
  0x38, 0x1C, 0x38, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0x80, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xCF, 0x83, 0x3F, 0xC6, 0xC3, 0x8F, 0x03, 0x9C, 0x03,
  0x30, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8,
  0x01, 0xB8, 0x07, 0x30, 0x0C, 0x70, 0x38, 0x70, 0xE0, 0xFF, 0x80, 0x7C,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xE1, 0xC0, 0xC0, 0x60, 0xE0, 0x38,
  0x60, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01, 0x8E, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0xC0, 0x60, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x38, 0x38, 0x38,
  0x0C, 0x38, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCE, 0x00, 0x66, 0x00, 0x33,
  0x80, 0x38, 0xC0, 0x18, 0x60, 0x1C, 0x3C, 0x3C, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x70, 0xE1, 0xC0, 0xE3, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0xD8, 0x03, 0xB8, 0x07, 0x30, 0x1E, 0x70, 0xF8, 0x7F, 0xB0, 0x7C,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x1E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xC0, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0,
  0x60, 0x60, 0x20, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0x3F, 0xFE, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFD, 0xFF, 0xF8, 0x10, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x07,
  0xC0, 0xFF, 0x0E, 0x1C, 0x60, 0x66, 0x03, 0xB0, 0x1D, 0x80, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x0E, 0x03, 0xC0, 0x60, 0xC0, 0xFF, 0x02, 0x18, 0x1C, 0x38, 0x21,
  0x81, 0x83, 0x02, 0x18, 0x30, 0x30, 0x23, 0x03, 0x03, 0x02, 0x30, 0x60,
  0x30, 0x22, 0x06, 0x06, 0x02, 0x60, 0xC0, 0x60, 0x26, 0x0C, 0x06, 0x06,
  0x60, 0xC0, 0x60, 0x66, 0x0C, 0x04, 0x06, 0x40, 0xC0, 0xC0, 0x44, 0x18,
  0x0C, 0x0C, 0xC1, 0x80, 0xC0, 0xCC, 0x18, 0x1C, 0x08, 0xC0, 0xC3, 0xC1,
  0x8C, 0x0C, 0x6C, 0x30, 0x40, 0xFC, 0x7E, 0x04, 0x07, 0x83, 0xC0, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0xC0,
  0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0,
  0x1C, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x70, 0x18, 0x06, 0x07, 0x00, 0xC0,
  0xC0, 0x18, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xC0, 0x0C, 0x30, 0x01, 0x8E,
  0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x30, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x18, 0x0E, 0x03, 0x00, 0xE0,
  0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3,
  0x80, 0x18, 0x70, 0x07, 0x0C, 0x01, 0xC1, 0x80, 0x70, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xC0, 0x38, 0x30, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x38, 0x60,
  0x07, 0x0C, 0x03, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x1E, 0x0F, 0x03, 0x00, 0x60, 0xC0, 0x0E, 0x38, 0x00, 0xC6,
  0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xCE, 0x00, 0x18, 0xC0,
  0x07, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x0E, 0x07, 0x83, 0x80, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x06, 0x03, 0x80,
  0x60, 0x1C, 0x0E, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0xE3, 0x00,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x60,
  0x03, 0x86, 0x00, 0x70, 0x60, 0x0E, 0x06, 0x03, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0x83, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x61, 0xC0,
  0x06, 0x18, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x03, 0xFC, 0x60, 0x3F, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x87, 0x00, 0x18, 0x38, 0x07,
  0x83, 0xC1, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80,
  0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C,
  0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C,
  0x18, 0x70, 0xC1, 0x83, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0,
  0xE0, 0x70, 0x1C, 0x38, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x38,
  0x18, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x00, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x19, 0xC0, 0x00, 0x6F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0x98, 0x00, 0x3C, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x03,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x1C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xE0,
  0x18, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0D, 0x80, 0x03, 0xE0, 0xD8, 0x00, 0x36,
  0x0D, 0x80, 0x07, 0xE0, 0xD8, 0x00, 0x6C, 0x0D, 0x80, 0x0E, 0xC1, 0xCC,
  0x00, 0xCC, 0x18, 0xC0, 0x1C, 0xC1, 0x8C, 0x01, 0x9C, 0x18, 0xC0, 0x31,
  0x81, 0x8C, 0x03, 0x18, 0x18, 0xC0, 0x61, 0x83, 0x86, 0x06, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x30, 0x61, 0x83, 0x03, 0x06, 0x18,
  0x30, 0x30, 0x63, 0x03, 0x07, 0x03, 0x30, 0x30, 0x60, 0x36, 0x07, 0x06,
  0x03, 0x60, 0x70, 0x60, 0x3C, 0x06, 0x06, 0x03, 0xC0, 0x60, 0xE0, 0x38,
  0x06, 0x0E, 0x01, 0x80, 0x60, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x1C,
  0x00, 0x30, 0x3C, 0x00, 0x60, 0xF8, 0x00, 0xC1, 0xB0, 0x03, 0x83, 0x30,
  0x06, 0x06, 0x60, 0x0C, 0x0C, 0xC0, 0x18, 0x38, 0xC0, 0x30, 0x71, 0x80,
  0xE0, 0xC3, 0x81, 0xC1, 0x83, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x1C, 0x0C, 0x18, 0x30, 0x18, 0x70, 0x60, 0x18, 0xE0, 0xC0, 0x31, 0x81,
  0x80, 0x73, 0x03, 0x00, 0x66, 0x0E, 0x00, 0xCC, 0x18, 0x01, 0xF8, 0x30,
  0x01, 0xE0, 0x60, 0x03, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0x83, 0xC0, 0x60, 0x0C,
  0x0C, 0x00, 0xE1, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x60, 0x00, 0xCE, 0x00, 0x0C, 0xE0,
  0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0x60, 0x03, 0x86,
  0x00, 0x70, 0x70, 0x0E, 0x03, 0xC3, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x06, 0x01, 0xC0, 0x60, 0x0E, 0x0E, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x71, 0xC0,
  0x06, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18,
  0x07, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0x83, 0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xE1, 0xC0,
  0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x70,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xE6,
  0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C,
  0xE0, 0x01, 0x8E, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x70, 0x70, 0x0E,
  0x03, 0xC3, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x18, 0x0F, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x03, 0x8C,
  0x00, 0xE1, 0x80, 0x38, 0x30, 0x0F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x07, 0x00, 0xE0, 0xE0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x63, 0x80,
  0x0C, 0x70, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x03,
  0x00, 0xE0, 0xE0, 0x0C, 0x18, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x60, 0x01, 0xCC, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xC3, 0x00,
  0x38, 0x70, 0x0E, 0x07, 0x87, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x07,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00,
  0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x03, 0x06,
  0x00, 0x60, 0x70, 0x0E, 0x03, 0x83, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x39,
  0xC0, 0x06, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x81,
  0x80, 0x30, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x01,
  0x83, 0x80, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x03, 0x60, 0x0F, 0x00, 0x6C, 0x01, 0xE0, 0x1D,
  0x80, 0x7C, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x01, 0xB0, 0x1C, 0xE0, 0x66,
  0x03, 0x1C, 0x0C, 0x40, 0x61, 0x83, 0x8C, 0x1C, 0x30, 0x61, 0x83, 0x06,
  0x0C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x18, 0x60, 0xC3, 0x03, 0x1C, 0x18,
  0x60, 0x63, 0x03, 0x18, 0x0C, 0x60, 0x63, 0x01, 0x98, 0x0C, 0xE0, 0x33,
  0x01, 0x98, 0x06, 0x60, 0x33, 0x00, 0xD8, 0x06, 0xE0, 0x1B, 0x00, 0x58,
  0x03, 0xC0, 0x0B, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x38,
  0x0E, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0xC6, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x30, 0x70, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xE0,
  0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x03,
  0x00, 0x07, 0x00, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x30, 0x01,
  0x86, 0x00, 0x70, 0xE0, 0x1C, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x38,
  0x03, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0xCC, 0x00, 0x1B, 0x80,
  0x03, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x3E, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xC0, 0xFC, 0x00, 0xC3,
  0x0C, 0x18, 0x61, 0x86, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x03, 0xE0,
  0xFC, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x81, 0xF0, 0x3E, 0x00, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x40, 0x68, 0x19,
  0x83, 0x30, 0xC6, 0x18, 0xC6, 0x18, 0xC1, 0x30, 0x36, 0x07, 0x80, 0xC0,
  0xFF, 0xFD, 0xFF, 0xF8, 0xE3, 0x0C, 0x61, 0x80, 0x01, 0xF0, 0x0F, 0xF8,
  0x38, 0x70, 0xE0, 0x73, 0x80, 0x66, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x0F, 0xF8, 0x7F, 0xF1, 0xC0, 0x67, 0x00, 0xDC, 0x03, 0xB0, 0x07,
  0x60, 0x0C, 0xC0, 0x39, 0x80, 0xF3, 0xC7, 0x63, 0xFC, 0xC3, 0xE1, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0xF8, 0x1B, 0xFC, 0x1F, 0x0E,
  0x1C, 0x06, 0x18, 0x07, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x07, 0x70, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x0E, 0x60, 0x0C, 0xF0, 0x1C, 0xD8, 0x38, 0xCF, 0xF0, 0xC7, 0xC0,
  0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xDC,
  0x01, 0xB0, 0x03, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x70, 0xE1, 0xC1,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03,
  0xE3, 0x83, 0xFD, 0x83, 0x86, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0x80, 0x18,
  0xC0, 0x1C, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x1C, 0x38,
  0x1E, 0x0E, 0x1F, 0x07, 0xFB, 0x00, 0xF9, 0x80, 0x03, 0xF0, 0x0F, 0xF8,
  0x38, 0x70, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x30, 0xE1, 0xE1, 0xFF, 0x80, 0xFC, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x03, 0xFE, 0x1F, 0xF0, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x00, 0x01, 0xF0, 0xC0, 0xFF, 0x60, 0x70, 0xD8, 0x38, 0x0E, 0x1C, 0x03,
  0x86, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x0E, 0x0E, 0x07, 0x81, 0xC3, 0xE0, 0x7F, 0xB0, 0x0F, 0xCC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x10, 0x0E, 0x07,
  0x07, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x31, 0xF0, 0x67, 0xF0, 0xD8, 0x71, 0xE0, 0x63, 0x80, 0xCE, 0x01, 0x9C,
  0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x37, 0x00, 0xEC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x80, 0x76, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x00, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18,
  0x30, 0x60, 0xC3, 0x86, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x07, 0x18, 0x0E, 0x18, 0x1C, 0x18, 0x38, 0x18, 0x70, 0x38,
  0xE0, 0x31, 0xC0, 0x33, 0x80, 0x37, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7B,
  0x80, 0x71, 0x80, 0x61, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0x60, 0x60, 0xE0,
  0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0x06, 0x0C, 0x18, 0x30, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x00, 0x18, 0xF8,
  0x1F, 0x06, 0xFF, 0x1F, 0xE1, 0xF0, 0xEE, 0x1C, 0x70, 0x1A, 0x03, 0x1C,
  0x07, 0x80, 0xCE, 0x01, 0xC0, 0x33, 0x00, 0x70, 0x0C, 0xC0, 0x18, 0x03,
  0x30, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x33, 0x00, 0xE0, 0x1D, 0xC0, 0x38,
  0x07, 0x60, 0x0C, 0x01, 0x98, 0x03, 0x00, 0x66, 0x00, 0xC0, 0x19, 0x80,
  0x30, 0x06, 0xE0, 0x1C, 0x03, 0xB0, 0x06, 0x00, 0xEC, 0x01, 0x80, 0x33,
  0x00, 0x60, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0x18, 0xF8, 0x33, 0xF8, 0x6C,
  0x38, 0xF0, 0x31, 0xC0, 0x67, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x1B, 0x80, 0x76, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x60, 0x0D, 0xC0, 0x3B, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x80, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x07, 0x30, 0x03, 0x30,
  0x03, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x70, 0x18, 0x38,
  0x78, 0x1F, 0xF0, 0x0F, 0xC0, 0x06, 0x3E, 0x01, 0xBF, 0xC0, 0x7C, 0x38,
  0x1C, 0x06, 0x06, 0x01, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x0F, 0x01, 0xC3, 0x60, 0xE0,
  0xCF, 0xF0, 0x31, 0xF0, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xC3, 0x0F, 0xF6, 0x1C, 0x3E, 0x38, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x0E, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x38, 0x70,
  0xF0, 0x7F, 0xB0, 0x1F, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x18, 0xF1, 0xBE,
  0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0x70, 0xC0,
  0x63, 0x80, 0xE6, 0x00, 0xCE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0xC0, 0x71, 0xC3, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE3, 0xFF, 0xFF, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x3E, 0x0F, 0x00, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0xE0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x38, 0xE0, 0x70, 0x71, 0xF0, 0x7F, 0xB0, 0x3F, 0x30, 0x60, 0x0E,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x18,
  0x38, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30,
  0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xC0, 0x30, 0x0D, 0x80, 0x60, 0x1B, 0x01, 0xC0, 0x76, 0x03,
  0x80, 0xCC, 0x0D, 0x81, 0x98, 0x1B, 0x06, 0x30, 0x66, 0x0C, 0x60, 0xCC,
  0x38, 0x61, 0x98, 0x60, 0xC6, 0x30, 0xC1, 0x8C, 0x63, 0x03, 0x30, 0xC6,
  0x06, 0x61, 0x98, 0x0D, 0x83, 0x30, 0x1B, 0x06, 0x60, 0x36, 0x05, 0x80,
  0x78, 0x0B, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x83, 0x80, 0xE0, 0x60, 0x70, 0x1C, 0x18,
  0x03, 0x0E, 0x00, 0xC7, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xDC, 0x00, 0x63,
  0x00, 0x38, 0xC0, 0x1C, 0x18, 0x06, 0x06, 0x03, 0x81, 0xC1, 0xC0, 0x30,
  0x60, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x06,
  0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x70,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x10, 0x01, 0xC0, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0E,
  0x01, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x06, 0x0C,
  0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0x02, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x80, 0x00, 0x1F, 0x00, 0x67, 0xF0, 0x0D, 0xC7, 0x03, 0x30, 0x70, 0x6E,
  0x07, 0x19, 0x80, 0x7F, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 8, 1, -28 },
  { 26, 8, 9, 11, 4, -30 },
  { 35, 20, 28, 20, 1, -28 },
  { 105, 16, 36, 19, 2, -32 },
  { 177, 18, 28, 25, 4, -28 },
  { 240, 18, 28, 21, 1, -28 },
  { 303, 3, 9, 7, 4, -30 },
  { 307, 11, 41, 11, 2, -32 },
  { 364, 11, 41, 12, -2, -32 },
  { 421, 16, 16, 16, 2, -28 },
  { 453, 16, 20, 19, 2, -23 },
  { 493, 6, 9, 7, -2, -4 },
  { 500, 8, 2, 10, 1, -14 },
  { 502, 3, 3, 9, 1, -3 },
  { 504, 17, 30, 14, -2, -28 },
  { 568, 16, 28, 19, 2, -28 },
  { 624, 9, 28, 19, 5, -28 },
  { 656, 17, 28, 19, 1, -28 },
  { 716, 17, 28, 19, 1, -28 },
  { 776, 17, 28, 19, 1, -28 },
  { 836, 17, 28, 19, 2, -28 },
  { 896, 15, 28, 19, 2, -28 },
  { 949, 17, 28, 19, 3, -28 },
  { 1009, 17, 28, 19, 1, -28 },
  { 1069, 15, 28, 19, 3, -28 },
  { 1122, 6, 21, 8, 1, -21 },
  { 1138, 9, 26, 7, -2, -21 },
  { 1168, 14, 16, 17, 2, -21 },
  { 1196, 15, 10, 19, 2, -18 },
  { 1215, 15, 17, 18, 1, -21 },
  { 1247, 13, 28, 16, 3, -28 },
  { 1293, 28, 37, 30, 1, -28 },
  { 1423, 19, 28, 21, -1, -28 },
  { 1490, 19, 28, 21, 1, -28 },
  { 1557, 19, 28, 22, 2, -28 },
  { 1624, 20, 28, 22, 1, -28 },
  { 1694, 20, 28, 19, 1, -28 },
  { 1764, 20, 28, 19, 1, -28 },
  { 1834, 20, 28, 23, 2, -28 },
  { 1904, 23, 28, 24, 1, -28 },
  { 1985, 7, 28, 9, 2, -28 },
  { 2010, 18, 28, 19, 1, -28 },
  { 2073, 22, 28, 21, 1, -28 },
  { 2150, 14, 28, 18, 1, -28 },
  { 2199, 28, 28, 29, 1, -28 },
  { 2297, 23, 28, 24, 1, -28 },
  { 2378, 20, 28, 23, 2, -28 },
  { 2448, 20, 28, 21, 1, -28 },
  { 2518, 20, 33, 23, 2, -28 },
  { 2601, 19, 28, 21, 1, -28 },
  { 2668, 19, 28, 20, 1, -28 },
  { 2735, 18, 28, 20, 4, -28 },
  { 2798, 20, 28, 22, 2, -28 },
  { 2868, 19, 28, 21, 4, -28 },
  { 2935, 27, 28, 30, 4, -28 },
  { 3030, 23, 28, 21, -1, -28 },
  { 3111, 19, 28, 20, 4, -28 },
  { 3178, 21, 28, 20, 0, -28 },
  { 3252, 12, 39, 9, 0, -33 },
  { 3311, 6, 30, 14, 4, -28 },
  { 3334, 11, 39, 9, -2, -33 },
  { 3388, 11, 14, 14, 2, -28 },
  { 3408, 15, 2, 15, -2, 0 },
  { 3412, 5, 5, 11, 5, -30 },
  { 3416, 15, 21, 18, 1, -21 },
  { 3456, 16, 30, 19, 1, -30 },
  { 3516, 15, 21, 18, 1, -21 },
  { 3556, 17, 30, 19, 2, -30 },
  { 3620, 15, 21, 18, 1, -21 },
  { 3660, 13, 30, 12, 2, -30 },
  { 3709, 18, 29, 19, 0, -21 },
  { 3775, 15, 30, 19, 1, -30 },
  { 3832, 7, 29, 8, 1, -29 },
  { 3858, 13, 37, 8, -5, -29 },
  { 3919, 16, 30, 17, 1, -30 },
  { 3979, 7, 30, 8, 1, -30 },
  { 4006, 26, 21, 30, 1, -21 },
  { 4075, 15, 21, 19, 1, -21 },
  { 4115, 16, 21, 19, 1, -21 },
  { 4157, 18, 29, 19, -1, -21 },
  { 4223, 16, 29, 19, 2, -21 },
  { 4281, 12, 21, 12, 1, -21 },
  { 4313, 15, 21, 17, 1, -21 },
  { 4353, 9, 27, 11, 2, -27 },
  { 4384, 16, 21, 19, 2, -21 },
  { 4426, 15, 21, 16, 2, -21 },
  { 4466, 23, 21, 25, 3, -21 },
  { 4527, 18, 21, 17, -1, -21 },
  { 4575, 19, 29, 16, -2, -21 },
  { 4644, 16, 21, 17, 0, -21 },
  { 4686, 13, 39, 12, 1, -31 },
  { 4750, 7, 33, 9, 1, -28 },
  { 4779, 12, 39, 12, -2, -31 },
  { 4838, 19, 7, 23, 2, -15 },
};

const GFXfont RobotoCondensed_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC40PT7B_H_
