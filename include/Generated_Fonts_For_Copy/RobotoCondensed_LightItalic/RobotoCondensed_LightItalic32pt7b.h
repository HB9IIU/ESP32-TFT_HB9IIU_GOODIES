#ifndef _ROBOTOCONDENSED_LIGHTITALIC32PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x00, 0x66, 0xC9, 0x92, 0x64, 0xC9,
  0xB2, 0x00, 0x00, 0xC2, 0x00, 0xC6, 0x00, 0x84, 0x01, 0x84, 0x01, 0x8C,
  0x01, 0x08, 0x1F, 0xFF, 0x3F, 0xFF, 0x02, 0x10, 0x06, 0x10, 0x06, 0x30,
  0x04, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x08, 0x60, 0xFF, 0xF8, 0xFF, 0xF8,
  0x10, 0xC0, 0x10, 0x80, 0x31, 0x80, 0x21, 0x80, 0x21, 0x00, 0x63, 0x00,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x07, 0xC0, 0x7F, 0x06, 0x0C, 0x60, 0x63,
  0x03, 0x10, 0x08, 0x80, 0x44, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x19,
  0x81, 0x8C, 0x1C, 0x3F, 0xC0, 0xF8, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0xEC, 0x01, 0x08, 0x06, 0x10, 0x6C, 0x31, 0x98, 0x42, 0x20,
  0x8C, 0x61, 0x30, 0xC6, 0x40, 0xD9, 0x80, 0xE6, 0x00, 0x08, 0x00, 0x23,
  0x80, 0xDD, 0x83, 0x21, 0x04, 0xC3, 0x19, 0x86, 0x63, 0x0C, 0x86, 0x13,
  0x0C, 0x24, 0x18, 0xC0, 0x1B, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x1F, 0x80,
  0xC3, 0x03, 0x0C, 0x08, 0x30, 0x20, 0xC0, 0x86, 0x03, 0x18, 0x0D, 0xC0,
  0x3E, 0x00, 0x60, 0x03, 0x80, 0x1B, 0x04, 0xC4, 0x36, 0x18, 0xF0, 0x32,
  0xC0, 0xDB, 0x01, 0xEC, 0x07, 0x30, 0x1C, 0x60, 0xF1, 0xFE, 0x61, 0xF1,
  0x80, 0x6D, 0x2D, 0xB0, 0x00, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x00, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x10,
  0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0xC6, 0x3F, 0x7F, 0x1F, 0x80, 0xE0, 0x1A, 0x03, 0x30, 0x31,
  0x86, 0x18, 0x40, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x33, 0x36, 0x6C, 0x80,
  0xFF, 0xF0, 0x7C, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x18,
  0x63, 0x03, 0x30, 0x36, 0x03, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x2C, 0x02, 0x80, 0x68, 0x06, 0x80, 0x68, 0x04, 0x80,
  0xCC, 0x0C, 0xC1, 0x87, 0xF0, 0x3E, 0x00, 0x02, 0x0E, 0x7E, 0xE6, 0x86,
  0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x30,
  0x33, 0x01, 0x98, 0x0C, 0x80, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0x87,
  0x0C, 0x30, 0x33, 0x01, 0x98, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x81, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x36,
  0x01, 0xB0, 0x19, 0x80, 0xC6, 0x0C, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0B, 0x00, 0xD8, 0x0C, 0xC0, 0x46, 0x06,
  0x20, 0x63, 0x06, 0x18, 0x30, 0xC3, 0x06, 0x30, 0x31, 0x81, 0x1F, 0xFF,
  0xFF, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x0F, 0xF8, 0x7F, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x37, 0x81, 0xFE, 0x1C, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x66, 0x03, 0x30, 0x19, 0x81, 0x86, 0x1C, 0x3F, 0xC0,
  0x78, 0x00, 0x00, 0xE0, 0x7C, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x6F, 0x8B, 0xFB, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x78, 0x0F, 0x01, 0x60, 0x66, 0x18, 0xFF, 0x07, 0x80, 0x7F, 0xFD,
  0xFF, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0x06, 0x30, 0x31, 0x80, 0x88,
  0x04, 0xC0, 0x66, 0x03, 0x10, 0x18, 0xC1, 0x83, 0xF8, 0x3F, 0x83, 0x8E,
  0x30, 0x11, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x09, 0x80, 0xC6,
  0x0C, 0x3F, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xFC, 0x38, 0x63, 0x02, 0x60,
  0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x76, 0x06, 0x60,
  0xA3, 0xFE, 0x1E, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x07, 0xC0, 0x70, 0x00, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x00, 0x00, 0x10,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x40, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x20, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x30, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x00, 0x80, 0x00, 0x1E, 0x0F, 0xE6, 0x1B, 0x02, 0xC0, 0xF0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x38, 0x04, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1C, 0x03, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x21, 0x80, 0x00, 0x86, 0x07, 0x83, 0x30, 0x7F, 0x0C, 0xC3, 0x04,
  0x32, 0x08, 0x30, 0xD8, 0x60, 0xC3, 0x41, 0x02, 0x0D, 0x0C, 0x08, 0x2C,
  0x30, 0x60, 0xB0, 0xC1, 0x82, 0xC2, 0x04, 0x1B, 0x08, 0x30, 0x4C, 0x20,
  0xC1, 0x30, 0xC5, 0x08, 0xC3, 0xF6, 0x63, 0x07, 0x0E, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x80, 0x07,
  0xDE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x68, 0x00, 0x68, 0x00, 0xC8, 0x00, 0xCC, 0x01, 0x8C, 0x01, 0x8C, 0x03,
  0x0C, 0x03, 0x0C, 0x06, 0x04, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x06, 0x0F,
  0xFE, 0x1F, 0xFE, 0x18, 0x06, 0x30, 0x06, 0x30, 0x02, 0x60, 0x02, 0x60,
  0x03, 0xC0, 0x03, 0x0F, 0xF0, 0x1F, 0xF0, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0x63, 0x00, 0xC6, 0x01, 0x88, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xFF, 0xC1,
  0xFF, 0x03, 0x03, 0x04, 0x03, 0x18, 0x06, 0x30, 0x04, 0x60, 0x08, 0xC0,
  0x31, 0x80, 0x62, 0x01, 0xCC, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x23, 0x00, 0x66, 0x00, 0xD8, 0x01,
  0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x62, 0x01,
  0x86, 0x06, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x18,
  0x0C, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x02, 0x10, 0x02, 0x30,
  0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x40, 0x30, 0xC0,
  0x70, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xFF, 0xC1, 0xFF, 0x83, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xC1, 0xFF, 0x83,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xC8, 0x01, 0xB0, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x0F, 0xD8, 0x1F, 0xB0,
  0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x63, 0x00, 0xC7, 0x03,
  0x87, 0xFE, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x08,
  0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x40, 0x06, 0x30,
  0x01, 0x0C, 0x00, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0x03, 0x08, 0x00,
  0x86, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x0C, 0x30, 0xC2,
  0x18, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18,
  0x41, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x40, 0x30, 0x80,
  0x61, 0x80, 0x83, 0x03, 0x06, 0x0C, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x0C,
  0x03, 0x84, 0x03, 0x86, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80,
  0x61, 0x80, 0x21, 0x80, 0x31, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x07, 0xE0,
  0x03, 0x98, 0x01, 0x8C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x08, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x71, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0x20, 0x0D, 0x84, 0x80, 0x36, 0x33, 0x01, 0x90, 0xCC, 0x06, 0x43,
  0x30, 0x33, 0x0C, 0xC0, 0xCC, 0x31, 0x06, 0x30, 0x84, 0x18, 0xC6, 0x18,
  0xC2, 0x18, 0x63, 0x18, 0x61, 0x98, 0x61, 0x86, 0x61, 0x86, 0x0B, 0x06,
  0x10, 0x28, 0x18, 0xC0, 0xE0, 0x43, 0x03, 0x03, 0x0C, 0x0C, 0x0C, 0x00,
  0x0C, 0x00, 0xC3, 0x00, 0x31, 0xE0, 0x08, 0x78, 0x06, 0x1A, 0x01, 0x86,
  0xC0, 0x61, 0xB0, 0x18, 0x44, 0x06, 0x31, 0x81, 0x0C, 0x60, 0xC3, 0x08,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x18, 0xC6, 0x06, 0x21, 0x80, 0x98,
  0x60, 0x36, 0x18, 0x0D, 0x86, 0x01, 0x61, 0x00, 0x78, 0xC0, 0x1C, 0x30,
  0x03, 0x0C, 0x00, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x33,
  0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x33, 0x00, 0x66, 0x01, 0x86, 0x06, 0x07, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xF8, 0x0F, 0xFC, 0x18, 0x0E, 0x18, 0x06, 0x18, 0x02, 0x18, 0x02,
  0x18, 0x02, 0x10, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x1C,
  0x3F, 0xF8, 0x3F, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x0F, 0xF0, 0x70, 0x30, 0xC0, 0x23, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x60, 0x06, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x58, 0x00,
  0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01, 0x86,
  0x06, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x88, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x61, 0xFF, 0x83,
  0xFE, 0x04, 0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x20, 0xC0, 0x61, 0x80,
  0xC2, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x06, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x30, 0x30, 0xC0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x86, 0x07,
  0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x30, 0x06, 0x20,
  0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40,
  0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x60, 0x7F, 0xC0, 0x1F, 0x80, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x88, 0x03, 0x18, 0x0C,
  0x30, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x03, 0x06, 0x02, 0x0C, 0x04,
  0x30, 0x0C, 0x60, 0x19, 0x80, 0x33, 0x00, 0x64, 0x00, 0xD8, 0x00, 0xA0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x07, 0x01, 0xB0, 0x1C, 0x06, 0xC0, 0x50, 0x1B, 0x03, 0x40, 0xCC,
  0x09, 0x03, 0x10, 0x66, 0x08, 0x41, 0x98, 0x61, 0x04, 0x61, 0x84, 0x31,
  0x84, 0x10, 0x86, 0x30, 0x46, 0x18, 0xC1, 0x98, 0x62, 0x06, 0x40, 0x98,
  0x1B, 0x02, 0x60, 0x6C, 0x0B, 0x01, 0xA0, 0x2C, 0x07, 0x80, 0xB0, 0x1C,
  0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0xC0, 0xC0, 0x38, 0x18, 0x06, 0x01, 0x81, 0x80, 0x30, 0x70, 0x06,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x07, 0x80, 0x19, 0x80, 0x63,
  0x00, 0xC6, 0x03, 0x04, 0x0E, 0x0C, 0x18, 0x18, 0x60, 0x30, 0xC0, 0x23,
  0x00, 0x6C, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x07, 0x83, 0xC1, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x07,
  0xC3, 0xE0, 0xC6, 0x10, 0x84, 0x31, 0x8C, 0x61, 0x08, 0x43, 0x18, 0xC6,
  0x10, 0x84, 0x31, 0x8C, 0x61, 0x08, 0x07, 0x83, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x87, 0xC3, 0xE0, 0x06, 0x06, 0x0E, 0x1A, 0x1A, 0x33, 0x33,
  0x63, 0x63, 0xC1, 0xC1, 0x7F, 0xFF, 0xFF, 0xC6, 0x23, 0x07, 0xC1, 0xFE,
  0x38, 0x63, 0x03, 0x60, 0x30, 0x03, 0x00, 0x20, 0xFE, 0x3E, 0x66, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1, 0xCF, 0xFC, 0x3C, 0xC0, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x78,
  0x3F, 0xE1, 0xC1, 0x8C, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x0D, 0x80, 0x4C,
  0x02, 0x60, 0x32, 0x01, 0x90, 0x0D, 0x80, 0x4C, 0x06, 0x70, 0x73, 0x7F,
  0x11, 0xE0, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x60, 0x36, 0x03, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0xC0, 0x6C, 0x0C, 0x60,
  0xC7, 0xF8, 0x1F, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x81, 0xE6, 0x1F, 0xD8, 0xE1, 0xE3, 0x03, 0x98,
  0x04, 0x60, 0x11, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x8C,
  0x06, 0x30, 0x18, 0x40, 0x61, 0x83, 0x87, 0xF6, 0x0F, 0x90, 0x07, 0xC1,
  0xFE, 0x38, 0x63, 0x03, 0x60, 0x36, 0x03, 0x40, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0xC7, 0xFC, 0x1F, 0x00,
  0x03, 0xC3, 0xE0, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x03, 0xFC, 0xFE, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0xC3, 0xC6,
  0x07, 0x30, 0x08, 0xC0, 0x23, 0x01, 0x88, 0x06, 0x60, 0x19, 0x80, 0x66,
  0x01, 0x18, 0x04, 0x60, 0x31, 0x80, 0xC3, 0x07, 0x0F, 0xEC, 0x1F, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x43, 0x03, 0x07, 0xF8, 0x07, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x3C,
  0x37, 0xE3, 0x83, 0x30, 0x33, 0x03, 0x20, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x24, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x48, 0x0C,
  0x08, 0x71, 0x80, 0x00, 0x00, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18,
  0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0x00, 0x40, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xF0, 0x3C,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x06, 0x30, 0x61, 0x87, 0x0C, 0x70, 0x67, 0x02, 0x70, 0x37, 0x01,
  0xF0, 0x0F, 0x80, 0x76, 0x03, 0x30, 0x10, 0xC1, 0x86, 0x0C, 0x18, 0x60,
  0xC3, 0x03, 0x10, 0x18, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0x33, 0xC1,
  0xE1, 0xBF, 0x3F, 0x8E, 0x0F, 0x0E, 0x60, 0x70, 0x33, 0x03, 0x81, 0x90,
  0x18, 0x0D, 0x80, 0xC0, 0x6C, 0x06, 0x03, 0x60, 0x30, 0x13, 0x01, 0x01,
  0x90, 0x18, 0x0D, 0x80, 0xC0, 0x6C, 0x06, 0x03, 0x60, 0x30, 0x1B, 0x01,
  0x80, 0x98, 0x08, 0x0C, 0x80, 0xC0, 0x60, 0x33, 0xC3, 0x7E, 0x38, 0x33,
  0x03, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x02, 0x40, 0x64,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0x80, 0xC0, 0x07, 0xC0, 0xFF,
  0x06, 0x0C, 0x60, 0x66, 0x01, 0xB0, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x16,
  0x00, 0xB0, 0x0D, 0x80, 0x6C, 0x02, 0x30, 0x31, 0x83, 0x07, 0xF0, 0x1F,
  0x00, 0x0C, 0xF0, 0x1F, 0xF0, 0x38, 0x30, 0x60, 0x60, 0xC0, 0x41, 0x00,
  0xC6, 0x01, 0x0C, 0x02, 0x18, 0x04, 0x30, 0x18, 0x60, 0x30, 0x80, 0x63,
  0x00, 0x86, 0x03, 0x0E, 0x0C, 0x1F, 0xF8, 0x23, 0xC0, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x0F, 0x98,
  0xFE, 0xCE, 0x0E, 0x60, 0x76, 0x01, 0x30, 0x19, 0x80, 0xC8, 0x06, 0xC0,
  0x36, 0x01, 0xB0, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x31, 0x83, 0x8F, 0xEC,
  0x3E, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x33, 0x9F, 0xCE, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x00, 0x07, 0x81, 0xFE,
  0x30, 0x63, 0x02, 0x20, 0x32, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xC0, 0x0C, 0x80, 0x4C, 0x0C, 0xC1, 0xC7, 0xF8, 0x3E, 0x00, 0x18,
  0x30, 0x40, 0x8F, 0xFF, 0xCC, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x07, 0x87, 0x00, 0x60, 0x36, 0x03, 0x60, 0x36, 0x02,
  0x40, 0x24, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0x80, 0xC8, 0x0C,
  0x80, 0xCC, 0x1C, 0xC3, 0xCF, 0xE8, 0x7C, 0x80, 0xC0, 0x2C, 0x06, 0xC0,
  0x4C, 0x0C, 0x40, 0xC4, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x20, 0x26,
  0x02, 0x40, 0x2C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x30, 0x00, 0xC0, 0xC0,
  0xF0, 0x30, 0x34, 0x0C, 0x09, 0x07, 0x06, 0x41, 0x41, 0x90, 0xD8, 0xC4,
  0x26, 0x31, 0x19, 0x88, 0x66, 0x66, 0x19, 0x19, 0x86, 0xC6, 0x41, 0xA0,
  0xB0, 0x78, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x00, 0x08, 0x0C, 0x30, 0x60, 0xC1, 0x81, 0x0C, 0x06, 0x60, 0x09, 0x80,
  0x3C, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x68, 0x03, 0x30, 0x0C, 0xC0,
  0x61, 0x83, 0x06, 0x1C, 0x18, 0x60, 0x30, 0x18, 0x04, 0x30, 0x18, 0x60,
  0x30, 0xC0, 0xC0, 0x81, 0x81, 0x06, 0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60,
  0x18, 0x80, 0x33, 0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xC0, 0x70, 0x30,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x0E, 0x0F, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x08,
  0x46, 0x31, 0x8C, 0x42, 0x31, 0x8C, 0x62, 0x11, 0x8C, 0x63, 0x10, 0x84,
  0x63, 0x18, 0xC4, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x07,
  0x03, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3C, 0x06, 0xFC, 0x09, 0x0C,
  0x16, 0x0C, 0x6C, 0x1F, 0x90, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 7, 7, 9, 3, -24 },
  { 26, 16, 23, 16, 1, -23 },
  { 72, 13, 29, 15, 1, -26 },
  { 120, 15, 23, 20, 3, -23 },
  { 164, 14, 23, 17, 1, -23 },
  { 205, 3, 7, 5, 3, -24 },
  { 208, 9, 33, 9, 2, -26 },
  { 246, 9, 33, 9, -2, -26 },
  { 284, 12, 13, 13, 2, -23 },
  { 304, 13, 17, 15, 1, -19 },
  { 332, 4, 7, 6, -1, -3 },
  { 336, 6, 2, 8, 1, -11 },
  { 338, 2, 3, 7, 1, -3 },
  { 339, 13, 25, 11, -1, -23 },
  { 380, 12, 23, 15, 2, -23 },
  { 415, 8, 23, 15, 4, -23 },
  { 438, 13, 23, 15, 1, -23 },
  { 476, 13, 23, 15, 1, -23 },
  { 514, 13, 23, 15, 1, -23 },
  { 552, 13, 23, 15, 2, -23 },
  { 590, 11, 23, 15, 2, -23 },
  { 622, 14, 23, 15, 2, -23 },
  { 663, 13, 23, 15, 1, -23 },
  { 701, 12, 23, 15, 2, -23 },
  { 736, 5, 17, 6, 1, -17 },
  { 747, 7, 21, 6, -1, -17 },
  { 766, 12, 13, 14, 1, -17 },
  { 786, 12, 9, 15, 2, -15 },
  { 800, 12, 13, 14, 1, -17 },
  { 820, 10, 23, 13, 3, -23 },
  { 849, 22, 29, 24, 1, -22 },
  { 929, 16, 23, 17, -1, -23 },
  { 975, 15, 23, 17, 1, -23 },
  { 1019, 15, 23, 18, 2, -23 },
  { 1063, 16, 23, 18, 1, -23 },
  { 1109, 15, 23, 15, 1, -23 },
  { 1153, 15, 23, 15, 1, -23 },
  { 1197, 15, 23, 18, 2, -23 },
  { 1241, 18, 23, 19, 1, -23 },
  { 1293, 6, 23, 8, 1, -23 },
  { 1311, 15, 23, 15, 0, -23 },
  { 1355, 17, 23, 17, 1, -23 },
  { 1404, 11, 23, 14, 1, -23 },
  { 1436, 22, 23, 23, 1, -23 },
  { 1500, 18, 23, 19, 1, -23 },
  { 1552, 15, 23, 18, 2, -23 },
  { 1596, 16, 23, 17, 1, -23 },
  { 1642, 15, 27, 18, 2, -23 },
  { 1693, 15, 23, 17, 1, -23 },
  { 1737, 15, 23, 16, 1, -23 },
  { 1781, 15, 23, 16, 3, -23 },
  { 1825, 16, 23, 18, 2, -23 },
  { 1871, 15, 23, 17, 3, -23 },
  { 1915, 22, 23, 24, 3, -23 },
  { 1979, 19, 23, 17, -1, -23 },
  { 2034, 15, 23, 16, 3, -23 },
  { 2078, 17, 23, 16, 0, -23 },
  { 2127, 9, 31, 7, 0, -26 },
  { 2162, 5, 25, 11, 3, -23 },
  { 2178, 9, 31, 7, -2, -26 },
  { 2213, 8, 11, 11, 2, -23 },
  { 2224, 12, 2, 12, -2, 0 },
  { 2227, 4, 4, 9, 4, -24 },
  { 2229, 12, 17, 15, 1, -17 },
  { 2255, 13, 24, 15, 1, -24 },
  { 2294, 12, 17, 14, 1, -17 },
  { 2320, 14, 24, 15, 1, -24 },
  { 2362, 12, 17, 14, 1, -17 },
  { 2388, 10, 24, 9, 2, -24 },
  { 2418, 14, 24, 15, 0, -17 },
  { 2460, 12, 24, 15, 1, -24 },
  { 2496, 6, 24, 7, 1, -24 },
  { 2514, 11, 31, 7, -4, -24 },
  { 2557, 13, 24, 13, 1, -24 },
  { 2596, 6, 24, 7, 1, -24 },
  { 2614, 21, 17, 24, 1, -17 },
  { 2659, 12, 17, 15, 1, -17 },
  { 2685, 13, 17, 15, 1, -17 },
  { 2713, 15, 24, 15, -1, -17 },
  { 2758, 13, 24, 15, 1, -17 },
  { 2797, 9, 17, 9, 1, -17 },
  { 2817, 12, 17, 14, 1, -17 },
  { 2843, 7, 21, 9, 2, -21 },
  { 2862, 12, 17, 15, 2, -17 },
  { 2888, 12, 17, 13, 2, -17 },
  { 2914, 18, 17, 20, 2, -17 },
  { 2953, 14, 17, 13, -1, -17 },
  { 2983, 15, 24, 13, -1, -17 },
  { 3028, 13, 17, 13, 0, -17 },
  { 3056, 10, 31, 9, 1, -25 },
  { 3095, 5, 27, 7, 1, -23 },
  { 3112, 10, 31, 9, -2, -25 },
  { 3151, 15, 6, 18, 2, -13 },
};

const GFXfont RobotoCondensed_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC32PT7B_H_
