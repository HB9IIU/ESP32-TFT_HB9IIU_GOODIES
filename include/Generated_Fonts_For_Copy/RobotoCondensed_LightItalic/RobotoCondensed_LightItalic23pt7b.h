#ifndef _ROBOTOCONDENSED_LIGHTITALIC23PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x64, 0x44, 0x44, 0x00, 0x08, 0x80, 0x4A, 0x54,
  0xA9, 0x00, 0x02, 0x60, 0x88, 0x11, 0x02, 0x60, 0x88, 0x7F, 0xC2, 0x20,
  0xC8, 0x11, 0x02, 0x20, 0x48, 0x7F, 0xC2, 0x20, 0x48, 0x11, 0x02, 0x20,
  0x48, 0x00, 0x02, 0x01, 0x03, 0xC3, 0x32, 0x09, 0x04, 0x82, 0x40, 0x20,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0A, 0x05, 0x02, 0xC3, 0x23, 0x0F, 0x02,
  0x01, 0x00, 0x38, 0x09, 0x01, 0x11, 0x42, 0x48, 0x89, 0x12, 0x32, 0x83,
  0x90, 0x04, 0x01, 0x38, 0x29, 0x09, 0x12, 0x42, 0xC8, 0x51, 0x10, 0x12,
  0x03, 0x80, 0x0E, 0x06, 0x41, 0x10, 0xC4, 0x31, 0x0C, 0x81, 0x40, 0x60,
  0x38, 0x1B, 0x14, 0x46, 0x1A, 0x82, 0xA0, 0xC8, 0x33, 0x1E, 0x3C, 0x80,
  0x56, 0x80, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x00, 0x10,
  0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08,
  0x41, 0x08, 0x63, 0x08, 0x00, 0x04, 0x02, 0x03, 0x1D, 0x33, 0xE0, 0xE0,
  0xD0, 0xCC, 0x42, 0x00, 0x04, 0x02, 0x01, 0x01, 0x80, 0x87, 0xFC, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x00, 0x25, 0xA8, 0xF0, 0xC0, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x08, 0xC8, 0x24,
  0x16, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xE0, 0xF0, 0x50, 0x28, 0x14, 0x1B,
  0x08, 0x8C, 0x3C, 0x00, 0x09, 0xF2, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x42,
  0x10, 0x84, 0x60, 0x07, 0x86, 0x21, 0x04, 0xC1, 0x20, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xFF,
  0x80, 0x0F, 0x08, 0x88, 0x2C, 0x14, 0x08, 0x04, 0x06, 0x06, 0x1C, 0x01,
  0x00, 0x40, 0x28, 0x14, 0x0A, 0x0C, 0x8C, 0x3C, 0x00, 0x00, 0xC0, 0x30,
  0x1C, 0x0A, 0x02, 0x81, 0x20, 0xC8, 0x26, 0x11, 0x8C, 0x42, 0x11, 0x04,
  0xFF, 0xC0, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x1F, 0xC4, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x03, 0xE0, 0xCC, 0x01, 0x00, 0x60, 0x18, 0x06, 0xC1, 0x30,
  0x44, 0x31, 0x98, 0x3C, 0x00, 0x03, 0x06, 0x06, 0x06, 0x02, 0x03, 0x01,
  0x78, 0xE6, 0x41, 0x60, 0xB0, 0x70, 0x28, 0x16, 0x09, 0x0C, 0xCC, 0x3C,
  0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x00, 0x0F, 0x08, 0xC8,
  0x24, 0x12, 0x09, 0x04, 0x86, 0x66, 0x3E, 0x31, 0xB0, 0x50, 0x28, 0x14,
  0x0A, 0x0D, 0x8C, 0x3C, 0x00, 0x1C, 0x62, 0x43, 0xC1, 0x81, 0x81, 0x81,
  0x83, 0x83, 0xC7, 0x7A, 0x02, 0x06, 0x04, 0x08, 0x30, 0xE0, 0x33, 0x00,
  0x00, 0x00, 0x00, 0x4C, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x46,
  0x22, 0x00, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0x60, 0x38, 0x0E, 0x02, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x40, 0x70, 0x1C, 0x06, 0x01, 0x06, 0x38,
  0xE0, 0x80, 0x3C, 0xCF, 0x0C, 0x10, 0x20, 0xC1, 0x04, 0x10, 0x60, 0x83,
  0x00, 0x00, 0x00, 0x20, 0xC0, 0x01, 0xF0, 0x0C, 0x18, 0x20, 0x10, 0x80,
  0x13, 0x00, 0x24, 0x3C, 0x50, 0x88, 0xA3, 0x11, 0x44, 0x23, 0x18, 0x46,
  0x21, 0x0C, 0x42, 0x18, 0x84, 0x51, 0x18, 0xA2, 0x52, 0x43, 0x38, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x1C,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x86,
  0x18, 0x21, 0xFE, 0x30, 0x22, 0x02, 0x60, 0x24, 0x02, 0x40, 0x20, 0x3F,
  0x0C, 0x32, 0x04, 0x81, 0x20, 0x48, 0x16, 0x0D, 0x86, 0x7F, 0x10, 0x64,
  0x09, 0x02, 0xC0, 0xB0, 0x28, 0x1A, 0x0C, 0xFE, 0x00, 0x07, 0x83, 0x18,
  0x41, 0x90, 0x12, 0x02, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x04, 0x81, 0x90, 0x23, 0x18, 0x3E, 0x00, 0x3F, 0x06, 0x18,
  0x81, 0x10, 0x32, 0x02, 0x40, 0x58, 0x0B, 0x03, 0x40, 0x68, 0x09, 0x01,
  0x20, 0x2C, 0x0D, 0x81, 0x20, 0x64, 0x38, 0xFC, 0x00, 0x3F, 0xE6, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x7F, 0x88, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFF, 0x00, 0x3F, 0xE6, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x7F, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x00, 0x07, 0x83, 0x08,
  0x40, 0x90, 0x12, 0x02, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x7D, 0x01,
  0x60, 0x24, 0x04, 0x80, 0x90, 0x31, 0x0C, 0x1F, 0x00, 0x30, 0x11, 0x80,
  0x88, 0x04, 0x40, 0x22, 0x03, 0x10, 0x19, 0x80, 0x8C, 0x04, 0x7F, 0xE2,
  0x01, 0x10, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x22, 0x01, 0x10, 0x08, 0x80,
  0xC0, 0x11, 0x32, 0x22, 0x22, 0x64, 0x44, 0x44, 0xC8, 0x80, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xCC, 0x19, 0x82, 0x10, 0xC3, 0x30, 0x3C, 0x00, 0x30, 0x33,
  0x06, 0x20, 0xC2, 0x18, 0x23, 0x02, 0x60, 0x64, 0x06, 0x80, 0x5C, 0x06,
  0x40, 0x46, 0x04, 0x20, 0xC2, 0x0C, 0x10, 0x81, 0x08, 0x18, 0x80, 0x80,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0xC0, 0x80, 0x80, 0xFF, 0x30, 0x02, 0x60, 0x0C, 0xE0, 0x19, 0x40,
  0x52, 0x80, 0xA5, 0x02, 0xDA, 0x05, 0x34, 0x12, 0x4C, 0x24, 0x98, 0x89,
  0x11, 0x32, 0x24, 0x6C, 0x48, 0x98, 0xA1, 0x21, 0x42, 0x43, 0x04, 0x82,
  0x18, 0x30, 0x11, 0x80, 0x8E, 0x04, 0x50, 0x22, 0x81, 0x16, 0x19, 0x90,
  0x8C, 0x84, 0x42, 0x22, 0x11, 0x10, 0x88, 0x82, 0xCC, 0x14, 0x60, 0xE2,
  0x03, 0x10, 0x18, 0x80, 0xC0, 0x07, 0x83, 0x18, 0xC1, 0x90, 0x12, 0x02,
  0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x07, 0x01, 0xE0, 0x2C, 0x04, 0x81,
  0x90, 0x23, 0x18, 0x1E, 0x00, 0x3F, 0x86, 0x18, 0x81, 0x90, 0x12, 0x02,
  0x40, 0xD8, 0x1B, 0x02, 0x41, 0x8F, 0xE1, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x00, 0x07, 0x83, 0x18, 0xC1, 0x90, 0x16, 0x02,
  0x80, 0x50, 0x0A, 0x01, 0x40, 0x38, 0x07, 0x01, 0xE0, 0x2C, 0x05, 0x81,
  0x90, 0x23, 0x18, 0x3E, 0x00, 0x60, 0x06, 0x00, 0x40, 0x3F, 0x86, 0x18,
  0x81, 0x10, 0x32, 0x06, 0x40, 0xD8, 0x13, 0x06, 0x41, 0x8F, 0xE1, 0x08,
  0x21, 0x8C, 0x11, 0x82, 0x20, 0x64, 0x0C, 0x80, 0x80, 0x0F, 0x03, 0x18,
  0x81, 0x10, 0x26, 0x04, 0xC0, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x48, 0x09, 0x01, 0x20, 0x63, 0x18, 0x3C, 0x00, 0xFF, 0xE0, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x30, 0x32, 0x03,
  0x20, 0x22, 0x02, 0x20, 0x26, 0x02, 0x60, 0x64, 0x06, 0x40, 0x44, 0x04,
  0x40, 0x4C, 0x04, 0xC0, 0xCC, 0x08, 0x41, 0x86, 0x30, 0x3E, 0x00, 0x80,
  0x78, 0x0B, 0x01, 0x20, 0x64, 0x08, 0x83, 0x10, 0x42, 0x18, 0x42, 0x0C,
  0x40, 0x90, 0x12, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x00, 0xC1,
  0x81, 0xC1, 0x83, 0xC1, 0x82, 0xC2, 0x82, 0x42, 0x84, 0x42, 0x84, 0x44,
  0x84, 0x44, 0x88, 0x4C, 0x88, 0x48, 0x88, 0x48, 0xD0, 0x50, 0x50, 0x50,
  0x70, 0x50, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x10, 0x10, 0x81,
  0x86, 0x18, 0x10, 0x80, 0x8C, 0x06, 0xC0, 0x14, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0xC0, 0x32, 0x01, 0x10, 0x18, 0xC1, 0x82, 0x08, 0x18, 0xC0,
  0x40, 0xC0, 0x68, 0x09, 0x02, 0x20, 0xC6, 0x10, 0x46, 0x08, 0x81, 0x20,
  0x1C, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0xFF, 0xC0, 0x1E, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x30, 0x40,
  0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x38, 0x00,
  0xC4, 0x44, 0x44, 0x46, 0x22, 0x22, 0x22, 0x23, 0x11, 0x1C, 0x10, 0x43,
  0x0C, 0x20, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x10, 0xC2, 0x08,
  0x20, 0x8E, 0x00, 0x08, 0x61, 0x4D, 0x25, 0x94, 0x71, 0xFF, 0xC9, 0x80,
  0x0F, 0x08, 0xC8, 0x24, 0x10, 0x08, 0xFC, 0x86, 0x82, 0x41, 0x21, 0x99,
  0xC7, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x70, 0xA2,
  0x30, 0xC8, 0x32, 0x0C, 0x83, 0x60, 0x90, 0x24, 0x09, 0x06, 0x63, 0x17,
  0x80, 0x1E, 0x23, 0x41, 0xC1, 0x80, 0x80, 0x80, 0x80, 0x83, 0x82, 0xC6,
  0x78, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x21, 0xC8, 0x8A, 0x41,
  0x90, 0x4C, 0x12, 0x04, 0x81, 0x20, 0x48, 0x32, 0x0C, 0xC6, 0x1E, 0x80,
  0x1E, 0x23, 0x41, 0xC1, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0xC6, 0x7C,
  0x0E, 0x30, 0x40, 0x83, 0x06, 0x1F, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08,
  0x10, 0x20, 0xC1, 0x80, 0x0E, 0x44, 0x52, 0x0C, 0x83, 0x60, 0x90, 0x24,
  0x09, 0x02, 0x41, 0x90, 0x66, 0x30, 0xF4, 0x01, 0x00, 0x40, 0x23, 0x18,
  0x3C, 0x00, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xDC, 0x53, 0x30,
  0x90, 0x48, 0x24, 0x16, 0x0A, 0x05, 0x06, 0x82, 0x41, 0x20, 0x80, 0x33,
  0x00, 0x02, 0x64, 0x44, 0x44, 0xC8, 0x88, 0x80, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x30, 0xE0, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x0C, 0x86, 0x23, 0x09, 0x82, 0xC0, 0xE0, 0x6C, 0x11, 0x04,
  0x61, 0x08, 0x42, 0x10, 0x40, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0xCC,
  0x88, 0x88, 0x37, 0x1E, 0x29, 0xA2, 0x30, 0xC3, 0x20, 0xC3, 0x20, 0x83,
  0x20, 0x82, 0x60, 0x82, 0x40, 0x82, 0x41, 0x82, 0x41, 0x06, 0x41, 0x06,
  0xC1, 0x04, 0x37, 0x1C, 0xCC, 0x24, 0x12, 0x09, 0x05, 0x82, 0x81, 0x41,
  0xA0, 0x90, 0x48, 0x20, 0x1E, 0x19, 0x98, 0x68, 0x1C, 0x0C, 0x06, 0x07,
  0x02, 0x81, 0x41, 0x91, 0x87, 0x80, 0x37, 0x0E, 0x63, 0x0C, 0x83, 0x20,
  0xC8, 0x36, 0x09, 0x02, 0x40, 0x90, 0x66, 0x31, 0x78, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x1C, 0x91, 0x50, 0x68, 0x3C, 0x14, 0x0A, 0x05,
  0x02, 0x83, 0x41, 0xB1, 0x8F, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x00,
  0x36, 0x70, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x00, 0x0F,
  0x18, 0xC8, 0x24, 0x13, 0x00, 0xC0, 0x18, 0x06, 0x41, 0x20, 0x98, 0x87,
  0x80, 0x11, 0x8D, 0xF2, 0x10, 0x8C, 0x42, 0x10, 0x84, 0x21, 0xC0, 0x60,
  0xA0, 0x50, 0x68, 0x24, 0x12, 0x0B, 0x05, 0x02, 0x83, 0x61, 0x11, 0x8F,
  0x40, 0xC1, 0xA0, 0x90, 0xC8, 0x44, 0x62, 0x21, 0x90, 0x50, 0x28, 0x18,
  0x0C, 0x04, 0x00, 0x86, 0x1C, 0x30, 0xA1, 0x8D, 0x14, 0x48, 0xA2, 0x49,
  0x22, 0x49, 0x14, 0x58, 0xA2, 0x85, 0x14, 0x30, 0x41, 0x82, 0x00, 0x20,
  0x8C, 0x61, 0x30, 0x48, 0x1C, 0x03, 0x00, 0xC0, 0x50, 0x34, 0x18, 0x84,
  0x22, 0x0C, 0x10, 0x62, 0x08, 0x43, 0x08, 0x41, 0x18, 0x22, 0x06, 0x40,
  0xD0, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0xE0, 0x00, 0x3F, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20,
  0x30, 0x30, 0x1F, 0xE0, 0x02, 0x18, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30,
  0x41, 0x84, 0x04, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x04,
  0x00, 0x18, 0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42,
  0x11, 0x80, 0x10, 0x10, 0x20, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x10,
  0x30, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x08, 0x20, 0x00, 0x38,
  0x29, 0x85, 0x19, 0x41, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 5, 5, 6, 2, -17 },
  { 14, 11, 17, 11, 1, -17 },
  { 38, 9, 21, 11, 1, -19 },
  { 62, 11, 17, 14, 2, -17 },
  { 86, 10, 17, 12, 1, -17 },
  { 108, 2, 5, 4, 2, -17 },
  { 110, 7, 23, 7, 1, -18 },
  { 131, 6, 23, 7, -1, -18 },
  { 149, 9, 9, 9, 1, -17 },
  { 160, 9, 11, 11, 1, -13 },
  { 173, 3, 5, 4, -1, -2 },
  { 175, 4, 1, 6, 1, -8 },
  { 176, 1, 2, 5, 1, -2 },
  { 177, 10, 18, 8, -1, -17 },
  { 200, 9, 17, 11, 1, -17 },
  { 220, 5, 17, 11, 3, -17 },
  { 231, 10, 17, 11, 0, -17 },
  { 253, 9, 17, 11, 1, -17 },
  { 273, 10, 17, 11, 0, -17 },
  { 295, 10, 17, 11, 1, -17 },
  { 317, 9, 17, 11, 1, -17 },
  { 337, 9, 17, 11, 2, -17 },
  { 357, 9, 17, 11, 1, -17 },
  { 377, 8, 17, 11, 2, -17 },
  { 394, 4, 12, 5, 0, -12 },
  { 400, 5, 15, 4, -1, -12 },
  { 410, 8, 9, 10, 1, -12 },
  { 419, 9, 5, 11, 1, -10 },
  { 425, 8, 9, 10, 1, -12 },
  { 434, 7, 17, 9, 2, -17 },
  { 449, 15, 21, 18, 1, -16 },
  { 489, 12, 17, 12, -1, -17 },
  { 515, 10, 17, 12, 1, -17 },
  { 537, 11, 17, 13, 1, -17 },
  { 561, 11, 17, 13, 1, -17 },
  { 585, 11, 17, 11, 1, -17 },
  { 609, 11, 17, 11, 1, -17 },
  { 633, 11, 17, 13, 1, -17 },
  { 657, 13, 17, 14, 1, -17 },
  { 685, 4, 17, 5, 1, -17 },
  { 694, 11, 17, 11, 0, -17 },
  { 718, 12, 17, 12, 1, -17 },
  { 744, 8, 17, 10, 1, -17 },
  { 761, 15, 17, 17, 1, -17 },
  { 793, 13, 17, 14, 1, -17 },
  { 821, 11, 17, 13, 1, -17 },
  { 845, 11, 17, 12, 1, -17 },
  { 869, 11, 20, 13, 1, -17 },
  { 897, 11, 17, 12, 1, -17 },
  { 921, 11, 17, 12, 1, -17 },
  { 945, 11, 17, 12, 2, -17 },
  { 969, 12, 17, 13, 1, -17 },
  { 995, 11, 17, 12, 2, -17 },
  { 1019, 16, 17, 17, 2, -17 },
  { 1053, 13, 17, 12, 0, -17 },
  { 1081, 11, 17, 12, 2, -17 },
  { 1105, 12, 17, 12, 0, -17 },
  { 1131, 7, 23, 5, 0, -19 },
  { 1152, 4, 18, 8, 2, -17 },
  { 1161, 6, 23, 5, -1, -19 },
  { 1179, 6, 8, 8, 1, -17 },
  { 1185, 8, 1, 9, -1, 0 },
  { 1186, 3, 3, 6, 3, -17 },
  { 1188, 9, 12, 11, 0, -12 },
  { 1202, 10, 18, 11, 0, -18 },
  { 1225, 8, 12, 10, 1, -12 },
  { 1237, 10, 18, 11, 1, -18 },
  { 1260, 8, 12, 10, 1, -12 },
  { 1272, 7, 18, 7, 1, -18 },
  { 1288, 10, 17, 11, 0, -12 },
  { 1310, 9, 18, 11, 0, -18 },
  { 1331, 4, 17, 5, 1, -17 },
  { 1340, 8, 22, 5, -3, -17 },
  { 1362, 10, 18, 10, 0, -18 },
  { 1385, 4, 18, 5, 1, -18 },
  { 1394, 16, 12, 17, 0, -12 },
  { 1418, 9, 12, 11, 0, -12 },
  { 1432, 9, 12, 11, 1, -12 },
  { 1446, 10, 17, 11, 0, -12 },
  { 1468, 9, 17, 11, 1, -12 },
  { 1488, 7, 12, 7, 0, -12 },
  { 1499, 9, 12, 10, 0, -12 },
  { 1513, 5, 15, 6, 1, -15 },
  { 1523, 9, 12, 11, 1, -12 },
  { 1537, 9, 12, 9, 1, -12 },
  { 1551, 13, 12, 15, 2, -12 },
  { 1571, 10, 12, 10, 0, -12 },
  { 1586, 11, 17, 9, -1, -12 },
  { 1610, 9, 12, 10, 0, -12 },
  { 1624, 7, 23, 7, 1, -18 },
  { 1645, 5, 20, 5, 0, -17 },
  { 1658, 7, 23, 7, -1, -18 },
  { 1679, 11, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC23PT7B_H_
