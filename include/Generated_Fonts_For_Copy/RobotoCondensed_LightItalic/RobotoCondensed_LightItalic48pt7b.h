#ifndef _ROBOTOCONDENSED_LIGHTITALIC48PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xE0, 0xF0, 0x30, 0x00, 0x31, 0x98, 0xDC, 0x6E, 0x36, 0x3B, 0x19, 0x8C,
  0xC6, 0xC3, 0x61, 0xB1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x30, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xE0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC1, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x83, 0x80, 0x03, 0x03, 0x00, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0x81, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0xE0, 0xE0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00,
  0x61, 0xC0, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x8E,
  0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x81, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xE3, 0x80, 0x01, 0x83, 0x00, 0x07, 0x03,
  0x01, 0x0C, 0x06, 0x03, 0x18, 0x0C, 0x0C, 0x30, 0x18, 0x30, 0x60, 0x30,
  0xE0, 0xC0, 0xE1, 0x81, 0x81, 0x86, 0x03, 0x03, 0x1C, 0x06, 0x0E, 0x30,
  0x0E, 0x38, 0xC0, 0x0F, 0xE3, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC7, 0xC0, 0x03, 0x1F, 0xC0, 0x0C, 0x71, 0xC0,
  0x31, 0xC1, 0x80, 0xE3, 0x03, 0x01, 0x86, 0x06, 0x06, 0x1C, 0x0C, 0x1C,
  0x30, 0x18, 0x30, 0x60, 0x30, 0xC0, 0xC0, 0x63, 0x81, 0x80, 0xC6, 0x03,
  0x03, 0x80, 0x03, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x70, 0x70,
  0x01, 0x80, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xC0, 0x30, 0x03,
  0x01, 0xC0, 0x0C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x8E,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xF3, 0x01, 0xC7, 0x8E, 0x07, 0x1C, 0x1C, 0x18, 0xE0,
  0x70, 0x67, 0x00, 0xE3, 0x9C, 0x03, 0x8C, 0x70, 0x07, 0x31, 0x80, 0x1D,
  0xC6, 0x00, 0x3E, 0x18, 0x00, 0xF0, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x03,
  0x80, 0x7E, 0x0F, 0xCF, 0x9C, 0x1F, 0xFC, 0x70, 0x1F, 0x80, 0xE0, 0x39,
  0x8C, 0x67, 0x39, 0x8C, 0x63, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x0E,
  0x0C, 0x1F, 0xE3, 0x1F, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x60, 0x03, 0x9C, 0x01, 0xC3, 0x00, 0xE0, 0xE0, 0x78, 0x18,
  0x1C, 0x07, 0x02, 0x00, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x8E, 0x1C, 0x71, 0xC1, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xF6, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0x9F, 0x03, 0xC0, 0xE0, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x00,
  0x38, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x9C, 0x00,
  0x33, 0x80, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x03,
  0x98, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0C,
  0x30, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x0E, 0x07, 0x01, 0xF3, 0xC0,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x9F, 0xF7, 0xCF,
  0xE1, 0xA0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0xC0,
  0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xF7,
  0xC0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01,
  0xC7, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x70, 0x38, 0x0F, 0x01, 0xF3,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0,
  0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x9C, 0x00, 0x71, 0xC0, 0x06, 0x1C,
  0x00, 0xE1, 0xC0, 0x1C, 0x18, 0x03, 0x81, 0x80, 0x30, 0x38, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x30, 0x38, 0x03, 0x07, 0x00,
  0x70, 0x60, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x19, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xC0, 0xF0, 0x18,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x38,
  0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x1C,
  0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0xFC, 0x0E, 0xFF, 0x83, 0x7D, 0xF0, 0xF8, 0x1E, 0x7C, 0x03, 0x9E, 0x00,
  0x67, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D,
  0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x07, 0x0C, 0x01, 0xC3, 0x80, 0xE0, 0x7D, 0xF0, 0x0F, 0xF8, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7C, 0xF8, 0x07, 0x81, 0xE0, 0x38, 0x07, 0x03,
  0x80, 0x38, 0x1C, 0x00, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0x7C, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xC1, 0xC0,
  0x38, 0x07, 0x03, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x03, 0x0E, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x87,
  0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x3C, 0x07, 0xEF, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xEF, 0x83, 0x81,
  0xE3, 0x80, 0x71, 0x80, 0x19, 0xC0, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x06, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x03, 0xCE, 0x07, 0xE7, 0xEF,
  0x61, 0xFF, 0x30, 0x3E, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x0F, 0x0E, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x01, 0xC0, 0xF0, 0x3C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xC0, 0xE7, 0x00, 0xCE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0xF8, 0x03, 0x0C, 0x03, 0xFE, 0x03, 0x1C,
  0x07, 0x8F, 0x03, 0x18, 0x0E, 0x07, 0x03, 0x38, 0x0C, 0x06, 0x03, 0x30,
  0x1C, 0x06, 0x03, 0x30, 0x18, 0x06, 0x03, 0x70, 0x30, 0x0E, 0x03, 0x60,
  0x30, 0x0C, 0x03, 0x60, 0x70, 0x0C, 0x03, 0x60, 0x60, 0x0C, 0x03, 0xE0,
  0x60, 0x0C, 0x06, 0xC0, 0x60, 0x1C, 0x06, 0xC0, 0xE0, 0x18, 0x06, 0xC0,
  0xE0, 0x18, 0x06, 0xC0, 0xC0, 0x38, 0x0C, 0xC0, 0xC0, 0x38, 0x0C, 0xC0,
  0xC0, 0x78, 0x0C, 0xC0, 0xE0, 0x78, 0x18, 0xC0, 0xE0, 0xF8, 0x30, 0xC0,
  0x73, 0x98, 0x70, 0xC0, 0x7F, 0x1F, 0xE0, 0xC0, 0x3E, 0x0F, 0x80, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xB0, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x06, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x0C, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00,
  0x06, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x18, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x06,
  0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x3C, 0x06, 0x03, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x70, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x07, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1E, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x30,
  0x00, 0x38, 0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70,
  0x07, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x70,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x1F, 0xF1, 0x80, 0x7F, 0xE7, 0x00, 0xFF, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0,
  0x38, 0x00, 0xF0, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x80,
  0xE0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x33, 0xC0, 0x00, 0x0D, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x03, 0xC0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0x6C, 0x0E, 0xC0, 0x00, 0x76, 0x06, 0x60, 0x00, 0x77, 0x03, 0x30,
  0x00, 0x3B, 0x81, 0x9C, 0x00, 0x39, 0xC1, 0xCE, 0x00, 0x1C, 0xC0, 0xE7,
  0x00, 0x1C, 0x60, 0x71, 0x80, 0x0E, 0x70, 0x30, 0xC0, 0x0E, 0x38, 0x18,
  0x60, 0x07, 0x1C, 0x0C, 0x30, 0x07, 0x0E, 0x0E, 0x1C, 0x03, 0x86, 0x07,
  0x0E, 0x03, 0x83, 0x03, 0x83, 0x01, 0xC3, 0x81, 0x81, 0x81, 0xC1, 0xC0,
  0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x60, 0x70, 0x38, 0x60, 0x30,
  0x38, 0x1C, 0x70, 0x38, 0x1C, 0x06, 0x30, 0x1C, 0x0C, 0x03, 0x38, 0x0E,
  0x06, 0x01, 0x98, 0x07, 0x07, 0x00, 0xDC, 0x03, 0x03, 0x80, 0x7C, 0x01,
  0x81, 0xC0, 0x3E, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x00,
  0x70, 0x30, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x60, 0x78, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x0E, 0x0F,
  0xC0, 0x01, 0x81, 0xD8, 0x00, 0x70, 0x3B, 0x80, 0x0E, 0x07, 0x70, 0x01,
  0xC0, 0xC6, 0x00, 0x38, 0x18, 0xE0, 0x06, 0x07, 0x0C, 0x00, 0xC0, 0xE1,
  0xC0, 0x38, 0x1C, 0x38, 0x07, 0x03, 0x83, 0x00, 0xE0, 0x60, 0x70, 0x1C,
  0x0C, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x70, 0x1C, 0x1C, 0x0E, 0x03,
  0x83, 0x81, 0xC0, 0x30, 0x70, 0x30, 0x07, 0x0E, 0x0E, 0x00, 0x61, 0x81,
  0xC0, 0x0E, 0x30, 0x38, 0x01, 0xCE, 0x07, 0x00, 0x19, 0xC0, 0xC0, 0x03,
  0xB8, 0x18, 0x00, 0x77, 0x07, 0x00, 0x06, 0xC0, 0xE0, 0x00, 0xF8, 0x1C,
  0x00, 0x1F, 0x03, 0x80, 0x01, 0xE0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3C, 0x03,
  0xC0, 0x70, 0x03, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x0C, 0x00, 0x3C, 0x0C, 0x00, 0x78, 0x1F, 0xE7, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x03, 0x81,
  0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x98, 0x00, 0x07,
  0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1E,
  0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x18, 0x01, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0x80, 0x70, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x06,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x60, 0x00, 0x71, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC3,
  0x00, 0x03, 0x87, 0x00, 0x0E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x00, 0xE7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x70, 0x00,
  0x18, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xB8, 0x00,
  0xF0, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xCE, 0x00, 0x7C, 0x00, 0xE7, 0x00,
  0x36, 0x00, 0x73, 0x80, 0x3B, 0x00, 0x31, 0xC0, 0x1D, 0x80, 0x38, 0xE0,
  0x0C, 0xC0, 0x1C, 0x70, 0x0E, 0x60, 0x0C, 0x38, 0x06, 0x30, 0x0E, 0x1C,
  0x07, 0x18, 0x07, 0x0E, 0x03, 0x8C, 0x07, 0x07, 0x01, 0x86, 0x03, 0x83,
  0x81, 0xC3, 0x81, 0x80, 0xC0, 0xC1, 0xC1, 0xC0, 0x60, 0xE0, 0xE0, 0xE0,
  0x30, 0x70, 0x30, 0x60, 0x18, 0x30, 0x18, 0x70, 0x0C, 0x38, 0x0C, 0x38,
  0x06, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0x8E,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x67, 0x00, 0x33, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x0D, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x0C, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x30,
  0x1C, 0x00, 0x60, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0x87,
  0x00, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0xE0, 0xC1, 0x83, 0x06,
  0x0E, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x0E, 0xC0, 0x33, 0x01, 0xCC,
  0x06, 0x30, 0x38, 0xC0, 0xC3, 0x87, 0x0E, 0x18, 0x18, 0xE0, 0x63, 0x01,
  0x9C, 0x06, 0x60, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC7, 0x0E,
  0x18, 0x70, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x3C, 0x0F,
  0x0E, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC0, 0xE3, 0xC0,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x1C,
  0xE0, 0x07, 0x38, 0x03, 0xC7, 0x03, 0xF1, 0xFF, 0xDC, 0x3F, 0xE7, 0x07,
  0xE1, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0xFC, 0x07, 0x7F, 0xC0, 0xFF, 0xFC, 0x1F, 0x03, 0x83,
  0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0xE3, 0xC0, 0x1C, 0x6C, 0x0F, 0x1D, 0xF7, 0xC3, 0x9F,
  0xF0, 0x60, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xF9, 0xF0, 0x78,
  0x0E, 0x3C, 0x03, 0x8E, 0x00, 0x67, 0x00, 0x19, 0xC0, 0x07, 0x60, 0x01,
  0xD8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x33, 0x00,
  0x1C, 0xE0, 0x06, 0x38, 0x03, 0x87, 0x01, 0xC1, 0xFB, 0xE0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x7C, 0x18, 0x0F, 0xF9, 0xC0, 0xFF,
  0xEE, 0x0F, 0x03, 0xF0, 0x70, 0x0F, 0x87, 0x00, 0x38, 0x30, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0xF7, 0xB0, 0x0F, 0xF9, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x3E, 0x07, 0x81, 0xE0,
  0xE0, 0x1C, 0x38, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xEE,
  0x00, 0x19, 0xC0, 0x03, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x04, 0x0E, 0x01, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7C, 0x18, 0x0F, 0xF8, 0xC0, 0xFF, 0xEE, 0x0F, 0x03, 0xF0, 0x70,
  0x0F, 0x87, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x06, 0x0E,
  0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0x70, 0x1F,
  0x03, 0xFF, 0xB0, 0x0F, 0xF9, 0x80, 0x1F, 0x9C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x01, 0xC0,
  0xF0, 0x1E, 0x03, 0xF3, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0xFC, 0x07, 0x7F, 0xC0, 0xFF, 0x7C, 0x1B, 0x03, 0x83, 0xC0, 0x70, 0xF0,
  0x06, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x61, 0x80,
  0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00,
  0x30, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00,
  0xE3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03,
  0x80, 0x03, 0x01, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x1C,
  0x0E, 0x03, 0xC0, 0xC0, 0x78, 0x0C, 0x0F, 0x01, 0xC1, 0xE0, 0x1C, 0x3C,
  0x01, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0x9E, 0x00, 0x19, 0xC0, 0x03, 0xB8,
  0x00, 0x3F, 0xC0, 0x03, 0xEC, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x30,
  0x70, 0x07, 0x07, 0x00, 0x70, 0x38, 0x07, 0x03, 0x80, 0x60, 0x1C, 0x06,
  0x01, 0xC0, 0x60, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00, 0x70,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x30, 0x38, 0x1C, 0x00, 0x0E, 0x3E, 0x01, 0xF8, 0x0E, 0xFF, 0x87,
  0xFC, 0x0D, 0xEF, 0x8F, 0xBE, 0x0F, 0x81, 0xDC, 0x0E, 0x1E, 0x01, 0xD8,
  0x06, 0x1E, 0x00, 0xF0, 0x07, 0x1C, 0x00, 0xF0, 0x07, 0x1C, 0x00, 0xE0,
  0x07, 0x18, 0x00, 0xE0, 0x07, 0x18, 0x00, 0xC0, 0x07, 0x38, 0x00, 0xC0,
  0x06, 0x38, 0x01, 0xC0, 0x06, 0x38, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0,
  0x0E, 0x30, 0x01, 0xC0, 0x0E, 0x30, 0x01, 0x80, 0x0E, 0x70, 0x01, 0x80,
  0x0C, 0x70, 0x03, 0x80, 0x0C, 0x70, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x80,
  0x1C, 0x60, 0x03, 0x80, 0x1C, 0x60, 0x03, 0x00, 0x1C, 0xE0, 0x03, 0x00,
  0x18, 0xE0, 0x07, 0x00, 0x18, 0xE0, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x00,
  0x38, 0x0E, 0x3F, 0x01, 0xDF, 0xF0, 0x37, 0xDF, 0x06, 0xC0, 0xE0, 0xF0,
  0x1C, 0x3C, 0x01, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00,
  0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00,
  0x71, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01,
  0xC6, 0x00, 0x38, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x07,
  0x1C, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x7E, 0x07, 0x01,
  0xC1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x33, 0x80, 0x06, 0x70, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x0E,
  0x70, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xF3, 0xE0,
  0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0x8F, 0xC0, 0x1D, 0xFF, 0x00, 0xDE,
  0xFC, 0x07, 0xC0, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0x60,
  0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00,
  0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C,
  0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0xFC, 0x0F, 0x07, 0x79, 0xF0, 0x39, 0xFF, 0x01, 0xC3,
  0xE0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x60, 0xFF, 0x8C, 0x3F, 0x7B, 0x8F,
  0x01, 0xF1, 0xC0, 0x1E, 0x70, 0x03, 0x8C, 0x00, 0x33, 0x80, 0x0E, 0x70,
  0x01, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x80,
  0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x1C, 0x07, 0x83, 0xF7,
  0xB0, 0x3F, 0xE6, 0x01, 0xF1, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0E, 0x7C, 0x3B, 0xF0, 0xDF, 0xC3,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7D, 0xF8, 0x38,
  0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x07, 0x38, 0x03, 0x87, 0x01, 0xE0, 0xFB, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x1F,
  0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7E, 0x0F, 0x80, 0xF0, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x63, 0x80, 0x0C, 0x70,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0,
  0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00,
  0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x86, 0x00,
  0xE0, 0xE0, 0x1C, 0x1C, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xEE, 0x01, 0xF0,
  0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0xE6, 0x00, 0x63,
  0x00, 0x71, 0x80, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x1C, 0x0E,
  0x06, 0x06, 0x03, 0x07, 0x01, 0x83, 0x00, 0xC3, 0x80, 0x71, 0x80, 0x38,
  0xC0, 0x1C, 0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0xF8, 0x03, 0x80, 0x3B, 0x00, 0x70, 0x07, 0x60, 0x1E, 0x00, 0xCC, 0x03,
  0xE0, 0x39, 0x80, 0x7C, 0x07, 0x30, 0x1F, 0x81, 0xC6, 0x03, 0x70, 0x38,
  0xE0, 0xE6, 0x06, 0x1C, 0x18, 0xC1, 0xC3, 0x83, 0x18, 0x38, 0x70, 0xE3,
  0x06, 0x0E, 0x18, 0x61, 0xC1, 0xC7, 0x0C, 0x30, 0x38, 0xC1, 0x8E, 0x03,
  0x38, 0x31, 0xC0, 0x66, 0x07, 0x30, 0x0C, 0xC0, 0xEE, 0x01, 0xB8, 0x1D,
  0x80, 0x36, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x1C, 0x00, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x00, 0xCE,
  0x00, 0x07, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x1C, 0xE0,
  0x01, 0xC3, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x60, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x98, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0x00, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x33, 0xFE, 0x00, 0xDC, 0x3C, 0x06, 0xE0,
  0x70, 0x1B, 0x80, 0xE0, 0xEC, 0x01, 0xFF, 0x30, 0x03, 0xF8, 0x00, 0x07,
  0xC0,
};

const GFXglyph RobotoCondensed_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 9, 11, 13, 5, -36 },
  { 53, 24, 34, 24, 1, -34 },
  { 155, 20, 43, 23, 2, -39 },
  { 263, 23, 34, 30, 4, -34 },
  { 361, 22, 34, 25, 1, -34 },
  { 455, 5, 10, 8, 4, -36 },
  { 462, 14, 49, 14, 2, -38 },
  { 548, 14, 49, 14, -3, -38 },
  { 634, 18, 19, 20, 3, -34 },
  { 677, 20, 25, 23, 2, -29 },
  { 740, 7, 11, 9, -2, -4 },
  { 750, 10, 2, 12, 1, -16 },
  { 753, 4, 4, 11, 1, -4 },
  { 755, 20, 37, 17, -2, -34 },
  { 848, 19, 34, 23, 2, -34 },
  { 929, 11, 34, 23, 6, -34 },
  { 976, 20, 34, 23, 1, -34 },
  { 1061, 20, 34, 23, 1, -34 },
  { 1146, 20, 34, 23, 1, -34 },
  { 1231, 20, 34, 23, 3, -34 },
  { 1316, 18, 34, 23, 2, -34 },
  { 1393, 19, 34, 23, 4, -34 },
  { 1474, 21, 34, 23, 1, -34 },
  { 1564, 17, 34, 23, 4, -34 },
  { 1637, 8, 26, 10, 1, -26 },
  { 1663, 10, 33, 9, -2, -26 },
  { 1705, 18, 21, 21, 2, -26 },
  { 1753, 18, 13, 23, 3, -22 },
  { 1783, 19, 20, 21, 1, -25 },
  { 1831, 15, 34, 19, 4, -34 },
  { 1895, 32, 44, 37, 2, -33 },
  { 2071, 24, 34, 26, -2, -34 },
  { 2173, 23, 34, 25, 1, -34 },
  { 2271, 23, 34, 26, 3, -34 },
  { 2369, 24, 34, 27, 1, -34 },
  { 2471, 24, 34, 23, 1, -34 },
  { 2573, 24, 34, 23, 1, -34 },
  { 2675, 23, 34, 28, 3, -34 },
  { 2773, 27, 34, 29, 1, -34 },
  { 2888, 9, 34, 11, 2, -34 },
  { 2927, 21, 34, 22, 1, -34 },
  { 3017, 26, 34, 26, 1, -34 },
  { 3128, 17, 34, 22, 1, -34 },
  { 3201, 33, 34, 35, 1, -34 },
  { 3342, 27, 34, 29, 1, -34 },
  { 3457, 23, 34, 27, 3, -34 },
  { 3555, 24, 34, 25, 1, -34 },
  { 3657, 23, 40, 27, 3, -34 },
  { 3772, 23, 34, 26, 1, -34 },
  { 3870, 23, 34, 24, 1, -34 },
  { 3968, 22, 34, 24, 4, -34 },
  { 4062, 24, 34, 27, 3, -34 },
  { 4164, 23, 34, 25, 4, -34 },
  { 4262, 33, 34, 36, 5, -34 },
  { 4403, 27, 34, 25, -1, -34 },
  { 4518, 23, 34, 24, 4, -34 },
  { 4616, 25, 34, 24, 0, -34 },
  { 4723, 14, 46, 10, 0, -39 },
  { 4804, 7, 37, 16, 5, -34 },
  { 4837, 14, 46, 10, -3, -39 },
  { 4918, 14, 17, 17, 2, -34 },
  { 4948, 17, 2, 18, -2, 0 },
  { 4953, 6, 7, 13, 6, -36 },
  { 4959, 18, 26, 22, 1, -26 },
  { 5018, 19, 36, 23, 1, -36 },
  { 5104, 18, 26, 21, 2, -26 },
  { 5163, 21, 36, 23, 2, -36 },
  { 5258, 19, 26, 21, 1, -26 },
  { 5320, 15, 36, 14, 3, -36 },
  { 5388, 21, 36, 23, 0, -26 },
  { 5483, 19, 36, 22, 1, -36 },
  { 5569, 9, 35, 10, 1, -35 },
  { 5609, 15, 45, 10, -5, -35 },
  { 5694, 20, 36, 20, 1, -36 },
  { 5784, 9, 36, 10, 1, -36 },
  { 5825, 32, 26, 36, 1, -26 },
  { 5929, 19, 26, 22, 1, -26 },
  { 5991, 19, 26, 23, 2, -26 },
  { 6053, 21, 36, 23, -1, -26 },
  { 6148, 19, 36, 23, 2, -26 },
  { 6234, 14, 26, 14, 1, -26 },
  { 6280, 18, 26, 21, 1, -26 },
  { 6339, 11, 32, 14, 2, -32 },
  { 6383, 19, 26, 22, 2, -26 },
  { 6445, 17, 26, 20, 3, -26 },
  { 6501, 27, 26, 30, 4, -26 },
  { 6589, 21, 26, 20, -1, -26 },
  { 6658, 23, 36, 19, -2, -26 },
  { 6762, 20, 26, 20, 0, -26 },
  { 6827, 14, 47, 14, 2, -38 },
  { 6910, 9, 40, 10, 1, -34 },
  { 6955, 15, 47, 14, -3, -37 },
  { 7044, 22, 9, 28, 3, -19 },
};

const GFXfont RobotoCondensed_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC48PT7B_H_
