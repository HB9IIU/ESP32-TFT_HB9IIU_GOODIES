#ifndef _ROBOTOCONDENSED_LIGHTITALIC29PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x08, 0xC6, 0x31, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x4D, 0x24, 0xB2, 0xCA, 0x60, 0x01, 0x8C, 0x04, 0x20,
  0x10, 0x80, 0xC6, 0x02, 0x10, 0x08, 0x43, 0xFF, 0xC1, 0x88, 0x04, 0x20,
  0x11, 0x80, 0xC4, 0x02, 0x10, 0x08, 0xC0, 0x62, 0x0F, 0xFF, 0x04, 0x60,
  0x31, 0x00, 0x84, 0x02, 0x30, 0x18, 0x80, 0x42, 0x00, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x7C, 0x0F, 0xE1, 0x83, 0x10, 0x33, 0x03, 0x30, 0x33, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0xC0, 0x6C, 0x04, 0xC0, 0xC6, 0x0C, 0x7F, 0x81, 0xE0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x38, 0x03, 0x60, 0x31, 0x01, 0x0C, 0x28, 0x62, 0x42, 0x32,
  0x13, 0x10, 0x90, 0xC9, 0x03, 0x98, 0x00, 0x80, 0x09, 0xE0, 0xD9, 0x04,
  0x84, 0x4C, 0x26, 0x61, 0x62, 0x0A, 0x10, 0xD0, 0xC4, 0x02, 0x60, 0x0E,
  0x00, 0x03, 0x80, 0x76, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x20, 0x63,
  0x03, 0x30, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x6C, 0x36, 0x31, 0xA1, 0x8B,
  0x06, 0xD8, 0x16, 0xC0, 0xE6, 0x02, 0x30, 0x38, 0xEF, 0x43, 0xE3, 0x00,
  0x5F, 0xA0, 0x00, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x00, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x0C, 0x4E, 0xFF, 0x83, 0x80, 0xE0, 0x36, 0x0C, 0x41,
  0x8C, 0x20, 0x80, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x33, 0x26, 0x6C, 0x80, 0xF8, 0xF0, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xEE, 0x18,
  0x21, 0x03, 0x30, 0x33, 0x03, 0x20, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x24, 0x02, 0x40, 0x64, 0x06, 0xC0, 0x6C, 0x04, 0x40, 0xC4, 0x0C, 0x61,
  0x83, 0x70, 0x1E, 0x00, 0x04, 0x7F, 0xF3, 0x0C, 0x30, 0x82, 0x18, 0x61,
  0x86, 0x10, 0x43, 0x0C, 0x30, 0xC2, 0x08, 0x60, 0x03, 0xE0, 0x3F, 0x83,
  0x0C, 0x30, 0x31, 0x01, 0x88, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0xEE, 0x18, 0x23,
  0x03, 0x30, 0x32, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x3C, 0x0F, 0x00,
  0x1C, 0x00, 0xC0, 0x04, 0x00, 0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0x41, 0x87,
  0xF8, 0x3E, 0x00, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x0B, 0x00,
  0xD8, 0x0C, 0x80, 0x44, 0x06, 0x60, 0x63, 0x02, 0x18, 0x30, 0xC3, 0x04,
  0x10, 0x21, 0x83, 0x0F, 0xFF, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x1F, 0xF1, 0xFF, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0xF0, 0x7F, 0x86, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0xC8, 0x0C, 0x80, 0xCC, 0x18, 0xC1, 0x87, 0x70, 0x3E, 0x00, 0x00, 0xE0,
  0x7C, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x3C, 0x7D, 0xCE, 0x09,
  0x81, 0xB0, 0x34, 0x06, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x4C, 0x19, 0x82,
  0x1D, 0xC1, 0xE0, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x07,
  0xC0, 0xEE, 0x18, 0x31, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x02, 0x10,
  0x61, 0xDC, 0x1F, 0x83, 0x0C, 0x60, 0x4C, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0x4C, 0x0C, 0xC0, 0xC7, 0x78, 0x3E, 0x00, 0x0F, 0x03, 0xF0, 0xC3, 0x30,
  0x26, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0B, 0x03, 0x30, 0xE7,
  0xFC, 0x79, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x3E, 0x0F, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x80, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC2, 0x18, 0x63, 0x08,
  0x00, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x20, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x80, 0x40, 0x00, 0x1F,
  0x1F, 0xD8, 0x6C, 0x14, 0x08, 0x04, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x7E, 0x00, 0x1E, 0x38, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x21,
  0x80, 0x02, 0x10, 0x78, 0x23, 0x0C, 0xE3, 0x21, 0x84, 0x36, 0x10, 0x43,
  0x43, 0x04, 0x34, 0x20, 0xC2, 0xC2, 0x08, 0x2C, 0x60, 0x82, 0x86, 0x08,
  0x28, 0x61, 0x86, 0x84, 0x18, 0x48, 0x63, 0x8C, 0x87, 0x49, 0x8C, 0x38,
  0xF0, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x34, 0x00,
  0x90, 0x06, 0x40, 0x19, 0x00, 0xC6, 0x03, 0x18, 0x08, 0x60, 0x61, 0x81,
  0x02, 0x0C, 0x08, 0x3F, 0xE1, 0xFF, 0x84, 0x03, 0x30, 0x0C, 0x80, 0x36,
  0x00, 0xD8, 0x01, 0xC0, 0x04, 0x1F, 0xE0, 0xFF, 0x86, 0x06, 0x20, 0x31,
  0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x31, 0xFF, 0x0F, 0xF0, 0xC0,
  0xC6, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x06, 0x40, 0x36, 0x01, 0x30, 0x19,
  0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x86, 0x06, 0x60, 0x32, 0x00,
  0xB0, 0x05, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0xD0, 0x06, 0xC0, 0x26, 0x03, 0x18, 0x30, 0xFF,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0x81, 0x86, 0x02, 0x10, 0x0C,
  0x40, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x32, 0x00, 0xD8, 0x02,
  0x60, 0x09, 0x80, 0x66, 0x01, 0x90, 0x04, 0x40, 0x33, 0x01, 0x8C, 0x0E,
  0x3F, 0xF0, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0x83, 0xFE, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0x83, 0xFE,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x8C,
  0x02, 0x20, 0x0D, 0x80, 0x36, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x1F, 0xB0, 0x7E, 0xC0, 0x13, 0x00, 0x48, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x00, 0xC6, 0x06, 0x0F, 0xF0, 0x1F, 0x00, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x02, 0x10, 0x02, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x3F, 0xFC, 0x3F, 0xFC, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x18, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x42, 0x31, 0x8C, 0x62,
  0x11, 0x8C, 0x00, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x88, 0x0C, 0x40, 0x42, 0x06, 0x18, 0x30, 0x7F, 0x01,
  0xE0, 0x00, 0x18, 0x06, 0x30, 0x18, 0x60, 0x60, 0xC1, 0x81, 0x06, 0x02,
  0x18, 0x0C, 0x70, 0x19, 0xC0, 0x33, 0x00, 0x4C, 0x00, 0xB8, 0x03, 0xD8,
  0x07, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x20, 0x60, 0x40, 0xC1, 0x80, 0xC3,
  0x01, 0x86, 0x01, 0x8C, 0x03, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0xE1, 0x40, 0x0E, 0x14, 0x01, 0xA1, 0x40, 0x1E,
  0x36, 0x03, 0x63, 0x60, 0x36, 0x36, 0x06, 0x42, 0x20, 0x64, 0x22, 0x0C,
  0xC6, 0x20, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x30, 0x84, 0x12,
  0x08, 0x41, 0x61, 0x8C, 0x14, 0x18, 0xC1, 0xC1, 0x8C, 0x18, 0x10, 0xC1,
  0x81, 0x00, 0x18, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x14, 0x03, 0x16, 0x02,
  0x36, 0x02, 0x32, 0x06, 0x33, 0x06, 0x31, 0x06, 0x21, 0x04, 0x21, 0x84,
  0x60, 0x84, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0x4C, 0x40, 0x68, 0x40, 0x68,
  0xC0, 0x28, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x18, 0x07, 0xE0, 0x3F, 0xC1,
  0x81, 0x8C, 0x06, 0x20, 0x09, 0x80, 0x34, 0x00, 0xD0, 0x03, 0xC0, 0x0B,
  0x00, 0x2C, 0x01, 0xB0, 0x06, 0x80, 0x1A, 0x00, 0x68, 0x01, 0x20, 0x0C,
  0xC0, 0x33, 0x01, 0x86, 0x0C, 0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0xE0, 0x7F,
  0xE1, 0x81, 0x84, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30,
  0x18, 0x80, 0xE3, 0xBF, 0x1F, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0xC1, 0x81, 0x8C, 0x06, 0x20, 0x09, 0x80, 0x24, 0x00, 0x90, 0x02,
  0xC0, 0x0B, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0x80, 0x1A, 0x00, 0x68, 0x01,
  0x20, 0x0C, 0x80, 0x33, 0x01, 0x8E, 0x0C, 0x1F, 0xE0, 0x1F, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x1F, 0xE0, 0x7F, 0xC1, 0x81, 0x84,
  0x02, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x18, 0x80, 0xC3,
  0xFE, 0x1F, 0xE0, 0x60, 0x81, 0x83, 0x06, 0x0C, 0x10, 0x10, 0x40, 0x63,
  0x01, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x30, 0x03, 0xE0, 0x3F, 0xC1, 0x81,
  0x84, 0x06, 0x30, 0x08, 0xC0, 0x23, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x20, 0x0C, 0xC0,
  0x33, 0x01, 0x86, 0x06, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xC1,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x0C, 0xC0, 0x32, 0x00,
  0xC8, 0x03, 0x60, 0x09, 0x80, 0x26, 0x01, 0x98, 0x06, 0x40, 0x19, 0x00,
  0x6C, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x08, 0x80,
  0x63, 0x01, 0x8C, 0x0C, 0x1F, 0xE0, 0x3F, 0x00, 0x80, 0x0A, 0x00, 0x6C,
  0x01, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x10, 0x30, 0x40, 0xC1,
  0x02, 0x06, 0x18, 0x18, 0x40, 0x63, 0x01, 0x88, 0x02, 0x60, 0x09, 0x80,
  0x2C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x60, 0x3C,
  0x0E, 0x02, 0xC0, 0xE0, 0x6C, 0x0E, 0x06, 0xC1, 0xA0, 0x4C, 0x12, 0x0C,
  0xC1, 0x20, 0x8C, 0x32, 0x18, 0xC2, 0x21, 0x8C, 0x62, 0x10, 0xC6, 0x23,
  0x0C, 0x42, 0x30, 0xCC, 0x22, 0x04, 0x83, 0x60, 0x58, 0x36, 0x05, 0x83,
  0x40, 0x50, 0x3C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x00, 0x18, 0x03, 0x08, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x18,
  0x06, 0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x18, 0x60,
  0x30, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x18, 0xC0, 0x1E, 0x01, 0xB0,
  0x0C, 0x80, 0xC6, 0x04, 0x30, 0x60, 0x86, 0x04, 0x30, 0x33, 0x01, 0x90,
  0x05, 0x80, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x0F,
  0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xF0, 0x86, 0x31, 0x84, 0x21, 0x08, 0x63, 0x18, 0x42, 0x10,
  0x84, 0x31, 0x8C, 0x21, 0x08, 0x40, 0x07, 0x80, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04,
  0x1E, 0x00, 0x06, 0x06, 0x0E, 0x0A, 0x1B, 0x13, 0x31, 0x21, 0x61, 0x41,
  0xFF, 0xC0, 0xD9, 0x90, 0x0F, 0x83, 0xF8, 0xC1, 0x30, 0x36, 0x06, 0x00,
  0x80, 0x10, 0xFE, 0x78, 0xD8, 0x1B, 0x03, 0x40, 0x48, 0x19, 0x87, 0x3F,
  0xE3, 0xCC, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0D, 0xE1,
  0xFE, 0x30, 0x64, 0x0C, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0x50, 0x1A, 0x03,
  0xC0, 0x78, 0x0B, 0x03, 0x70, 0x6B, 0xF9, 0x3C, 0x00, 0x0F, 0x83, 0xB8,
  0xC1, 0xB0, 0x36, 0x06, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x6C, 0x0C, 0x83, 0x1D, 0xC1, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x3C, 0xC3, 0xF6, 0x30, 0x73, 0x03, 0x18,
  0x08, 0x80, 0xC4, 0x06, 0x60, 0x33, 0x01, 0x98, 0x08, 0xC0, 0x46, 0x06,
  0x30, 0x30, 0x83, 0x87, 0xF8, 0x1E, 0x40, 0x0F, 0x83, 0xB8, 0xC1, 0x30,
  0x36, 0x06, 0x80, 0xF0, 0x1F, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x81, 0x1F, 0xE1, 0xF0, 0x07, 0x87, 0x86, 0x02, 0x01, 0x01, 0x83,
  0xF8, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x00, 0x07, 0x98, 0x7E, 0xC6, 0x0C, 0x60,
  0x63, 0x01, 0x10, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x23, 0x01, 0x18, 0x08,
  0xC0, 0xC6, 0x06, 0x10, 0x70, 0xFF, 0x03, 0xC8, 0x00, 0x40, 0x06, 0x00,
  0x31, 0x83, 0x07, 0x70, 0x1F, 0x00, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0D, 0xE1, 0xFE, 0x38, 0x66, 0x0C, 0x81, 0xB0, 0x36, 0x06,
  0xC0, 0x90, 0x12, 0x02, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x48, 0x09, 0x01,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08, 0xC6,
  0x31, 0x88, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x78, 0x38, 0x00, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x63, 0x0C, 0x21, 0x82,
  0x30, 0x26, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0x40, 0x46, 0x0C,
  0x20, 0xC3, 0x0C, 0x30, 0x81, 0x88, 0x18, 0x18, 0xC6, 0x21, 0x08, 0xC6,
  0x31, 0x08, 0x46, 0x31, 0x88, 0x42, 0x31, 0x8C, 0x40, 0x1B, 0xC3, 0xC1,
  0x7E, 0x7E, 0x18, 0x38, 0x31, 0x83, 0x83, 0x30, 0x30, 0x33, 0x03, 0x03,
  0x30, 0x30, 0x33, 0x02, 0x02, 0x20, 0x20, 0x22, 0x02, 0x02, 0x60, 0x60,
  0x66, 0x06, 0x06, 0x60, 0x60, 0x66, 0x04, 0x04, 0x40, 0x40, 0x44, 0x04,
  0x04, 0x37, 0x87, 0xF8, 0xE1, 0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x02,
  0x40, 0x48, 0x0B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0x20, 0x24, 0x04, 0x0F,
  0x83, 0xF8, 0xC1, 0x90, 0x36, 0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x2C, 0x0C, 0xC3, 0x1F, 0xE0, 0xF0, 0x1B, 0xC1, 0x7E,
  0x18, 0x31, 0x03, 0x30, 0x13, 0x01, 0x30, 0x13, 0x01, 0x20, 0x32, 0x03,
  0x60, 0x36, 0x02, 0x60, 0x67, 0x04, 0x5D, 0xC4, 0xF0, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x31, 0xFB, 0x30, 0x66, 0x06,
  0x60, 0x24, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0x4C, 0x0C,
  0xC0, 0xC4, 0x1C, 0x77, 0x83, 0xC8, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x37, 0x3F, 0x38, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x0F, 0x07, 0xF3, 0x0D, 0x81,
  0x60, 0x08, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x18, 0x02, 0x81, 0xB0,
  0x67, 0xF0, 0xF8, 0x08, 0x30, 0x63, 0xF1, 0x02, 0x04, 0x18, 0x30, 0x60,
  0x81, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF0, 0xE0, 0x30, 0x33, 0x02, 0x20,
  0x22, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0x40, 0x44, 0x04, 0xC0,
  0xCC, 0x0C, 0x40, 0xC4, 0x18, 0x7F, 0x83, 0xC8, 0x80, 0xF0, 0x3C, 0x0B,
  0x06, 0xC1, 0x10, 0xC4, 0x21, 0x18, 0x46, 0x19, 0x06, 0xC1, 0xA0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0xC1, 0x81, 0x60, 0xC1, 0xB0, 0x60, 0xD8, 0x70,
  0x4C, 0x28, 0x66, 0x34, 0x21, 0x12, 0x30, 0x89, 0x98, 0x4C, 0xC8, 0x24,
  0x6C, 0x16, 0x34, 0x0A, 0x0A, 0x07, 0x07, 0x03, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x80, 0x18, 0x18, 0x41, 0x83, 0x0C, 0x18, 0xC0, 0x4C, 0x03, 0x40,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0x60, 0x31, 0x01, 0x8C, 0x18,
  0x61, 0x81, 0x0C, 0x0C, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x30, 0x61, 0x82,
  0x04, 0x30, 0x21, 0x01, 0x18, 0x08, 0xC0, 0x6C, 0x03, 0x60, 0x1A, 0x00,
  0xF0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x0F, 0x00, 0x70, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x81, 0x81, 0x80, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x03, 0x07, 0x03, 0x00, 0xC0, 0x20, 0x10,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41, 0x04, 0x30, 0xC3,
  0x08, 0x20, 0x86, 0x18, 0x61, 0x04, 0x10, 0x40, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x30, 0x0C,
  0x06, 0x06, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x0C, 0x0C, 0x04, 0x00, 0x38, 0x0B, 0xE0, 0xF1, 0x85, 0x07, 0xE8,
  0x1E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 6, 8, 3, -22 },
  { 20, 14, 21, 14, 1, -21 },
  { 57, 12, 27, 14, 1, -24 },
  { 98, 13, 21, 18, 3, -21 },
  { 133, 13, 21, 15, 1, -21 },
  { 168, 2, 6, 5, 3, -22 },
  { 170, 9, 30, 8, 1, -23 },
  { 204, 9, 30, 8, -2, -23 },
  { 238, 11, 12, 12, 2, -21 },
  { 255, 12, 16, 14, 1, -18 },
  { 279, 4, 7, 5, -1, -3 },
  { 283, 6, 1, 7, 1, -9 },
  { 284, 2, 2, 7, 1, -2 },
  { 285, 12, 23, 10, -1, -21 },
  { 320, 12, 21, 14, 1, -21 },
  { 352, 6, 21, 14, 4, -21 },
  { 368, 13, 21, 14, 0, -21 },
  { 403, 12, 21, 14, 1, -21 },
  { 435, 13, 21, 14, 0, -21 },
  { 470, 12, 21, 14, 2, -21 },
  { 502, 11, 21, 14, 1, -21 },
  { 531, 12, 21, 14, 2, -21 },
  { 563, 12, 21, 14, 1, -21 },
  { 595, 11, 21, 14, 2, -21 },
  { 624, 5, 15, 6, 0, -15 },
  { 634, 6, 19, 5, -1, -15 },
  { 649, 11, 12, 13, 1, -15 },
  { 666, 10, 9, 14, 2, -14 },
  { 678, 11, 12, 13, 1, -15 },
  { 695, 9, 21, 11, 2, -21 },
  { 719, 20, 26, 22, 1, -20 },
  { 784, 14, 21, 15, -1, -21 },
  { 821, 13, 21, 15, 1, -21 },
  { 856, 13, 21, 16, 2, -21 },
  { 891, 14, 21, 16, 1, -21 },
  { 928, 14, 21, 14, 1, -21 },
  { 965, 14, 21, 14, 1, -21 },
  { 1002, 14, 21, 17, 2, -21 },
  { 1039, 16, 21, 17, 1, -21 },
  { 1081, 5, 21, 7, 1, -21 },
  { 1095, 13, 21, 14, 0, -21 },
  { 1130, 15, 21, 15, 1, -21 },
  { 1170, 10, 21, 13, 1, -21 },
  { 1197, 20, 21, 21, 1, -21 },
  { 1250, 16, 21, 17, 1, -21 },
  { 1292, 14, 21, 17, 2, -21 },
  { 1329, 14, 21, 15, 1, -21 },
  { 1366, 14, 25, 17, 2, -21 },
  { 1410, 14, 21, 15, 1, -21 },
  { 1447, 14, 21, 15, 1, -21 },
  { 1484, 13, 21, 15, 3, -21 },
  { 1519, 14, 21, 16, 2, -21 },
  { 1556, 14, 21, 15, 3, -21 },
  { 1593, 20, 21, 22, 3, -21 },
  { 1646, 16, 21, 15, 0, -21 },
  { 1688, 13, 21, 15, 3, -21 },
  { 1723, 15, 21, 15, 0, -21 },
  { 1763, 8, 28, 6, 0, -24 },
  { 1791, 5, 23, 10, 3, -21 },
  { 1806, 9, 28, 6, -2, -24 },
  { 1838, 8, 10, 10, 1, -21 },
  { 1848, 10, 1, 11, -1, 0 },
  { 1850, 3, 4, 8, 4, -22 },
  { 1852, 11, 16, 13, 1, -16 },
  { 1874, 11, 22, 14, 1, -22 },
  { 1905, 11, 16, 13, 1, -16 },
  { 1927, 13, 22, 14, 1, -22 },
  { 1963, 11, 16, 13, 1, -16 },
  { 1985, 9, 22, 8, 2, -22 },
  { 2010, 13, 22, 14, 0, -16 },
  { 2046, 11, 22, 14, 1, -22 },
  { 2077, 5, 21, 6, 1, -21 },
  { 2091, 9, 27, 6, -3, -21 },
  { 2122, 12, 22, 12, 1, -22 },
  { 2155, 5, 22, 6, 1, -22 },
  { 2169, 20, 16, 21, 0, -16 },
  { 2209, 11, 16, 14, 1, -16 },
  { 2231, 11, 16, 14, 1, -16 },
  { 2253, 12, 22, 14, 0, -16 },
  { 2286, 12, 22, 14, 1, -16 },
  { 2319, 8, 16, 9, 1, -16 },
  { 2335, 10, 16, 13, 1, -16 },
  { 2355, 7, 19, 8, 1, -19 },
  { 2372, 12, 16, 14, 1, -16 },
  { 2396, 10, 16, 12, 2, -16 },
  { 2416, 17, 16, 18, 2, -16 },
  { 2450, 13, 16, 12, -1, -16 },
  { 2476, 13, 22, 12, -1, -16 },
  { 2512, 12, 16, 12, 0, -16 },
  { 2536, 9, 29, 8, 1, -23 },
  { 2569, 6, 25, 6, 0, -21 },
  { 2588, 9, 29, 8, -2, -23 },
  { 2621, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC29PT7B_H_
