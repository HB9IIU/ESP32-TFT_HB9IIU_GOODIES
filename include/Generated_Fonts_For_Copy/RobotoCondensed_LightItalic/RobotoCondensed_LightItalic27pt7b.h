#ifndef _ROBOTOCONDENSED_LIGHTITALIC27PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x84, 0x63, 0x18, 0x84, 0x23, 0x18, 0x84, 0x20, 0x00, 0x06,
  0x20, 0x4A, 0x77, 0x29, 0x48, 0x01, 0x18, 0x18, 0x80, 0x84, 0x04, 0x60,
  0x62, 0x02, 0x10, 0xFF, 0xE1, 0x88, 0x08, 0x40, 0x46, 0x02, 0x20, 0x21,
  0x0F, 0xFE, 0x08, 0x80, 0x84, 0x04, 0x60, 0x22, 0x02, 0x10, 0x11, 0x80,
  0x01, 0x00, 0x20, 0x04, 0x03, 0xC0, 0xDC, 0x30, 0xCC, 0x19, 0x81, 0x20,
  0x26, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x20, 0x06, 0xC0, 0xD8,
  0x1B, 0x03, 0x20, 0xC7, 0x70, 0x7C, 0x02, 0x00, 0xC0, 0x38, 0x04, 0x80,
  0x84, 0x28, 0x46, 0x84, 0x48, 0x48, 0x89, 0x8D, 0x90, 0x72, 0x00, 0x40,
  0x0D, 0xE0, 0x92, 0x12, 0x13, 0x21, 0x62, 0x14, 0x23, 0x82, 0x20, 0x36,
  0x01, 0xC0, 0x07, 0x80, 0xCC, 0x18, 0xC1, 0x04, 0x10, 0xC1, 0x08, 0x19,
  0x81, 0xF0, 0x0C, 0x01, 0xC0, 0x36, 0x36, 0x23, 0xC3, 0x2C, 0x16, 0x81,
  0xCC, 0x0C, 0xC1, 0xC7, 0x34, 0x3C, 0x60, 0xFA, 0xA0, 0x01, 0x03, 0x06,
  0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC3,
  0x04, 0x00, 0x02, 0x00, 0x40, 0x08, 0x23, 0x17, 0x5E, 0x3F, 0x03, 0x80,
  0xD0, 0x33, 0x04, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x00, 0x32, 0x26, 0x48, 0xF8, 0xF0, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x00,
  0x07, 0x81, 0x98, 0x41, 0x98, 0x32, 0x02, 0x40, 0x58, 0x1B, 0x03, 0x40,
  0x68, 0x0D, 0x01, 0x20, 0x2C, 0x05, 0x81, 0xB0, 0x22, 0x04, 0x41, 0x8E,
  0xE0, 0xF8, 0x00, 0x06, 0x39, 0xD6, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10,
  0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC0, 0x03, 0xC0, 0xEE, 0x18,
  0x31, 0x83, 0x10, 0x33, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x7F,
  0xC0, 0x07, 0x83, 0x98, 0xC1, 0x90, 0x32, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x03, 0x81, 0xE0, 0x06, 0x00, 0x40, 0x0C, 0x01, 0xA0, 0x34, 0x04, 0xC1,
  0x8E, 0xE0, 0xF8, 0x00, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0A, 0x01, 0x60,
  0x36, 0x06, 0x60, 0x44, 0x08, 0x41, 0x84, 0x30, 0xC2, 0x0C, 0x60, 0x87,
  0xFF, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x1F, 0xE3, 0xFC,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0xF0, 0x7F, 0x08, 0x30, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x20, 0x64, 0x0C, 0xC3, 0x0C, 0xC0, 0xF0, 0x00,
  0x01, 0xC1, 0xE0, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0xBC, 0x79, 0x98,
  0x36, 0x05, 0x01, 0xC0, 0x70, 0x14, 0x0D, 0x02, 0x61, 0x8C, 0xC1, 0xE0,
  0x7F, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x00, 0x07, 0x83, 0x98, 0x41, 0x98, 0x12, 0x02, 0x40, 0x48,
  0x19, 0x82, 0x19, 0x83, 0xE0, 0xC6, 0x20, 0x6C, 0x0D, 0x01, 0xA0, 0x34,
  0x04, 0xC1, 0x8C, 0xE0, 0xF8, 0x00, 0x0F, 0x0E, 0xE6, 0x09, 0x83, 0x40,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x64, 0x19, 0xDA, 0x3D, 0x80, 0x40,
  0x30, 0x08, 0x0C, 0x0E, 0x0F, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x20, 0x86, 0x10, 0x80, 0x00, 0x40, 0x70, 0x70, 0x70, 0x70, 0x30, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x10, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x20, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x08, 0x00, 0x1E, 0x1B, 0x98, 0x48, 0x3C, 0x18, 0x08,
  0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x61, 0xC0, 0x60, 0x18, 0x30, 0x02,
  0x08, 0x00, 0xC4, 0x00, 0x13, 0x07, 0x04, 0x86, 0x31, 0x61, 0x08, 0x50,
  0x82, 0x14, 0x20, 0x87, 0x18, 0x61, 0xC4, 0x10, 0x61, 0x04, 0x38, 0x41,
  0x0A, 0x10, 0xC2, 0x84, 0x71, 0x21, 0xB4, 0xC8, 0x39, 0xE3, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xE1, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0x98, 0x0C, 0xC0,
  0x46, 0x06, 0x10, 0x20, 0x83, 0x04, 0x10, 0x21, 0x81, 0x8F, 0xFC, 0xC0,
  0x64, 0x01, 0x60, 0x0B, 0x00, 0x70, 0x02, 0x1F, 0xC1, 0x0E, 0x10, 0x31,
  0x01, 0x30, 0x13, 0x01, 0x30, 0x32, 0x06, 0x21, 0xC7, 0xF8, 0x60, 0x46,
  0x06, 0x40, 0x24, 0x02, 0x40, 0x6C, 0x06, 0xC0, 0xCC, 0x38, 0xFF, 0x00,
  0x07, 0xC1, 0xCE, 0x30, 0x32, 0x03, 0x60, 0x14, 0x01, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x06, 0x80, 0x68, 0x04,
  0xC0, 0xC7, 0x38, 0x3E, 0x00, 0x1F, 0xC0, 0x87, 0x04, 0x0C, 0x20, 0x23,
  0x01, 0x98, 0x0C, 0xC0, 0x64, 0x03, 0x20, 0x1B, 0x00, 0xD8, 0x04, 0xC0,
  0x24, 0x03, 0x20, 0x19, 0x00, 0x98, 0x0C, 0xC0, 0xC6, 0x1C, 0x3F, 0x80,
  0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0xFE, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0xFE, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x00, 0x07, 0xC0, 0xE7, 0x0C, 0x0C, 0x40, 0x26, 0x01, 0x20, 0x0D,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xFD, 0x00, 0x48, 0x02, 0x40,
  0x12, 0x01, 0x98, 0x0C, 0x40, 0xE3, 0x9E, 0x07, 0xC0, 0x18, 0x06, 0x20,
  0x0C, 0x40, 0x10, 0x80, 0x23, 0x00, 0x46, 0x01, 0x8C, 0x03, 0x10, 0x06,
  0x20, 0x08, 0xFF, 0xF1, 0x80, 0x23, 0x00, 0xC4, 0x01, 0x88, 0x03, 0x10,
  0x04, 0x60, 0x08, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC0, 0x18, 0xC4, 0x21,
  0x18, 0xC6, 0x21, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x30, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x60, 0x21, 0x03, 0x08, 0x18, 0x61,
  0x83, 0xB8, 0x07, 0x80, 0x18, 0x0C, 0x40, 0x61, 0x03, 0x04, 0x18, 0x30,
  0xC0, 0xC6, 0x03, 0x30, 0x09, 0x80, 0x2C, 0x01, 0xF8, 0x07, 0x20, 0x18,
  0xC0, 0x41, 0x01, 0x06, 0x04, 0x08, 0x30, 0x30, 0xC0, 0x43, 0x01, 0x88,
  0x06, 0x00, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xE0,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCD,
  0x00, 0xA2, 0x40, 0x68, 0x90, 0x32, 0x24, 0x09, 0x99, 0x86, 0x66, 0x61,
  0x19, 0x88, 0xC4, 0x42, 0x21, 0x10, 0x98, 0xC4, 0x24, 0x33, 0x0F, 0x0C,
  0xC3, 0x82, 0x30, 0x60, 0x88, 0x10, 0x20, 0x18, 0x06, 0x30, 0x0C, 0x70,
  0x10, 0xE0, 0x23, 0x40, 0x46, 0xC1, 0x8C, 0x83, 0x11, 0x06, 0x23, 0x08,
  0xC2, 0x11, 0x84, 0x23, 0x0C, 0xC4, 0x09, 0x88, 0x1B, 0x10, 0x34, 0x60,
  0x28, 0xC0, 0x71, 0x80, 0x62, 0x00, 0xC0, 0x03, 0xE0, 0x3D, 0xC1, 0x81,
  0x84, 0x02, 0x30, 0x08, 0x80, 0x26, 0x00, 0x98, 0x02, 0x60, 0x09, 0x80,
  0x24, 0x01, 0x90, 0x06, 0x40, 0x19, 0x00, 0x44, 0x03, 0x10, 0x08, 0x60,
  0x60, 0xE7, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x83, 0x84, 0x04, 0x20, 0x33,
  0x01, 0x98, 0x0C, 0xC0, 0x64, 0x02, 0x20, 0x33, 0x07, 0x1F, 0xE0, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00,
  0x03, 0xE0, 0x39, 0xC1, 0x81, 0x84, 0x02, 0x30, 0x08, 0x80, 0x26, 0x00,
  0x98, 0x02, 0x60, 0x09, 0x00, 0x64, 0x01, 0x90, 0x06, 0xC0, 0x11, 0x00,
  0x44, 0x03, 0x10, 0x08, 0x60, 0x60, 0xEF, 0x01, 0xF8, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x1F, 0xC0, 0x87, 0x84, 0x0C, 0x20, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0x44, 0x06, 0x20, 0x33, 0x0F, 0x1F, 0xE0, 0xC3, 0x04, 0x18,
  0x20, 0x41, 0x03, 0x18, 0x18, 0xC0, 0x46, 0x03, 0x20, 0x18, 0x07, 0xC0,
  0x77, 0x06, 0x0C, 0x60, 0x22, 0x01, 0x10, 0x08, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0x06, 0x40, 0x32, 0x01, 0x98, 0x0C,
  0xC0, 0xC3, 0xDC, 0x07, 0xC0, 0x7F, 0xF8, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x08, 0x80, 0x22, 0x01,
  0x88, 0x06, 0x60, 0x19, 0x80, 0x46, 0x01, 0x10, 0x0C, 0x40, 0x31, 0x00,
  0xC4, 0x02, 0x10, 0x18, 0x60, 0x40, 0xE7, 0x01, 0xF0, 0x00, 0xC0, 0x1A,
  0x00, 0xD0, 0x04, 0x80, 0x66, 0x02, 0x30, 0x31, 0x81, 0x0C, 0x18, 0x20,
  0x81, 0x0C, 0x08, 0x60, 0x42, 0x03, 0x30, 0x19, 0x00, 0x58, 0x02, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x80, 0xC0, 0xE0, 0x30, 0x38, 0x1C, 0x0A,
  0x05, 0x06, 0x83, 0x41, 0xA0, 0x90, 0x48, 0x24, 0x32, 0x19, 0x08, 0xC4,
  0x42, 0x33, 0x11, 0x8C, 0x84, 0x43, 0x21, 0x10, 0xD8, 0x6C, 0x34, 0x1A,
  0x0D, 0x07, 0x83, 0x80, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x00,
  0x18, 0x06, 0x30, 0x18, 0x20, 0x60, 0x60, 0x80, 0x43, 0x00, 0xCC, 0x01,
  0xB0, 0x01, 0x60, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xC8,
  0x03, 0x18, 0x06, 0x10, 0x18, 0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC0,
  0x40, 0x1B, 0x01, 0x98, 0x0C, 0x40, 0xC2, 0x04, 0x18, 0x60, 0xC6, 0x02,
  0x20, 0x13, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xF0, 0x88, 0x8C, 0xC4, 0x44, 0x44,
  0x66, 0x62, 0x22, 0x23, 0x33, 0x10, 0x0F, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0xF0, 0x04, 0x0C, 0x0E, 0x1A,
  0x12, 0x32, 0x22, 0x22, 0x43, 0x43, 0xFF, 0x80, 0x46, 0x23, 0x0F, 0x0E,
  0xE2, 0x0D, 0x83, 0x00, 0xC0, 0x31, 0xF9, 0xC2, 0xC0, 0xA0, 0x68, 0x1A,
  0x06, 0x83, 0x3F, 0x47, 0x90, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x78, 0xF7, 0x30, 0xD8, 0x16, 0x05, 0x81, 0x40, 0x50, 0x14, 0x07,
  0x03, 0xC0, 0xF0, 0x2C, 0x1A, 0xCC, 0x9E, 0x00, 0x0F, 0x0E, 0x62, 0x0D,
  0x81, 0x40, 0x70, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x0B, 0x06, 0xC1,
  0x19, 0xC3, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x0F, 0x63, 0xBE, 0x20, 0xE6, 0x04, 0x40, 0x44, 0x04, 0xC0, 0xCC, 0x0C,
  0xC0, 0xCC, 0x08, 0xC0, 0x8C, 0x08, 0xC1, 0x86, 0x78, 0x3D, 0x80, 0x0F,
  0x0E, 0x62, 0x0D, 0x83, 0x40, 0x70, 0x1C, 0x0F, 0xFF, 0x80, 0x20, 0x08,
  0x03, 0x00, 0xC1, 0x1D, 0xC3, 0xE0, 0x07, 0x87, 0x42, 0x03, 0x01, 0x80,
  0x81, 0xF8, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0xB1, 0xDF, 0x10, 0x73, 0x02,
  0x20, 0x22, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0x60, 0x46, 0x04,
  0x60, 0xC3, 0xBC, 0x1E, 0xC0, 0x08, 0x01, 0x88, 0x18, 0x67, 0x03, 0xE0,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x78, 0xB6, 0x30, 0xD8,
  0x16, 0x05, 0x83, 0x40, 0xD0, 0x34, 0x0B, 0x02, 0xC0, 0xB0, 0x68, 0x1A,
  0x06, 0x81, 0x00, 0x18, 0x80, 0x00, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x21,
  0x18, 0xC6, 0x21, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x41, 0xE0, 0xE0, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x31, 0x0C, 0x23, 0x0C, 0x61, 0x98,
  0x36, 0x05, 0x80, 0xF0, 0x1B, 0x06, 0x20, 0xC6, 0x18, 0xC2, 0x0C, 0x41,
  0x88, 0x10, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x08,
  0xC6, 0x31, 0x08, 0x00, 0x13, 0xC7, 0x87, 0x33, 0x71, 0x87, 0x04, 0xC1,
  0xC1, 0x30, 0x60, 0x4C, 0x18, 0x12, 0x06, 0x04, 0x81, 0x81, 0x20, 0x40,
  0xD8, 0x10, 0x36, 0x04, 0x0D, 0x83, 0x02, 0x40, 0xC0, 0x90, 0x30, 0x24,
  0x08, 0x18, 0x27, 0x8B, 0x63, 0x0D, 0x81, 0x60, 0x58, 0x34, 0x0D, 0x03,
  0x40, 0xB0, 0x2C, 0x0B, 0x06, 0x81, 0xA0, 0x68, 0x10, 0x0F, 0x03, 0x30,
  0xC3, 0x30, 0x24, 0x04, 0x80, 0xF0, 0x16, 0x02, 0xC0, 0x58, 0x0B, 0x03,
  0x60, 0x44, 0x18, 0xEE, 0x0F, 0x80, 0x13, 0xC3, 0xDC, 0x61, 0x98, 0x13,
  0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x2C, 0x0D, 0x81, 0xB0, 0x26, 0x0C,
  0xB3, 0x13, 0xC6, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x00, 0x0F, 0x67,
  0x7C, 0x83, 0xB0, 0x24, 0x04, 0x80, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x13,
  0x02, 0x60, 0x4C, 0x18, 0xCF, 0x0F, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x2E, 0x7C, 0xC3, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x06,
  0x08, 0x10, 0x20, 0x00, 0x0F, 0x0E, 0xE2, 0x09, 0x83, 0x60, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x40, 0x12, 0x04, 0x83, 0x3B, 0x83, 0xC0, 0x18,
  0x30, 0x47, 0xE1, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x10,
  0x20, 0x60, 0x60, 0x20, 0x64, 0x0C, 0x81, 0x30, 0x26, 0x04, 0xC1, 0x90,
  0x32, 0x06, 0x40, 0x98, 0x13, 0x02, 0x60, 0xC4, 0x18, 0xEF, 0x0F, 0x40,
  0x80, 0xC0, 0xE0, 0x58, 0x6C, 0x36, 0x11, 0x18, 0x88, 0x4C, 0x24, 0x12,
  0x0E, 0x07, 0x01, 0x80, 0x80, 0x81, 0x03, 0x86, 0x0F, 0x0C, 0x16, 0x18,
  0x6C, 0x58, 0xD8, 0xB1, 0x33, 0x66, 0x64, 0x48, 0x58, 0x90, 0xA1, 0x61,
  0x42, 0x83, 0x87, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x00, 0x18, 0x30,
  0x82, 0x08, 0x60, 0xCC, 0x04, 0x80, 0x58, 0x07, 0x00, 0x20, 0x07, 0x00,
  0xD0, 0x09, 0x01, 0x98, 0x30, 0x86, 0x0C, 0x60, 0xC0, 0x10, 0x10, 0x81,
  0x86, 0x08, 0x30, 0xC1, 0x84, 0x0C, 0x60, 0x23, 0x01, 0x10, 0x09, 0x80,
  0x48, 0x02, 0xC0, 0x1C, 0x00, 0xE0, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x3F, 0xE0, 0x01, 0x03, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x60, 0xC0, 0x60, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x30, 0x10, 0x08, 0x42, 0x31, 0x8C, 0x42, 0x10, 0x8C,
  0x62, 0x10, 0x84, 0x63, 0x18, 0x84, 0x21, 0x00, 0x18, 0x0C, 0x04, 0x04,
  0x04, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x06, 0x03, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x60, 0xC0, 0x80, 0x1C, 0x09,
  0xF0, 0x50, 0xC4, 0x83, 0x64, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 5, 6, 8, 3, -20 },
  { 17, 13, 19, 13, 1, -19 },
  { 48, 11, 24, 13, 1, -22 },
  { 81, 12, 19, 17, 3, -19 },
  { 110, 12, 19, 14, 1, -19 },
  { 139, 2, 6, 4, 3, -20 },
  { 141, 8, 28, 8, 1, -22 },
  { 169, 7, 28, 8, -1, -22 },
  { 194, 11, 11, 11, 1, -19 },
  { 210, 11, 14, 13, 1, -16 },
  { 230, 4, 6, 5, -1, -3 },
  { 233, 5, 1, 7, 1, -9 },
  { 234, 2, 2, 6, 1, -2 },
  { 235, 11, 21, 9, -1, -19 },
  { 264, 11, 19, 13, 1, -19 },
  { 291, 7, 19, 13, 3, -19 },
  { 308, 12, 19, 13, 0, -19 },
  { 337, 11, 19, 13, 1, -19 },
  { 364, 12, 19, 13, 0, -19 },
  { 393, 11, 19, 13, 2, -19 },
  { 420, 10, 19, 13, 1, -19 },
  { 444, 11, 19, 13, 2, -19 },
  { 471, 11, 19, 13, 1, -19 },
  { 498, 10, 19, 13, 2, -19 },
  { 522, 5, 14, 5, 0, -14 },
  { 531, 6, 17, 5, -1, -14 },
  { 544, 10, 11, 12, 1, -14 },
  { 558, 11, 6, 13, 1, -12 },
  { 567, 10, 11, 12, 1, -14 },
  { 581, 9, 19, 11, 2, -19 },
  { 603, 18, 25, 21, 1, -19 },
  { 660, 13, 19, 14, -1, -19 },
  { 691, 12, 19, 14, 1, -19 },
  { 720, 12, 19, 15, 2, -19 },
  { 749, 13, 19, 15, 1, -19 },
  { 780, 13, 19, 13, 1, -19 },
  { 811, 13, 19, 13, 1, -19 },
  { 842, 13, 19, 16, 2, -19 },
  { 873, 15, 19, 16, 1, -19 },
  { 909, 5, 19, 6, 1, -19 },
  { 921, 13, 19, 13, 0, -19 },
  { 952, 14, 19, 14, 1, -19 },
  { 986, 9, 19, 12, 1, -19 },
  { 1008, 18, 19, 20, 1, -19 },
  { 1051, 15, 19, 16, 1, -19 },
  { 1087, 14, 19, 15, 1, -19 },
  { 1121, 13, 19, 14, 1, -19 },
  { 1152, 14, 22, 15, 1, -19 },
  { 1191, 13, 19, 14, 1, -19 },
  { 1222, 13, 19, 14, 1, -19 },
  { 1253, 13, 19, 14, 2, -19 },
  { 1284, 14, 19, 15, 1, -19 },
  { 1318, 13, 19, 14, 2, -19 },
  { 1349, 18, 19, 20, 3, -19 },
  { 1392, 15, 19, 14, 0, -19 },
  { 1428, 13, 19, 14, 2, -19 },
  { 1459, 14, 19, 14, 0, -19 },
  { 1493, 8, 26, 6, 0, -22 },
  { 1519, 4, 21, 9, 3, -19 },
  { 1530, 8, 26, 6, -2, -22 },
  { 1556, 8, 10, 10, 1, -19 },
  { 1566, 9, 1, 10, -1, 0 },
  { 1568, 4, 4, 7, 3, -21 },
  { 1570, 10, 15, 12, 1, -15 },
  { 1589, 10, 21, 13, 1, -21 },
  { 1616, 10, 15, 12, 1, -15 },
  { 1635, 12, 21, 13, 1, -21 },
  { 1667, 10, 15, 12, 1, -15 },
  { 1686, 9, 21, 8, 1, -21 },
  { 1710, 12, 20, 13, 0, -15 },
  { 1740, 10, 21, 13, 1, -21 },
  { 1767, 5, 20, 6, 1, -20 },
  { 1780, 9, 25, 6, -3, -20 },
  { 1809, 11, 21, 11, 1, -21 },
  { 1838, 5, 21, 6, 1, -21 },
  { 1852, 18, 15, 20, 0, -15 },
  { 1886, 10, 15, 13, 1, -15 },
  { 1905, 11, 15, 13, 1, -15 },
  { 1926, 11, 20, 13, 0, -15 },
  { 1954, 11, 20, 13, 1, -15 },
  { 1982, 7, 15, 8, 1, -15 },
  { 1996, 10, 15, 12, 1, -15 },
  { 2015, 7, 18, 8, 1, -18 },
  { 2031, 11, 15, 13, 1, -15 },
  { 2052, 9, 15, 11, 2, -15 },
  { 2069, 15, 15, 17, 2, -15 },
  { 2098, 12, 15, 11, -1, -15 },
  { 2121, 13, 20, 11, -1, -15 },
  { 2154, 11, 15, 11, 0, -15 },
  { 2175, 8, 26, 8, 1, -21 },
  { 2201, 5, 23, 6, 0, -19 },
  { 2216, 8, 26, 8, -1, -21 },
  { 2242, 13, 5, 16, 1, -11 },
};

const GFXfont RobotoCondensed_LightItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC27PT7B_H_
