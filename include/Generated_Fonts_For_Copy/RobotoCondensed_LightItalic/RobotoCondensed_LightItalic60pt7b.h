#ifndef _ROBOTOCONDENSED_LIGHTITALIC60PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0,
  0x10, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xC6, 0x0C, 0x61, 0xCE, 0x1C, 0xE1, 0x80, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x01, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x07, 0x00, 0x67, 0x00,
  0xE0, 0x1C, 0xE0, 0x1C, 0x07, 0x1C, 0x03, 0x80, 0xE3, 0x00, 0x70, 0x38,
  0x60, 0x0E, 0x0E, 0x0C, 0x01, 0x81, 0xC1, 0x80, 0x30, 0x70, 0x38, 0x0E,
  0x1C, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0xE0, 0x0E, 0x1C, 0x38, 0x00,
  0xFF, 0x87, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x40, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x0F, 0xE0, 0x01, 0xC3, 0xFE, 0x00, 0x30, 0xF1, 0xE0, 0x0E, 0x1C,
  0x0C, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x1C, 0x18, 0x07, 0x07,
  0x07, 0x00, 0xE1, 0xC0, 0xE0, 0x1C, 0x38, 0x1C, 0x03, 0x8E, 0x03, 0x80,
  0x73, 0x80, 0x70, 0x0E, 0x70, 0x0E, 0x01, 0x9C, 0x01, 0xC0, 0x71, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xC0,
  0x1E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE1, 0xC0, 0x18, 0x78,
  0x3C, 0x07, 0x1E, 0x03, 0xC0, 0xE7, 0x80, 0x78, 0x1C, 0xF0, 0x07, 0x83,
  0x9C, 0x00, 0xF0, 0xE7, 0x80, 0x0F, 0x1C, 0xF0, 0x00, 0xE7, 0x1C, 0x00,
  0x1E, 0xE3, 0x80, 0x01, 0xF8, 0x70, 0x00, 0x3F, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xF0, 0x3C, 0x03,
  0xEE, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0xFC, 0x1E, 0x03, 0xFF, 0x03, 0xC0,
  0x04, 0x00, 0x00, 0x39, 0xDC, 0xE7, 0x39, 0xCC, 0xE7, 0x39, 0xCC, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x1C, 0x02,
  0x78, 0x1C, 0x1E, 0x7E, 0x1C, 0x7E, 0x7F, 0xDB, 0xFE, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xCE, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x80,
  0x1E, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x10, 0x01, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78,
  0xF0, 0xE0, 0x40, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x03, 0xDF, 0xF7, 0x90,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x1C, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0F,
  0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x3F, 0xFB, 0xFC, 0xEF, 0x87,
  0xB8, 0x1C, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x1E, 0x00,
  0x3C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x83, 0x80,
  0x03, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xDE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x0F, 0x00,
  0x1C, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0xFC, 0x00, 0x1D, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xF1, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x80,
  0x0F, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x0F, 0xC0, 0x3C, 0xFF, 0xC0, 0xE7, 0xFF, 0x83, 0xBC,
  0x1F, 0x0F, 0xC0, 0x3C, 0x7E, 0x00, 0x79, 0xF0, 0x00, 0xE7, 0x80, 0x03,
  0x9E, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0xF1, 0xE0, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x81, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x07,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0x03, 0xC0, 0x1F, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x0F, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC1,
  0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0xF0,
  0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x3C, 0xE0,
  0x00, 0x73, 0x80, 0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00,
  0x07, 0x9E, 0x00, 0x3E, 0x38, 0x01, 0xF8, 0xF0, 0x0F, 0xE1, 0xF0, 0xFF,
  0x07, 0xFF, 0xDC, 0x0F, 0xFC, 0x70, 0x0F, 0xC3, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0x01, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3E,
  0x0F, 0x83, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x00,
  0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x0F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xE0, 0x78, 0x78, 0x07,
  0x8E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x00, 0x18, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x3F, 0x00, 0x18, 0x1C, 0x00, 0x7F,
  0xC0, 0x0C, 0x0E, 0x00, 0x7F, 0xF8, 0x07, 0x0E, 0x00, 0x78, 0x1C, 0x03,
  0x87, 0x00, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x00, 0xE3, 0x80,
  0x38, 0x03, 0x80, 0x71, 0xC0, 0x38, 0x01, 0x80, 0x39, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0x70, 0x06,
  0x70, 0x0E, 0x00, 0x30, 0x03, 0x38, 0x07, 0x00, 0x38, 0x01, 0x9C, 0x03,
  0x80, 0x1C, 0x00, 0xCE, 0x01, 0xC0, 0x0E, 0x00, 0xE6, 0x01, 0xC0, 0x06,
  0x00, 0x73, 0x00, 0xE0, 0x07, 0x00, 0x33, 0x80, 0x70, 0x03, 0x80, 0x19,
  0xC0, 0x38, 0x01, 0xC0, 0x1C, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x70, 0x0E,
  0x00, 0xE0, 0x06, 0x38, 0x07, 0x00, 0x70, 0x07, 0x1C, 0x03, 0x80, 0x78,
  0x03, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x87, 0x00, 0xE0, 0x36, 0x01, 0x83,
  0x80, 0x70, 0x33, 0x81, 0xC1, 0xC0, 0x3E, 0x79, 0xC3, 0xC0, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x30, 0x03, 0xF0, 0x3F, 0xC0, 0x1C, 0x00, 0x40, 0x02,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0xC0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x38, 0x00,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0x80, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0x00,
  0x3F, 0xFC, 0xF0, 0x03, 0xFF, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x00, 0xF8, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x07, 0x03, 0xE0, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x7E, 0x00, 0x00,
  0x0E, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0x00, 0x00, 0x1F, 0xCF, 0x00, 0x00,
  0x1F, 0x87, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0x70, 0x00,
  0x00, 0xEE, 0x03, 0xB8, 0x00, 0x00, 0xFF, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x73,
  0xC0, 0x00, 0x3C, 0xE0, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x1C, 0x70, 0x00,
  0x1E, 0x78, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x0F, 0x1C, 0x00, 0x0F, 0x1C,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x07, 0x87, 0x01, 0xC1,
  0xC0, 0x03, 0x87, 0x80, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x3C, 0x1C, 0x00, 0xE0, 0x70,
  0x1C, 0x0E, 0x00, 0xF0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01,
  0xC0, 0x78, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x1C, 0x03, 0xC0,
  0x70, 0x07, 0x0E, 0x01, 0xE0, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x3C, 0x01,
  0xC7, 0x00, 0x70, 0x1E, 0x00, 0xE7, 0x00, 0x38, 0x0E, 0x00, 0x73, 0x80,
  0x1C, 0x07, 0x00, 0x3B, 0x80, 0x1E, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x01,
  0xC0, 0x07, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x78, 0x1F,
  0x80, 0x00, 0x38, 0x0E, 0xE0, 0x00, 0x1C, 0x07, 0x70, 0x00, 0x0E, 0x03,
  0xBC, 0x00, 0x07, 0x01, 0xCE, 0x00, 0x07, 0x81, 0xE7, 0x00, 0x03, 0xC0,
  0xF3, 0xC0, 0x01, 0xC0, 0x70, 0xE0, 0x00, 0xE0, 0x38, 0x70, 0x00, 0x70,
  0x1C, 0x3C, 0x00, 0x38, 0x0E, 0x0E, 0x00, 0x3C, 0x0F, 0x07, 0x00, 0x1E,
  0x07, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x78, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x78,
  0x1C, 0x07, 0x00, 0x1C, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x03, 0xC0, 0x03,
  0x87, 0x01, 0xE0, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0xE1, 0xC0, 0x70, 0x00,
  0x38, 0xE0, 0x38, 0x00, 0x1C, 0xF0, 0x3C, 0x00, 0x0F, 0x78, 0x1E, 0x00,
  0x03, 0xB8, 0x0E, 0x00, 0x01, 0xDC, 0x07, 0x00, 0x00, 0xFE, 0x03, 0x80,
  0x00, 0x3F, 0x01, 0xC0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0xC0, 0x3C,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0xE0, 0x78, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0x8F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0xE0, 0x00, 0x73, 0xC0, 0x03, 0xB8, 0x00, 0x79, 0xE0, 0x01, 0xDC, 0x00,
  0x38, 0xF0, 0x00, 0xEE, 0x00, 0x1C, 0x78, 0x00, 0xE7, 0x00, 0x1E, 0x3C,
  0x00, 0x73, 0x80, 0x0E, 0x0E, 0x00, 0x39, 0xC0, 0x07, 0x07, 0x00, 0x38,
  0xE0, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x01,
  0xC0, 0xE0, 0x0E, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x38,
  0x07, 0x03, 0x00, 0xF0, 0x1C, 0x03, 0x81, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x0F, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01,
  0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0xC7, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x00, 0x0C, 0x70, 0x00, 0x73,
  0x80, 0x06, 0x38, 0x00, 0x3B, 0x80, 0x03, 0x38, 0x00, 0x1D, 0xC0, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0x70, 0x03, 0x98, 0x03, 0x8C, 0x01, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x70, 0x18, 0x38, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x87, 0x80,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xE0, 0x01, 0xC7,
  0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0xF0,
  0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x87, 0x80,
  0x3F, 0x0F, 0x01, 0xEE, 0x0F, 0xFF, 0x9C, 0x0F, 0xFE, 0x38, 0x0F, 0xF0,
  0x70, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x80, 0x03, 0x8F, 0xF0, 0x07, 0xBF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x1E, 0x07, 0xC0, 0x0E, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00,
  0x3C, 0x7C, 0x00, 0x78, 0x7E, 0x00, 0x78, 0x77, 0x01, 0xF0, 0x73, 0xFF,
  0xE0, 0xE1, 0xFF, 0xC0, 0xE0, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x78, 0x07,
  0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x71, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x07, 0x80, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x0F, 0x00,
  0x7F, 0xF1, 0xC0, 0x1F, 0xFF, 0x38, 0x07, 0xC0, 0x77, 0x01, 0xE0, 0x06,
  0xE0, 0x38, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0xE0, 0x78,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x80, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x70, 0x00, 0xFF, 0x8E, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x78, 0x07, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x02, 0x07, 0x80, 0x0E, 0x07,
  0x80, 0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFC, 0x3C, 0x01,
  0xFF, 0xC7, 0x00, 0x7F, 0xFC, 0xE0, 0x1F, 0x01, 0xDC, 0x07, 0x80, 0x1B,
  0x80, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x03, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFD, 0xC0, 0x03, 0xFE, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x03, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x81,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x8F, 0xF0, 0x07, 0x9F, 0xF8, 0x07, 0xBF, 0xFC,
  0x07, 0x70, 0x3E, 0x07, 0xE0, 0x1E, 0x07, 0xC0, 0x0E, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1E,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x7C, 0x07, 0x00, 0x7C, 0x03, 0x80, 0x7C, 0x01, 0xC0, 0x3C, 0x00, 0xE0,
  0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFD, 0xC0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x03, 0xC0,
  0x07, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x07, 0x8F, 0xF0, 0x0F, 0xF8, 0x07, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xF0, 0x3E, 0x70, 0x1E, 0x07,
  0xC0, 0x1E, 0xE0, 0x0E, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x8F,
  0xF0, 0x07, 0x9F, 0xF8, 0x07, 0x3F, 0xFC, 0x07, 0x70, 0x3E, 0x07, 0xE0,
  0x1E, 0x07, 0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0x70, 0x00,
  0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x38, 0xFF, 0x00, 0x1C,
  0xFF, 0xF0, 0x07, 0x7F, 0xFC, 0x01, 0xFC, 0x07, 0x80, 0x7C, 0x00, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x1F,
  0x00, 0x1E, 0x07, 0x70, 0x1F, 0x01, 0xDF, 0xFF, 0x80, 0xF3, 0xFF, 0xC0,
  0x38, 0x3F, 0xE0, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xC3, 0x80, 0x7F, 0xF1, 0xC0, 0x7F, 0xFC, 0xE0, 0x7C, 0x07, 0x70, 0x78,
  0x01, 0xB8, 0x38, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x1E,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x80,
  0x1F, 0x01, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xC0, 0x0F,
  0xF8, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xF0, 0x7B, 0xFC, 0x1D,
  0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0xF0, 0x07,
  0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0xC3, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x04, 0x00, 0x1E, 0x00, 0x0E,
  0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3,
  0x80, 0x03, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x83, 0x80, 0x3F, 0x07, 0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFE, 0x70, 0x0F, 0xF8, 0xE0, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x3B, 0x80,
  0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x07,
  0x00, 0x78, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80,
  0x06, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xF7, 0x00, 0x1E, 0x00,
  0x39, 0xC0, 0x0F, 0x80, 0x0E, 0x70, 0x03, 0xE0, 0x07, 0x9C, 0x00, 0xF8,
  0x01, 0xC7, 0x00, 0x7E, 0x00, 0xF1, 0xC0, 0x1F, 0x80, 0x38, 0x70, 0x0E,
  0xE0, 0x0E, 0x1C, 0x03, 0x98, 0x07, 0x87, 0x01, 0xC7, 0x01, 0xC1, 0xC0,
  0x71, 0xC0, 0xF0, 0x70, 0x1C, 0x70, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x07,
  0x03, 0x87, 0x07, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0x78, 0x70, 0x70, 0x70,
  0x0E, 0x38, 0x1C, 0x38, 0x03, 0x8E, 0x07, 0x0E, 0x00, 0xE3, 0x81, 0xC7,
  0x00, 0x39, 0xC0, 0x31, 0xC0, 0x0E, 0x70, 0x0C, 0x70, 0x03, 0xB8, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x70, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x0E, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x81,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x00, 0x70, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01,
  0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0x1F, 0xFC, 0x00, 0x73, 0xE3, 0xE0, 0x07, 0x38, 0x1F, 0x00,
  0x67, 0x80, 0xF0, 0x0E, 0x70, 0x07, 0x81, 0xE7, 0x00, 0x3E, 0x3C, 0x60,
  0x01, 0xFF, 0x8E, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 44, 13, 1, -43 },
  { 62, 12, 13, 17, 6, -45 },
  { 82, 30, 43, 30, 2, -43 },
  { 244, 25, 56, 28, 2, -50 },
  { 419, 27, 45, 37, 6, -44 },
  { 571, 27, 45, 31, 2, -44 },
  { 723, 5, 13, 10, 6, -45 },
  { 732, 17, 62, 17, 3, -48 },
  { 864, 17, 62, 17, -3, -48 },
  { 996, 24, 24, 25, 3, -43 },
  { 1068, 25, 31, 29, 2, -35 },
  { 1165, 8, 14, 11, -2, -6 },
  { 1179, 12, 3, 15, 2, -20 },
  { 1184, 5, 6, 14, 1, -5 },
  { 1188, 26, 47, 21, -3, -43 },
  { 1341, 24, 45, 28, 3, -44 },
  { 1476, 14, 43, 28, 8, -43 },
  { 1552, 26, 44, 28, 1, -44 },
  { 1695, 25, 45, 28, 2, -44 },
  { 1836, 25, 43, 28, 1, -43 },
  { 1971, 25, 44, 28, 4, -43 },
  { 2109, 22, 44, 28, 3, -43 },
  { 2230, 25, 43, 28, 4, -43 },
  { 2365, 25, 45, 28, 2, -44 },
  { 2506, 22, 44, 28, 4, -44 },
  { 2627, 10, 33, 12, 1, -32 },
  { 2669, 12, 40, 11, -2, -32 },
  { 2729, 23, 25, 26, 2, -32 },
  { 2801, 23, 15, 28, 3, -27 },
  { 2845, 22, 25, 27, 2, -32 },
  { 2914, 19, 45, 24, 5, -44 },
  { 3021, 41, 55, 46, 2, -42 },
  { 3303, 30, 43, 32, -2, -43 },
  { 3465, 27, 43, 31, 2, -43 },
  { 3611, 29, 45, 33, 3, -44 },
  { 3775, 29, 43, 33, 2, -43 },
  { 3931, 29, 43, 29, 2, -43 },
  { 4087, 29, 43, 29, 2, -43 },
  { 4243, 28, 45, 35, 4, -44 },
  { 4401, 33, 43, 36, 2, -43 },
  { 4579, 11, 43, 14, 2, -43 },
  { 4639, 27, 44, 28, 1, -43 },
  { 4788, 32, 43, 32, 2, -43 },
  { 4960, 21, 43, 27, 2, -43 },
  { 5073, 41, 43, 44, 2, -43 },
  { 5294, 33, 43, 36, 2, -43 },
  { 5472, 29, 45, 34, 3, -44 },
  { 5636, 29, 43, 31, 2, -43 },
  { 5792, 29, 51, 34, 3, -44 },
  { 5977, 29, 43, 32, 2, -43 },
  { 6133, 29, 45, 30, 1, -44 },
  { 6297, 27, 43, 30, 6, -43 },
  { 6443, 30, 44, 33, 3, -43 },
  { 6608, 29, 43, 32, 5, -43 },
  { 6764, 41, 43, 45, 6, -43 },
  { 6985, 34, 43, 31, -1, -43 },
  { 7168, 28, 43, 30, 6, -43 },
  { 7319, 31, 43, 30, 0, -43 },
  { 7486, 17, 58, 13, 0, -49 },
  { 7610, 10, 47, 21, 6, -43 },
  { 7669, 18, 58, 13, -4, -49 },
  { 7800, 17, 21, 22, 3, -43 },
  { 7845, 22, 3, 22, -3, 0 },
  { 7854, 8, 8, 17, 7, -45 },
  { 7862, 23, 34, 27, 1, -33 },
  { 7960, 24, 46, 28, 1, -45 },
  { 8098, 23, 34, 26, 2, -33 },
  { 8196, 27, 46, 28, 2, -45 },
  { 8352, 23, 34, 27, 2, -33 },
  { 8450, 19, 46, 17, 3, -46 },
  { 8560, 27, 45, 28, 0, -33 },
  { 8712, 24, 45, 28, 1, -45 },
  { 8847, 10, 44, 12, 2, -44 },
  { 8902, 19, 56, 12, -7, -44 },
  { 9035, 25, 45, 25, 1, -45 },
  { 9176, 11, 45, 12, 2, -45 },
  { 9238, 40, 33, 44, 1, -33 },
  { 9403, 24, 33, 28, 1, -33 },
  { 9502, 24, 34, 29, 2, -33 },
  { 9604, 26, 45, 28, -1, -33 },
  { 9751, 25, 45, 29, 2, -33 },
  { 9892, 18, 33, 18, 1, -33 },
  { 9967, 23, 34, 26, 1, -33 },
  { 10065, 14, 41, 17, 3, -40 },
  { 10137, 23, 33, 28, 3, -32 },
  { 10232, 22, 32, 25, 4, -32 },
  { 10320, 34, 32, 38, 4, -32 },
  { 10456, 26, 32, 25, -1, -32 },
  { 10560, 28, 44, 24, -2, -32 },
  { 10714, 24, 32, 25, 0, -32 },
  { 10810, 19, 59, 17, 2, -47 },
  { 10951, 11, 51, 13, 1, -43 },
  { 11022, 18, 59, 17, -3, -47 },
  { 11155, 28, 11, 35, 3, -23 },
};

const GFXfont RobotoCondensed_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC60PT7B_H_
