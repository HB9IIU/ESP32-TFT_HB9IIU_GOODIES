#ifndef _ROBOTOCONDENSED_LIGHTITALIC44PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x60, 0x63, 0x63, 0x63, 0x63,
  0xE6, 0xC6, 0xC6, 0xC6, 0xC6, 0x84, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60,
  0x01, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC1, 0xC0, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x60, 0xC0, 0x03, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7C, 0xF0,
  0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x1C, 0x60, 0x07, 0x18,
  0x01, 0xC6, 0x00, 0x71, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0,
  0x06, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x3C, 0xF8, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x66, 0x04, 0x0C, 0xC0, 0x60, 0xCC, 0x04, 0x18, 0xC0, 0xC3, 0x0C, 0x0C,
  0x70, 0xC0, 0xC6, 0x06, 0x18, 0xC0, 0x61, 0x98, 0x03, 0xF1, 0x80, 0x1E,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE3, 0xC0, 0x0C, 0xFE, 0x01, 0x9C, 0x70,
  0x31, 0x83, 0x03, 0x18, 0x30, 0x63, 0x03, 0x0C, 0x30, 0x31, 0xC3, 0x03,
  0x18, 0x30, 0x33, 0x03, 0x03, 0x60, 0x30, 0x32, 0x03, 0x06, 0x00, 0x18,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x01,
  0xC7, 0x00, 0x38, 0x38, 0x03, 0x01, 0x80, 0x30, 0x18, 0x07, 0x01, 0x80,
  0x70, 0x38, 0x07, 0x03, 0x00, 0x70, 0x70, 0x03, 0x0E, 0x00, 0x33, 0xC0,
  0x03, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0E, 0xE0,
  0x01, 0xC7, 0x03, 0x38, 0x30, 0x73, 0x03, 0x86, 0x70, 0x18, 0x66, 0x01,
  0xCE, 0x60, 0x0C, 0xCE, 0x00, 0xFC, 0xE0, 0x07, 0x86, 0x00, 0x78, 0x70,
  0x07, 0x87, 0x00, 0xF8, 0x3C, 0x3D, 0xC1, 0xFF, 0x8C, 0x07, 0xC0, 0xE0,
  0x33, 0x76, 0x66, 0x66, 0xCC, 0x00, 0x10, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00, 0x01, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x02, 0x06, 0x01, 0xC3, 0x0F, 0xF9, 0xBF, 0x1F, 0xFE, 0x01, 0xF8,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x66, 0x00, 0x73, 0x80, 0x70, 0xC0, 0x70,
  0x70, 0x70, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x71, 0xC7, 0x18,
  0xE3, 0x9C, 0xE1, 0x00, 0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x78,
  0x70, 0x1C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x38, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x01, 0x9C,
  0x00, 0x67, 0x00, 0x19, 0x80, 0x0E, 0x60, 0x03, 0x98, 0x00, 0xC6, 0x00,
  0x33, 0x80, 0x0C, 0xE0, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x18,
  0xE0, 0x0E, 0x18, 0x03, 0x06, 0x01, 0xC1, 0xC0, 0xE0, 0x38, 0x70, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0xF1, 0xF9, 0xFE, 0xF1, 0xB0, 0x60,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3C, 0x78, 0x1C, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x1E,
  0x03, 0x80, 0xE0, 0x60, 0x1C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06,
  0x1C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x38, 0x00, 0xC7,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x03,
  0xC3, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0xB8, 0x00,
  0xCE, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x03, 0x87,
  0x00, 0xC1, 0xC0, 0x60, 0x60, 0x38, 0x18, 0x1C, 0x06, 0x06, 0x01, 0x83,
  0x80, 0xE1, 0xC0, 0x38, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xEF, 0xC0, 0x37, 0xF8, 0x0F, 0x9F,
  0x03, 0x81, 0xC0, 0x40, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x0E, 0x30, 0x03, 0x0E, 0x01, 0xC1, 0x80, 0xE0, 0x78, 0xF0, 0x0F, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x31, 0xF8, 0x37, 0xFC, 0x3F, 0x1E, 0x7C, 0x0E, 0x78, 0x07, 0x70,
  0x07, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x3C,
  0x78, 0x1F, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0x0E, 0x03, 0xC0,
  0xE0, 0x70, 0x0C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00,
  0xE1, 0x80, 0x18, 0x30, 0x03, 0x07, 0x00, 0xE0, 0x60, 0x38, 0x0F, 0x1E,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0x0E, 0x03, 0x00, 0xE0, 0xE0, 0x0C,
  0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x0C, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x07, 0x03, 0xC3, 0xC0,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0x1E, 0x1C,
  0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x03, 0x70, 0x03, 0x60, 0x03, 0x60,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x0F, 0x70, 0x0E, 0x70, 0x3E, 0x3C, 0x76, 0x1F, 0xEE, 0x0F, 0x8C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x0C, 0x3C, 0x78, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x1C, 0x38, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x81, 0xC0, 0x60, 0x10, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0x3C, 0xE0, 0x77, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x07,
  0xC0, 0x30, 0xE0, 0x3F, 0xC0, 0xC3, 0x01, 0xC3, 0x83, 0x1C, 0x0E, 0x0C,
  0x0C, 0x60, 0x70, 0x30, 0x11, 0x81, 0x80, 0xC0, 0xCC, 0x0E, 0x03, 0x03,
  0x30, 0x30, 0x0C, 0x0C, 0xC0, 0xC0, 0x60, 0x37, 0x06, 0x01, 0x80, 0xD8,
  0x18, 0x06, 0x03, 0x60, 0x60, 0x18, 0x0D, 0x81, 0x80, 0xC0, 0x26, 0x0E,
  0x03, 0x01, 0x98, 0x30, 0x0C, 0x06, 0x60, 0xC0, 0x70, 0x11, 0x83, 0x01,
  0xC0, 0xC6, 0x0C, 0x0F, 0x03, 0x18, 0x38, 0x2C, 0x18, 0x60, 0x63, 0xB0,
  0xC1, 0x81, 0xFC, 0xFE, 0x06, 0x03, 0xC1, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x30, 0x03,
  0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x30, 0x00, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x76,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x18,
  0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00,
  0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x1E, 0x0E, 0x03, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x18, 0x03, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70,
  0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xC0, 0x0F, 0x06, 0x01, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xC3, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x33,
  0x80, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60,
  0x07, 0x07, 0x00, 0xE0, 0x3C, 0x3C, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x3E, 0x01, 0xC0, 0x1C, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xE0, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18,
  0x70, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60,
  0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x18, 0x01, 0xC0, 0x60, 0x3E, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xF0, 0xF8, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00,
  0xE7, 0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x3F, 0xE7, 0x01, 0xFF, 0x38, 0x00, 0x19, 0x80, 0x01, 0xCC, 0x00,
  0x0E, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x18, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x0F, 0x03, 0xE3, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC0, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E,
  0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x1C,
  0x01, 0x83, 0x80, 0x70, 0x38, 0x1C, 0x07, 0xCF, 0x80, 0x7F, 0xC0, 0x03,
  0xF0, 0x00, 0x03, 0x00, 0x0F, 0x03, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07,
  0x00, 0x78, 0x06, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x60,
  0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xD8, 0x00, 0x1F,
  0x81, 0xB0, 0x00, 0x36, 0x07, 0x60, 0x00, 0xEC, 0x0E, 0xC0, 0x01, 0x98,
  0x19, 0x80, 0x07, 0x30, 0x33, 0x80, 0x0C, 0xE0, 0x63, 0x00, 0x39, 0xC0,
  0xC6, 0x00, 0x63, 0x03, 0x8C, 0x01, 0xC6, 0x07, 0x18, 0x03, 0x0C, 0x0C,
  0x30, 0x0E, 0x38, 0x18, 0x70, 0x18, 0x70, 0x30, 0x60, 0x70, 0xC0, 0x60,
  0xC0, 0xC1, 0x81, 0xC1, 0x83, 0x83, 0x03, 0x83, 0x06, 0x0E, 0x06, 0x06,
  0x1C, 0x1C, 0x0C, 0x0E, 0x30, 0x38, 0x18, 0x0C, 0xE0, 0x60, 0x70, 0x19,
  0x80, 0xC0, 0xE0, 0x37, 0x01, 0x81, 0xC0, 0x6C, 0x07, 0x03, 0x00, 0xF8,
  0x0E, 0x06, 0x01, 0xE0, 0x1C, 0x0C, 0x01, 0xC0, 0x30, 0x38, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0x60, 0x7C, 0x00, 0x30, 0x36, 0x00, 0x18, 0x1B, 0x80, 0x1C,
  0x1C, 0xC0, 0x0E, 0x0E, 0x60, 0x06, 0x07, 0x38, 0x03, 0x03, 0x0C, 0x01,
  0x81, 0x86, 0x01, 0xC0, 0xC3, 0x80, 0xE0, 0xE0, 0xC0, 0x70, 0x70, 0x60,
  0x30, 0x38, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x07, 0x0E, 0x06, 0x01,
  0x87, 0x07, 0x00, 0xC3, 0x83, 0x80, 0x71, 0x81, 0x80, 0x18, 0xC0, 0xC0,
  0x0C, 0x60, 0x60, 0x07, 0x70, 0x70, 0x01, 0xB8, 0x38, 0x00, 0xF8, 0x1C,
  0x00, 0x7C, 0x0C, 0x00, 0x1E, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x3E, 0x3E, 0x01,
  0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x01, 0x87, 0x00,
  0x06, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x07,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1,
  0xC0, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x1F, 0x1F, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x70,
  0x1F, 0x01, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0x60, 0x60, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x00, 0x3E, 0x3E, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x00,
  0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x67, 0x00, 0x01,
  0x9C, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x18, 0x00,
  0x38, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xE0,
  0x1F, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xC0, 0x7C, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x83,
  0x00, 0x1C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x03, 0x83, 0x00, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0E, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00,
  0x60, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xF8, 0xF8, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x18,
  0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0,
  0x00, 0xC3, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0xF0, 0x0F, 0x03, 0xE1, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C,
  0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x07,
  0x00, 0x38, 0x0E, 0x01, 0xC0, 0x3E, 0x1E, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00,
  0xC6, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x70,
  0x01, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x00, 0x60,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x38, 0x18, 0x01, 0xC1,
  0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x0D, 0xC0, 0x07, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0x73,
  0x00, 0x3C, 0x00, 0xC6, 0x00, 0x78, 0x03, 0x8C, 0x01, 0xB0, 0x07, 0x18,
  0x03, 0x60, 0x0C, 0x30, 0x0E, 0xC0, 0x38, 0x60, 0x19, 0x80, 0x60, 0xC0,
  0x33, 0x00, 0xC1, 0x80, 0xC6, 0x03, 0x83, 0x01, 0x8C, 0x06, 0x06, 0x07,
  0x1C, 0x0C, 0x0C, 0x0C, 0x18, 0x38, 0x18, 0x18, 0x30, 0x60, 0x30, 0x60,
  0x61, 0xC0, 0x70, 0xC0, 0xC3, 0x80, 0xE3, 0x81, 0x86, 0x01, 0xC6, 0x03,
  0x1C, 0x03, 0x8C, 0x06, 0x30, 0x07, 0x30, 0x0C, 0x60, 0x0E, 0x60, 0x19,
  0xC0, 0x0D, 0xC0, 0x33, 0x00, 0x1B, 0x00, 0x66, 0x00, 0x36, 0x00, 0xDC,
  0x00, 0x78, 0x01, 0xB0, 0x00, 0xF0, 0x01, 0x60, 0x01, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x73, 0x00, 0x03, 0x98, 0x00, 0x38, 0xE0, 0x01,
  0x87, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x18,
  0x0E, 0x00, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x38, 0x30, 0x00, 0xC3, 0x80,
  0x06, 0x38, 0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0xE0, 0x3F, 0x00, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x01, 0xF8,
  0x0F, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x60, 0x76, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0xC6, 0x18,
  0x63, 0x83, 0x30, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x71, 0xC3, 0x86, 0x1C, 0x30, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xE3, 0xC1,
  0xC0, 0xE1, 0xC0, 0x30, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xE0, 0x73, 0x80, 0x31, 0x80,
  0x19, 0xC0, 0x0C, 0xC0, 0x0E, 0x60, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x87,
  0x9E, 0xC3, 0xFE, 0x60, 0x7C, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC7, 0xC0, 0x37, 0xFC, 0x1F, 0x8F, 0x07,
  0x80, 0xE1, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x06,
  0x70, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x1C, 0x70, 0x06, 0x3E,
  0x03, 0x8E, 0xE3, 0xC3, 0x3F, 0xE0, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xC3, 0xC3, 0x80, 0x61, 0xC0, 0x39, 0xC0, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18,
  0x03, 0x0E, 0x03, 0x83, 0xC7, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x86,
  0x07, 0xFC, 0xC1, 0xF1, 0xD8, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0xC3,
  0x00, 0x38, 0x60, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x1E, 0x3B, 0x01,
  0xFE, 0xE0, 0x1F, 0x9C, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xC3, 0xC1,
  0xC0, 0xE1, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01,
  0xB0, 0x01, 0xDF, 0xFF, 0xEF, 0xFF, 0xF6, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x01, 0x0E, 0x01, 0x83,
  0xC3, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x1C, 0x40,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x07,
  0xFE, 0x1F, 0xF8, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x60, 0x3F, 0xE6, 0x07, 0xC7, 0x60,
  0xF0, 0x16, 0x0E, 0x01, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0x80, 0x0C,
  0x18, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00,
  0x30, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x1E, 0x3B, 0x00, 0xFF, 0x70, 0x07,
  0xE7, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x04,
  0x00, 0xC0, 0xE0, 0x1C, 0x07, 0x87, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x1F, 0x01,
  0x9F, 0xE1, 0xFC, 0xF0, 0xF8, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x18, 0x01,
  0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0xE0, 0x06, 0x70, 0x07, 0x38, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x67, 0x00, 0x33, 0x80, 0x39, 0x80, 0x1C, 0xC0, 0x0C, 0x00, 0x02,
  0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x00, 0x08, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x09, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x30, 0x0E, 0x1C, 0x07,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0x60, 0xE0, 0x18, 0x70, 0x06, 0x38, 0x03,
  0x9C, 0x00, 0xEE, 0x00, 0x37, 0x80, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xE3,
  0x00, 0x70, 0xE0, 0x1C, 0x18, 0x06, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x38,
  0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x0C, 0x00, 0x03, 0x03,
  0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x0C, 0x7C, 0x07, 0xC0, 0x6F,
  0xF0, 0xFF, 0x87, 0xE3, 0xCF, 0x1C, 0x3C, 0x07, 0xE0, 0x71, 0xC0, 0x3E,
  0x03, 0x8E, 0x01, 0xE0, 0x0C, 0x60, 0x0F, 0x00, 0x67, 0x00, 0x70, 0x03,
  0x38, 0x03, 0x80, 0x39, 0xC0, 0x1C, 0x01, 0xCC, 0x00, 0xC0, 0x0E, 0x60,
  0x06, 0x00, 0x63, 0x00, 0x30, 0x03, 0x38, 0x03, 0x80, 0x19, 0xC0, 0x1C,
  0x01, 0xCC, 0x00, 0xE0, 0x0E, 0x60, 0x06, 0x00, 0x73, 0x00, 0x30, 0x03,
  0x18, 0x01, 0x80, 0x19, 0xC0, 0x1C, 0x00, 0xCE, 0x00, 0xE0, 0x0E, 0x60,
  0x07, 0x00, 0x73, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x7C, 0x06, 0x7F, 0x87,
  0xF3, 0xC3, 0xE0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0x60, 0x06, 0x30, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x80,
  0x19, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C,
  0x00, 0xCE, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x30, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xC7, 0x83, 0x80, 0xE3, 0x80, 0x31, 0x80, 0x19, 0xC0, 0x0E, 0xC0,
  0x07, 0x60, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x06, 0x60, 0x07, 0x38, 0x03,
  0x0E, 0x03, 0x87, 0x87, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0x1F, 0x00,
  0x37, 0xFC, 0x07, 0xE3, 0xC0, 0x78, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x83, 0xE0, 0x38, 0x3F,
  0x0F, 0x03, 0xBF, 0xE0, 0x30, 0xF8, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE1, 0x87, 0xFC, 0xC7, 0x87, 0x67,
  0x80, 0xB3, 0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x70, 0x03, 0xB8, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x06, 0x38, 0x07, 0x1C, 0x07, 0x87,
  0x8F, 0xC1, 0xFE, 0xE0, 0x7E, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x78, 0x6F, 0xC7, 0xFC, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x07, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xE0, 0x0C, 0x60, 0x1C, 0x78, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xF8,
  0x1E, 0x00, 0x18, 0x01, 0x8C, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x00,
  0x39, 0x80, 0x18, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x07, 0x38, 0x03, 0x98,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x07, 0x0C, 0x07, 0x87, 0x8F, 0xC1, 0xFE,
  0xE0, 0x7C, 0x60, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xE0, 0x0C, 0xE0,
  0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0x70, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x33, 0x80, 0x33,
  0x00, 0x37, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x0F, 0x00, 0xDC, 0x07,
  0x80, 0xE6, 0x03, 0xC0, 0x63, 0x03, 0x60, 0x71, 0x81, 0xB0, 0x30, 0xC1,
  0xD8, 0x18, 0x60, 0xCC, 0x1C, 0x30, 0xE6, 0x0C, 0x18, 0x63, 0x8E, 0x0C,
  0x30, 0xC6, 0x06, 0x30, 0x63, 0x03, 0x18, 0x33, 0x81, 0x98, 0x19, 0x80,
  0xCC, 0x0D, 0xC0, 0x6E, 0x06, 0xC0, 0x3E, 0x03, 0x60, 0x1F, 0x01, 0xE0,
  0x07, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0xE0, 0x60, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x38, 0x03,
  0x07, 0x00, 0x38, 0x70, 0x01, 0x8E, 0x00, 0x1D, 0xC0, 0x00, 0xD8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xB8, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00, 0xE1, 0xC0, 0x1C, 0x0C,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x07, 0x00, 0x06,
  0x00, 0x38, 0x30, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xC0, 0x70, 0x0E,
  0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x18,
  0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x4F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x07, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x02, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xCF,
  0x78, 0x06, 0xE0, 0xE0, 0x66, 0x03, 0x83, 0x30, 0x1E, 0x73, 0x80, 0x7F,
  0x80, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 8, 10, 12, 5, -33 },
  { 42, 22, 31, 22, 1, -31 },
  { 128, 18, 39, 21, 2, -35 },
  { 216, 20, 31, 27, 4, -31 },
  { 294, 20, 31, 23, 1, -31 },
  { 372, 4, 10, 7, 4, -33 },
  { 377, 13, 45, 12, 2, -35 },
  { 451, 12, 45, 13, -2, -35 },
  { 519, 17, 18, 18, 2, -31 },
  { 558, 18, 22, 21, 2, -25 },
  { 608, 6, 10, 8, -2, -4 },
  { 616, 9, 2, 11, 1, -15 },
  { 619, 4, 4, 10, 1, -4 },
  { 621, 19, 34, 15, -2, -31 },
  { 702, 18, 31, 21, 2, -31 },
  { 772, 10, 31, 21, 6, -31 },
  { 811, 18, 31, 21, 1, -31 },
  { 881, 19, 31, 21, 1, -31 },
  { 955, 18, 31, 21, 1, -31 },
  { 1025, 18, 31, 21, 3, -31 },
  { 1095, 16, 31, 21, 2, -31 },
  { 1157, 18, 31, 21, 3, -31 },
  { 1227, 19, 31, 21, 1, -31 },
  { 1301, 16, 31, 21, 3, -31 },
  { 1363, 7, 24, 9, 1, -24 },
  { 1384, 10, 30, 8, -2, -24 },
  { 1422, 16, 18, 19, 2, -23 },
  { 1458, 17, 11, 21, 2, -20 },
  { 1482, 17, 18, 19, 1, -23 },
  { 1521, 13, 31, 17, 4, -31 },
  { 1572, 30, 41, 33, 1, -31 },
  { 1726, 21, 31, 23, -1, -31 },
  { 1808, 21, 31, 23, 1, -31 },
  { 1890, 20, 31, 24, 3, -31 },
  { 1968, 22, 31, 24, 1, -31 },
  { 2054, 22, 31, 21, 1, -31 },
  { 2140, 22, 31, 21, 1, -31 },
  { 2226, 21, 31, 25, 3, -31 },
  { 2308, 25, 31, 26, 1, -31 },
  { 2405, 8, 31, 10, 2, -31 },
  { 2436, 19, 31, 21, 1, -31 },
  { 2510, 24, 31, 23, 1, -31 },
  { 2603, 16, 31, 20, 1, -31 },
  { 2665, 31, 31, 32, 1, -31 },
  { 2786, 25, 31, 26, 1, -31 },
  { 2883, 22, 31, 25, 2, -31 },
  { 2969, 22, 31, 23, 1, -31 },
  { 3055, 22, 36, 25, 2, -31 },
  { 3154, 21, 31, 23, 1, -31 },
  { 3236, 21, 31, 22, 1, -31 },
  { 3318, 20, 31, 22, 4, -31 },
  { 3396, 22, 31, 24, 2, -31 },
  { 3482, 21, 31, 23, 4, -31 },
  { 3564, 31, 31, 33, 4, -31 },
  { 3685, 25, 31, 23, -1, -31 },
  { 3782, 21, 31, 22, 4, -31 },
  { 3864, 23, 31, 22, 0, -31 },
  { 3954, 13, 43, 10, 0, -36 },
  { 4024, 7, 34, 15, 4, -31 },
  { 4054, 13, 43, 10, -3, -36 },
  { 4124, 12, 16, 16, 2, -31 },
  { 4148, 16, 2, 16, -2, 0 },
  { 4152, 6, 6, 12, 5, -33 },
  { 4157, 17, 23, 20, 1, -23 },
  { 4206, 18, 33, 21, 1, -33 },
  { 4281, 17, 23, 19, 1, -23 },
  { 4330, 19, 33, 21, 2, -33 },
  { 4409, 17, 23, 20, 1, -23 },
  { 4458, 14, 33, 13, 2, -33 },
  { 4516, 20, 32, 21, 0, -23 },
  { 4596, 17, 33, 21, 1, -33 },
  { 4667, 8, 32, 9, 1, -32 },
  { 4699, 14, 41, 9, -5, -32 },
  { 4771, 18, 33, 19, 1, -33 },
  { 4846, 8, 33, 9, 1, -33 },
  { 4879, 29, 23, 33, 1, -23 },
  { 4963, 17, 23, 21, 1, -23 },
  { 5012, 17, 23, 21, 2, -23 },
  { 5061, 20, 32, 21, -1, -23 },
  { 5141, 17, 32, 21, 2, -23 },
  { 5209, 13, 23, 13, 1, -23 },
  { 5247, 16, 23, 19, 1, -23 },
  { 5293, 10, 29, 12, 2, -29 },
  { 5330, 17, 23, 21, 2, -23 },
  { 5379, 16, 23, 18, 3, -23 },
  { 5425, 25, 23, 28, 3, -23 },
  { 5497, 20, 23, 18, -1, -23 },
  { 5555, 21, 32, 18, -2, -23 },
  { 5639, 18, 23, 18, 0, -23 },
  { 5691, 14, 43, 13, 1, -34 },
  { 5767, 8, 37, 9, 1, -31 },
  { 5804, 13, 43, 13, -2, -34 },
  { 5874, 21, 8, 25, 2, -17 },
};

const GFXfont RobotoCondensed_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC44PT7B_H_
