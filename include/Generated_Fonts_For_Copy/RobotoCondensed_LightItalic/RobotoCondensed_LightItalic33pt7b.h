#ifndef _ROBOTOCONDENSED_LIGHTITALIC33PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x21, 0x86,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x00, 0x26, 0xCD, 0x93, 0x24, 0x49,
  0x93, 0x00, 0x00, 0x43, 0x00, 0xC2, 0x00, 0x86, 0x00, 0x86, 0x01, 0x84,
  0x01, 0x0C, 0x1F, 0xFF, 0x1F, 0xFF, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10,
  0x04, 0x30, 0x04, 0x30, 0x0C, 0x20, 0x08, 0x60, 0xFF, 0xFC, 0xFF, 0xFC,
  0x10, 0xC0, 0x10, 0xC0, 0x30, 0x80, 0x21, 0x80, 0x21, 0x00, 0x61, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0xF8, 0x07, 0xF0, 0x30, 0x61, 0x80,
  0x86, 0x03, 0x18, 0x0C, 0x40, 0x31, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x30, 0x0C, 0xC0,
  0x33, 0x00, 0xC6, 0x07, 0x1C, 0x38, 0x3F, 0xC0, 0x7C, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x6C, 0x01, 0x8C, 0x02, 0x18, 0x2C, 0x30,
  0xD8, 0x63, 0x30, 0xCC, 0x61, 0x10, 0xC6, 0x60, 0xD9, 0x80, 0xE2, 0x00,
  0x08, 0x00, 0x33, 0xC0, 0xCD, 0x81, 0x31, 0x86, 0x41, 0x18, 0x82, 0x63,
  0x04, 0x86, 0x0B, 0x0C, 0x30, 0x08, 0x40, 0x1B, 0x80, 0x1E, 0x00, 0x01,
  0xE0, 0x0F, 0xE0, 0x18, 0xC0, 0x60, 0x80, 0xC1, 0x01, 0x06, 0x02, 0x0C,
  0x06, 0x30, 0x0C, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xB0, 0x66,
  0x30, 0x98, 0x63, 0x60, 0x66, 0xC0, 0xC9, 0x80, 0xF3, 0x00, 0xC6, 0x01,
  0x86, 0x0F, 0x87, 0xFB, 0x07, 0xC3, 0x00, 0x6D, 0xA5, 0xB0, 0x00, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x00, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x08, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x0C, 0x23, 0x7D, 0x7C, 0x7F, 0x01, 0xC0, 0x0F, 0x00, 0xD8,
  0x0C, 0x60, 0xC1, 0x04, 0x08, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x33, 0x33, 0x66, 0xC8, 0xFF, 0xF8, 0x5B, 0x00, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x7F, 0x06, 0x0C, 0x60, 0x63, 0x01,
  0x30, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x12, 0x00, 0xB0, 0x0D, 0x80, 0x6C,
  0x03, 0x60, 0x1B, 0x00, 0xD0, 0x04, 0x80, 0x64, 0x03, 0x30, 0x11, 0x81,
  0x8E, 0x18, 0x3F, 0x80, 0xF8, 0x00, 0x03, 0x0F, 0x7E, 0xE2, 0x86, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x03, 0xE0, 0x3F, 0xC0, 0xC1, 0x86, 0x06,
  0x30, 0x08, 0xC0, 0x23, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xE0,
  0x3F, 0xC1, 0xC1, 0x86, 0x06, 0x30, 0x08, 0xC0, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x7E, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x60, 0xE0, 0xFF,
  0x01, 0xF0, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x00,
  0xD8, 0x04, 0xC0, 0x66, 0x06, 0x30, 0x61, 0x82, 0x08, 0x30, 0xC3, 0x06,
  0x30, 0x31, 0x81, 0x9F, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x37, 0x80, 0xFF, 0x03, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC0, 0x33, 0x00,
  0x8C, 0x06, 0x30, 0x18, 0x60, 0xC0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x3E, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x67, 0x87,
  0xFC, 0x70, 0x6E, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C,
  0x06, 0xC0, 0x6C, 0x0C, 0x61, 0xC7, 0xF8, 0x1E, 0x00, 0x7F, 0xFD, 0xFF,
  0xF0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xC1, 0x86, 0x03, 0x18, 0x0C, 0x40,
  0x31, 0x00, 0xC4, 0x02, 0x18, 0x18, 0x60, 0xC0, 0xFE, 0x03, 0xF0, 0x38,
  0x61, 0x80, 0xC6, 0x03, 0x30, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x30,
  0x18, 0x60, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xFE, 0x18, 0x73,
  0x03, 0x60, 0x36, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14, 0x03, 0x40, 0x36,
  0x07, 0x60, 0xF3, 0xFA, 0x1E, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x18, 0x07, 0x07, 0xE0, 0x70, 0x00, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0xC6, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x18, 0x20, 0x00, 0x00, 0x08, 0x01, 0x80, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0C,
  0x00, 0x20, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x20, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x30, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x00, 0x80, 0x00,
  0x1F, 0x0F, 0xE6, 0x1D, 0x83, 0xC0, 0xF0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x18, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00,
  0x01, 0x0C, 0x0F, 0x02, 0x10, 0x3F, 0x04, 0x60, 0xC3, 0x08, 0x83, 0x04,
  0x13, 0x04, 0x08, 0x26, 0x18, 0x30, 0x48, 0x20, 0x60, 0x90, 0x40, 0x81,
  0x61, 0x81, 0x02, 0xC3, 0x06, 0x0D, 0x86, 0x0C, 0x13, 0x0C, 0x18, 0x26,
  0x18, 0x60, 0xCC, 0x31, 0xE3, 0x18, 0x7E, 0xEC, 0x30, 0x78, 0xF0, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x28, 0x00, 0x6C, 0x00, 0x4C, 0x00, 0xCC, 0x00, 0x8C,
  0x01, 0x84, 0x01, 0x04, 0x03, 0x04, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x06, 0x0F, 0xFE, 0x1F, 0xFE, 0x18, 0x02, 0x30, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x0F, 0xF0, 0x1F, 0xF8, 0x20, 0x30,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x10, 0x0C, 0x60,
  0x38, 0xFF, 0xC1, 0xFF, 0x83, 0x03, 0x86, 0x03, 0x18, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x62, 0x00, 0xCC, 0x03, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x0C, 0x18, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x20, 0x02, 0x60, 0x02, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x18, 0x60, 0x30, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80,
  0x0F, 0xF0, 0x0F, 0xFC, 0x08, 0x0E, 0x18, 0x06, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C,
  0x60, 0x1C, 0x40, 0x38, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF,
  0x0F, 0xFF, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E,
  0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0xFE, 0xC0, 0xFE, 0xC0, 0x04,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x0C, 0x70, 0x38,
  0x3F, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06, 0x10, 0x01,
  0x8C, 0x00, 0x63, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0x03, 0x0C, 0x00, 0xC2,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x40, 0x0C, 0x30, 0xC3, 0x08,
  0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x61,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x80, 0x22, 0x01, 0x8C, 0x06, 0x30,
  0x30, 0xE1, 0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x0C, 0x01, 0x83, 0x00, 0xC0,
  0x80, 0x60, 0x60, 0x30, 0x18, 0x18, 0x06, 0x0E, 0x01, 0x87, 0x00, 0x63,
  0x80, 0x11, 0xC0, 0x0C, 0xE0, 0x03, 0x70, 0x00, 0xFE, 0x00, 0x3D, 0x80,
  0x0E, 0x70, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x60, 0x18, 0x18, 0x06,
  0x03, 0x01, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0x40, 0x0D, 0x86, 0x80, 0x1B, 0x0D, 0x80, 0x64, 0x13, 0x00, 0xD8,
  0x66, 0x03, 0x30, 0xCC, 0x06, 0x61, 0x88, 0x18, 0xC3, 0x10, 0x31, 0x06,
  0x30, 0xC6, 0x08, 0x61, 0x8C, 0x30, 0xC6, 0x18, 0x61, 0x88, 0x30, 0xC1,
  0x30, 0x61, 0x82, 0x40, 0x82, 0x07, 0x83, 0x0C, 0x0E, 0x06, 0x18, 0x1C,
  0x0C, 0x30, 0x10, 0x18, 0x00, 0x0C, 0x00, 0x43, 0x00, 0x30, 0xE0, 0x0C,
  0x78, 0x03, 0x1B, 0x00, 0xC6, 0xC0, 0x21, 0xB0, 0x18, 0x66, 0x06, 0x11,
  0x81, 0x8C, 0x20, 0x63, 0x0C, 0x18, 0xC3, 0x04, 0x30, 0x43, 0x0C, 0x18,
  0xC6, 0x06, 0x31, 0x80, 0xCC, 0x60, 0x33, 0x18, 0x04, 0x86, 0x01, 0xE1,
  0x00, 0x78, 0xC0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xC0, 0x01, 0xF0, 0x07,
  0xFC, 0x0C, 0x0E, 0x18, 0x06, 0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60,
  0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x08,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x1C, 0x3F, 0xF8, 0x3F, 0xE0, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0C, 0x0C, 0x18,
  0x06, 0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xE0, 0x38, 0x70, 0x70, 0x3F,
  0xE0, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x10, 0x0F,
  0xF8, 0x0F, 0xFC, 0x08, 0x0E, 0x18, 0x06, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x02, 0x10, 0x06, 0x30, 0x0E, 0x30, 0x1C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x30, 0x60, 0x60, 0x60, 0x60, 0x20, 0x60, 0x30, 0x60, 0x30, 0x60,
  0x30, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0x01, 0xF0, 0x07,
  0xFC, 0x0E, 0x0C, 0x18, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x02, 0x10,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xE0,
  0x18, 0x70, 0x70, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x04, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x70, 0x7F, 0xE0, 0x1F,
  0x80, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x0C, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x20,
  0x40, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x33, 0x00, 0x13,
  0x00, 0x16, 0x00, 0x16, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0,
  0x10, 0x07, 0x80, 0x70, 0x1B, 0x00, 0xE0, 0x36, 0x03, 0xC0, 0x6C, 0x07,
  0x81, 0x88, 0x0B, 0x03, 0x10, 0x36, 0x06, 0x20, 0x4C, 0x18, 0x41, 0x88,
  0x30, 0xC3, 0x10, 0x41, 0x84, 0x21, 0x83, 0x18, 0x43, 0x06, 0x20, 0x8C,
  0x0C, 0xC1, 0x18, 0x19, 0x83, 0x30, 0x32, 0x06, 0xC0, 0x6C, 0x0D, 0x80,
  0xD0, 0x1A, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x06, 0x01, 0x81, 0xC0, 0x30, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C,
  0x60, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01, 0xC3,
  0x00, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x01,
  0x80, 0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x38, 0x30,
  0x30, 0x30, 0x60, 0x30, 0x60, 0x10, 0xC0, 0x19, 0x80, 0x19, 0x80, 0x1B,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF0,
  0x07, 0xC1, 0xE0, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0F, 0x83, 0xE0, 0xC1, 0x04, 0x18, 0x61, 0x86, 0x18, 0x20, 0x83,
  0x0C, 0x30, 0xC3, 0x04, 0x10, 0x61, 0x86, 0x18, 0x60, 0x82, 0x08, 0x07,
  0x81, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x0F, 0x83, 0xE0, 0x06, 0x03, 0x03, 0x81, 0x41, 0xB0, 0xD8, 0xCC, 0x62,
  0x61, 0x30, 0xB0, 0x78, 0x30, 0x7F, 0xFF, 0xFF, 0xC6, 0x63, 0x10, 0x07,
  0xC1, 0xFE, 0x18, 0x33, 0x03, 0x20, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x3F,
  0xF6, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC1, 0xE7, 0xF6, 0x3C,
  0x60, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x33, 0xE1, 0xBF, 0x8E, 0x0C, 0x60, 0x33, 0x01, 0x90, 0x0D,
  0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x04, 0x80, 0x6C, 0x03, 0x70,
  0x33, 0x83, 0x9B, 0xF8, 0x8F, 0x80, 0x07, 0xC0, 0xFF, 0x0E, 0x0C, 0x60,
  0x66, 0x01, 0x30, 0x09, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x4C, 0x06, 0x60, 0x31, 0x83, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x07, 0x88, 0x3F, 0xF0, 0xE0, 0xE1, 0x80, 0xC6, 0x01, 0x8C, 0x03,
  0x18, 0x04, 0x20, 0x18, 0x40, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C,
  0x02, 0x08, 0x0C, 0x18, 0x38, 0x3F, 0xF0, 0x1E, 0x60, 0x07, 0xC1, 0xFE,
  0x38, 0x33, 0x03, 0x60, 0x16, 0x01, 0x40, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0xE3, 0xFC, 0x1F, 0x00, 0x03,
  0xC1, 0xF0, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x3F, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x03, 0xC6, 0x1F, 0xE8, 0x70,
  0x70, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x18,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x04, 0x06, 0x0C, 0x1C, 0x1F,
  0xF8, 0x0F, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x18, 0x18,
  0x1F, 0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x33, 0xE3, 0x7F, 0x3C, 0x33, 0x83, 0x30, 0x13,
  0x01, 0x60, 0x16, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x02, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x60, 0x08, 0x70, 0x80, 0x00, 0x00, 0x06,
  0x10, 0xC3, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30,
  0x00, 0x40, 0x1C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x01, 0xC1, 0xF0, 0x3C, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x19, 0x81, 0x8C,
  0x18, 0x61, 0x83, 0x18, 0x11, 0x81, 0x98, 0x0D, 0x80, 0x7E, 0x03, 0xB0,
  0x18, 0xC0, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0x60,
  0x0C, 0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC0, 0x33, 0xE1, 0xF0, 0xDF, 0xCF,
  0xE3, 0x83, 0x61, 0x8E, 0x0F, 0x02, 0x30, 0x18, 0x08, 0x80, 0x60, 0x26,
  0x03, 0x00, 0x98, 0x0C, 0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0x66, 0x03,
  0x01, 0x90, 0x08, 0x06, 0xC0, 0x60, 0x13, 0x01, 0x80, 0xCC, 0x06, 0x03,
  0x30, 0x18, 0x0C, 0x80, 0x60, 0x30, 0x13, 0xE3, 0x7F, 0x3C, 0x33, 0x83,
  0x30, 0x13, 0x01, 0x60, 0x16, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x02,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x60, 0x07, 0xC0, 0x7F, 0x86,
  0x0C, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x6C, 0x03, 0x30, 0x31, 0x83, 0x87, 0xF8, 0x1F, 0x00,
  0x04, 0xF8, 0x1B, 0xF8, 0x38, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC2,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x80, 0x63, 0x00,
  0xC6, 0x03, 0x0E, 0x0E, 0x1B, 0xF8, 0x33, 0xE0, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x07, 0x8C, 0x7F,
  0xA3, 0x83, 0x8C, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x10, 0x04, 0x40,
  0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x0E, 0x1F,
  0xF8, 0x1E, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x13, 0x9B, 0xCF, 0x07, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x07,
  0xC1, 0xFE, 0x38, 0x73, 0x03, 0x20, 0x33, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xC7, 0xF8, 0x3E,
  0x00, 0x18, 0x30, 0x60, 0xC1, 0x1F, 0xFF, 0x98, 0x30, 0x40, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x07, 0x8E, 0x00, 0x20, 0x16, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x34, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x68, 0x04, 0x80, 0xCC, 0x0C, 0xC1, 0xCF, 0xEC, 0x7C, 0xC0, 0xC0,
  0x3C, 0x06, 0xC0, 0x64, 0x04, 0x40, 0xC6, 0x08, 0x61, 0x86, 0x18, 0x63,
  0x06, 0x30, 0x26, 0x02, 0x60, 0x2C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x10,
  0x00, 0xC0, 0x60, 0x68, 0x1C, 0x09, 0x03, 0x83, 0x20, 0xF0, 0x64, 0x1E,
  0x18, 0x82, 0xC3, 0x18, 0xD8, 0x43, 0x11, 0x18, 0x66, 0x23, 0x0C, 0x84,
  0xC1, 0xB0, 0x98, 0x36, 0x12, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x20, 0x30, 0x00, 0x0C, 0x0E, 0x18, 0x18, 0x30, 0x60,
  0x31, 0x80, 0x63, 0x00, 0x4C, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x1B, 0x00, 0x66, 0x00, 0xC4, 0x03, 0x0C, 0x0C, 0x18, 0x38, 0x18,
  0x60, 0x30, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0x40, 0x40, 0xC1, 0x81,
  0x82, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x13, 0x00, 0x26,
  0x00, 0x58, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x40, 0x70, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x83, 0xC0, 0xE0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x08, 0x20, 0x86, 0x18, 0x61,
  0x84, 0x10, 0xC3, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C,
  0x30, 0xC2, 0x08, 0x00, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x01, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x3C, 0x02,
  0xFC, 0x0D, 0x8C, 0x1E, 0x0C, 0x6C, 0x0F, 0xD0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 7, 7, 9, 3, -25 },
  { 26, 16, 23, 16, 1, -23 },
  { 72, 14, 29, 16, 1, -26 },
  { 123, 15, 23, 20, 3, -23 },
  { 167, 15, 23, 17, 1, -23 },
  { 211, 3, 7, 5, 3, -25 },
  { 214, 9, 34, 9, 2, -26 },
  { 253, 10, 34, 10, -2, -26 },
  { 296, 13, 13, 14, 2, -23 },
  { 318, 14, 17, 16, 1, -19 },
  { 348, 4, 8, 6, -1, -3 },
  { 352, 7, 2, 8, 1, -12 },
  { 354, 3, 3, 8, 1, -3 },
  { 356, 14, 25, 11, -1, -23 },
  { 400, 13, 23, 16, 2, -23 },
  { 438, 8, 23, 16, 4, -23 },
  { 461, 14, 23, 16, 1, -23 },
  { 502, 14, 23, 16, 1, -23 },
  { 543, 13, 23, 16, 1, -23 },
  { 581, 14, 23, 16, 2, -23 },
  { 622, 12, 23, 16, 2, -23 },
  { 657, 14, 23, 16, 2, -23 },
  { 698, 14, 23, 16, 1, -23 },
  { 739, 12, 23, 16, 2, -23 },
  { 774, 5, 18, 7, 1, -18 },
  { 786, 7, 23, 6, -1, -18 },
  { 807, 13, 14, 14, 1, -18 },
  { 830, 12, 9, 15, 2, -15 },
  { 844, 12, 13, 15, 1, -17 },
  { 864, 10, 23, 13, 3, -23 },
  { 893, 23, 30, 25, 1, -23 },
  { 980, 16, 23, 18, -1, -23 },
  { 1026, 15, 23, 17, 1, -23 },
  { 1070, 16, 23, 18, 2, -23 },
  { 1116, 16, 23, 18, 1, -23 },
  { 1162, 16, 23, 16, 1, -23 },
  { 1208, 16, 23, 16, 1, -23 },
  { 1254, 16, 23, 19, 2, -23 },
  { 1300, 18, 23, 20, 1, -23 },
  { 1352, 6, 23, 8, 1, -23 },
  { 1370, 14, 23, 15, 1, -23 },
  { 1411, 18, 23, 18, 1, -23 },
  { 1463, 12, 23, 15, 1, -23 },
  { 1498, 23, 23, 24, 1, -23 },
  { 1565, 18, 23, 20, 1, -23 },
  { 1617, 16, 23, 19, 2, -23 },
  { 1663, 16, 23, 17, 1, -23 },
  { 1709, 16, 27, 19, 2, -23 },
  { 1763, 16, 23, 18, 1, -23 },
  { 1809, 16, 23, 17, 1, -23 },
  { 1855, 15, 23, 17, 3, -23 },
  { 1899, 16, 23, 18, 2, -23 },
  { 1945, 16, 23, 17, 3, -23 },
  { 1991, 23, 23, 25, 3, -23 },
  { 2058, 19, 23, 17, -1, -23 },
  { 2113, 16, 23, 17, 3, -23 },
  { 2159, 17, 23, 17, 0, -23 },
  { 2208, 10, 32, 7, 0, -27 },
  { 2248, 6, 25, 11, 3, -23 },
  { 2267, 10, 32, 7, -2, -27 },
  { 2307, 9, 12, 12, 2, -23 },
  { 2321, 12, 2, 12, -2, 0 },
  { 2324, 4, 5, 9, 4, -25 },
  { 2327, 12, 17, 15, 1, -17 },
  { 2353, 13, 25, 16, 1, -25 },
  { 2394, 13, 17, 15, 1, -17 },
  { 2422, 15, 25, 16, 1, -25 },
  { 2469, 12, 17, 15, 1, -17 },
  { 2495, 10, 25, 10, 2, -25 },
  { 2527, 15, 24, 16, 0, -17 },
  { 2572, 12, 25, 15, 1, -25 },
  { 2610, 6, 24, 7, 1, -24 },
  { 2628, 11, 31, 7, -4, -24 },
  { 2671, 13, 25, 14, 1, -25 },
  { 2712, 6, 25, 7, 1, -25 },
  { 2731, 22, 17, 24, 1, -17 },
  { 2778, 12, 17, 15, 1, -17 },
  { 2804, 13, 17, 16, 1, -17 },
  { 2832, 15, 24, 16, -1, -17 },
  { 2877, 14, 24, 16, 1, -17 },
  { 2919, 9, 17, 10, 1, -17 },
  { 2939, 12, 17, 14, 1, -17 },
  { 2965, 7, 22, 9, 2, -22 },
  { 2985, 12, 17, 15, 2, -17 },
  { 3011, 12, 17, 14, 2, -17 },
  { 3037, 19, 17, 21, 2, -17 },
  { 3078, 15, 17, 14, -1, -17 },
  { 3110, 15, 24, 13, -1, -17 },
  { 3155, 13, 17, 14, 0, -17 },
  { 3183, 10, 32, 10, 1, -26 },
  { 3223, 6, 27, 7, 1, -23 },
  { 3244, 10, 33, 10, -2, -26 },
  { 3286, 15, 6, 19, 2, -13 },
};

const GFXfont RobotoCondensed_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC33PT7B_H_
