#ifndef _ROBOTOCONDENSED_LIGHTITALIC66PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x00, 0x38, 0x39, 0xC3, 0xCE, 0x1C,
  0x70, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x18,
  0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0x60, 0x02, 0x1C, 0x01, 0xC0, 0x1C, 0x70, 0x07,
  0x00, 0x71, 0xC0, 0x1C, 0x03, 0x8E, 0x00, 0x70, 0x1C, 0x38, 0x01, 0xC0,
  0x70, 0xE0, 0x07, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x0E, 0x00, 0xE0, 0x70,
  0x38, 0x03, 0x83, 0x80, 0x70, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0xF0, 0x07,
  0x83, 0x83, 0x80, 0x0F, 0xFE, 0x1C, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x3F,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x83,
  0xF8, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xE0, 0x03, 0x87, 0x83,
  0x80, 0x1C, 0x1C, 0x07, 0x00, 0xF0, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x70,
  0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x70, 0x07, 0x03, 0x81, 0xC0, 0x1C, 0x1C,
  0x07, 0x00, 0x70, 0xE0, 0x1C, 0x01, 0xC7, 0x80, 0x70, 0x07, 0x1C, 0x01,
  0xC0, 0x1C, 0xE0, 0x07, 0x00, 0x73, 0x80, 0x1C, 0x03, 0x84, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0x80, 0x78, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x0F,
  0x00, 0x70, 0xF0, 0x3C, 0x03, 0x8F, 0x01, 0xE0, 0x1C, 0xF0, 0x07, 0x81,
  0xE7, 0x80, 0x3C, 0x0E, 0x78, 0x00, 0xF0, 0x73, 0xC0, 0x07, 0x87, 0x9C,
  0x00, 0x1E, 0x39, 0xE0, 0x00, 0xF1, 0xCF, 0x00, 0x03, 0xDE, 0x78, 0x00,
  0x1E, 0xE3, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xE0, 0x78, 0x00, 0xFF, 0x83,
  0xE0, 0x0F, 0xBC, 0x0F, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x07, 0x80, 0x7F,
  0xE0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x9E,
  0x71, 0xC7, 0x1C, 0xE3, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x1E, 0x03,
  0xFE, 0x0E, 0x07, 0xFF, 0xC7, 0x1F, 0xEF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x08, 0x00, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x80, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC1,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFE, 0x3F, 0xDE, 0x7F, 0x1E,
  0x7C, 0x1E, 0x60, 0x1C, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C,
  0x03, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x0E, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x40, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x1F, 0xC0, 0x1E, 0x7F, 0xF0, 0x1C, 0xFF, 0xF8,
  0x1D, 0xF9, 0xFC, 0x3F, 0xC0, 0x3E, 0x3F, 0x80, 0x1E, 0x3E, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0x78, 0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0x70, 0x00,
  0x7E, 0x78, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x3E, 0x03, 0xDC, 0x3F, 0x9F,
  0xBC, 0x1F, 0xFF, 0x3C, 0x0F, 0xFE, 0x38, 0x03, 0xF8, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x80,
  0x78, 0x1F, 0x83, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x38, 0x00,
  0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x18, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x78, 0x00,
  0xFF, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0xFF, 0x00, 0x38, 0x3C, 0x00, 0xF8,
  0x3C, 0x01, 0xC1, 0xC0, 0x0F, 0x00, 0xE0, 0x0E, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x87, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x1C, 0x01, 0xC0, 0x07, 0x00, 0x39, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0xCE,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x80,
  0x78, 0x00, 0xE0, 0x03, 0x38, 0x03, 0x80, 0x07, 0x00, 0x39, 0xC0, 0x1C,
  0x00, 0x38, 0x01, 0xCE, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x70, 0x0F, 0x00,
  0x1C, 0x00, 0x73, 0x80, 0x70, 0x00, 0xE0, 0x03, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0x39, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xCE, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x70, 0x07, 0x00, 0x3C, 0x00, 0xE3, 0x80, 0x38, 0x01, 0xE0, 0x07,
  0x1C, 0x01, 0xC0, 0x1F, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x87,
  0x00, 0x78, 0x0D, 0xC0, 0x38, 0x38, 0x03, 0xC0, 0xEF, 0x03, 0x80, 0xC0,
  0x0F, 0x9E, 0x38, 0x7C, 0x07, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x38, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x38, 0x07, 0xFC, 0x01, 0xE0, 0x01, 0xF8, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x01, 0xC0, 0x01, 0xF8, 0x07, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3E, 0x07, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x1F, 0xF0,
  0x01, 0xE0, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x70, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0xFF, 0xF8,
  0x70, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x03, 0x80,
  0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x70, 0xF8, 0x00,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x3F,
  0x80, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x00,
  0xFE, 0x3C, 0x00, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x01, 0xF8, 0x1E, 0x00,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0xF0, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x80, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x07, 0xBC, 0x00,
  0x00, 0x39, 0xC0, 0x39, 0xE0, 0x00, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0xF0, 0x0E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x00, 0x0E,
  0x3C, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x00, 0x07, 0x0E,
  0x01, 0xC3, 0xC0, 0x00, 0x78, 0x70, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80,
  0x70, 0x70, 0x00, 0x3C, 0x3C, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xE0, 0x3C,
  0x1E, 0x00, 0x1E, 0x0E, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x70, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x70, 0x1C, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xE0,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x03,
  0xC0, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x0E, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x80,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x38, 0x01, 0xE0, 0x1C,
  0x00, 0x73, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0x9C, 0x00, 0x78, 0x0F, 0x00,
  0x1D, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xEE, 0x00, 0x1C, 0x03, 0xC0, 0x07,
  0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1C, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0x78,
  0x07, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0x00, 0x1E, 0x01, 0xDE, 0x00,
  0x00, 0xE0, 0x1E, 0x70, 0x00, 0x07, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0x07,
  0x9E, 0x00, 0x03, 0xC0, 0x3C, 0x70, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x00,
  0xF0, 0x0E, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x07, 0x83,
  0xC0, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x70, 0x00, 0xF0,
  0x0E, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0x0E, 0x07, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x01, 0xC1, 0xC0,
  0x1C, 0x00, 0x0F, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x01,
  0xC7, 0x80, 0x78, 0x00, 0x0F, 0x3C, 0x03, 0xC0, 0x00, 0x79, 0xE0, 0x1C,
  0x00, 0x01, 0xCE, 0x01, 0xE0, 0x00, 0x0F, 0x70, 0x0F, 0x00, 0x00, 0x7F,
  0x80, 0x78, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x1C, 0x00,
  0x00, 0x3F, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xF0, 0x0F, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0xF8, 0x01, 0xE0,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xC0, 0x00, 0x3D, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1F,
  0x80, 0x00, 0xF3, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x1E, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xBC, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xC7, 0x00, 0x0F,
  0x0F, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF1, 0xC0, 0x07, 0x83,
  0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xC0, 0xF0,
  0x03, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x78, 0x07, 0x00, 0xF0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0xF0, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x1C, 0x1E, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x0F,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0xCF,
  0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xF3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0x00,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7,
  0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x07,
  0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x78, 0x70, 0x07,
  0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x3C, 0x1F,
  0x80, 0x0F, 0x0F, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC1, 0xE0,
  0x07, 0xF0, 0x7C, 0x07, 0xFC, 0x0F, 0xFF, 0xEF, 0x01, 0xFF, 0xF3, 0xC0,
  0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x3F,
  0xF0, 0x03, 0xDF, 0xFF, 0x00, 0x77, 0xFF, 0xF0, 0x0F, 0xE0, 0x3E, 0x03,
  0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0x81, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87,
  0xE0, 0x01, 0xE0, 0xFE, 0x00, 0x7C, 0x1C, 0xE0, 0x1F, 0x03, 0x9F, 0xFF,
  0xC0, 0x71, 0xFF, 0xF0, 0x1E, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3E, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x8E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x7C, 0x07, 0x00, 0x1F, 0xF8, 0x38, 0x01, 0xFF, 0xE3, 0xC0, 0x3F, 0xFF,
  0x9E, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x00, 0x37, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0xE0, 0x07, 0xFF,
  0xEF, 0x00, 0x1F, 0xFE, 0x70, 0x00, 0x7F, 0xE3, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x40, 0x78, 0x00, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC1,
  0xC0, 0x0F, 0xFF, 0x0E, 0x01, 0xFF, 0xFC, 0xF0, 0x0F, 0x80, 0xF7, 0x80,
  0xF8, 0x01, 0xB8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xF3, 0x80,
  0x03, 0xFF, 0x1C, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x08, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x1F, 0xF8, 0x03, 0xCF, 0xFF, 0x00, 0xE7,
  0xFF, 0xC0, 0x3B, 0xC0, 0xF8, 0x1F, 0xC0, 0x1E, 0x07, 0xE0, 0x03, 0xC1,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x6F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x03, 0x80, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x7C,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0xE7, 0xC0, 0x00, 0x0E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFD, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x70,
  0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0x9F, 0xFF, 0x07, 0xFF, 0xC0, 0x3B, 0xFF, 0xF0,
  0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0x9F, 0x03, 0xE0, 0x7F, 0x00, 0x79, 0xC0,
  0x1E, 0x07, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE1, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0xF1, 0xFF, 0x80, 0x3C, 0xFF, 0xF0, 0x0E, 0x7F, 0xFC, 0x03,
  0xBC, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x1F, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0xF8, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0x8F, 0xFC, 0x00, 0x39, 0xFF, 0xF0, 0x01, 0xDF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x1E,
  0x03, 0xF0, 0x01, 0xF0, 0x1D, 0xE0, 0x1F, 0x00, 0xE7, 0xFF, 0xF0, 0x0F,
  0x1F, 0xFF, 0x00, 0x78, 0x7F, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0,
  0x70, 0x1F, 0xFE, 0x1C, 0x1F, 0xFF, 0xCF, 0x07, 0xC0, 0x7B, 0xC3, 0xE0,
  0x06, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x07, 0xE0, 0x7C, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0x00,
  0x3F, 0xF1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0xFF, 0x03, 0xDF, 0xE0, 0x3B, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80,
  0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x07, 0x80, 0x1F, 0x81, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0x70,
  0x07, 0xFF, 0x9C, 0x00, 0xFF, 0xC7, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x70, 0x78, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01,
  0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x3D, 0xE0, 0x03, 0xE0,
  0x01, 0xEF, 0x00, 0x1F, 0x00, 0x0E, 0x78, 0x00, 0xF8, 0x00, 0xF3, 0xC0,
  0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x7F, 0x00, 0x38, 0xF0, 0x07, 0xF8, 0x03,
  0xC7, 0x80, 0x39, 0xC0, 0x1C, 0x1C, 0x03, 0xCE, 0x01, 0xE0, 0xE0, 0x1C,
  0x70, 0x0F, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x38, 0x0E, 0x1C, 0x07, 0x81,
  0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x07, 0x87, 0x03, 0xC0, 0x70, 0x38, 0x38,
  0x1C, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x1C, 0x1C, 0x0F, 0x0F, 0x00, 0xE0,
  0xE0, 0x78, 0x70, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x0E, 0x38,
  0x01, 0xE7, 0x80, 0x71, 0xC0, 0x0F, 0x38, 0x03, 0x9E, 0x00, 0x7B, 0xC0,
  0x1C, 0xE0, 0x03, 0xDC, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x07, 0x70, 0x00,
  0x7E, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x05, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x71,
  0xFF, 0xC0, 0x01, 0xCF, 0xFF, 0x80, 0x07, 0x3C, 0x1F, 0x00, 0x3D, 0xE0,
  0x3E, 0x00, 0xE7, 0x00, 0x7C, 0x07, 0xBC, 0x00, 0xF8, 0x3C, 0xE0, 0x01,
  0xFF, 0xF3, 0x80, 0x03, 0xFF, 0x8E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xC0,
};

const GFXglyph RobotoCondensed_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 48, 14, 2, -47 },
  { 67, 13, 15, 18, 7, -50 },
  { 92, 33, 47, 33, 2, -47 },
  { 286, 27, 62, 31, 3, -55 },
  { 496, 30, 49, 41, 6, -48 },
  { 680, 29, 49, 34, 2, -48 },
  { 858, 6, 14, 11, 6, -50 },
  { 869, 19, 68, 19, 3, -53 },
  { 1031, 18, 68, 19, -3, -53 },
  { 1184, 25, 26, 27, 4, -47 },
  { 1266, 27, 35, 32, 3, -39 },
  { 1385, 9, 15, 12, -3, -6 },
  { 1402, 13, 3, 17, 2, -22 },
  { 1407, 5, 6, 15, 2, -5 },
  { 1411, 28, 51, 23, -3, -47 },
  { 1590, 26, 49, 31, 3, -48 },
  { 1750, 16, 47, 31, 8, -47 },
  { 1844, 28, 48, 31, 1, -48 },
  { 2012, 27, 49, 31, 2, -48 },
  { 2178, 28, 47, 31, 1, -47 },
  { 2343, 28, 48, 31, 4, -47 },
  { 2511, 24, 48, 31, 3, -47 },
  { 2655, 27, 47, 31, 5, -47 },
  { 2814, 28, 49, 31, 2, -48 },
  { 2986, 24, 48, 31, 5, -48 },
  { 3130, 11, 36, 13, 1, -35 },
  { 3180, 14, 44, 12, -3, -35 },
  { 3257, 24, 28, 29, 3, -35 },
  { 3341, 25, 18, 31, 3, -31 },
  { 3398, 25, 28, 29, 2, -35 },
  { 3486, 20, 49, 26, 6, -48 },
  { 3609, 45, 61, 50, 2, -46 },
  { 3953, 32, 47, 35, -2, -47 },
  { 4141, 30, 47, 34, 2, -47 },
  { 4318, 31, 49, 36, 4, -48 },
  { 4508, 32, 47, 36, 2, -47 },
  { 4696, 32, 47, 32, 2, -47 },
  { 4884, 32, 47, 31, 2, -47 },
  { 5072, 32, 49, 38, 4, -48 },
  { 5268, 37, 47, 39, 2, -47 },
  { 5486, 11, 47, 16, 3, -47 },
  { 5551, 30, 48, 31, 1, -47 },
  { 5731, 36, 47, 35, 2, -47 },
  { 5943, 23, 47, 30, 2, -47 },
  { 6079, 45, 47, 48, 2, -47 },
  { 6344, 37, 47, 39, 2, -47 },
  { 6562, 32, 49, 38, 4, -48 },
  { 6758, 32, 47, 35, 2, -47 },
  { 6946, 32, 56, 38, 3, -48 },
  { 7170, 32, 47, 35, 2, -47 },
  { 7358, 31, 49, 33, 2, -48 },
  { 7548, 30, 47, 33, 6, -47 },
  { 7725, 34, 48, 37, 3, -47 },
  { 7929, 32, 47, 35, 6, -47 },
  { 8117, 45, 47, 49, 7, -47 },
  { 8382, 37, 47, 34, -1, -47 },
  { 8600, 31, 47, 33, 6, -47 },
  { 8783, 34, 47, 33, 0, -47 },
  { 8983, 19, 64, 14, 0, -54 },
  { 9135, 10, 51, 23, 7, -47 },
  { 9199, 19, 64, 14, -4, -54 },
  { 9351, 19, 23, 24, 3, -47 },
  { 9406, 24, 3, 25, -3, 0 },
  { 9415, 9, 9, 18, 8, -49 },
  { 9426, 26, 37, 30, 1, -36 },
  { 9547, 27, 51, 31, 1, -50 },
  { 9720, 25, 37, 29, 2, -36 },
  { 9836, 29, 51, 31, 3, -50 },
  { 10021, 25, 37, 29, 2, -36 },
  { 10137, 20, 51, 19, 4, -51 },
  { 10265, 29, 49, 31, 0, -36 },
  { 10443, 26, 50, 31, 1, -50 },
  { 10606, 12, 47, 14, 2, -47 },
  { 10677, 22, 60, 14, -8, -47 },
  { 10842, 28, 50, 28, 1, -50 },
  { 11017, 12, 50, 14, 2, -50 },
  { 11092, 44, 36, 49, 1, -36 },
  { 11290, 26, 36, 31, 1, -36 },
  { 11407, 26, 37, 31, 2, -36 },
  { 11528, 29, 49, 31, -1, -36 },
  { 11706, 26, 49, 31, 3, -36 },
  { 11866, 20, 36, 19, 1, -36 },
  { 11956, 25, 37, 29, 1, -36 },
  { 12072, 15, 45, 19, 3, -44 },
  { 12157, 26, 36, 31, 3, -35 },
  { 12274, 24, 35, 27, 4, -35 },
  { 12379, 37, 35, 42, 5, -35 },
  { 12541, 29, 35, 28, -1, -35 },
  { 12668, 31, 48, 27, -3, -35 },
  { 12854, 27, 35, 28, 0, -35 },
  { 12973, 21, 65, 19, 2, -52 },
  { 13144, 12, 56, 14, 1, -47 },
  { 13228, 21, 64, 19, -4, -51 },
  { 13396, 30, 12, 38, 4, -26 },
};

const GFXfont RobotoCondensed_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC66PT7B_H_
