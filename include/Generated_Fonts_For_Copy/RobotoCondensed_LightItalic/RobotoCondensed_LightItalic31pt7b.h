#ifndef _ROBOTOCONDENSED_LIGHTITALIC31PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x88, 0x42, 0x31, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x65, 0x94, 0xD3, 0x4B, 0x2C, 0x80, 0x00, 0x86, 0x01,
  0x08, 0x06, 0x30, 0x08, 0x60, 0x10, 0x80, 0x63, 0x00, 0x86, 0x1F, 0xFF,
  0x06, 0x30, 0x08, 0x60, 0x10, 0x80, 0x63, 0x00, 0x86, 0x01, 0x08, 0x3F,
  0xFE, 0x0C, 0x60, 0x10, 0x80, 0x61, 0x00, 0xC6, 0x01, 0x08, 0x06, 0x10,
  0x0C, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x07, 0x80, 0xFF, 0x06,
  0x18, 0x60, 0x62, 0x03, 0x10, 0x19, 0x80, 0xC4, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x30, 0x09, 0x80, 0x4C,
  0x06, 0x20, 0x31, 0x83, 0x07, 0xF0, 0x1F, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x3C, 0x01, 0x98, 0x04, 0x20, 0x30, 0x82, 0x82, 0x12, 0x08, 0xC8,
  0x26, 0x31, 0x90, 0x4C, 0xC1, 0xE6, 0x00, 0x10, 0x00, 0x80, 0x06, 0x78,
  0x33, 0x20, 0x98, 0xC6, 0x41, 0x31, 0x04, 0x84, 0x14, 0x10, 0xD0, 0x42,
  0x01, 0x98, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0xC2, 0x02, 0x0C, 0x18,
  0x30, 0x60, 0x81, 0x86, 0x02, 0x30, 0x0D, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x80, 0x33, 0x0D, 0x86, 0x24, 0x18, 0xB0, 0x36, 0xC0, 0xD3, 0x01, 0xCC,
  0x06, 0x18, 0x3C, 0x7F, 0xB0, 0x7C, 0x60, 0x69, 0x6D, 0xA0, 0x01, 0x03,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x81, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x61,
  0xE6, 0x77, 0xFE, 0x0E, 0x01, 0xE0, 0x1B, 0x03, 0x30, 0x61, 0x84, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F,
  0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x33, 0x36, 0x6C, 0x80, 0xFF, 0xF0, 0x7C, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0x07, 0x81, 0xFE, 0x18, 0x63, 0x02, 0x20, 0x36, 0x03, 0x60, 0x34, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x68, 0x06, 0x80, 0x68, 0x04,
  0x80, 0xC8, 0x0C, 0xC1, 0x8C, 0x18, 0x7F, 0x03, 0xC0, 0x02, 0x3D, 0xFF,
  0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x04, 0x00, 0x03, 0xC0, 0x7F, 0x06, 0x0C, 0x20, 0x23,
  0x01, 0x98, 0x0C, 0x80, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xC0, 0x7F, 0x06, 0x0C, 0x20, 0x23,
  0x01, 0x98, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x01, 0xF0, 0x0F,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0xC0, 0x26, 0x03, 0x30, 0x18,
  0xC1, 0x87, 0xF8, 0x0F, 0x80, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x1B, 0x00, 0x90, 0x0C, 0x80, 0xCC, 0x0C, 0x60, 0x43, 0x06, 0x18, 0x60,
  0x86, 0x04, 0x20, 0x63, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x2F, 0x81, 0xFE, 0x1C, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x80, 0x66, 0x02, 0x30, 0x30,
  0x83, 0x07, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0xFC, 0x38, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x4F, 0x8B, 0xFB, 0xC3, 0x70, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x58, 0x1B, 0x03, 0x30, 0xC7, 0xF0, 0x7C, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x00,
  0x03, 0xE0, 0x7F, 0x87, 0x0C, 0x30, 0x31, 0x01, 0x98, 0x0C, 0xC0, 0x66,
  0x06, 0x18, 0x30, 0x7F, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x20, 0x13, 0x00,
  0x98, 0x06, 0xC0, 0x26, 0x03, 0x30, 0x18, 0xC1, 0x87, 0xF8, 0x0F, 0x80,
  0x0F, 0x81, 0xFC, 0x30, 0x63, 0x06, 0x60, 0x26, 0x02, 0x40, 0x3C, 0x03,
  0xC0, 0x2C, 0x02, 0xC0, 0x64, 0x06, 0x60, 0xE3, 0xF6, 0x1E, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x7C, 0x07, 0x00, 0x08, 0x61, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x31, 0x86,
  0x30, 0x80, 0x00, 0x10, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x04, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x20, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x0E, 0x00, 0x80, 0x00, 0x1E, 0x3F, 0x98, 0x78, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x03, 0x03, 0x83, 0x81, 0x81, 0x80, 0x80, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x9E, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00, 0x08, 0x60, 0x00,
  0x62, 0x07, 0x81, 0x30, 0x77, 0x09, 0x06, 0x18, 0x48, 0x60, 0x82, 0xC3,
  0x04, 0x14, 0x10, 0x60, 0xA1, 0x83, 0x0F, 0x0C, 0x10, 0x78, 0x40, 0x82,
  0xC2, 0x0C, 0x16, 0x10, 0x61, 0xA0, 0x87, 0x09, 0x04, 0x38, 0xCC, 0x3E,
  0xEC, 0x60, 0xE3, 0xC3, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x22,
  0x00, 0xC4, 0x01, 0x08, 0x06, 0x18, 0x08, 0x30, 0x30, 0x60, 0x40, 0xC1,
  0x81, 0x83, 0xFF, 0x0F, 0xFE, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00,
  0x36, 0x00, 0x78, 0x00, 0x40, 0x0F, 0xF0, 0x7F, 0xE1, 0x80, 0xC6, 0x03,
  0x18, 0x0C, 0x60, 0x31, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xFF, 0xC3, 0xFE,
  0x0C, 0x0C, 0x20, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x00,
  0x64, 0x03, 0x30, 0x18, 0xFF, 0xE3, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xE1,
  0xC1, 0xC6, 0x03, 0x30, 0x0C, 0x80, 0x16, 0x00, 0x58, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x06,
  0xC0, 0x1B, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x3F, 0xC0, 0x7C, 0x00, 0x0F,
  0xE0, 0x1F, 0xF0, 0x60, 0x70, 0xC0, 0x61, 0x80, 0x63, 0x00, 0xC4, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x22, 0x00, 0x4C,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x18, 0x80, 0x31, 0x00, 0xC6, 0x03,
  0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xE0,
  0xFF, 0xC1, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xC1, 0xFF, 0x82, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x30, 0xC0,
  0x63, 0x00, 0x44, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x0F, 0xEC, 0x1F, 0xD8, 0x01, 0x30, 0x02, 0x60, 0x0C, 0xC0,
  0x19, 0x80, 0x31, 0x00, 0x63, 0x03, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x08,
  0x01, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x08,
  0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x1F, 0xFF, 0x8F, 0xFF, 0x86, 0x00,
  0xC2, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x20,
  0x06, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x40, 0x0C, 0x30,
  0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x86,
  0x10, 0x43, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x40, 0x21, 0x01, 0x86, 0x06,
  0x18, 0x30, 0x3F, 0x80, 0x7C, 0x00, 0x08, 0x03, 0x04, 0x03, 0x06, 0x03,
  0x03, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x43, 0x80, 0x63, 0x80, 0x33,
  0x80, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x98, 0x03, 0x8C, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x20, 0x30, 0x10, 0x0C, 0x18, 0x06,
  0x0C, 0x01, 0x86, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x18, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0xF1, 0xE0,
  0x05, 0x0B, 0x00, 0x68, 0x58, 0x02, 0xC6, 0x40, 0x36, 0x32, 0x01, 0x31,
  0x98, 0x19, 0x8C, 0xC0, 0x88, 0x46, 0x0C, 0xC2, 0x30, 0x46, 0x30, 0x86,
  0x31, 0x84, 0x21, 0x8C, 0x23, 0x0C, 0x61, 0x90, 0x42, 0x0D, 0x86, 0x10,
  0x78, 0x31, 0x81, 0xC1, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x40, 0x0C, 0x01,
  0x8E, 0x00, 0xC7, 0x00, 0x63, 0xC0, 0x31, 0xE0, 0x10, 0xD0, 0x08, 0x4C,
  0x0C, 0x62, 0x06, 0x31, 0x83, 0x18, 0xC1, 0x8C, 0x20, 0x86, 0x18, 0x42,
  0x0C, 0x63, 0x02, 0x31, 0x81, 0x98, 0xC0, 0xCC, 0x60, 0x24, 0x20, 0x1A,
  0x10, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xC6, 0x00, 0x60, 0x03, 0xE0, 0x1F,
  0xF0, 0x70, 0x70, 0xC0, 0x63, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x40, 0x06, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0xC3, 0x03, 0x03, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x60, 0x30, 0xC0, 0x31, 0x80,
  0x63, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x61,
  0xFF, 0xC3, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0xF0, 0x70, 0x71, 0x80, 0x63, 0x00, 0x4C, 0x00, 0x98, 0x01, 0xB0, 0x03,
  0x40, 0x05, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0,
  0x02, 0x40, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00, 0xC3, 0x03, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x0F, 0xF0,
  0x3F, 0xF0, 0x60, 0x30, 0xC0, 0x21, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x98,
  0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0xFF, 0x83, 0xFC, 0x0C, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x80, 0x41, 0x00, 0xC6, 0x01, 0x8C,
  0x03, 0x18, 0x03, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x60, 0xC0, 0x63,
  0x00, 0xC6, 0x00, 0x8C, 0x01, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x23, 0x00, 0xC3, 0x03, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x32, 0x00, 0x44, 0x00,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x26, 0x00, 0x4C,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x63, 0x00,
  0xC7, 0x03, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0xC0, 0x05, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0xCC, 0x01, 0x88, 0x06, 0x10, 0x0C, 0x30, 0x30, 0x60, 0x60,
  0xC1, 0x81, 0x83, 0x03, 0x04, 0x02, 0x18, 0x04, 0x20, 0x08, 0xC0, 0x19,
  0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x05, 0x80, 0xE0, 0x6C,
  0x0F, 0x03, 0x60, 0x58, 0x13, 0x06, 0x41, 0x98, 0x32, 0x0C, 0x41, 0x10,
  0x42, 0x18, 0x86, 0x10, 0x84, 0x30, 0x8C, 0x23, 0x04, 0x61, 0x18, 0x22,
  0x0C, 0x81, 0x30, 0x6C, 0x09, 0x03, 0x60, 0x58, 0x1A, 0x02, 0xC0, 0xF0,
  0x14, 0x07, 0x80, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x0C,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x08, 0x0C, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x19, 0xC0, 0x06, 0x60, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xE8, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C,
  0x18, 0x03, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x01,
  0x80, 0xC0, 0x0F, 0x00, 0x64, 0x01, 0x98, 0x0C, 0x60, 0x31, 0x81, 0x83,
  0x0C, 0x0C, 0x30, 0x31, 0x80, 0x4C, 0x01, 0xB0, 0x07, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0x07, 0x83, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0F, 0x87, 0x80, 0xC6, 0x10,
  0x84, 0x21, 0x8C, 0x63, 0x08, 0x42, 0x18, 0xC6, 0x30, 0x84, 0x21, 0x8C,
  0x63, 0x07, 0x83, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x0F, 0x87, 0x80, 0x02,
  0x03, 0x81, 0xC1, 0xA0, 0x90, 0xC8, 0x44, 0x63, 0x21, 0xB0, 0xD0, 0x20,
  0x7F, 0xFF, 0xFE, 0xC6, 0x63, 0x07, 0x83, 0xFC, 0xC1, 0x90, 0x16, 0x02,
  0x00, 0x40, 0x18, 0x7F, 0x3C, 0x6C, 0x0F, 0x01, 0x60, 0x28, 0x0D, 0x01,
  0xB0, 0x77, 0xF6, 0x7C, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x33, 0xC3, 0xFE, 0x38, 0x33, 0x03, 0x20, 0x32, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x36, 0x03, 0x40, 0x34, 0x02, 0xC0, 0x6C, 0x06, 0xE0,
  0xCB, 0xF8, 0x8F, 0x00, 0x07, 0x81, 0xFE, 0x30, 0x62, 0x02, 0x60, 0x36,
  0x03, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C,
  0x0C, 0x60, 0xC7, 0xF8, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0xF9, 0x87, 0xF6, 0x30, 0x50, 0xC0, 0xC6,
  0x03, 0x18, 0x0C, 0x40, 0x31, 0x00, 0xCC, 0x02, 0x30, 0x08, 0xC0, 0x63,
  0x01, 0x8C, 0x06, 0x30, 0x18, 0x60, 0xC1, 0xFD, 0x03, 0xEC, 0x00, 0x07,
  0x81, 0xFC, 0x30, 0x62, 0x02, 0x60, 0x36, 0x03, 0x40, 0x3F, 0xFF, 0xFF,
  0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0xC7, 0xF8, 0x1F,
  0x00, 0x07, 0x87, 0xC3, 0x03, 0x01, 0x80, 0x83, 0xF9, 0xFC, 0x30, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0x82, 0x86, 0x06, 0x30, 0x18,
  0xC0, 0x62, 0x01, 0x88, 0x04, 0x60, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x80, 0x83, 0x06, 0x0F, 0xF8, 0x1F, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0xC0, 0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x33, 0xC3, 0x7E, 0x38, 0x63, 0x03, 0x30,
  0x32, 0x03, 0x60, 0x36, 0x02, 0x60, 0x66, 0x06, 0x40, 0x64, 0x06, 0xC0,
  0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0x80, 0xC0, 0x00, 0xC6, 0x00, 0x00, 0x02,
  0x31, 0x8C, 0x62, 0x11, 0x8C, 0x63, 0x10, 0x8C, 0x63, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x78, 0x3C, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0xC6,
  0x0C, 0x30, 0xC1, 0x8C, 0x08, 0xC0, 0x4C, 0x06, 0xC0, 0x3E, 0x01, 0xF0,
  0x0C, 0xC0, 0x46, 0x02, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0x42,
  0x03, 0x00, 0x08, 0x46, 0x31, 0x8C, 0x46, 0x31, 0x8C, 0x42, 0x31, 0x8C,
  0x62, 0x11, 0x8C, 0x63, 0x00, 0x33, 0xC3, 0xC3, 0xFE, 0x7E, 0x38, 0x6C,
  0x33, 0x03, 0x83, 0x20, 0x30, 0x36, 0x03, 0x03, 0x60, 0x20, 0x36, 0x02,
  0x03, 0x60, 0x60, 0x34, 0x06, 0x03, 0x40, 0x60, 0x2C, 0x06, 0x06, 0xC0,
  0x40, 0x6C, 0x04, 0x06, 0xC0, 0xC0, 0x68, 0x0C, 0x06, 0x80, 0xC0, 0x40,
  0x33, 0xC3, 0x7E, 0x38, 0x63, 0x03, 0x30, 0x36, 0x03, 0x60, 0x36, 0x02,
  0x60, 0x66, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x0C,
  0x80, 0xC0, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x03, 0x60, 0x36, 0x01, 0x40,
  0x14, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x64, 0x06, 0x60,
  0xC3, 0xF8, 0x1F, 0x00, 0x0C, 0xF0, 0x3F, 0xE0, 0xE0, 0xC3, 0x03, 0x08,
  0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x00, 0xCC,
  0x02, 0x30, 0x18, 0xC0, 0x63, 0x83, 0x0B, 0xF8, 0x23, 0xC1, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x98, 0xFE,
  0xCC, 0x1C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x00, 0xC8, 0x04, 0xC0, 0x26,
  0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x21, 0x83, 0x0F, 0xF8, 0x3E,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x37,
  0x9F, 0xCE, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x00, 0x0F, 0x83, 0xF8, 0xC1, 0x90,
  0x32, 0x02, 0x40, 0x0C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x68,
  0x0D, 0x81, 0xB0, 0x63, 0xFC, 0x3E, 0x00, 0x18, 0x20, 0x41, 0x8F, 0xFF,
  0x8C, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x07,
  0x87, 0x00, 0x60, 0x36, 0x02, 0x60, 0x66, 0x06, 0x40, 0x6C, 0x06, 0xC0,
  0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0x80, 0xC8, 0x0C, 0x80, 0xC8, 0x18, 0xC3,
  0x8F, 0xF8, 0x7D, 0x80, 0xC0, 0x78, 0x0F, 0x03, 0x60, 0x64, 0x18, 0x83,
  0x10, 0x43, 0x18, 0x62, 0x0C, 0xC1, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0E,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0xF0, 0x30, 0x6C, 0x1C, 0x19, 0x07,
  0x04, 0x43, 0x43, 0x10, 0xD0, 0xC4, 0x24, 0x21, 0x19, 0x18, 0x44, 0x44,
  0x13, 0x13, 0x04, 0x86, 0xC1, 0xA1, 0xA0, 0x78, 0x78, 0x1C, 0x1C, 0x07,
  0x07, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x18, 0x0C, 0x30, 0x60, 0xC3,
  0x01, 0x0C, 0x06, 0x60, 0x1B, 0x00, 0x2C, 0x00, 0xE0, 0x03, 0x00, 0x0E,
  0x00, 0x78, 0x03, 0x20, 0x18, 0xC0, 0x63, 0x03, 0x06, 0x18, 0x18, 0x60,
  0x20, 0x18, 0x0C, 0x60, 0x31, 0x81, 0x86, 0x06, 0x08, 0x30, 0x20, 0xC0,
  0x86, 0x03, 0x18, 0x0C, 0x40, 0x33, 0x00, 0xC8, 0x03, 0x60, 0x05, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x80,
  0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x0C, 0x0E, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x08, 0xC6, 0x31, 0x08, 0x46, 0x31, 0x8C, 0x42, 0x31, 0x8C, 0x62, 0x10,
  0x8C, 0x63, 0x10, 0x84, 0x00, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x1C,
  0x07, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x00, 0x3C, 0x05, 0xF8, 0x34, 0x70,
  0xF0, 0xC2, 0x81, 0xFA, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 6, 1, -22 },
  { 15, 6, 7, 9, 3, -23 },
  { 21, 15, 22, 15, 1, -22 },
  { 63, 13, 28, 15, 1, -25 },
  { 109, 14, 22, 19, 3, -22 },
  { 148, 14, 22, 16, 1, -22 },
  { 187, 3, 7, 5, 3, -23 },
  { 190, 8, 32, 9, 2, -25 },
  { 222, 9, 32, 9, -2, -25 },
  { 258, 12, 12, 13, 2, -22 },
  { 276, 13, 16, 15, 1, -18 },
  { 302, 4, 7, 6, -1, -3 },
  { 306, 6, 2, 8, 1, -11 },
  { 308, 2, 3, 7, 1, -3 },
  { 309, 13, 24, 11, -1, -22 },
  { 348, 12, 22, 15, 2, -22 },
  { 381, 7, 22, 15, 4, -22 },
  { 401, 13, 22, 15, 1, -22 },
  { 437, 13, 22, 15, 1, -22 },
  { 473, 13, 22, 15, 1, -22 },
  { 509, 13, 22, 15, 2, -22 },
  { 545, 11, 22, 15, 2, -22 },
  { 576, 13, 22, 15, 2, -22 },
  { 612, 13, 22, 15, 1, -22 },
  { 648, 12, 22, 15, 2, -22 },
  { 681, 6, 17, 6, 0, -17 },
  { 694, 6, 21, 6, -1, -17 },
  { 710, 12, 12, 13, 1, -16 },
  { 728, 11, 9, 15, 2, -15 },
  { 741, 12, 13, 14, 1, -16 },
  { 761, 9, 22, 12, 3, -22 },
  { 786, 21, 29, 24, 1, -22 },
  { 863, 15, 22, 17, -1, -22 },
  { 905, 14, 22, 16, 1, -22 },
  { 944, 14, 22, 17, 2, -22 },
  { 983, 15, 22, 17, 1, -22 },
  { 1025, 15, 22, 15, 1, -22 },
  { 1067, 15, 22, 15, 1, -22 },
  { 1109, 15, 22, 18, 2, -22 },
  { 1151, 17, 22, 18, 1, -22 },
  { 1198, 6, 22, 7, 1, -22 },
  { 1215, 14, 22, 15, 0, -22 },
  { 1254, 17, 22, 17, 1, -22 },
  { 1301, 11, 22, 14, 1, -22 },
  { 1332, 21, 22, 22, 1, -22 },
  { 1390, 17, 22, 19, 1, -22 },
  { 1437, 15, 22, 18, 2, -22 },
  { 1479, 15, 22, 16, 1, -22 },
  { 1521, 15, 26, 18, 2, -22 },
  { 1570, 15, 22, 17, 1, -22 },
  { 1612, 15, 22, 16, 1, -22 },
  { 1654, 14, 22, 16, 3, -22 },
  { 1693, 15, 22, 17, 2, -22 },
  { 1735, 15, 22, 16, 3, -22 },
  { 1777, 21, 22, 23, 3, -22 },
  { 1835, 18, 22, 16, -1, -22 },
  { 1885, 14, 22, 16, 3, -22 },
  { 1924, 16, 22, 16, 0, -22 },
  { 1968, 9, 30, 7, 0, -25 },
  { 2002, 5, 24, 11, 3, -22 },
  { 2017, 9, 30, 7, -2, -25 },
  { 2051, 9, 11, 11, 1, -22 },
  { 2064, 12, 2, 12, -2, 0 },
  { 2067, 4, 4, 9, 4, -23 },
  { 2069, 11, 17, 14, 1, -17 },
  { 2093, 12, 23, 15, 1, -23 },
  { 2128, 12, 17, 14, 1, -17 },
  { 2154, 14, 23, 15, 1, -23 },
  { 2195, 12, 17, 14, 1, -17 },
  { 2221, 9, 23, 9, 2, -23 },
  { 2247, 14, 23, 15, 0, -17 },
  { 2288, 12, 23, 14, 1, -23 },
  { 2323, 5, 24, 6, 1, -24 },
  { 2338, 10, 30, 6, -4, -24 },
  { 2376, 13, 23, 13, 1, -23 },
  { 2414, 5, 23, 6, 1, -23 },
  { 2429, 20, 17, 23, 1, -17 },
  { 2472, 12, 17, 14, 1, -17 },
  { 2498, 12, 17, 15, 1, -17 },
  { 2524, 14, 23, 15, -1, -17 },
  { 2565, 13, 23, 15, 1, -17 },
  { 2603, 9, 17, 9, 1, -17 },
  { 2623, 11, 17, 13, 1, -17 },
  { 2647, 7, 21, 9, 2, -21 },
  { 2666, 12, 17, 14, 2, -17 },
  { 2692, 11, 17, 13, 2, -17 },
  { 2716, 18, 17, 20, 2, -17 },
  { 2755, 14, 17, 13, -1, -17 },
  { 2785, 14, 23, 13, -1, -17 },
  { 2826, 13, 17, 13, 0, -17 },
  { 2854, 10, 30, 9, 1, -24 },
  { 2892, 5, 26, 7, 1, -22 },
  { 2909, 10, 30, 9, -2, -24 },
  { 2947, 14, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC31PT7B_H_
