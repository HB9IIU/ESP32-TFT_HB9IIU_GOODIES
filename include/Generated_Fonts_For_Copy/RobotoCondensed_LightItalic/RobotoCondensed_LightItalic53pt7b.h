#ifndef _ROBOTOCONDENSED_LIGHTITALIC53PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0xC0, 0xF0, 0x1C,
  0x00, 0x00, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x63, 0x0C, 0x63, 0x9C, 0x73,
  0x8E, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xF1, 0xF0,
  0x0F, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x18, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00,
  0xF0, 0x38, 0x07, 0x80, 0xF8, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x04, 0x60,
  0x30, 0x0E, 0xE0, 0x30, 0x1C, 0xE0, 0x30, 0x18, 0xE0, 0x30, 0x38, 0xC0,
  0x30, 0x70, 0xC0, 0x30, 0x60, 0xC0, 0x30, 0xC0, 0xE0, 0x71, 0xC0, 0x60,
  0x61, 0x80, 0x70, 0xE3, 0x00, 0x3F, 0xC7, 0x00, 0x3F, 0x86, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0xFC, 0x00, 0xE3, 0xFE, 0x00, 0xC3, 0x86, 0x01, 0xC7, 0x07, 0x03,
  0x86, 0x03, 0x03, 0x0E, 0x03, 0x07, 0x0C, 0x03, 0x0E, 0x0C, 0x03, 0x0C,
  0x0C, 0x03, 0x1C, 0x0C, 0x03, 0x38, 0x0C, 0x07, 0x30, 0x0C, 0x07, 0x70,
  0x0C, 0x06, 0x20, 0x0E, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0x8F, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x03,
  0x80, 0x18, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0xC0,
  0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xE7, 0x00, 0x07, 0x8E, 0x01, 0x9E,
  0x0E, 0x07, 0x38, 0x1C, 0x0E, 0xE0, 0x1C, 0x19, 0xC0, 0x38, 0x77, 0x00,
  0x38, 0xEE, 0x00, 0x79, 0x9C, 0x00, 0x77, 0x38, 0x00, 0xFE, 0x70, 0x00,
  0xF8, 0xE0, 0x01, 0xE1, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0xC3, 0xC0, 0x3F,
  0x83, 0xC1, 0xF3, 0x83, 0xFF, 0xC7, 0x03, 0xFE, 0x07, 0x00, 0x40, 0x00,
  0x31, 0x8C, 0xE7, 0x39, 0x8C, 0x67, 0x39, 0x80, 0x00, 0x04, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x40,
  0x70, 0x17, 0x07, 0x0F, 0xFE, 0x73, 0xF3, 0xFF, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3B, 0x00, 0x07, 0x38, 0x00, 0xF1, 0xC0,
  0x1E, 0x1C, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x00, 0x04,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x8F, 0x1C, 0x78,
  0xE3, 0x82, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x77, 0xFE, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xC7, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC1,
  0x80, 0x0E, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x80, 0x03, 0x1C, 0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0x60, 0x00, 0xE3,
  0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x03,
  0xC0, 0xE0, 0x3C, 0x03, 0xC3, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0x6F, 0x8E, 0xE0,
  0xE8, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7C, 0x3E, 0x03, 0xC0,
  0x38, 0x0E, 0x00, 0xF0, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x80,
  0x70, 0x1C, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1E,
  0x01, 0xC0, 0x3E, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x30, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x38,
  0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x1F, 0x00, 0x0E, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3E,
  0x0F, 0x80, 0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x00,
  0xE0, 0x3C, 0x01, 0xF0, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x71, 0xF8,
  0x0E, 0xFF, 0xC1, 0xBF, 0xFC, 0x7F, 0x03, 0x8F, 0x80, 0x39, 0xE0, 0x07,
  0x38, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE0,
  0xE0, 0x3C, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x20, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x7C, 0x03, 0xC0, 0x78, 0x1E,
  0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x1C, 0x07, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x1C,
  0x0E, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1E, 0x01, 0xE0,
  0x3C, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xC7, 0xC1, 0xE0, 0x3C, 0x38,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xE7, 0x00,
  0x3C, 0xE0, 0x0F, 0x8E, 0x07, 0xF1, 0xFF, 0xEE, 0x1F, 0xF1, 0x80, 0xFC,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0,
  0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x3E, 0x3C,
  0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x70, 0x03, 0xE0, 0x06, 0x06, 0x00, 0xFF, 0x80, 0x60, 0xE0,
  0x1F, 0x7C, 0x07, 0x0C, 0x03, 0xC0, 0xC0, 0x71, 0xC0, 0x70, 0x0C, 0x03,
  0x18, 0x07, 0x00, 0xC0, 0x33, 0x80, 0xE0, 0x1C, 0x03, 0x38, 0x0C, 0x01,
  0xC0, 0x73, 0x01, 0xC0, 0x18, 0x07, 0x70, 0x1C, 0x01, 0x80, 0x77, 0x01,
  0x80, 0x38, 0x06, 0x60, 0x38, 0x03, 0x80, 0x66, 0x03, 0x80, 0x30, 0x06,
  0xE0, 0x38, 0x03, 0x00, 0x6E, 0x03, 0x00, 0x70, 0x06, 0xE0, 0x70, 0x07,
  0x00, 0xCC, 0x07, 0x00, 0x60, 0x0C, 0xC0, 0x70, 0x06, 0x00, 0xCC, 0x07,
  0x00, 0xE0, 0x1C, 0xC0, 0x70, 0x0E, 0x01, 0x8C, 0x07, 0x01, 0xE0, 0x38,
  0xC0, 0x70, 0x1E, 0x03, 0x0C, 0x07, 0x03, 0x60, 0x70, 0xC0, 0x38, 0xE7,
  0x0E, 0x0C, 0x03, 0xFC, 0x7F, 0xC0, 0xE0, 0x1F, 0x83, 0xF8, 0x0E, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x78, 0x00,
  0x06, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x7C, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x80, 0x70, 0x01, 0xE0,
  0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x01, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xE1, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x01, 0xFF, 0xC7, 0x00, 0x7F, 0xF1, 0xC0, 0x1F, 0xFC, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0x78,
  0x03, 0xE0, 0x1F, 0x87, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80,
  0x70, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x1E, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00,
  0xF0, 0x00, 0x60, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x1D, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x9C, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x3E,
  0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xF0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xEE, 0x06, 0x60, 0x00,
  0x0E, 0xE0, 0x66, 0x00, 0x01, 0xCC, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0xE7,
  0x00, 0x03, 0x9C, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0xE7, 0x00, 0x07, 0x1C,
  0x0C, 0x30, 0x00, 0x71, 0x81, 0xC3, 0x00, 0x0E, 0x38, 0x1C, 0x38, 0x00,
  0xE3, 0x81, 0xC3, 0x80, 0x1C, 0x38, 0x1C, 0x38, 0x01, 0xC3, 0x81, 0xC3,
  0x80, 0x38, 0x38, 0x1C, 0x18, 0x03, 0x83, 0x03, 0x81, 0x80, 0x70, 0x70,
  0x38, 0x1C, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0x38, 0x0C, 0x1C, 0x0E, 0x07, 0x00,
  0xC3, 0x80, 0xE0, 0x70, 0x0E, 0x38, 0x0E, 0x07, 0x00, 0xE7, 0x00, 0xE0,
  0x70, 0x0E, 0x70, 0x0E, 0x07, 0x00, 0xEE, 0x00, 0xE0, 0x70, 0x06, 0xE0,
  0x1C, 0x0E, 0x00, 0x7C, 0x01, 0xC0, 0xE0, 0x07, 0xC0, 0x1C, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x70, 0x7E, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x38, 0x1D, 0x80,
  0x01, 0xC0, 0xEE, 0x00, 0x0E, 0x07, 0x70, 0x00, 0x70, 0x39, 0x80, 0x03,
  0x83, 0x8E, 0x00, 0x38, 0x1C, 0x70, 0x01, 0xC0, 0xE1, 0xC0, 0x0E, 0x07,
  0x0E, 0x00, 0x70, 0x38, 0x70, 0x03, 0x83, 0x81, 0xC0, 0x1C, 0x1C, 0x0E,
  0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x30, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0xE0, 0x0E, 0x0E, 0x07,
  0x00, 0x38, 0x70, 0x38, 0x01, 0xC3, 0x81, 0xC0, 0x0E, 0x1C, 0x0E, 0x00,
  0x38, 0xE0, 0xE0, 0x01, 0xC7, 0x07, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x3B,
  0x81, 0xC0, 0x01, 0xDC, 0x0E, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x3F, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0E, 0x00, 0x7C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x01, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x1E, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xF1, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x78,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x1E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1F, 0x87,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0x87, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x77, 0x00, 0x03, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x00,
  0x1D, 0xC0, 0x01, 0xE0, 0x01, 0xCE, 0x00, 0x1F, 0x00, 0x0E, 0x30, 0x00,
  0xF8, 0x00, 0x71, 0x80, 0x06, 0xC0, 0x07, 0x0C, 0x00, 0x76, 0x00, 0x38,
  0x70, 0x03, 0xB0, 0x01, 0xC3, 0x80, 0x39, 0x80, 0x1C, 0x1C, 0x01, 0xCE,
  0x00, 0xE0, 0xE0, 0x0C, 0x70, 0x06, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x38,
  0x07, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0x01,
  0xC0, 0x70, 0x18, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x1C, 0x0E,
  0x06, 0x07, 0x00, 0xE0, 0x60, 0x30, 0x38, 0x07, 0x07, 0x01, 0x83, 0x80,
  0x38, 0x30, 0x0C, 0x1C, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x0E, 0x1C, 0x03,
  0x8E, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0xE3, 0x00, 0x0C,
  0x60, 0x07, 0x38, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x01, 0xCC,
  0x00, 0x19, 0x80, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x37, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC1, 0xC0, 0x01,
  0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x78, 0x00, 0xC0, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x18, 0x0C, 0x07, 0x03, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x7C,
  0x01, 0xB0, 0x0E, 0xC0, 0x3B, 0x01, 0xCC, 0x07, 0x38, 0x38, 0xE0, 0xE3,
  0x87, 0x06, 0x1C, 0x18, 0xE0, 0x63, 0x81, 0xDC, 0x07, 0x70, 0x1F, 0x80,
  0x7E, 0x00, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3C, 0x3E, 0x07, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x0E, 0x1E, 0x00,
  0xE3, 0x80, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0xC7, 0x00, 0xF8, 0x7C,
  0x7F, 0x83, 0xFF, 0xB8, 0x1F, 0xE1, 0x80, 0x20, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x73, 0xFC, 0x03, 0x3F, 0xF0, 0x3B, 0xC7,
  0xC1, 0xF0, 0x0E, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18,
  0x00, 0x71, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x07, 0x1E, 0x00, 0x38, 0xF0, 0x03, 0x86, 0xC0, 0x3C, 0x73, 0x87,
  0xC3, 0x9F, 0xFC, 0x1C, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xF8, 0x3C, 0x0E, 0x01, 0xE1, 0xC0, 0x0E,
  0x3C, 0x00, 0x63, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x07, 0x07,
  0x00, 0xF0, 0x3C, 0x3E, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x1C,
  0x01, 0xFE, 0x18, 0x07, 0xFF, 0x38, 0x0F, 0xC7, 0xB8, 0x0F, 0x01, 0xB8,
  0x1C, 0x00, 0xF8, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60,
  0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x70, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0x3C, 0x3F, 0x80, 0x3F, 0xFB, 0x80, 0x1F, 0xF3, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x78,
  0x3C, 0x0E, 0x01, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x06, 0x30,
  0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x01, 0x07, 0x80, 0x78, 0x3E, 0x1F, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xF1, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x86, 0x01, 0xFF,
  0xCE, 0x03, 0xF1, 0xEE, 0x03, 0xC0, 0x6E, 0x07, 0x00, 0x3E, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x38, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x0F,
  0xE0, 0x0F, 0xFE, 0xE0, 0x07, 0xFC, 0xE0, 0x00, 0x40, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x40, 0x03,
  0x80, 0x60, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x73, 0xFC, 0x03, 0x3F, 0xF0, 0x3B, 0xC7, 0xC1, 0xF8, 0x0E, 0x0F, 0x80,
  0x70, 0x78, 0x01, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x3C, 0x18, 0x01,
  0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x78, 0x0E, 0x03, 0xC0, 0x38, 0x1E, 0x00,
  0xE0, 0xF0, 0x03, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xCF,
  0x00, 0x07, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0x9C, 0x00, 0x3C, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C,
  0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC7, 0xF8, 0x0F, 0xE0, 0x39,
  0xFF, 0x87, 0xFF, 0x07, 0x70, 0xF9, 0xE1, 0xE0, 0xF8, 0x0F, 0x70, 0x1E,
  0x1E, 0x00, 0xEC, 0x01, 0xC3, 0xC0, 0x1F, 0x00, 0x38, 0x70, 0x01, 0xE0,
  0x07, 0x1E, 0x00, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x1C, 0x70, 0x00,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x0E, 0x30,
  0x00, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x0E,
  0x38, 0x00, 0x60, 0x01, 0xC7, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x80,
  0x07, 0x18, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x00, 0x38, 0xE0, 0x01,
  0xC0, 0x07, 0x1C, 0x00, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x00, 0x1C, 0x70,
  0x01, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0x00, 0x73, 0x80, 0x07, 0x00, 0x1C,
  0x70, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x39, 0xFE, 0x01, 0x9F, 0xF8, 0x1D, 0xE3, 0xE0, 0xFC, 0x07, 0x07, 0xC0,
  0x38, 0x3C, 0x00, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x00, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0x87,
  0xC0, 0xF0, 0x0E, 0x0F, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x33, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x3C, 0x0F, 0x87,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x1F, 0xE0, 0x06, 0x7F, 0xE0, 0x1D, 0xC3, 0xE0, 0x3E, 0x01, 0xC0,
  0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x3E, 0x01, 0xE0,
  0xEF, 0x0F, 0x81, 0xCF, 0xFE, 0x03, 0x8F, 0xF8, 0x07, 0x01, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xF0, 0xC1, 0xFF, 0xCE,
  0x1F, 0x0F, 0x70, 0xF0, 0x1F, 0x8E, 0x00, 0x7C, 0x70, 0x01, 0xE7, 0x00,
  0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7,
  0x00, 0x06, 0x38, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0x70, 0x03, 0x83, 0xC0, 0x7C,
  0x0F, 0x0F, 0xE0, 0x7F, 0xF7, 0x01, 0xFF, 0x38, 0x00, 0x81, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x3F, 0x06, 0x7E, 0x0E, 0xFE, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x80, 0x70, 0x3C, 0x1F, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x08, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x79, 0x07, 0xE0, 0x3E, 0x00, 0x80, 0x1C, 0x00, 0x71, 0x80,
  0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x63, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x1F, 0x07, 0x87,
  0xF0, 0x7F, 0xF7, 0x03, 0xFC, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0x60, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x70, 0x30, 0x07, 0x03, 0x00, 0xE0, 0x30, 0x0E,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x38, 0x01, 0x83,
  0x00, 0x18, 0x70, 0x01, 0x87, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1D,
  0xC0, 0x01, 0xDC, 0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80,
  0x1C, 0x00, 0xEE, 0x00, 0xF0, 0x03, 0xB8, 0x03, 0xC0, 0x0C, 0xE0, 0x0F,
  0x00, 0x73, 0x80, 0x7C, 0x01, 0xCE, 0x01, 0xB8, 0x0E, 0x38, 0x0E, 0xE0,
  0x38, 0xE0, 0x3B, 0x80, 0xC1, 0x81, 0xCE, 0x07, 0x06, 0x07, 0x38, 0x1C,
  0x18, 0x18, 0xE0, 0xE0, 0x60, 0xE1, 0x83, 0x81, 0x83, 0x06, 0x0C, 0x07,
  0x1C, 0x18, 0x70, 0x1C, 0x70, 0x61, 0xC0, 0x73, 0x81, 0x8E, 0x01, 0xCE,
  0x07, 0x38, 0x07, 0x30, 0x1C, 0xC0, 0x1D, 0xC0, 0x77, 0x00, 0x76, 0x01,
  0xD8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x0E, 0x00,
  0xF0, 0x1C, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78,
  0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0xCF, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x0F, 0x01,
  0xC0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x00, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x08,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0x8F, 0xFC, 0x00, 0xC7,
  0x0F, 0x00, 0x67, 0x03, 0xC0, 0x73, 0x00, 0xE0, 0x33, 0x80, 0x3C, 0x39,
  0xC0, 0x0F, 0xF8, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 39, 11, 1, -38 },
  { 50, 11, 12, 15, 5, -40 },
  { 67, 26, 38, 26, 2, -38 },
  { 191, 22, 50, 25, 2, -44 },
  { 329, 24, 40, 33, 5, -39 },
  { 449, 23, 40, 28, 2, -39 },
  { 564, 5, 12, 9, 5, -40 },
  { 572, 15, 54, 15, 3, -42 },
  { 674, 15, 54, 15, -3, -42 },
  { 776, 20, 21, 22, 3, -38 },
  { 829, 22, 27, 25, 2, -31 },
  { 904, 7, 12, 10, -2, -5 },
  { 915, 11, 3, 13, 1, -18 },
  { 920, 5, 5, 12, 1, -4 },
  { 924, 22, 41, 18, -2, -38 },
  { 1037, 21, 40, 25, 3, -39 },
  { 1142, 12, 38, 25, 7, -38 },
  { 1199, 22, 39, 25, 1, -39 },
  { 1307, 22, 40, 25, 2, -39 },
  { 1417, 22, 38, 25, 1, -38 },
  { 1522, 23, 39, 25, 3, -38 },
  { 1635, 19, 39, 25, 3, -38 },
  { 1728, 22, 38, 25, 4, -38 },
  { 1833, 22, 40, 25, 2, -39 },
  { 1943, 19, 39, 25, 4, -39 },
  { 2036, 8, 29, 11, 1, -28 },
  { 2065, 11, 35, 10, -2, -28 },
  { 2114, 20, 22, 23, 2, -28 },
  { 2169, 20, 13, 25, 3, -24 },
  { 2202, 21, 22, 23, 1, -28 },
  { 2260, 16, 40, 21, 5, -39 },
  { 2340, 36, 49, 40, 2, -37 },
  { 2561, 26, 38, 28, -2, -38 },
  { 2685, 24, 38, 28, 2, -38 },
  { 2799, 25, 40, 29, 3, -39 },
  { 2924, 25, 38, 29, 2, -38 },
  { 3043, 25, 38, 26, 2, -38 },
  { 3162, 25, 38, 25, 2, -38 },
  { 3281, 26, 40, 31, 3, -39 },
  { 3411, 29, 38, 32, 2, -38 },
  { 3549, 10, 38, 13, 2, -38 },
  { 3597, 24, 39, 25, 1, -38 },
  { 3714, 28, 38, 28, 2, -38 },
  { 3847, 18, 38, 24, 2, -38 },
  { 3933, 36, 38, 38, 2, -38 },
  { 4104, 29, 38, 32, 2, -38 },
  { 4242, 26, 40, 30, 3, -39 },
  { 4372, 26, 38, 28, 2, -38 },
  { 4496, 26, 46, 30, 3, -39 },
  { 4646, 25, 38, 28, 2, -38 },
  { 4765, 26, 40, 27, 1, -39 },
  { 4895, 24, 38, 27, 5, -38 },
  { 5009, 26, 39, 29, 3, -38 },
  { 5136, 25, 38, 28, 5, -38 },
  { 5255, 37, 38, 40, 5, -38 },
  { 5431, 30, 38, 28, -1, -38 },
  { 5574, 25, 38, 27, 5, -38 },
  { 5693, 28, 38, 27, 0, -38 },
  { 5826, 15, 51, 12, 0, -43 },
  { 5922, 9, 41, 18, 5, -38 },
  { 5969, 15, 51, 12, -3, -43 },
  { 6065, 14, 19, 19, 3, -38 },
  { 6099, 20, 3, 20, -3, 0 },
  { 6107, 8, 7, 15, 6, -40 },
  { 6114, 20, 30, 24, 1, -29 },
  { 6189, 21, 41, 25, 1, -40 },
  { 6297, 20, 30, 23, 2, -29 },
  { 6372, 24, 41, 25, 2, -40 },
  { 6495, 20, 30, 24, 2, -29 },
  { 6570, 16, 41, 15, 3, -41 },
  { 6652, 24, 40, 25, 0, -29 },
  { 6772, 21, 40, 25, 1, -40 },
  { 6877, 10, 38, 11, 1, -38 },
  { 6925, 17, 49, 11, -6, -38 },
  { 7030, 22, 40, 22, 1, -40 },
  { 7140, 10, 40, 11, 1, -40 },
  { 7190, 35, 29, 39, 1, -29 },
  { 7317, 21, 29, 25, 1, -29 },
  { 7394, 21, 30, 25, 2, -29 },
  { 7473, 23, 40, 25, -1, -29 },
  { 7588, 21, 40, 25, 2, -29 },
  { 7693, 16, 29, 16, 1, -29 },
  { 7751, 20, 30, 23, 1, -29 },
  { 7826, 12, 36, 15, 3, -35 },
  { 7880, 20, 29, 25, 3, -28 },
  { 7953, 20, 28, 22, 3, -28 },
  { 8023, 30, 28, 34, 4, -28 },
  { 8128, 23, 28, 22, -1, -28 },
  { 8209, 25, 39, 22, -2, -28 },
  { 8331, 22, 28, 22, 0, -28 },
  { 8408, 16, 51, 15, 2, -41 },
  { 8510, 10, 45, 11, 1, -38 },
  { 8567, 17, 52, 15, -3, -41 },
  { 8678, 25, 10, 31, 3, -21 },
};

const GFXfont RobotoCondensed_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC53PT7B_H_
