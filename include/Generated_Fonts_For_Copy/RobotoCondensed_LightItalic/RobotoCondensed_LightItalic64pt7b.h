#ifndef _ROBOTOCONDENSED_LIGHTITALIC64PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x18, 0x00, 0x38, 0x73, 0x87, 0x38, 0x77, 0x07,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCC, 0x18, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x01, 0x8E, 0x01, 0xC0, 0x1C, 0x60,
  0x0E, 0x00, 0xE7, 0x00, 0x70, 0x0E, 0x38, 0x03, 0x80, 0xE1, 0xC0, 0x1C,
  0x07, 0x0E, 0x00, 0xE0, 0x70, 0x70, 0x07, 0x07, 0x03, 0x80, 0x70, 0x78,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0x3C, 0x38, 0x03, 0x81, 0xC3, 0xC0, 0x0F,
  0xFC, 0x1C, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x3F, 0x80,
  0x03, 0x83, 0xFE, 0x00, 0x3C, 0x3F, 0xF8, 0x01, 0xC3, 0xC1, 0xC0, 0x1C,
  0x1C, 0x07, 0x01, 0xE1, 0xC0, 0x38, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x70,
  0x0E, 0x0F, 0x03, 0x00, 0x70, 0x70, 0x38, 0x03, 0x87, 0x01, 0xC0, 0x1C,
  0x78, 0x0E, 0x00, 0xE3, 0x80, 0x70, 0x07, 0x38, 0x03, 0x80, 0x3B, 0xC0,
  0x1C, 0x03, 0x8C, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0,
  0x78, 0x07, 0x1E, 0x07, 0x80, 0x73, 0xC0, 0x3C, 0x07, 0x3C, 0x03, 0xC0,
  0x77, 0x80, 0x1E, 0x0E, 0x78, 0x00, 0xE0, 0xE7, 0x00, 0x0F, 0x0E, 0xF0,
  0x00, 0x71, 0xCF, 0x00, 0x07, 0x9C, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x03,
  0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x83, 0xE0, 0x1F, 0x78, 0x1F, 0xFF,
  0xE3, 0xC0, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x38, 0xE3, 0x8E, 0x39, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x1C, 0x03,
  0xF8, 0x1C, 0x1F, 0xFF, 0x1C, 0xFF, 0x7F, 0xDB, 0xFE, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xCE, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x00, 0x0F, 0x07, 0x80,
  0x1E, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x30, 0x01, 0xC0,
  0x10, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x80, 0x80, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x11, 0xE7, 0xDF, 0x78, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x1E,
  0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xE0,
  0xFF, 0xCF, 0xFB, 0x9F, 0x87, 0x7C, 0x1E, 0xE0, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x3C,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x3B,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xF0,
  0x07, 0x80, 0x1F, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x1F, 0x80, 0x1C, 0x7F, 0xE0, 0x1D, 0xFF, 0xF0, 0x3F, 0xF1,
  0xF8, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x78, 0x0F,
  0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x7C, 0xF0, 0x01,
  0xF9, 0xE0, 0x07, 0xE1, 0xE0, 0x1F, 0xC3, 0xF1, 0xFB, 0x83, 0xFF, 0xEF,
  0x03, 0xFF, 0x1C, 0x01, 0xF8, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x00, 0x00, 0x20,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0,
  0x7C, 0x78, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x3F, 0x00, 0x0E,
  0x03, 0x80, 0x0F, 0xFC, 0x00, 0x60, 0x38, 0x01, 0xFF, 0xE0, 0x06, 0x07,
  0x00, 0x3E, 0x0F, 0x80, 0x60, 0x70, 0x07, 0x80, 0x70, 0x06, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x1C, 0x01, 0xE0,
  0x07, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x03, 0xC0, 0x0E,
  0x00, 0x63, 0x80, 0x38, 0x00, 0xE0, 0x06, 0x38, 0x03, 0x80, 0x0E, 0x00,
  0x63, 0x80, 0x78, 0x01, 0xC0, 0x06, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xE7,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x70, 0x0F, 0x00, 0x1C, 0x00, 0xE7, 0x00,
  0xE0, 0x01, 0xC0, 0x0E, 0x70, 0x0E, 0x00, 0x38, 0x00, 0xC7, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x60, 0x0E, 0x00, 0x38, 0x01, 0xCE, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0x8E, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0xE0, 0x0E, 0x01, 0xF0, 0x06, 0x0E, 0x00, 0xE0, 0x3F, 0x00, 0xE0, 0xE0,
  0x0F, 0x07, 0x78, 0x1C, 0x0E, 0x00, 0xF9, 0xE3, 0x83, 0x80, 0x60, 0x07,
  0xFC, 0x3F, 0xF0, 0x07, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x78, 0x07,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x0F, 0x80, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xF0, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xFF, 0xF1, 0xC0, 0x07, 0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0x8F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0xE0, 0x1F, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x00, 0xF7,
  0xF0, 0x00, 0x00, 0x3B, 0xDE, 0x00, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x07,
  0xF0, 0xF0, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x1D, 0xC0, 0x3D, 0xC0, 0x00, 0x03, 0xDC, 0x03, 0x9C, 0x00, 0x00, 0x39,
  0xC0, 0x39, 0xC0, 0x00, 0x07, 0x9C, 0x03, 0x9C, 0x00, 0x00, 0x73, 0xC0,
  0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x07, 0x9E, 0x00, 0x00, 0xE3, 0x80, 0x78,
  0xE0, 0x00, 0x1E, 0x38, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x00, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x00,
  0x78, 0x78, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x70, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0xF0,
  0x0E, 0x07, 0x00, 0x1C, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x1E,
  0x07, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC1, 0xC0,
  0x1C, 0x03, 0xC0, 0x1C, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC3, 0x80, 0x3C,
  0x03, 0x80, 0x1C, 0x78, 0x03, 0xC0, 0x38, 0x01, 0xC7, 0x00, 0x3C, 0x07,
  0x80, 0x1C, 0xF0, 0x03, 0x80, 0x78, 0x01, 0xEE, 0x00, 0x38, 0x07, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xFC, 0x00, 0x78, 0x07, 0x00, 0x0F,
  0xC0, 0x07, 0x80, 0x70, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x1D, 0xC0, 0x00,
  0x1C, 0x03, 0xDC, 0x00, 0x01, 0xC0, 0x3D, 0xE0, 0x00, 0x1C, 0x03, 0xCE,
  0x00, 0x03, 0xC0, 0x38, 0xE0, 0x00, 0x3C, 0x03, 0x8F, 0x00, 0x03, 0xC0,
  0x38, 0x70, 0x00, 0x38, 0x07, 0x87, 0x80, 0x03, 0x80, 0x78, 0x78, 0x00,
  0x78, 0x07, 0x83, 0x80, 0x07, 0x80, 0x70, 0x3C, 0x00, 0x78, 0x07, 0x03,
  0xC0, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x0E, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x1E, 0x00, 0x3C, 0x1E, 0x01,
  0xC0, 0x03, 0xC1, 0xE0, 0x1C, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x01, 0xE1,
  0xC0, 0x3C, 0x00, 0x0E, 0x1C, 0x03, 0xC0, 0x00, 0xE3, 0xC0, 0x3C, 0x00,
  0x0F, 0x3C, 0x03, 0x80, 0x00, 0x73, 0xC0, 0x38, 0x00, 0x07, 0x38, 0x07,
  0x80, 0x00, 0x7B, 0x80, 0x78, 0x00, 0x03, 0xB8, 0x07, 0x80, 0x00, 0x3F,
  0x80, 0x70, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x3F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x7F, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xF0,
  0x07, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x00, 0x01,
  0xF0, 0x00, 0x1C, 0x70, 0x00, 0x3F, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xB0,
  0x00, 0x3C, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x87, 0x00, 0x07, 0x38, 0x00,
  0x78, 0x70, 0x00, 0x73, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE3, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC3, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x38, 0x01, 0xE0, 0x78, 0x03,
  0xC3, 0x80, 0x1C, 0x07, 0x80, 0x38, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x83,
  0x80, 0x3C, 0x07, 0x80, 0x70, 0x38, 0x03, 0x80, 0x78, 0x07, 0x03, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00,
  0x39, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0x98, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x3C,
  0x70, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x0E,
  0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0x9C,
  0x00, 0x7F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3E,
  0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0x83, 0xE0, 0x03,
  0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x87, 0x00, 0x07, 0xC3, 0x80, 0x07, 0xC1, 0xE0, 0x07, 0xE0, 0xF8,
  0x0F, 0x70, 0x3F, 0xFF, 0x38, 0x0F, 0xFF, 0x1C, 0x03, 0xFF, 0x0E, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x38, 0xFF, 0xC0, 0x0E, 0x7F, 0xF8, 0x03, 0xBF, 0xFF, 0x00, 0xFE,
  0x03, 0xE0, 0x7E, 0x00, 0x78, 0x1F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x0E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xD8,
  0x00, 0xF0, 0x77, 0x80, 0xF8, 0x1C, 0xFF, 0xFC, 0x0F, 0x1F, 0xFE, 0x03,
  0xC3, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xFF,
  0x07, 0x00, 0x3F, 0xFE, 0x38, 0x03, 0xFF, 0xF1, 0xC0, 0x3E, 0x01, 0xDE,
  0x01, 0xE0, 0x07, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x3F, 0x80, 0x0F, 0xFF, 0xDC, 0x00, 0x7F, 0xFD, 0xE0, 0x00, 0xFF, 0x8F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x3C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x20, 0x3C,
  0x00, 0x70, 0x3E, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0x07, 0x00, 0x7F, 0xFC, 0x70, 0x0F, 0xFF, 0xC7, 0x01, 0xF0,
  0x0E, 0xF0, 0x1E, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xE0,
  0x07, 0xFF, 0xEE, 0x00, 0x7F, 0xFD, 0xE0, 0x01, 0xFF, 0x1E, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x02, 0x00, 0x07, 0x80, 0x70,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x0E, 0x1F, 0xF0, 0x07, 0x3F, 0xFC, 0x03, 0xBF,
  0xFF, 0x01, 0xFC, 0x07, 0x81, 0xF8, 0x01, 0xE0, 0xFC, 0x00, 0xF0, 0x7C,
  0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F,
  0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x70, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x08,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x70, 0x0F, 0x80, 0x0E, 0x03, 0xE0,
  0x01, 0xC0, 0xF8, 0x00, 0x38, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0x38, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x00, 0xEF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x9E,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1E,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x38,
  0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x71, 0xFF, 0x80, 0x7F, 0xC0, 0x0E, 0x7F, 0xF8,
  0x3F, 0xFC, 0x01, 0xDF, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0x00, 0xF3, 0xC0,
  0x7C, 0x0F, 0xC0, 0x1E, 0x70, 0x07, 0x81, 0xF0, 0x01, 0xFC, 0x00, 0x70,
  0x3C, 0x00, 0x3F, 0x00, 0x0E, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x87, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xC3,
  0xFE, 0x00, 0xE7, 0xFF, 0x80, 0x77, 0xFF, 0xE0, 0x7F, 0x80, 0xF0, 0x3F,
  0x00, 0x3C, 0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x03, 0x83,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78,
  0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x0E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03, 0xC0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x3F,
  0xF0, 0x00, 0xE7, 0xFF, 0x80, 0x0E, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x1F, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x78, 0x1D, 0x80, 0x0F, 0x01, 0xDC, 0x03, 0xE0, 0x1C, 0xFD,
  0xFC, 0x03, 0xC7, 0xFF, 0x80, 0x3C, 0x3F, 0xF0, 0x03, 0xC0, 0x7C, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0,
  0x70, 0x1F, 0xFF, 0x1C, 0x0F, 0xFF, 0xE7, 0x07, 0xC0, 0x3B, 0xC1, 0xE0,
  0x07, 0xF0, 0xF0, 0x00, 0xF8, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF8,
  0x0F, 0xE0, 0x1F, 0xDF, 0xF8, 0x07, 0xFF, 0xDE, 0x00, 0x7F, 0xC7, 0x80,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x71, 0xFC, 0x0E,
  0x7F, 0x81, 0xDF, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3,
  0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x1F, 0x03, 0xC0, 0x1F,
  0x81, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0xE0, 0x0F, 0xFC,
  0x70, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x01, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x78, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x0E, 0x00, 0x0E, 0xE0, 0x01, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0x00,
  0x1E, 0xE0, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x3F, 0x00, 0x3C, 0xE0, 0x07,
  0xF0, 0x03, 0x8F, 0x00, 0x77, 0x00, 0x78, 0xF0, 0x07, 0x70, 0x07, 0x0F,
  0x00, 0xE7, 0x00, 0x70, 0xF0, 0x0E, 0x70, 0x0F, 0x0F, 0x01, 0xE7, 0x00,
  0xE0, 0x70, 0x1C, 0x70, 0x1E, 0x07, 0x03, 0xC7, 0x01, 0xC0, 0x70, 0x38,
  0x70, 0x1C, 0x07, 0x03, 0x87, 0x03, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x07,
  0x07, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x38, 0x70, 0x07, 0x0E, 0x03, 0x87,
  0x00, 0x71, 0xE0, 0x38, 0xF0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x39, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x07,
  0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xB8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x38, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80,
  0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x13, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x70, 0xFF, 0xE0, 0x01, 0xC7, 0xFF, 0xC0, 0x07, 0x3C,
  0x0F, 0x00, 0x1C, 0xE0, 0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x03, 0x9C, 0x00,
  0xF8, 0x1C, 0x70, 0x01, 0xFB, 0xF1, 0xC0, 0x03, 0xFF, 0x87, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 47, 13, 2, -46 },
  { 66, 12, 14, 18, 7, -48 },
  { 87, 32, 46, 32, 2, -46 },
  { 271, 27, 60, 30, 2, -53 },
  { 474, 29, 48, 40, 6, -47 },
  { 648, 28, 48, 33, 2, -47 },
  { 816, 6, 14, 11, 6, -48 },
  { 827, 18, 66, 18, 3, -51 },
  { 976, 18, 66, 18, -3, -51 },
  { 1125, 24, 26, 26, 4, -46 },
  { 1203, 26, 34, 31, 3, -39 },
  { 1314, 9, 15, 12, -3, -6 },
  { 1331, 13, 3, 16, 2, -21 },
  { 1336, 6, 6, 15, 1, -5 },
  { 1341, 27, 50, 22, -3, -46 },
  { 1510, 25, 48, 30, 3, -47 },
  { 1660, 15, 46, 30, 8, -46 },
  { 1747, 27, 47, 30, 1, -47 },
  { 1906, 26, 48, 30, 2, -47 },
  { 2062, 27, 46, 30, 1, -46 },
  { 2218, 27, 47, 30, 4, -46 },
  { 2377, 24, 47, 30, 3, -46 },
  { 2518, 26, 46, 30, 5, -46 },
  { 2668, 27, 48, 30, 2, -47 },
  { 2830, 23, 47, 30, 5, -47 },
  { 2966, 10, 35, 13, 1, -34 },
  { 3010, 13, 43, 12, -2, -34 },
  { 3080, 23, 27, 28, 3, -34 },
  { 3158, 25, 16, 30, 3, -29 },
  { 3208, 24, 27, 28, 2, -34 },
  { 3289, 19, 48, 25, 6, -47 },
  { 3403, 44, 58, 49, 2, -44 },
  { 3722, 31, 46, 34, -2, -46 },
  { 3901, 29, 46, 33, 2, -46 },
  { 4068, 30, 48, 35, 4, -47 },
  { 4248, 31, 46, 35, 2, -46 },
  { 4427, 31, 46, 31, 2, -46 },
  { 4606, 31, 46, 30, 2, -46 },
  { 4785, 31, 48, 37, 4, -47 },
  { 4971, 36, 46, 38, 2, -46 },
  { 5178, 11, 46, 15, 3, -46 },
  { 5242, 29, 47, 30, 1, -46 },
  { 5413, 34, 46, 34, 2, -46 },
  { 5609, 22, 46, 29, 2, -46 },
  { 5736, 44, 46, 46, 2, -46 },
  { 5989, 36, 46, 38, 2, -46 },
  { 6196, 31, 48, 37, 4, -47 },
  { 6382, 31, 46, 33, 2, -46 },
  { 6561, 31, 55, 37, 3, -47 },
  { 6775, 31, 46, 34, 2, -46 },
  { 6954, 30, 48, 32, 2, -47 },
  { 7134, 29, 46, 32, 6, -46 },
  { 7301, 33, 47, 35, 3, -46 },
  { 7495, 31, 46, 34, 6, -46 },
  { 7674, 44, 46, 48, 6, -46 },
  { 7927, 36, 46, 33, -1, -46 },
  { 8134, 30, 46, 32, 6, -46 },
  { 8307, 33, 46, 32, 0, -46 },
  { 8497, 19, 62, 14, 0, -52 },
  { 8645, 10, 50, 22, 7, -46 },
  { 8708, 19, 62, 14, -4, -52 },
  { 8856, 18, 23, 23, 3, -46 },
  { 8908, 23, 3, 24, -3, 0 },
  { 8917, 8, 9, 18, 8, -48 },
  { 8926, 25, 36, 29, 1, -35 },
  { 9039, 26, 49, 30, 1, -48 },
  { 9199, 24, 36, 28, 2, -35 },
  { 9307, 29, 49, 30, 2, -48 },
  { 9485, 24, 36, 28, 2, -35 },
  { 9593, 20, 49, 19, 3, -49 },
  { 9716, 28, 48, 30, 0, -35 },
  { 9884, 25, 48, 30, 1, -48 },
  { 10034, 11, 46, 13, 2, -46 },
  { 10098, 20, 59, 13, -7, -46 },
  { 10246, 27, 48, 27, 1, -48 },
  { 10408, 11, 48, 13, 2, -48 },
  { 10474, 43, 35, 47, 1, -35 },
  { 10663, 25, 35, 30, 1, -35 },
  { 10773, 26, 36, 30, 2, -35 },
  { 10890, 28, 48, 30, -1, -35 },
  { 11058, 26, 48, 30, 2, -35 },
  { 11214, 19, 35, 19, 1, -35 },
  { 11298, 24, 36, 28, 1, -35 },
  { 11406, 15, 43, 18, 3, -42 },
  { 11487, 25, 35, 30, 3, -34 },
  { 11597, 23, 34, 26, 4, -34 },
  { 11695, 36, 34, 41, 5, -34 },
  { 11848, 28, 34, 27, -1, -34 },
  { 11967, 30, 47, 26, -3, -34 },
  { 12144, 26, 34, 27, 0, -34 },
  { 12255, 20, 63, 19, 2, -50 },
  { 12413, 12, 54, 14, 1, -46 },
  { 12494, 19, 63, 19, -3, -50 },
  { 12644, 30, 12, 37, 3, -25 },
};

const GFXfont RobotoCondensed_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC64PT7B_H_
