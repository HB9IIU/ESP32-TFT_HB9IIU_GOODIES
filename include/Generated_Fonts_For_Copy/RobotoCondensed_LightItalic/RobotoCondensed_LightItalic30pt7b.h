#ifndef _ROBOTOCONDENSED_LIGHTITALIC30PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x31, 0x88, 0x00,
  0x00, 0x0C, 0x60, 0x6D, 0x34, 0xD2, 0xCB, 0x28, 0x80, 0x00, 0x84, 0x03,
  0x18, 0x04, 0x20, 0x08, 0x40, 0x31, 0x80, 0x62, 0x00, 0x84, 0x1F, 0xFF,
  0x06, 0x30, 0x08, 0x40, 0x11, 0x80, 0x63, 0x00, 0x84, 0x01, 0x08, 0x3F,
  0xFE, 0x08, 0x40, 0x10, 0x80, 0x63, 0x00, 0x84, 0x01, 0x08, 0x06, 0x30,
  0x08, 0x40, 0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3C, 0x0F, 0xE1, 0x83,
  0x18, 0x31, 0x01, 0x30, 0x13, 0x01, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x6C, 0x06, 0xC0, 0x6C, 0x04,
  0x60, 0xC7, 0xF8, 0x1F, 0x00, 0x80, 0x08, 0x00, 0x80, 0x38, 0x01, 0x90,
  0x0C, 0x60, 0x20, 0x86, 0x82, 0x32, 0x18, 0x88, 0x64, 0x21, 0x30, 0xCC,
  0x81, 0xE4, 0x00, 0x30, 0x00, 0x80, 0x04, 0x70, 0x33, 0x60, 0x98, 0x84,
  0x42, 0x31, 0x0D, 0x8C, 0x24, 0x10, 0x90, 0x46, 0x01, 0xB0, 0x03, 0x80,
  0x03, 0xC0, 0x3F, 0x03, 0x18, 0x10, 0x41, 0x82, 0x0C, 0x30, 0x61, 0x01,
  0x18, 0x0F, 0x80, 0x70, 0x03, 0x80, 0x3C, 0x03, 0x30, 0xB1, 0x8F, 0x06,
  0x78, 0x32, 0xC0, 0xF6, 0x07, 0x30, 0x18, 0xC1, 0xC7, 0xFB, 0x0F, 0x08,
  0x57, 0xE8, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x40, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03, 0x02, 0x00,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x0E, 0x4E, 0xFF, 0x83, 0x80, 0xF0, 0x32,
  0x04, 0x61, 0x84, 0x20, 0x80, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x07, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x33, 0x26, 0x6C, 0x80, 0xFF, 0xF0, 0x3C,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x07, 0x83, 0xF8, 0xC1, 0x98, 0x36, 0x02, 0xC0, 0x50, 0x0A, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xA0, 0x14, 0x06, 0x80, 0xD0,
  0x12, 0x06, 0x61, 0x87, 0xF0, 0x78, 0x00, 0x06, 0x3D, 0xF6, 0x20, 0xC1,
  0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x82, 0x04, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0x06, 0x30, 0x31, 0x81, 0x88,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0xFF, 0x3F, 0xF8, 0x07, 0xC0, 0xFE, 0x18, 0x33, 0x03, 0x30, 0x13, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x0F, 0xC0, 0xF8, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xC6, 0x0C, 0x7F, 0x81, 0xE0,
  0x00, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0xA0, 0x0D, 0x00, 0xD8, 0x04, 0xC0,
  0x66, 0x06, 0x30, 0x61, 0x02, 0x08, 0x30, 0xC3, 0x06, 0x10, 0x31, 0xFF,
  0xEF, 0xFF, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x0F, 0xF1, 0xFF, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x2F, 0x07, 0xF8, 0x60, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x04,
  0x80, 0x48, 0x0C, 0xC0, 0xCC, 0x18, 0x7F, 0x03, 0xE0, 0x01, 0xC0, 0xF8,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x4F, 0x1B, 0xF3, 0x83,
  0x60, 0x6C, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xD0, 0x1B, 0x02, 0x60,
  0xC7, 0xF0, 0x7C, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x7F, 0x06, 0x0C, 0x30, 0x23, 0x01,
  0x18, 0x08, 0xC0, 0x46, 0x06, 0x18, 0x60, 0xFE, 0x07, 0xE0, 0x61, 0x86,
  0x06, 0x20, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x30, 0xC1,
  0x87, 0xF8, 0x0F, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x10, 0x36, 0x06, 0x80,
  0xD0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x76, 0x1C, 0x7E, 0x87,
  0xB0, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x07, 0xC0, 0xE0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x31, 0x86,
  0x30, 0x80, 0x00, 0x20, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x08, 0x7F, 0xEF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x20, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x18, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x08,
  0x00, 0x1E, 0x3F, 0xB0, 0x58, 0x38, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x03, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x3C, 0x03, 0x80, 0x40, 0x60, 0x02,
  0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x3C, 0x11, 0x06, 0xE1, 0x30, 0x82,
  0x12, 0x18, 0x61, 0x61, 0x06, 0x14, 0x30, 0x41, 0x42, 0x04, 0x1C, 0x20,
  0xC1, 0xC2, 0x0C, 0x3C, 0x60, 0x82, 0x86, 0x08, 0x28, 0x61, 0x86, 0x86,
  0x38, 0x48, 0x36, 0xC8, 0xC3, 0xC7, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x13, 0x00,
  0x66, 0x00, 0xCC, 0x03, 0x08, 0x06, 0x10, 0x18, 0x20, 0x30, 0x40, 0xC0,
  0xC1, 0x81, 0x83, 0xFF, 0x0F, 0xFE, 0x10, 0x0C, 0x60, 0x08, 0x80, 0x13,
  0x00, 0x26, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0xE0, 0x7F, 0xE1, 0x81, 0x86,
  0x02, 0x18, 0x0C, 0x40, 0x33, 0x00, 0x8C, 0x06, 0x30, 0x30, 0xFF, 0x83,
  0xFE, 0x08, 0x1C, 0x60, 0x31, 0x80, 0x46, 0x01, 0x18, 0x04, 0x60, 0x11,
  0x00, 0xCC, 0x03, 0x30, 0x18, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xE0, 0x3F,
  0xC1, 0x81, 0x8C, 0x02, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x04, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x18, 0x38, 0x7F, 0xC0, 0x7C, 0x00,
  0x0F, 0xE0, 0x3F, 0xE0, 0x60, 0x60, 0xC0, 0x61, 0x80, 0xC2, 0x00, 0x84,
  0x01, 0x18, 0x02, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x31, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x63, 0x00, 0xC6,
  0x07, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xC3,
  0xFE, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0xE1, 0xC1, 0x8C, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x7E, 0xC1, 0xFB, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x44, 0x03, 0x18, 0x1C, 0x3F,
  0xE0, 0x7E, 0x00, 0x08, 0x01, 0x8C, 0x00, 0x86, 0x00, 0x43, 0x00, 0x61,
  0x80, 0x30, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x04, 0x30, 0x06, 0x1F, 0xFF,
  0x0F, 0xFF, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x21, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x86,
  0x00, 0xC0, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x20,
  0x86, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x40,
  0x61, 0x01, 0x84, 0x0C, 0x18, 0x30, 0x3F, 0x80, 0x7C, 0x00, 0x08, 0x07,
  0x18, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x10, 0x60, 0x10, 0xC0,
  0x31, 0x80, 0x33, 0x00, 0x36, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7B, 0x00,
  0x71, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x40, 0x60, 0xC0, 0x60,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x30, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0x40, 0x0F, 0x0B,
  0x00, 0x58, 0x58, 0x06, 0x86, 0xC0, 0x24, 0x32, 0x03, 0x61, 0x90, 0x13,
  0x08, 0x81, 0x98, 0x46, 0x08, 0xC6, 0x30, 0xC4, 0x31, 0x84, 0x21, 0x84,
  0x63, 0x0C, 0x22, 0x18, 0x61, 0x30, 0xC2, 0x0D, 0x06, 0x30, 0x78, 0x21,
  0x83, 0x81, 0x0C, 0x0C, 0x18, 0x60, 0x40, 0xC0, 0x08, 0x01, 0x8E, 0x00,
  0x87, 0x00, 0x43, 0x80, 0x61, 0xE0, 0x30, 0x90, 0x18, 0xCC, 0x0C, 0x66,
  0x04, 0x31, 0x02, 0x18, 0xC3, 0x0C, 0x61, 0x84, 0x10, 0xC6, 0x0C, 0x63,
  0x06, 0x21, 0x81, 0x10, 0xC0, 0xD8, 0x60, 0x6C, 0x20, 0x16, 0x30, 0x0F,
  0x18, 0x07, 0x0C, 0x01, 0x86, 0x00, 0xC0, 0x03, 0xE0, 0x3F, 0xC1, 0x81,
  0x8C, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xD0, 0x03, 0x40, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x28, 0x01, 0xA0, 0x06, 0x80,
  0x13, 0x00, 0xCC, 0x02, 0x18, 0x38, 0x7F, 0xC0, 0x7C, 0x00, 0x0F, 0xF0,
  0x3F, 0xF0, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x18,
  0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0xFF, 0x87, 0xFC, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x30,
  0x0D, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x02, 0xC0, 0x0A, 0x00, 0x68, 0x01, 0xA0, 0x06, 0x80, 0x13, 0x00, 0xCC,
  0x02, 0x18, 0x38, 0x7F, 0xC0, 0x7E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0x81, 0x86, 0x03, 0x18, 0x0C, 0x40,
  0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x62, 0x03, 0x8F, 0xFC, 0x7F,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x40, 0x61, 0x01, 0x8C, 0x02, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0xC0, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x86, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0xC0, 0x13, 0x00,
  0xCC, 0x03, 0x18, 0x18, 0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xC1,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x30, 0x06, 0x60, 0x08,
  0xC0, 0x11, 0x00, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x04, 0x60,
  0x08, 0x80, 0x31, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x04,
  0x40, 0x18, 0x80, 0x31, 0x00, 0x63, 0x01, 0x87, 0x06, 0x07, 0xFC, 0x07,
  0xE0, 0x00, 0x80, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00,
  0xC4, 0x06, 0x10, 0x18, 0x40, 0x41, 0x83, 0x06, 0x08, 0x18, 0x60, 0x61,
  0x80, 0x8C, 0x02, 0x30, 0x08, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC0, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x16, 0x03, 0x01, 0xB0, 0x18,
  0x0D, 0x81, 0xC0, 0x4C, 0x0A, 0x06, 0x60, 0xD0, 0x33, 0x06, 0x81, 0x18,
  0x26, 0x18, 0xC3, 0x30, 0xC6, 0x11, 0x84, 0x31, 0x8C, 0x60, 0x8C, 0x63,
  0x04, 0x41, 0x10, 0x26, 0x09, 0x81, 0x30, 0x48, 0x09, 0x02, 0xC0, 0x58,
  0x16, 0x02, 0x80, 0xA0, 0x14, 0x05, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0x18, 0x03, 0x06, 0x03, 0x83, 0x01, 0x81, 0x81, 0x80,
  0x61, 0x80, 0x30, 0xC0, 0x08, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x36, 0x00, 0x19, 0x00, 0x18,
  0xC0, 0x18, 0x60, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x86,
  0x00, 0xC0, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0x18, 0x0C, 0x60, 0x61, 0x81,
  0x02, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x01, 0x20, 0x07, 0x80, 0x1C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x07, 0x87, 0x83, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x1E, 0x0F, 0x00, 0xC6, 0x30,
  0x84, 0x21, 0x0C, 0x63, 0x18, 0x42, 0x10, 0x86, 0x31, 0x84, 0x21, 0x08,
  0x63, 0x07, 0x87, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x1F, 0x0F, 0x00, 0x02, 0x03,
  0x01, 0x81, 0xE0, 0xB0, 0xC8, 0x44, 0x62, 0x21, 0x30, 0xD0, 0x60, 0x7F,
  0xFF, 0xFC, 0xC4, 0x62, 0x0F, 0x83, 0xF8, 0xC1, 0x90, 0x36, 0x06, 0x00,
  0xC0, 0x18, 0xFE, 0x78, 0x4C, 0x1B, 0x03, 0x40, 0x68, 0x0D, 0x83, 0x3F,
  0xA3, 0xE4, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x7C, 0x3F, 0xE3, 0x86, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x34, 0x02, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xE0, 0xCB, 0xF8, 0x9F,
  0x00, 0x0F, 0x83, 0xF8, 0xC1, 0xB0, 0x36, 0x02, 0x80, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x2C, 0x0C, 0x83, 0x1F, 0xE1, 0xF0, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x41, 0xE2,
  0x1F, 0xF1, 0x83, 0x98, 0x0C, 0xC0, 0x64, 0x02, 0x20, 0x13, 0x01, 0x98,
  0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11, 0x81, 0x86, 0x1C, 0x3F, 0xE0, 0xFB,
  0x00, 0x0F, 0x83, 0xF8, 0xC1, 0xB0, 0x36, 0x02, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC1, 0x1F, 0xE1, 0xF0, 0x07,
  0x87, 0xC6, 0x03, 0x01, 0x00, 0x80, 0xC1, 0xFC, 0x30, 0x18, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x00, 0x07, 0x88, 0x7F, 0xC6, 0x0E, 0x60, 0x33, 0x01, 0x90, 0x08, 0x80,
  0x4C, 0x06, 0x60, 0x33, 0x01, 0x98, 0x08, 0xC0, 0x46, 0x06, 0x18, 0x70,
  0xFF, 0x83, 0xEC, 0x00, 0x40, 0x02, 0x00, 0x31, 0x83, 0x07, 0xF8, 0x1F,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x9E,
  0x3F, 0xE7, 0x0C, 0xC0, 0x90, 0x16, 0x02, 0xC0, 0xD8, 0x1A, 0x03, 0x40,
  0x78, 0x0B, 0x01, 0x60, 0x6C, 0x0D, 0x01, 0xA0, 0x30, 0x18, 0xC0, 0x00,
  0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x08, 0x46, 0x31, 0x88, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x78, 0x38, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x07, 0x30, 0xE3, 0x1C, 0x21, 0x82, 0x30,
  0x66, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x66, 0x04, 0x60, 0xC3, 0x0C, 0x30,
  0xC1, 0x88, 0x18, 0x80, 0x80, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31, 0x8C,
  0x42, 0x31, 0x8C, 0x42, 0x11, 0x8C, 0x62, 0x00, 0x1B, 0xE1, 0xE0, 0xFF,
  0xBF, 0x87, 0x0F, 0x0C, 0x30, 0x70, 0x23, 0x01, 0x81, 0x18, 0x08, 0x08,
  0xC0, 0xC0, 0x46, 0x06, 0x06, 0x20, 0x30, 0x31, 0x01, 0x81, 0x98, 0x08,
  0x0C, 0xC0, 0x40, 0x46, 0x06, 0x02, 0x30, 0x30, 0x31, 0x01, 0x81, 0x88,
  0x08, 0x0C, 0x33, 0xC7, 0xFC, 0xE1, 0x98, 0x12, 0x02, 0xC0, 0x58, 0x1B,
  0x03, 0x60, 0x68, 0x0D, 0x01, 0x60, 0x2C, 0x0D, 0x81, 0xA0, 0x34, 0x06,
  0x07, 0x81, 0xFE, 0x30, 0x62, 0x03, 0x60, 0x34, 0x03, 0x40, 0x3C, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x46, 0x0C, 0x7F, 0x81, 0xE0,
  0x1B, 0xE0, 0xFF, 0x86, 0x0C, 0x30, 0x31, 0x01, 0x98, 0x0C, 0xC0, 0x66,
  0x03, 0x20, 0x11, 0x00, 0x88, 0x0C, 0xC0, 0x66, 0x02, 0x38, 0x31, 0x7F,
  0x09, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x00,
  0x0F, 0x11, 0xFF, 0x30, 0x76, 0x03, 0x60, 0x36, 0x02, 0x40, 0x2C, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x04, 0xC0, 0xC4, 0x1C, 0x7F, 0xC3, 0xEC,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x37, 0x3F, 0x38,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x0F, 0x83, 0xF8, 0xC1, 0x10, 0x36, 0x06, 0x40, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x02, 0x40, 0x68, 0x09, 0x83, 0x1F, 0xC1, 0xF0, 0x08,
  0x10, 0x60, 0xC7, 0xE3, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x30, 0x60, 0xC1, 0xE1, 0xC0, 0x30, 0x33, 0x03, 0x20, 0x32, 0x03, 0x60,
  0x26, 0x02, 0x60, 0x66, 0x06, 0x40, 0x64, 0x06, 0x40, 0x4C, 0x0C, 0x40,
  0xC6, 0x1C, 0x7F, 0xC3, 0xC8, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0xC4, 0x18,
  0x82, 0x10, 0xC2, 0x10, 0x66, 0x0C, 0x81, 0xB0, 0x16, 0x02, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0xC0, 0x81, 0xE0, 0xC0, 0xF0, 0x70, 0xD8, 0x78, 0x64,
  0x3C, 0x22, 0x16, 0x31, 0x1B, 0x18, 0x88, 0x88, 0x4C, 0x4C, 0x24, 0x24,
  0x16, 0x16, 0x0B, 0x0B, 0x05, 0x05, 0x03, 0x83, 0x81, 0x81, 0x80, 0xC0,
  0xC0, 0x18, 0x18, 0x20, 0x60, 0xC3, 0x01, 0x18, 0x06, 0x40, 0x1B, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0xD8, 0x02, 0x20, 0x18, 0xC0,
  0xC1, 0x06, 0x06, 0x18, 0x18, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x0C,
  0x08, 0x30, 0x20, 0x80, 0x86, 0x03, 0x10, 0x0C, 0xC0, 0x32, 0x00, 0xD8,
  0x03, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x81, 0xC1, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x03, 0x07, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x18, 0xC6, 0x21, 0x08, 0xC6, 0x31, 0x88,
  0x42, 0x31, 0x8C, 0x42, 0x11, 0x8C, 0x63, 0x10, 0x84, 0x00, 0x04, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x70, 0x1C, 0x0C, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x3C,
  0x0D, 0xF8, 0x2C, 0x71, 0xA0, 0xFC, 0x80, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 6, 1, -22 },
  { 15, 6, 7, 8, 3, -23 },
  { 21, 15, 22, 15, 1, -22 },
  { 63, 12, 28, 14, 1, -25 },
  { 105, 14, 22, 19, 3, -22 },
  { 144, 13, 22, 16, 1, -22 },
  { 180, 2, 7, 5, 3, -23 },
  { 182, 9, 31, 8, 1, -24 },
  { 217, 9, 31, 9, -2, -24 },
  { 252, 11, 12, 12, 2, -22 },
  { 269, 12, 16, 14, 1, -18 },
  { 293, 4, 7, 6, -1, -3 },
  { 297, 6, 2, 8, 1, -11 },
  { 299, 2, 3, 7, 1, -3 },
  { 300, 12, 24, 10, -1, -22 },
  { 336, 11, 22, 14, 2, -22 },
  { 367, 7, 22, 14, 4, -22 },
  { 387, 13, 22, 14, 0, -22 },
  { 423, 12, 22, 14, 1, -22 },
  { 456, 13, 22, 14, 0, -22 },
  { 492, 12, 22, 14, 2, -22 },
  { 525, 11, 22, 14, 2, -22 },
  { 556, 13, 22, 14, 2, -22 },
  { 592, 13, 22, 14, 1, -22 },
  { 628, 11, 22, 14, 2, -22 },
  { 659, 5, 17, 6, 0, -17 },
  { 670, 6, 21, 6, -1, -17 },
  { 686, 11, 13, 13, 1, -16 },
  { 704, 11, 8, 14, 2, -14 },
  { 715, 11, 13, 13, 1, -16 },
  { 733, 9, 22, 12, 3, -22 },
  { 758, 20, 28, 23, 1, -21 },
  { 828, 15, 22, 16, -1, -22 },
  { 870, 14, 22, 16, 1, -22 },
  { 909, 14, 22, 16, 2, -22 },
  { 948, 15, 22, 17, 1, -22 },
  { 990, 14, 22, 14, 1, -22 },
  { 1029, 14, 22, 14, 1, -22 },
  { 1068, 14, 22, 17, 2, -22 },
  { 1107, 17, 22, 18, 1, -22 },
  { 1154, 6, 22, 7, 1, -22 },
  { 1171, 14, 22, 14, 0, -22 },
  { 1210, 16, 22, 16, 1, -22 },
  { 1254, 10, 22, 14, 1, -22 },
  { 1282, 21, 22, 22, 1, -22 },
  { 1340, 17, 22, 18, 1, -22 },
  { 1387, 14, 22, 17, 2, -22 },
  { 1426, 15, 22, 16, 1, -22 },
  { 1468, 14, 26, 17, 2, -22 },
  { 1514, 14, 22, 16, 1, -22 },
  { 1553, 14, 22, 15, 1, -22 },
  { 1592, 13, 22, 15, 3, -22 },
  { 1628, 15, 22, 17, 2, -22 },
  { 1670, 14, 22, 16, 3, -22 },
  { 1709, 21, 22, 22, 3, -22 },
  { 1767, 17, 22, 16, 0, -22 },
  { 1814, 14, 22, 15, 3, -22 },
  { 1853, 16, 22, 15, 0, -22 },
  { 1897, 9, 29, 7, 0, -24 },
  { 1930, 5, 24, 10, 3, -22 },
  { 1945, 9, 29, 7, -2, -24 },
  { 1978, 9, 11, 11, 1, -22 },
  { 1991, 11, 2, 11, -2, 0 },
  { 1994, 4, 4, 8, 4, -22 },
  { 1996, 11, 16, 14, 1, -16 },
  { 2018, 12, 23, 14, 1, -23 },
  { 2053, 11, 16, 13, 1, -16 },
  { 2075, 13, 23, 14, 1, -23 },
  { 2113, 11, 16, 13, 1, -16 },
  { 2135, 9, 23, 9, 2, -23 },
  { 2161, 13, 22, 14, 0, -16 },
  { 2197, 11, 23, 14, 1, -23 },
  { 2229, 5, 21, 6, 1, -21 },
  { 2243, 9, 27, 6, -3, -21 },
  { 2274, 12, 23, 13, 1, -23 },
  { 2309, 5, 23, 6, 1, -23 },
  { 2324, 21, 16, 22, 0, -16 },
  { 2366, 11, 16, 14, 1, -16 },
  { 2388, 12, 16, 14, 1, -16 },
  { 2412, 13, 22, 14, 0, -16 },
  { 2448, 12, 22, 14, 1, -16 },
  { 2481, 8, 16, 9, 1, -16 },
  { 2497, 11, 16, 13, 1, -16 },
  { 2519, 7, 20, 8, 1, -20 },
  { 2537, 12, 16, 14, 1, -16 },
  { 2561, 11, 16, 12, 2, -16 },
  { 2583, 17, 16, 19, 2, -16 },
  { 2617, 14, 16, 13, -1, -16 },
  { 2645, 14, 22, 12, -1, -16 },
  { 2684, 12, 16, 13, 0, -16 },
  { 2708, 9, 29, 9, 1, -23 },
  { 2741, 5, 26, 6, 1, -22 },
  { 2758, 10, 29, 9, -2, -23 },
  { 2795, 14, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC30PT7B_H_
