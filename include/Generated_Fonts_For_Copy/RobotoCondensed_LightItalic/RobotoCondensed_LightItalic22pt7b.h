#ifndef _ROBOTOCONDENSED_LIGHTITALIC22PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x96, 0x92, 0x4B, 0x00, 0x24, 0x5A, 0x95, 0x29, 0x00, 0x04,
  0x40, 0x88, 0x12, 0x04, 0x40, 0x88, 0xFF, 0xC4, 0x40, 0x88, 0x12, 0x04,
  0x43, 0xFE, 0x12, 0x02, 0x40, 0x88, 0x12, 0x02, 0x40, 0x02, 0x02, 0x03,
  0x86, 0x22, 0x19, 0x05, 0x82, 0x40, 0x20, 0x0C, 0x03, 0x80, 0x40, 0x34,
  0x0A, 0x0D, 0x04, 0x46, 0x1E, 0x04, 0x02, 0x00, 0x30, 0x12, 0x08, 0x8A,
  0x22, 0x89, 0x22, 0x87, 0x20, 0x10, 0x08, 0x02, 0xE1, 0x24, 0x91, 0x64,
  0x51, 0x10, 0x4C, 0x0E, 0x0E, 0x09, 0x8C, 0x44, 0x22, 0x31, 0xB0, 0x70,
  0x30, 0x28, 0x26, 0x61, 0x30, 0xD8, 0x34, 0x1B, 0x1C, 0xF3, 0x5E, 0x80,
  0x04, 0x30, 0x84, 0x30, 0x82, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x08, 0x61, 0x08, 0x00,
  0x04, 0x04, 0x02, 0x1D, 0x73, 0xE0, 0xC0, 0xD0, 0xC8, 0x42, 0x00, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x30, 0x10, 0x08, 0x04, 0x00,
  0x25, 0xA8, 0xF0, 0x50, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x00,
  0x0E, 0x08, 0x88, 0x6C, 0x14, 0x0A, 0x05, 0x06, 0x82, 0xC1, 0x40, 0xA0,
  0x50, 0x28, 0x26, 0x11, 0x10, 0x70, 0x0B, 0xF6, 0x21, 0x08, 0x42, 0x31,
  0x08, 0x42, 0x31, 0x88, 0x0F, 0x06, 0x21, 0x0C, 0x83, 0x20, 0xC0, 0x20,
  0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE,
  0x1E, 0x18, 0x98, 0x68, 0x30, 0x18, 0x08, 0x08, 0x38, 0x02, 0x01, 0x80,
  0x40, 0x28, 0x34, 0x13, 0x18, 0xF0, 0x00, 0x80, 0x60, 0x38, 0x0A, 0x04,
  0x83, 0x60, 0x90, 0x44, 0x31, 0x08, 0x44, 0x13, 0xFF, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x1F, 0xC4, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE1, 0x8C,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x81, 0x30, 0x84, 0x60, 0xF0, 0x07, 0x0C,
  0x10, 0x20, 0x20, 0x5E, 0x62, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0x42,
  0x46, 0x38, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x00, 0x0E, 0x18, 0x88, 0x6C,
  0x16, 0x09, 0x08, 0x8C, 0x78, 0x62, 0x61, 0xA0, 0x50, 0x28, 0x34, 0x13,
  0x18, 0xF0, 0x3C, 0x66, 0x42, 0x83, 0x83, 0x83, 0x82, 0x82, 0x86, 0xCE,
  0x7A, 0x04, 0x04, 0x08, 0x30, 0xE0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x4C,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x46, 0x22, 0x00, 0x01, 0x07,
  0x0C, 0x30, 0xC0, 0xC0, 0x60, 0x18, 0x0E, 0x02, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x40, 0x60, 0x18, 0x0E, 0x03, 0x07, 0x0C, 0x30, 0xC0, 0x80, 0x38,
  0x8B, 0x1C, 0x30, 0x60, 0x83, 0x04, 0x10, 0x40, 0x82, 0x00, 0x00, 0x10,
  0x60, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x22, 0x00, 0x44, 0x38,
  0x50, 0x88, 0xA2, 0x11, 0x8C, 0x43, 0x10, 0x8A, 0x21, 0x14, 0x44, 0x28,
  0x88, 0x91, 0x31, 0x23, 0x9C, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x2C, 0x08, 0x81,
  0x10, 0x62, 0x08, 0x43, 0x08, 0x41, 0x1F, 0xF2, 0x06, 0xC0, 0x50, 0x0A,
  0x01, 0x3F, 0x08, 0x22, 0x0C, 0x83, 0x20, 0xD8, 0x26, 0x19, 0xF8, 0x41,
  0x10, 0x24, 0x0B, 0x02, 0x81, 0xA0, 0x48, 0x33, 0xF0, 0x0F, 0x83, 0x18,
  0xC1, 0x10, 0x36, 0x06, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x4C, 0x08, 0x83, 0x18, 0xC1, 0xF0, 0x3F, 0x08, 0x62, 0x0C, 0x81,
  0x20, 0x58, 0x16, 0x05, 0x01, 0x40, 0x50, 0x14, 0x0F, 0x02, 0x80, 0xA0,
  0x48, 0x63, 0xF0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0xFC, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFC, 0x3F,
  0xC8, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x7F, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x90,
  0x16, 0x02, 0x80, 0x10, 0x02, 0x00, 0x43, 0xC8, 0x0B, 0x01, 0x60, 0x64,
  0x0C, 0x81, 0x18, 0xE0, 0xF0, 0x30, 0x12, 0x03, 0x20, 0x22, 0x02, 0x20,
  0x26, 0x02, 0x60, 0x27, 0xFE, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x04, 0x80,
  0x48, 0x0C, 0x80, 0x88, 0x08, 0x13, 0x22, 0x22, 0x26, 0x44, 0x44, 0xCC,
  0x88, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x13, 0x04, 0xC1, 0x10, 0xC6, 0x60, 0xF0, 0x30, 0x62, 0x04,
  0x20, 0x82, 0x10, 0x22, 0x06, 0x40, 0x6C, 0x05, 0x80, 0x7C, 0x06, 0x40,
  0x46, 0x0C, 0x20, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0x30, 0x40, 0x81,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x7F, 0x30,
  0x06, 0x60, 0x1C, 0xC0, 0x31, 0xC0, 0xE2, 0x81, 0x4D, 0x06, 0x92, 0x0B,
  0x24, 0x34, 0x48, 0x48, 0x91, 0x91, 0x12, 0x26, 0x2C, 0x48, 0x51, 0x90,
  0xE2, 0x21, 0x84, 0x43, 0x08, 0x30, 0x13, 0x03, 0x30, 0x32, 0x82, 0x28,
  0x26, 0xC2, 0x64, 0x24, 0x46, 0x46, 0x64, 0x24, 0x42, 0x4C, 0x34, 0x81,
  0x48, 0x1C, 0x80, 0xC8, 0x08, 0x0F, 0x83, 0x18, 0xC1, 0x10, 0x36, 0x02,
  0x80, 0x50, 0x1A, 0x03, 0x40, 0x58, 0x0A, 0x01, 0x60, 0x2C, 0x08, 0x83,
  0x18, 0xC1, 0xF0, 0x3F, 0x88, 0x32, 0x04, 0x81, 0x20, 0x58, 0x16, 0x0D,
  0x06, 0x7F, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F,
  0x83, 0x18, 0xC1, 0x10, 0x36, 0x02, 0x80, 0x50, 0x1A, 0x02, 0xC0, 0x58,
  0x0A, 0x01, 0x40, 0x6C, 0x08, 0x83, 0x18, 0xC1, 0xF0, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x58, 0x14, 0x09, 0x06,
  0x7E, 0x10, 0x84, 0x23, 0x0C, 0x81, 0x20, 0x48, 0x12, 0x06, 0x0F, 0x0C,
  0x62, 0x0D, 0x81, 0x60, 0x58, 0x03, 0x00, 0x70, 0x06, 0x00, 0x40, 0x1A,
  0x06, 0x81, 0xA0, 0x44, 0x30, 0xF0, 0xFF, 0xC3, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x24, 0x04, 0x80, 0x90, 0x36, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x1B, 0x02, 0x60, 0x4C, 0x09, 0x83, 0x18, 0xC1, 0xF0,
  0x80, 0x50, 0x0B, 0x02, 0x60, 0x44, 0x18, 0x82, 0x10, 0xC2, 0x10, 0x46,
  0x08, 0x81, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x81, 0x03,
  0x02, 0x0E, 0x0C, 0x16, 0x14, 0x2C, 0x68, 0xD8, 0x91, 0x11, 0x22, 0x24,
  0x4C, 0x48, 0x90, 0x91, 0x21, 0x42, 0xC2, 0x85, 0x06, 0x0A, 0x0C, 0x18,
  0x18, 0x30, 0x20, 0x60, 0x30, 0x31, 0x02, 0x18, 0x40, 0x8C, 0x08, 0x80,
  0xD0, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1B, 0x01, 0x10, 0x31, 0x06,
  0x18, 0x40, 0x88, 0x0C, 0xC0, 0x70, 0x24, 0x19, 0x04, 0x63, 0x08, 0x82,
  0x40, 0xB0, 0x38, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x1F, 0xE0, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x07, 0xFC, 0x1C, 0x41,
  0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41, 0x0C,
  0x20, 0xE0, 0x8C, 0x44, 0x44, 0x44, 0x62, 0x22, 0x22, 0x22, 0x10, 0x1C,
  0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x41, 0x0C, 0x20,
  0x82, 0x08, 0xE0, 0x08, 0x61, 0x8A, 0x25, 0x14, 0x61, 0xFF, 0x89, 0x00,
  0x0F, 0x18, 0x88, 0x20, 0x10, 0x18, 0xF9, 0x84, 0x82, 0x41, 0x21, 0x91,
  0xC7, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0xF8, 0xE6, 0x41, 0x20,
  0x90, 0x48, 0x2C, 0x14, 0x0A, 0x0D, 0x04, 0xC6, 0x5E, 0x00, 0x1E, 0x63,
  0x41, 0xC1, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82, 0xC4, 0x78, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x87, 0x66, 0x39, 0x04, 0x41, 0x20, 0x48, 0x12,
  0x0C, 0x82, 0x20, 0x88, 0x23, 0x18, 0x7A, 0x00, 0x1E, 0x22, 0x41, 0xC1,
  0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0xC6, 0x7C, 0x0E, 0x30, 0x41, 0x82,
  0x0F, 0x88, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x80, 0x0E,
  0x4C, 0x62, 0x08, 0x82, 0x40, 0x90, 0x24, 0x19, 0x04, 0x41, 0x10, 0x46,
  0x30, 0xF4, 0x03, 0x00, 0x8C, 0x61, 0xF0, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0xB8, 0xA6, 0x61, 0x20, 0x90, 0x48, 0x2C, 0x34, 0x12, 0x09, 0x04,
  0x82, 0x41, 0x00, 0x22, 0x00, 0x66, 0x44, 0x44, 0xC8, 0x88, 0x88, 0x02,
  0x02, 0x00, 0x00, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x30, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x22, 0x10, 0x88, 0x24, 0x0A, 0x03, 0x81, 0xA0, 0x4C, 0x11,
  0x04, 0x61, 0x08, 0x43, 0x00, 0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0x88,
  0x88, 0x80, 0x27, 0x3C, 0x73, 0xCC, 0xC3, 0x09, 0x04, 0x12, 0x08, 0x2C,
  0x10, 0x50, 0x61, 0xA0, 0x82, 0x41, 0x04, 0x82, 0x09, 0x04, 0x16, 0x08,
  0x20, 0x37, 0x14, 0xCC, 0x24, 0x12, 0x09, 0x05, 0x86, 0x82, 0x41, 0x20,
  0x90, 0x48, 0x20, 0x1E, 0x23, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x46, 0x78, 0x2F, 0x1C, 0xC8, 0x24, 0x12, 0x0B, 0x05, 0x02, 0x81,
  0x41, 0xA0, 0x98, 0xDB, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x1C, 0xB1, 0x90,
  0x48, 0x28, 0x14, 0x0A, 0x0D, 0x04, 0x82, 0x41, 0x31, 0x8F, 0x40, 0x60,
  0x20, 0x10, 0x08, 0x3E, 0x70, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x00, 0x1E, 0x18, 0x88, 0x64, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x21, 0x99, 0x87, 0x80, 0x31, 0x09, 0xF2, 0x11, 0x88, 0x42, 0x10, 0x84,
  0x21, 0x80, 0x61, 0xA0, 0x90, 0x48, 0x24, 0x16, 0x0B, 0x0D, 0x04, 0x82,
  0x41, 0x31, 0x8F, 0x40, 0xC1, 0x43, 0x42, 0x42, 0x44, 0x44, 0x48, 0x48,
  0x38, 0x30, 0x30, 0x20, 0x84, 0x18, 0x42, 0x8E, 0x28, 0xA6, 0x9A, 0x49,
  0x24, 0x92, 0x8A, 0x28, 0xA2, 0x8C, 0x30, 0xC3, 0x0C, 0x20, 0x21, 0x90,
  0x84, 0xC2, 0xC1, 0xC0, 0x40, 0x60, 0x28, 0x24, 0x33, 0x10, 0x90, 0x40,
  0x30, 0x44, 0x31, 0x08, 0x46, 0x11, 0x04, 0x41, 0x20, 0x68, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x80, 0x3F, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x30, 0x1F, 0xC0, 0x04, 0x18,
  0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0xC2, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x03, 0x02, 0x00, 0x11, 0x11, 0x13, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0xC0, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18,
  0x18, 0x41, 0x02, 0x04, 0x08, 0x30, 0x40, 0x82, 0x08, 0x00, 0x38, 0x53,
  0x14, 0x6E, 0x0E,
};

const GFXglyph RobotoCondensed_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 5, 1, -16 },
  { 7, 5, 5, 6, 2, -17 },
  { 11, 11, 16, 11, 1, -16 },
  { 33, 9, 20, 10, 1, -18 },
  { 56, 10, 16, 14, 2, -16 },
  { 76, 9, 16, 11, 1, -16 },
  { 94, 2, 5, 4, 2, -17 },
  { 96, 6, 23, 6, 1, -18 },
  { 114, 6, 23, 6, -1, -18 },
  { 132, 9, 9, 9, 1, -16 },
  { 143, 9, 11, 11, 1, -13 },
  { 156, 3, 5, 4, -1, -2 },
  { 158, 4, 1, 6, 1, -7 },
  { 159, 2, 2, 5, 0, -2 },
  { 160, 9, 17, 8, -1, -16 },
  { 180, 9, 16, 10, 1, -16 },
  { 198, 5, 16, 10, 3, -16 },
  { 208, 10, 16, 10, 0, -16 },
  { 228, 9, 16, 10, 1, -16 },
  { 246, 10, 16, 10, 0, -16 },
  { 266, 10, 16, 10, 1, -16 },
  { 286, 8, 16, 10, 1, -16 },
  { 302, 9, 16, 10, 2, -16 },
  { 320, 9, 16, 10, 1, -16 },
  { 338, 8, 16, 10, 2, -16 },
  { 354, 4, 12, 4, 0, -12 },
  { 360, 5, 15, 4, -1, -12 },
  { 370, 8, 10, 10, 1, -12 },
  { 380, 8, 5, 10, 1, -10 },
  { 385, 8, 10, 10, 1, -12 },
  { 395, 7, 16, 9, 2, -16 },
  { 409, 15, 20, 17, 1, -15 },
  { 447, 11, 16, 12, -1, -16 },
  { 469, 10, 16, 11, 1, -16 },
  { 489, 11, 16, 12, 1, -16 },
  { 511, 10, 16, 12, 1, -16 },
  { 531, 10, 16, 11, 1, -16 },
  { 551, 10, 16, 10, 1, -16 },
  { 571, 11, 16, 13, 1, -16 },
  { 593, 12, 16, 13, 1, -16 },
  { 617, 4, 16, 5, 1, -16 },
  { 625, 10, 16, 10, 0, -16 },
  { 645, 12, 16, 12, 1, -16 },
  { 669, 7, 16, 10, 1, -16 },
  { 683, 15, 16, 16, 1, -16 },
  { 713, 12, 16, 13, 1, -16 },
  { 737, 11, 16, 13, 1, -16 },
  { 759, 10, 16, 12, 1, -16 },
  { 779, 11, 19, 13, 1, -16 },
  { 806, 10, 16, 12, 1, -16 },
  { 826, 10, 16, 11, 1, -16 },
  { 846, 10, 16, 11, 2, -16 },
  { 866, 11, 16, 12, 1, -16 },
  { 888, 11, 16, 12, 2, -16 },
  { 910, 15, 16, 16, 2, -16 },
  { 940, 12, 16, 11, 0, -16 },
  { 964, 10, 16, 11, 2, -16 },
  { 984, 11, 16, 11, 0, -16 },
  { 1006, 6, 21, 5, 0, -18 },
  { 1022, 4, 17, 8, 2, -16 },
  { 1031, 6, 21, 5, -1, -18 },
  { 1047, 6, 8, 8, 1, -16 },
  { 1053, 8, 1, 8, -1, 0 },
  { 1054, 3, 3, 6, 3, -17 },
  { 1056, 9, 12, 10, 0, -12 },
  { 1070, 9, 17, 10, 0, -17 },
  { 1090, 8, 12, 10, 1, -12 },
  { 1102, 10, 17, 10, 1, -17 },
  { 1124, 8, 12, 10, 1, -12 },
  { 1136, 7, 17, 6, 1, -17 },
  { 1151, 10, 16, 10, 0, -12 },
  { 1171, 9, 17, 10, 0, -17 },
  { 1191, 4, 16, 5, 1, -16 },
  { 1199, 8, 20, 5, -3, -16 },
  { 1219, 10, 17, 9, 0, -17 },
  { 1241, 4, 17, 5, 1, -17 },
  { 1250, 15, 12, 16, 0, -12 },
  { 1273, 9, 12, 10, 0, -12 },
  { 1287, 8, 12, 10, 1, -12 },
  { 1299, 9, 16, 10, 0, -12 },
  { 1317, 9, 16, 10, 1, -12 },
  { 1335, 7, 12, 6, 0, -12 },
  { 1346, 9, 12, 10, 0, -12 },
  { 1360, 5, 15, 6, 1, -15 },
  { 1370, 9, 12, 10, 1, -12 },
  { 1384, 8, 12, 9, 1, -12 },
  { 1396, 12, 12, 14, 2, -12 },
  { 1414, 9, 12, 9, 0, -12 },
  { 1428, 10, 16, 9, -1, -12 },
  { 1448, 9, 12, 9, 0, -12 },
  { 1462, 7, 21, 6, 1, -17 },
  { 1481, 4, 19, 5, 0, -16 },
  { 1491, 7, 21, 6, -1, -17 },
  { 1510, 10, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC22PT7B_H_
