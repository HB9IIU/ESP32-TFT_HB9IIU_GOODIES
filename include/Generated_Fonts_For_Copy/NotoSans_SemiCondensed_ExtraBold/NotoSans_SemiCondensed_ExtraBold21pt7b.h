#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x00, 0xFF, 0xF0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x1D,
  0xC1, 0xDC, 0x19, 0x8F, 0xFF, 0xFF, 0xF3, 0x98, 0x3B, 0x83, 0x38, 0x33,
  0x00, 0x08, 0x02, 0x07, 0xFB, 0xFE, 0xE9, 0xBA, 0x0F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0xBE, 0x27, 0xEB, 0xBF, 0xEF, 0xF0, 0x20, 0x08, 0x00, 0x78,
  0x38, 0x7E, 0x18, 0x33, 0x1C, 0x19, 0x8C, 0x0C, 0xEE, 0x06, 0x66, 0x03,
  0x37, 0x79, 0xFB, 0x3E, 0x7B, 0xBB, 0x81, 0x9D, 0xC1, 0xCE, 0xE0, 0xE7,
  0x70, 0xE3, 0xB8, 0x70, 0xF8, 0x70, 0x78, 0x1F, 0x01, 0xFE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xFE, 0x03, 0xF0, 0x1F, 0x8E, 0xFF, 0x7B, 0x9F,
  0xCE, 0x3F, 0x38, 0x78, 0xFF, 0xF3, 0xFF, 0xE3, 0xF7, 0xC0, 0xFF, 0xFE,
  0x3C, 0xE7, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C,
  0x38, 0xF0, 0xF1, 0xC3, 0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0x8E, 0x33, 0xC0, 0x0E, 0x03, 0x84, 0xE5, 0xFF, 0x7F, 0xE3, 0x81,
  0xF0, 0xEE, 0x73, 0x84, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xFF,
  0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xEE, 0xEC, 0xFF, 0xFE,
  0xFF, 0xF0, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x3E, 0x1F, 0xCF, 0xFB, 0xCE,
  0xE3, 0xB8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3B, 0xCE, 0x7F, 0x9F,
  0xC3, 0xE0, 0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x3E, 0x3F, 0xCF, 0xF9, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0x3F, 0xEF, 0xF9, 0x0E, 0x03, 0x81, 0xC3, 0xE0, 0xF8, 0x3F, 0x80,
  0xE0, 0x3E, 0x0E, 0xFF, 0xBF, 0xEF, 0xE0, 0x03, 0x80, 0xF0, 0x1E, 0x07,
  0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0x9C, 0x73, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x07, 0x00, 0xE0, 0x7F, 0xBF, 0xDF, 0xEE, 0x0F, 0x07, 0x73, 0xFD,
  0xFF, 0x07, 0x81, 0xC0, 0xF0, 0x7F, 0xFF, 0xFB, 0xF8, 0x1F, 0x8F, 0xE7,
  0xF9, 0xC0, 0xE0, 0x3B, 0xCF, 0xFB, 0xFE, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xFF, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x80, 0x3F,
  0x1F, 0xEF, 0x7B, 0x8E, 0xF3, 0x9F, 0xE7, 0xF0, 0xF8, 0x7F, 0xB8, 0xEE,
  0x3F, 0x8F, 0xF3, 0xBF, 0xE3, 0xF0, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3,
  0xB8, 0xFE, 0x3F, 0xFF, 0x7F, 0xCE, 0xE0, 0x38, 0x1E, 0x7F, 0x1F, 0x87,
  0xC0, 0x6F, 0xF6, 0x00, 0x00, 0x0F, 0xFF, 0x6F, 0xF6, 0x00, 0x00, 0x07,
  0xFE, 0xEE, 0xC0, 0x00, 0x40, 0xF0, 0xFC, 0xFC, 0xFC, 0x38, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xF9, 0xF8,
  0xF8, 0x38, 0x08, 0x00, 0x7F, 0x7F, 0xDF, 0xE8, 0x70, 0x38, 0x3C, 0x3C,
  0x3C, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x70, 0x07, 0xF0, 0x1F,
  0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x63, 0xF6, 0xE7, 0xF7, 0xEE, 0x77, 0xCC,
  0x77, 0xCC, 0x77, 0xCC, 0x77, 0xCE, 0xF6, 0xE7, 0xFC, 0x63, 0x18, 0x70,
  0x00, 0x3E, 0x70, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x07, 0xF0, 0x1D, 0xC0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x38, 0xF0, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFE, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xC0, 0xFF, 0x3F,
  0xEF, 0xFF, 0x8F, 0xE3, 0xF8, 0xEF, 0xFB, 0xFC, 0xFF, 0xF8, 0xFE, 0x1F,
  0x8F, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xC7, 0xFD, 0xFF, 0x3C, 0x2F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x17, 0xFC, 0x7F,
  0x87, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF1, 0xEF, 0xFD, 0xFF, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xF3, 0xFE, 0x7F, 0xE7, 0x80, 0xF0,
  0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F,
  0xF3, 0xFF, 0x1F, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x38, 0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xFF,
  0xC0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0xBF, 0xEF, 0xB0, 0xE1, 0xFC, 0x7B, 0x8E, 0x73, 0xCE, 0xF1, 0xDC,
  0x3F, 0x87, 0xF0, 0xFF, 0x1D, 0xE3, 0x9E, 0x73, 0xCE, 0x3D, 0xC3, 0xB8,
  0x78, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1B, 0xF6, 0x77, 0xEE, 0xEF, 0xDD, 0x9F, 0xBF,
  0x3F, 0x3E, 0x7E, 0x78, 0xFC, 0xF1, 0xF8, 0xE3, 0x80, 0xF0, 0x7F, 0x87,
  0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xEE, 0x7E, 0xF7, 0xE7, 0x7E, 0x7F,
  0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F,
  0xFC, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1E, 0xF0, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0xFE, 0x7F, 0xBF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xFF, 0xFF, 0x7E, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1E, 0xF0, 0xF7, 0xFF, 0x1F,
  0xF0, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0xFE, 0x1F, 0xF3,
  0xFE, 0x71, 0xEE, 0x3D, 0xC7, 0x39, 0xE7, 0xF8, 0xFE, 0x1D, 0xE3, 0x9C,
  0x73, 0xCE, 0x3D, 0xC7, 0xB8, 0x78, 0x3F, 0x3F, 0xFF, 0xFC, 0x2E, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xC0, 0xF0, 0x7F, 0xFF, 0xFB, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0,
  0xFF, 0xFC, 0xFF, 0x8F, 0xC0, 0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0xF1, 0xE7,
  0x8F, 0x1C, 0x70, 0xE3, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0xE0, 0xFE, 0x1E, 0x1D, 0xC3,
  0xC7, 0xB8, 0xF8, 0xE7, 0x1F, 0x1C, 0xF3, 0x63, 0x8E, 0x6E, 0xF1, 0xDD,
  0xDE, 0x3B, 0xBB, 0x87, 0x73, 0x70, 0xEC, 0x6E, 0x0F, 0x8F, 0xC1, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xC0, 0xF0, 0x7B, 0xC7, 0x8E, 0x38, 0x7B,
  0xC1, 0xDC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0x70,
  0x7B, 0xC7, 0x8F, 0x3C, 0x7B, 0xC1, 0xE0, 0xF0, 0x77, 0x0F, 0x78, 0xE3,
  0x9E, 0x3D, 0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x81, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xFF, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x0F, 0x81, 0xB8, 0x77, 0x0C, 0x73, 0x8E, 0x60, 0xFC, 0x1C,
  0xFF, 0xFF, 0xF0, 0xF1, 0xE1, 0xC0, 0x1E, 0x1F, 0xE7, 0xF9, 0x0E, 0x03,
  0xDF, 0xFF, 0xFF, 0x8F, 0xE3, 0xFD, 0xFF, 0xDD, 0xE7, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x71, 0xFF, 0x3F, 0xF7, 0x8E, 0xF1, 0xDE, 0x3F, 0xC7,
  0xF8, 0xEF, 0x1D, 0xFF, 0xBF, 0xF7, 0x7C, 0x1E, 0x1F, 0xDF, 0xDE, 0x2F,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x7F, 0x9F, 0xC7, 0xE0, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x39, 0xDF, 0x77, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xF1, 0xFF, 0xF7, 0xFC, 0xF7, 0x1E, 0x1F, 0xC7, 0xFB, 0xCF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x3E, 0x67, 0xF8, 0xFE, 0x1F, 0x3F, 0x3F, 0x38,
  0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x39, 0xDF, 0xF7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFF,
  0xF7, 0xFC, 0xF7, 0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF7, 0x3F, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0xF3, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x1F, 0xE3, 0xBC, 0xF7, 0xBC, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0xCF, 0x39,
  0xE7, 0xBC, 0x77, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0x0E, 0x77, 0xFF, 0xBF, 0xFF, 0xDE, 0x7C, 0xFF, 0x1C, 0x7F, 0x8E,
  0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE,
  0x38, 0xF0, 0xE7, 0x3B, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0x1E, 0x0F, 0xE7, 0xFB, 0xCF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xF1, 0xDE, 0xF7, 0xF8, 0xFC, 0xE7, 0x1D, 0xF3, 0xFF,
  0x78, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8E, 0xF1, 0xDF, 0xFB, 0xFF, 0x7F,
  0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x39, 0xDF, 0xF7, 0xFF,
  0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFF, 0xF7, 0xFC, 0xF7, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE7, 0xEF, 0xFE, 0xFE, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3C, 0x7F, 0xFE, 0xE2, 0xF0, 0xFC,
  0x7E, 0x1F, 0x07, 0xCF, 0xFF, 0xFE, 0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xF7, 0xFC, 0xF3, 0xF0,
  0xFE, 0x1D, 0xC7, 0xB8, 0xE7, 0x9C, 0x77, 0x8E, 0xE1, 0xDC, 0x1F, 0x83,
  0xE0, 0x7C, 0x07, 0x80, 0xF1, 0xC3, 0xF9, 0xF3, 0xDC, 0xF9, 0xCE, 0x6C,
  0xE7, 0x36, 0x73, 0xDB, 0xB8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x3E, 0x1F,
  0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF1, 0xEF, 0x3D, 0xEF, 0x1F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0x79, 0xE7, 0x78, 0xF0, 0xF0,
  0xFE, 0x1D, 0xC7, 0xB8, 0xE7, 0x9C, 0x77, 0x8E, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x7F,
  0xBF, 0xDF, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF0, 0x7C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x3E, 0x3C, 0xFB, 0xC7,
  0x0E, 0x1C, 0x38, 0xF1, 0xE0, 0xF8, 0x7F, 0xF8, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 12, 15, 13, 0, -15 },
  { 37, 10, 17, 11, 1, -16 },
  { 59, 17, 15, 18, 1, -15 },
  { 91, 14, 15, 15, 1, -15 },
  { 118, 3, 5, 6, 1, -15 },
  { 120, 6, 18, 7, 1, -15 },
  { 134, 6, 18, 7, 0, -15 },
  { 148, 10, 10, 11, 0, -16 },
  { 161, 10, 11, 11, 1, -13 },
  { 175, 4, 6, 6, 1, -3 },
  { 178, 5, 3, 7, 1, -7 },
  { 180, 4, 3, 6, 1, -3 },
  { 182, 9, 15, 9, 0, -15 },
  { 199, 10, 15, 11, 1, -15 },
  { 218, 8, 15, 11, 1, -15 },
  { 233, 10, 15, 11, 1, -15 },
  { 252, 10, 15, 11, 1, -15 },
  { 271, 11, 15, 11, 0, -15 },
  { 292, 9, 15, 11, 1, -15 },
  { 309, 10, 15, 11, 1, -15 },
  { 328, 10, 15, 11, 1, -15 },
  { 347, 10, 15, 11, 1, -15 },
  { 366, 10, 15, 11, 1, -15 },
  { 385, 4, 12, 6, 1, -12 },
  { 391, 4, 15, 6, 1, -12 },
  { 399, 10, 11, 11, 1, -13 },
  { 413, 10, 7, 11, 1, -11 },
  { 422, 10, 11, 11, 1, -13 },
  { 436, 9, 15, 9, 0, -15 },
  { 453, 16, 17, 18, 1, -15 },
  { 487, 14, 15, 14, 0, -15 },
  { 514, 10, 15, 13, 2, -15 },
  { 533, 11, 15, 12, 1, -15 },
  { 554, 11, 15, 14, 2, -15 },
  { 575, 8, 15, 11, 2, -15 },
  { 590, 8, 15, 11, 2, -15 },
  { 605, 12, 15, 14, 1, -15 },
  { 628, 11, 15, 15, 2, -15 },
  { 649, 6, 15, 8, 1, -15 },
  { 661, 6, 20, 7, -1, -15 },
  { 676, 11, 15, 13, 2, -15 },
  { 697, 8, 15, 11, 2, -15 },
  { 712, 15, 15, 19, 2, -15 },
  { 741, 12, 15, 16, 2, -15 },
  { 764, 13, 15, 15, 1, -15 },
  { 789, 9, 15, 12, 2, -15 },
  { 806, 13, 19, 15, 1, -15 },
  { 837, 11, 15, 13, 2, -15 },
  { 858, 9, 15, 11, 1, -15 },
  { 875, 11, 15, 11, 0, -15 },
  { 896, 11, 15, 15, 2, -15 },
  { 917, 13, 15, 13, 0, -15 },
  { 942, 19, 15, 19, 0, -15 },
  { 978, 13, 15, 13, 0, -15 },
  { 1003, 12, 15, 12, 0, -15 },
  { 1026, 11, 15, 11, 0, -15 },
  { 1047, 5, 18, 7, 1, -15 },
  { 1059, 9, 15, 9, 0, -15 },
  { 1076, 6, 18, 7, 0, -15 },
  { 1090, 11, 10, 11, 0, -15 },
  { 1104, 10, 2, 9, 0, 2 },
  { 1107, 6, 3, 8, 1, -16 },
  { 1110, 10, 12, 12, 1, -12 },
  { 1125, 11, 16, 12, 1, -16 },
  { 1147, 9, 12, 10, 1, -12 },
  { 1161, 10, 16, 12, 1, -16 },
  { 1181, 10, 12, 12, 1, -12 },
  { 1196, 8, 16, 8, 0, -16 },
  { 1212, 10, 17, 12, 1, -12 },
  { 1234, 10, 16, 13, 1, -16 },
  { 1254, 4, 16, 6, 1, -16 },
  { 1262, 6, 21, 6, -1, -16 },
  { 1278, 11, 16, 12, 1, -16 },
  { 1300, 4, 16, 6, 1, -16 },
  { 1308, 17, 12, 19, 1, -12 },
  { 1334, 10, 12, 13, 1, -12 },
  { 1349, 10, 12, 12, 1, -12 },
  { 1364, 11, 17, 12, 1, -12 },
  { 1388, 10, 17, 12, 1, -12 },
  { 1410, 8, 12, 9, 1, -12 },
  { 1422, 8, 12, 10, 1, -12 },
  { 1434, 8, 14, 9, 0, -14 },
  { 1448, 10, 12, 13, 1, -12 },
  { 1463, 11, 12, 11, 0, -12 },
  { 1480, 17, 12, 17, 0, -12 },
  { 1506, 11, 12, 11, 0, -12 },
  { 1523, 11, 17, 11, 0, -12 },
  { 1547, 9, 12, 10, 0, -12 },
  { 1561, 8, 18, 8, 0, -15 },
  { 1579, 2, 21, 10, 4, -16 },
  { 1585, 7, 18, 8, 1, -15 },
  { 1601, 10, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD21PT7B_H_
