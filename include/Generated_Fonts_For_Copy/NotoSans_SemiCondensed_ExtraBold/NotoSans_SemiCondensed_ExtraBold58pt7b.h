#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x83, 0x00, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0x87, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8,
  0x7F, 0xDF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF7, 0xBF, 0xCF, 0xF8, 0xF0, 0x71, 0xFF, 0x1E,
  0x01, 0x3F, 0xE3, 0xC0, 0x07, 0xFC, 0x78, 0x00, 0xFF, 0xCF, 0x00, 0x0F,
  0xFD, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xF7, 0xFE, 0x00, 0x1E, 0x7F, 0xC0, 0x03, 0xC7, 0xF8, 0x00,
  0x78, 0xFF, 0x40, 0x0F, 0x1F, 0xEF, 0x01, 0xE7, 0xFD, 0xFE, 0x3F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE3, 0xF8, 0x04, 0x01, 0xFC, 0x3F, 0x87,
  0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xC7, 0xF9, 0xFE, 0x3F,
  0x8F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFC,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0x8F, 0xE3,
  0xF8, 0xFF, 0x0F, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x1F,
  0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE1,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE,
  0x3F, 0xF0, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE3,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xC0,
  0xFC, 0x0E, 0x7F, 0x1F, 0x8F, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0x07, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC,
  0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x0F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF,
  0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFE, 0x03,
  0xFE, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF, 0xE7, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xF7, 0xFC,
  0xFF, 0x9F, 0xC7, 0xFC, 0x78, 0x7F, 0xE1, 0x83, 0xFF, 0x08, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xC7, 0xE0, 0x1F,
  0xF8, 0x78, 0x01, 0xFF, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0x01, 0xFF, 0xC3, 0x80, 0x1F, 0xF8, 0x20,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFE, 0xFF, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x1F, 0xCF, 0xF8, 0x00,
  0xFF, 0x3F, 0xE0, 0x03, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0xFF,
  0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x03,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x00, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF9,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE1, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0xE0, 0x03, 0xFF,
  0xBF, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x9F, 0xFE, 0x0F, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF9, 0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0,
  0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xDF, 0xF8, 0x1F,
  0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0x1F, 0xFF, 0xDF, 0xE1, 0xFF, 0xF3, 0xFC, 0x1F, 0xFC, 0xFF, 0x80, 0xFC,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x80, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x0C, 0x00, 0x1F,
  0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFF, 0x3F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x3F, 0x01, 0xFF, 0x8C, 0x00, 0x7F, 0xC4, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF,
  0x8F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x3F, 0x81, 0xFF, 0xFF, 0x87,
  0xF3, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x7F, 0x07, 0xFC, 0x3F, 0x83, 0xF7,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x7F, 0x0F, 0xF0, 0x3F, 0x83, 0xF7, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF7, 0xE1, 0xFC,
  0x03, 0xF8, 0x3F, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0xE1, 0xFC, 0x03,
  0xF8, 0x3F, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0xE1, 0xFC, 0x07, 0xF8,
  0x7F, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x7E,
  0x7E, 0x0F, 0xE0, 0xFF, 0x8F, 0xE7, 0xE0, 0xFF, 0x0F, 0xF8, 0xFE, 0x7F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0x03,
  0xFF, 0xE7, 0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xFF,
  0x81, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF,
  0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xE0, 0xFF, 0xF0, 0x01, 0x83,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x10, 0xFF, 0xF0, 0x01, 0xC1, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7C, 0x3F, 0xFE, 0x00, 0x18,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF,
  0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xFC, 0x01, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xB1, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xF3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFD, 0xFF, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0xFF, 0xEF, 0xF0,
  0x0F, 0xE7, 0xFF, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F,
  0x9F, 0xFF, 0xF3, 0xF8, 0x0F, 0xF3, 0xFF, 0xFE, 0x7F, 0x81, 0xFC, 0xFF,
  0xFF, 0xCF, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F,
  0x87, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0xFF, 0xC1, 0xFD, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F,
  0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xF8,
  0x1F, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0x9F,
  0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F,
  0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFC, 0x7F, 0xFE, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0x1F, 0xF8, 0x01, 0xC7,
  0xFC, 0x00, 0x11, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x7F, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF3,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0xC3,
  0xF8, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x80, 0x1F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0xFE, 0x3F, 0xE0,
  0x03, 0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xF3, 0xF8, 0x3F, 0xDF,
  0xF0, 0x00, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x07,
  0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F,
  0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xF0, 0x3C,
  0x03, 0xFF, 0x04, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFE, 0x7F, 0xFF, 0x3F, 0xC7, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0x7F, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF8,
  0x0F, 0xF9, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xF0, 0xFF, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xF0, 0x04, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x04, 0xFF, 0xE0, 0x06, 0x3F, 0xF8, 0x1F, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x83, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0x7F, 0xE1, 0xFF, 0xFD, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1,
  0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F,
  0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFF, 0x87, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xF8, 0x7F, 0xFE, 0x7F, 0xC1, 0xFF, 0xE1,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x03,
  0xFE, 0x7F, 0xE0, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x04, 0x3F, 0xF0, 0x01,
  0xC3, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x05, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0x04, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xC3, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x7F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xFC, 0x1F, 0xFE, 0x7F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x00, 0x30, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE2, 0x00, 0x03, 0xFF, 0x1E, 0x00, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x0F, 0xF9, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0x04, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFF, 0x3F, 0x81, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xC0,
  0x00, 0x10, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80,
  0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF7,
  0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xEF,
  0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFC,
  0x03, 0xFF, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x07, 0xFC,
  0x0F, 0xE1, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F,
  0xE7, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF1, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0x0F,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07,
  0xFE, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xF0, 0xFF, 0x9F,
  0xFE, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x80, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xC3, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x7F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xFC, 0x1F, 0xFE, 0x7F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x00, 0x38, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xF8, 0xFE, 0x7F, 0xC0, 0x38,
  0xFF, 0x80, 0x11, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x61, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0x9F,
  0xC7, 0xFF, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x1F, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF9,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x3F, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFD, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xF7, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xDF, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0x7F, 0x0F, 0xF8, 0x1F, 0xE1, 0xFC, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7,
  0xE3, 0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0x8F, 0xE3, 0xFC, 0x07, 0xFC, 0xFE,
  0x3F, 0x9F, 0xF0, 0x0F, 0xF3, 0xF8, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xE1,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0x07, 0xF7, 0xF8, 0x03, 0xFE, 0xFC, 0x1F,
  0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x23, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xD0, 0x00, 0x7F, 0xF2, 0x00,
  0x00, 0x60, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 42, 16, 3, -41 },
  { 54, 22, 15, 28, 3, -41 },
  { 96, 33, 41, 35, 1, -41 },
  { 266, 27, 47, 31, 2, -44 },
  { 425, 47, 42, 51, 2, -42 },
  { 672, 39, 43, 41, 2, -42 },
  { 882, 9, 15, 15, 3, -41 },
  { 899, 16, 51, 20, 2, -42 },
  { 1001, 16, 51, 20, 1, -42 },
  { 1103, 27, 26, 30, 1, -44 },
  { 1191, 27, 29, 32, 2, -35 },
  { 1289, 11, 16, 16, 2, -8 },
  { 1311, 15, 7, 18, 2, -19 },
  { 1325, 10, 11, 16, 3, -10 },
  { 1339, 24, 42, 24, 0, -42 },
  { 1465, 27, 43, 31, 2, -42 },
  { 1611, 21, 41, 31, 3, -41 },
  { 1719, 27, 42, 31, 2, -42 },
  { 1861, 27, 43, 31, 2, -42 },
  { 2007, 30, 41, 31, 1, -41 },
  { 2161, 26, 42, 31, 3, -41 },
  { 2298, 28, 43, 31, 2, -42 },
  { 2449, 27, 41, 31, 2, -41 },
  { 2588, 28, 43, 31, 2, -42 },
  { 2739, 27, 43, 31, 2, -42 },
  { 2885, 10, 33, 16, 3, -32 },
  { 2927, 11, 40, 16, 2, -32 },
  { 2982, 27, 30, 32, 2, -36 },
  { 3084, 27, 19, 32, 2, -30 },
  { 3149, 27, 30, 32, 2, -36 },
  { 3251, 25, 43, 26, 0, -42 },
  { 3386, 44, 47, 49, 2, -42 },
  { 3645, 38, 42, 38, 0, -42 },
  { 3845, 29, 41, 36, 4, -41 },
  { 3994, 30, 43, 34, 3, -42 },
  { 4156, 32, 41, 39, 4, -41 },
  { 4320, 23, 41, 30, 4, -41 },
  { 4438, 23, 41, 29, 4, -41 },
  { 4556, 32, 43, 39, 3, -42 },
  { 4728, 32, 41, 41, 4, -41 },
  { 4892, 18, 41, 22, 2, -41 },
  { 4985, 18, 54, 19, -4, -41 },
  { 5107, 32, 41, 36, 4, -41 },
  { 5271, 24, 41, 30, 4, -41 },
  { 5394, 43, 41, 52, 4, -41 },
  { 5615, 35, 41, 44, 4, -41 },
  { 5795, 36, 43, 42, 3, -42 },
  { 5989, 28, 41, 34, 4, -41 },
  { 6133, 36, 52, 42, 3, -42 },
  { 6367, 32, 41, 36, 4, -41 },
  { 6531, 26, 43, 30, 2, -42 },
  { 6671, 29, 41, 31, 1, -41 },
  { 6820, 32, 42, 40, 4, -41 },
  { 6988, 36, 41, 36, 0, -41 },
  { 7173, 53, 41, 53, 0, -41 },
  { 7445, 36, 41, 36, 0, -41 },
  { 7630, 34, 41, 34, 0, -41 },
  { 7805, 29, 41, 31, 1, -41 },
  { 7954, 14, 51, 19, 3, -42 },
  { 8044, 24, 42, 24, 0, -42 },
  { 8170, 14, 51, 19, 1, -42 },
  { 8260, 30, 27, 32, 1, -42 },
  { 8362, 26, 5, 26, 0, 5 },
  { 8379, 17, 9, 21, 2, -44 },
  { 8399, 27, 33, 33, 2, -32 },
  { 8511, 28, 45, 34, 4, -44 },
  { 8669, 25, 33, 28, 2, -32 },
  { 8773, 29, 45, 34, 2, -44 },
  { 8937, 28, 33, 32, 2, -32 },
  { 9053, 22, 44, 21, 1, -44 },
  { 9174, 29, 46, 34, 2, -32 },
  { 9341, 28, 44, 35, 4, -44 },
  { 9495, 10, 45, 17, 3, -45 },
  { 9552, 16, 59, 17, -3, -45 },
  { 9670, 30, 44, 34, 4, -44 },
  { 9835, 9, 44, 17, 4, -44 },
  { 9885, 45, 32, 53, 4, -32 },
  { 10065, 28, 32, 35, 4, -32 },
  { 10177, 29, 33, 34, 2, -32 },
  { 10297, 28, 46, 34, 4, -32 },
  { 10458, 29, 46, 34, 2, -32 },
  { 10625, 20, 32, 24, 4, -32 },
  { 10705, 23, 33, 27, 2, -32 },
  { 10800, 21, 39, 24, 1, -38 },
  { 10903, 27, 33, 35, 4, -32 },
  { 11015, 32, 32, 32, 0, -32 },
  { 11143, 46, 32, 47, 1, -32 },
  { 11327, 31, 32, 32, 0, -32 },
  { 11451, 32, 46, 32, 0, -32 },
  { 11635, 24, 32, 26, 1, -32 },
  { 11731, 20, 51, 23, 1, -42 },
  { 11859, 7, 57, 29, 11, -44 },
  { 11909, 20, 51, 23, 2, -42 },
  { 12037, 27, 11, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD58PT7B_H_
