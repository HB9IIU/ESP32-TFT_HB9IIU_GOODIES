#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x5C, 0xB4, 0x28, 0xA7, 0xDE, 0xFD, 0x45, 0x00, 0x23, 0xFB,
  0xC7, 0x1F, 0xEE, 0x20, 0x66, 0x7A, 0x3E, 0x0D, 0xE1, 0x58, 0xA8, 0x8C,
  0x78, 0xB1, 0xE3, 0xBD, 0xD9, 0x9F, 0x80, 0xC0, 0x69, 0x6C, 0x93, 0x20,
  0xCD, 0x92, 0xDA, 0xC0, 0x21, 0x3E, 0xE5, 0x00, 0x21, 0x3E, 0x42, 0x00,
  0x70, 0xE0, 0x70, 0x33, 0x26, 0x44, 0xC0, 0x72, 0xF7, 0xBD, 0xAD, 0xC0,
  0x3F, 0x73, 0x33, 0x30, 0xF2, 0xC6, 0x62, 0x23, 0xE0, 0xFA, 0xC6, 0xE1,
  0xCF, 0xC0, 0x11, 0x9C, 0xAF, 0xFC, 0x40, 0x7A, 0x1C, 0xF1, 0xCF, 0xC0,
  0x7A, 0x3D, 0xFC, 0xAD, 0xC0, 0xF8, 0xC4, 0x63, 0x11, 0x80, 0x7A, 0xDE,
  0xED, 0xED, 0xE0, 0x76, 0xF6, 0xF3, 0x8D, 0xC0, 0x70, 0x70, 0x50, 0x1C,
  0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC3, 0x86, 0xE8, 0x00, 0xF9, 0x36,
  0x66, 0x60, 0x3E, 0x43, 0x5D, 0xF5, 0xF5, 0x5E, 0x62, 0x1C, 0x30, 0xE6,
  0x9A, 0x7F, 0x3C, 0x40, 0xF4, 0xE5, 0xE9, 0xCF, 0xC0, 0x3D, 0x94, 0x30,
  0x41, 0x93, 0x80, 0xF4, 0xE7, 0x19, 0xCF, 0xC0, 0xF8, 0x8E, 0x88, 0xF0,
  0xF8, 0x8E, 0x88, 0x80, 0x3D, 0x94, 0x37, 0x4D, 0xB3, 0xC0, 0x8C, 0x63,
  0xF8, 0xC6, 0x20, 0xF6, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0xE0, 0x9D,
  0xA9, 0xCB, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0x9F, 0xAD, 0x5A,
  0xB7, 0x64, 0x80, 0xCF, 0xBE, 0xEF, 0xBE, 0x78, 0xC0, 0x7C, 0xC9, 0x1E,
  0x34, 0x6D, 0x8F, 0x00, 0xF9, 0x9F, 0xE8, 0x80, 0x7C, 0xC9, 0x1E, 0x34,
  0x6D, 0x8F, 0x06, 0x06, 0xF4, 0xE5, 0xEB, 0x4A, 0x60, 0x7E, 0x58, 0xE1,
  0xCF, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18, 0xED, 0xC0,
  0xCF, 0x34, 0x9A, 0x78, 0xC3, 0x00, 0xC9, 0xEE, 0xD7, 0x6A, 0xA7, 0x53,
  0xB8, 0xCC, 0xCD, 0xE3, 0x8C, 0x79, 0xAC, 0xC0, 0xCD, 0x67, 0x8C, 0x30,
  0xC3, 0x00, 0xF8, 0xCC, 0x46, 0x23, 0xE0, 0xEA, 0xAB, 0xC0, 0xC4, 0x46,
  0x23, 0x10, 0xED, 0xB6, 0xDF, 0xE0, 0x23, 0x95, 0x90, 0xF8, 0xC4, 0x33,
  0xC6, 0xFD, 0xB4, 0x84, 0x29, 0xE9, 0x4E, 0x5E, 0x3B, 0xB1, 0x84, 0xB8,
  0x08, 0x4A, 0xFC, 0xE5, 0x2F, 0x33, 0xF3, 0xF4, 0xBC, 0x37, 0x4F, 0x44,
  0x44, 0x2B, 0xF3, 0x94, 0xBC, 0x2F, 0x88, 0xAF, 0x99, 0x99, 0xFF, 0x55,
  0x55, 0x70, 0x84, 0x23, 0x6A, 0x72, 0xD3, 0xFF, 0xA5, 0xFE, 0x4C, 0x99,
  0x32, 0x40, 0xAF, 0x99, 0x99, 0x33, 0xF3, 0x94, 0xBC, 0xA7, 0xA5, 0x39,
  0x7A, 0x10, 0x2B, 0xF3, 0x94, 0xBC, 0x21, 0xBE, 0x49, 0x00, 0x2F, 0xE7,
  0x9F, 0x44, 0xF4, 0x44, 0x70, 0x99, 0x99, 0x9F, 0xCE, 0xD6, 0xA7, 0x18,
  0xDB, 0x5B, 0x5E, 0x76, 0x66, 0xDB, 0x9C, 0xFD, 0x80, 0xCE, 0xD6, 0xE7,
  0x18, 0x9C, 0xFF, 0x36, 0x4F, 0x76, 0x66, 0xC6, 0x67, 0x30, 0xFF, 0xC0,
  0xC6, 0x66, 0x36, 0x6E, 0xC0, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 3, 2, 5, 1, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 9, 7, 9, 0, -7 },
  { 24, 7, 7, 7, 0, -7 },
  { 31, 1, 2, 3, 1, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 3, 9, 3, 0, -7 },
  { 40, 5, 5, 5, 0, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 4, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 5, 7, 5, 0, -7 },
  { 99, 5, 7, 5, 0, -7 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 7, 3, 0, -6 },
  { 108, 5, 5, 5, 0, -6 },
  { 112, 5, 3, 5, 0, -5 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 4, 7, 5, 0, -7 },
  { 122, 8, 8, 8, 0, -7 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 5, 7, 6, 1, -7 },
  { 141, 6, 7, 6, 0, -7 },
  { 147, 5, 7, 7, 1, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 4, 7, 5, 1, -7 },
  { 160, 6, 7, 7, 0, -7 },
  { 166, 5, 7, 7, 1, -7 },
  { 171, 4, 7, 4, 0, -7 },
  { 175, 3, 9, 3, -1, -7 },
  { 179, 5, 7, 6, 1, -7 },
  { 184, 4, 7, 5, 1, -7 },
  { 188, 7, 7, 9, 1, -7 },
  { 195, 6, 7, 8, 1, -7 },
  { 201, 7, 7, 7, 0, -7 },
  { 208, 4, 7, 6, 1, -7 },
  { 212, 7, 9, 7, 0, -7 },
  { 220, 5, 7, 6, 1, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 5, 7, 7, 1, -7 },
  { 240, 6, 7, 6, 0, -7 },
  { 246, 9, 7, 9, 0, -7 },
  { 254, 6, 7, 6, 0, -7 },
  { 260, 6, 7, 6, 0, -7 },
  { 266, 5, 7, 5, 0, -7 },
  { 271, 2, 9, 3, 1, -7 },
  { 274, 4, 7, 4, 0, -7 },
  { 278, 3, 9, 3, 0, -7 },
  { 282, 5, 4, 5, 0, -7 },
  { 285, 5, 1, 5, 0, 1 },
  { 286, 3, 2, 4, 0, -8 },
  { 287, 5, 6, 6, 0, -6 },
  { 291, 5, 8, 6, 1, -8 },
  { 296, 5, 6, 5, 0, -6 },
  { 300, 5, 8, 6, 0, -8 },
  { 305, 5, 6, 6, 0, -6 },
  { 309, 4, 8, 4, 0, -8 },
  { 313, 5, 8, 6, 0, -6 },
  { 318, 4, 8, 6, 1, -8 },
  { 322, 1, 8, 3, 1, -8 },
  { 323, 2, 10, 3, 0, -8 },
  { 326, 5, 8, 6, 1, -8 },
  { 331, 1, 8, 3, 1, -8 },
  { 332, 7, 6, 9, 1, -6 },
  { 338, 4, 6, 6, 1, -6 },
  { 341, 5, 6, 6, 0, -6 },
  { 345, 5, 8, 6, 1, -6 },
  { 350, 5, 8, 6, 0, -6 },
  { 355, 3, 6, 4, 1, -6 },
  { 358, 4, 6, 5, 0, -6 },
  { 361, 4, 7, 4, 0, -7 },
  { 365, 4, 6, 6, 1, -6 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 8, 5, 8, 0, -5 },
  { 377, 5, 5, 5, 0, -5 },
  { 381, 5, 8, 5, 0, -6 },
  { 386, 4, 6, 5, 0, -6 },
  { 389, 4, 9, 4, 0, -7 },
  { 394, 1, 10, 5, 2, -8 },
  { 396, 4, 9, 4, 0, -7 },
  { 401, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD10PT7B_H_
