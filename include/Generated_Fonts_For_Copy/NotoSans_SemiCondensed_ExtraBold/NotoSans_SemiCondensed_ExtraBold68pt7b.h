#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xF3, 0xFF, 0xBF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF9, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x78, 0x00, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x1F,
  0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF9, 0xF0, 0xFC,
  0x7F, 0xE3, 0xE0, 0x18, 0xFF, 0x87, 0xC0, 0x01, 0xFF, 0x0F, 0x80, 0x03,
  0xFF, 0x1F, 0x00, 0x07, 0xFE, 0x3E, 0x00, 0x0F, 0xFF, 0x7C, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xBF, 0xFC, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x7C,
  0x7F, 0xF0, 0x00, 0xF8, 0x7F, 0xF0, 0x01, 0xF1, 0xFF, 0xFC, 0x03, 0xE3,
  0xFF, 0xFF, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xFF,
  0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xC3, 0xFF,
  0xE0, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF,
  0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x3F, 0xF3, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFE, 0x3F, 0xE1, 0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x8F,
  0xFF, 0xBF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x0F, 0xE0,
  0x0C, 0xF8, 0x1F, 0xC0, 0xF9, 0xFE, 0x3F, 0x8F, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFE, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x7F, 0xE7, 0xFF, 0x3F, 0xE3, 0xFF, 0x8F, 0xE1, 0xFF, 0xC3,
  0xE0, 0xFF, 0xE0, 0xC0, 0x7F, 0xF0, 0x20, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFE, 0x0F, 0x80, 0x0F,
  0xFE, 0x0F, 0x00, 0x0F, 0xFE, 0x04, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0x00, 0x1F,
  0xFE, 0x04, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0x83, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x20, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xB0, 0x00, 0x0F, 0xFF, 0x7C, 0x00, 0x3F, 0xFE, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x7F, 0xF7, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xE0, 0x0F,
  0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x18,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF,
  0xE1, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFE, 0x03, 0xFF, 0xC7, 0x80, 0x0F, 0xFE, 0x10, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0xE1, 0xFE,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC7, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0x81, 0xFE,
  0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFE, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0xDF, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFB, 0xFC, 0x0F, 0xF8, 0x7F, 0xF1,
  0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF,
  0x1F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0x40,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x1F, 0xFE,
  0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF,
  0xBF, 0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFE,
  0x00, 0x3C, 0x0F, 0xFF, 0x80, 0x00, 0x83, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x60, 0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xF8, 0x01,
  0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0xCF,
  0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xBF,
  0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFE,
  0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x00, 0x0E, 0x07, 0xFF,
  0xE0, 0x00, 0x08, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFD,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xF3,
  0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xC7,
  0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFE, 0x00,
  0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF,
  0xEF, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xFE,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xDF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0x01,
  0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x1F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xC7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xEF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xFF, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFE, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xBF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xE1,
  0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00,
  0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0x8F, 0xFF, 0x00, 0x3E, 0x3F, 0xF8, 0x00,
  0x18, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F,
  0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x3F, 0xE0,
  0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFC, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF3, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07,
  0xFC, 0x7F, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE3, 0xFE,
  0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x3F, 0xC7, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0x00,
  0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x7F,
  0x9F, 0xF8, 0x00, 0x0F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC7, 0xFF, 0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xFE, 0x03, 0xC0, 0x0F, 0xFF, 0x01,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0x7F,
  0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x3C, 0x7F, 0xF8, 0x00,
  0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x02,
  0x7F, 0xFC, 0x00, 0xE7, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xF3,
  0xFF, 0x87, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xBF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xDF, 0xFE, 0x03, 0xFF,
  0xEF, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF9,
  0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0,
  0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0C, 0x3F, 0xFC, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF,
  0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xF0,
  0x3F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC6, 0x00, 0x01, 0xFF, 0xE3, 0xC0, 0x01, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xF8,
  0x7F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE3,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xBF,
  0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xEF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFB, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFC,
  0x7F, 0xE1, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0xFF,
  0xFB, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x70, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xFE, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0x3F, 0xF0, 0x03, 0x8F, 0xFC,
  0x00, 0x23, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x78, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF9,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x7F, 0x81, 0xFF, 0x83, 0xFF, 0x83,
  0xFD, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x3F, 0xC3, 0xFF,
  0x01, 0xFF, 0xC7, 0xF8, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xE3, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF1, 0xFE,
  0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xF8, 0x01, 0xFF,
  0x9F, 0xC1, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x07, 0xF9, 0xFF, 0x80,
  0x1F, 0xFB, 0xFC, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x3F, 0xBF,
  0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02,
  0x7F, 0xFC, 0x00, 0x05, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFA, 0x00,
  0x03, 0xFF, 0xE4, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 50, 19, 3, -49 },
  { 83, 25, 18, 33, 4, -49 },
  { 140, 39, 48, 41, 1, -48 },
  { 374, 31, 56, 37, 3, -52 },
  { 591, 56, 50, 60, 2, -49 },
  { 941, 46, 50, 48, 2, -49 },
  { 1229, 10, 18, 18, 4, -49 },
  { 1252, 19, 60, 23, 3, -49 },
  { 1395, 19, 60, 23, 1, -49 },
  { 1538, 31, 31, 35, 2, -52 },
  { 1659, 31, 33, 37, 3, -41 },
  { 1787, 14, 18, 19, 2, -9 },
  { 1819, 18, 9, 22, 2, -23 },
  { 1840, 13, 12, 19, 3, -11 },
  { 1860, 28, 50, 29, 0, -49 },
  { 2035, 32, 50, 37, 2, -49 },
  { 2235, 25, 49, 37, 3, -49 },
  { 2389, 32, 49, 37, 2, -49 },
  { 2585, 32, 50, 37, 2, -49 },
  { 2785, 35, 49, 37, 1, -49 },
  { 3000, 31, 50, 37, 3, -49 },
  { 3194, 33, 50, 37, 2, -49 },
  { 3401, 33, 49, 37, 2, -49 },
  { 3604, 33, 50, 37, 2, -49 },
  { 3811, 32, 50, 37, 2, -49 },
  { 4011, 13, 39, 19, 3, -38 },
  { 4075, 14, 47, 19, 2, -38 },
  { 4158, 31, 35, 37, 3, -42 },
  { 4294, 31, 22, 37, 3, -35 },
  { 4380, 31, 35, 37, 3, -42 },
  { 4516, 29, 50, 31, 0, -49 },
  { 4698, 51, 54, 57, 3, -49 },
  { 5043, 44, 49, 44, 0, -49 },
  { 5313, 34, 49, 42, 5, -49 },
  { 5522, 35, 50, 40, 3, -49 },
  { 5741, 38, 49, 46, 5, -49 },
  { 5974, 26, 49, 35, 5, -49 },
  { 6134, 26, 49, 34, 5, -49 },
  { 6294, 38, 50, 46, 3, -49 },
  { 6532, 38, 49, 48, 5, -49 },
  { 6765, 22, 49, 26, 2, -49 },
  { 6900, 21, 64, 22, -5, -49 },
  { 7068, 38, 49, 42, 5, -49 },
  { 7301, 28, 49, 35, 5, -49 },
  { 7473, 50, 49, 61, 5, -49 },
  { 7780, 41, 49, 51, 5, -49 },
  { 8032, 43, 50, 49, 3, -49 },
  { 8301, 32, 49, 40, 5, -49 },
  { 8497, 43, 61, 49, 3, -49 },
  { 8825, 37, 49, 42, 5, -49 },
  { 9052, 30, 50, 35, 3, -49 },
  { 9240, 34, 49, 36, 1, -49 },
  { 9449, 37, 50, 47, 5, -49 },
  { 9681, 42, 49, 42, 0, -49 },
  { 9939, 62, 49, 62, 0, -49 },
  { 10319, 42, 49, 42, 0, -49 },
  { 10577, 40, 49, 40, 0, -49 },
  { 10822, 33, 49, 37, 2, -49 },
  { 11025, 16, 60, 22, 4, -49 },
  { 11145, 28, 50, 29, 0, -49 },
  { 11320, 16, 60, 22, 2, -49 },
  { 11440, 35, 32, 37, 1, -49 },
  { 11580, 31, 7, 31, 0, 5 },
  { 11608, 19, 11, 25, 3, -52 },
  { 11635, 32, 39, 38, 2, -38 },
  { 11791, 33, 53, 40, 4, -52 },
  { 12010, 28, 39, 33, 3, -38 },
  { 12147, 33, 53, 40, 3, -52 },
  { 12366, 32, 39, 38, 3, -38 },
  { 12522, 26, 52, 25, 1, -52 },
  { 12691, 33, 54, 40, 3, -38 },
  { 12914, 33, 52, 41, 4, -52 },
  { 13129, 12, 52, 20, 4, -52 },
  { 13207, 19, 68, 20, -3, -52 },
  { 13369, 36, 52, 40, 4, -52 },
  { 13603, 11, 52, 20, 4, -52 },
  { 13675, 53, 38, 62, 4, -38 },
  { 13927, 33, 38, 41, 4, -38 },
  { 14084, 34, 39, 40, 3, -38 },
  { 14250, 33, 54, 40, 4, -38 },
  { 14473, 33, 54, 40, 3, -38 },
  { 14696, 24, 38, 29, 4, -38 },
  { 14810, 26, 39, 31, 3, -38 },
  { 14937, 25, 46, 28, 1, -45 },
  { 15081, 33, 38, 41, 4, -37 },
  { 15238, 37, 37, 37, 0, -37 },
  { 15410, 54, 37, 56, 1, -37 },
  { 15660, 37, 37, 37, 0, -37 },
  { 15832, 37, 53, 37, 0, -37 },
  { 16078, 27, 37, 31, 2, -37 },
  { 16203, 23, 60, 27, 1, -49 },
  { 16376, 8, 67, 34, 13, -52 },
  { 16443, 23, 60, 27, 2, -49 },
  { 16616, 31, 12, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD68PT7B_H_
