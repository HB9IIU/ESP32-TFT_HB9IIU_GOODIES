#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x00, 0x3E, 0xFB, 0xFF, 0xBE, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x0F, 0xF0, 0xF0, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x79,
  0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0x8F, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE1, 0xE7, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1C, 0x03, 0xC7,
  0x00, 0xF3, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xE0, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xBC, 0xF9, 0x84, 0xF9, 0x80, 0xFD, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xBF, 0x01, 0x9F, 0xC1, 0x9F, 0xF9, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x78,
  0x07, 0xF0, 0x0F, 0x01, 0xFF, 0x03, 0xC0, 0x7F, 0xE0, 0x78, 0x0F, 0x3C,
  0x1E, 0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x78, 0xF0, 0x07, 0x8F, 0x1E, 0x00,
  0xF1, 0xE7, 0x80, 0x1E, 0x3C, 0xF0, 0x83, 0xCF, 0xBC, 0xFE, 0x3F, 0xE7,
  0xBF, 0xE7, 0xFD, 0xE7, 0xFC, 0x7F, 0x3C, 0xF3, 0xC7, 0xCF, 0x3C, 0x78,
  0x01, 0xE7, 0x8F, 0x00, 0x78, 0xF1, 0xE0, 0x0F, 0x1E, 0x3C, 0x03, 0xC3,
  0xC7, 0x80, 0x78, 0x78, 0xF0, 0x1E, 0x07, 0xBE, 0x03, 0xC0, 0xFF, 0x80,
  0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x3E, 0x3F, 0xF0, 0xF9, 0xFF, 0xE7, 0xE7, 0xFF, 0xDF, 0x3F,
  0x3F, 0xFC, 0xFC, 0x7F, 0xF3, 0xF0, 0xFF, 0x8F, 0xC1, 0xFC, 0x3F, 0x8F,
  0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0x83, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x07, 0x87, 0xC7, 0xC3, 0xC3, 0xE1,
  0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x80,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x0E, 0x38, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xCF,
  0xC3, 0x8E, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7E, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFB, 0xEF, 0xFE, 0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x7E, 0x7C,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01,
  0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0x73,
  0xF2, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x78, 0x7E, 0x20,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x20, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x3E, 0xE0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3C, 0x7C, 0x7C,
  0x7C, 0x78, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x87, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xEC, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x40, 0xF9,
  0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0xFE, 0xFC,
  0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFE, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDE, 0x0F,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFB, 0xEF, 0xFE, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xEF, 0xBF, 0xFB, 0xE0, 0x7C, 0xF9, 0xFB, 0xE7, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBE, 0x7C, 0xF9, 0xE3,
  0xCF, 0x9E, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0xF8, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0xF8, 0x3E,
  0x3C, 0x78, 0xFF, 0xCF, 0x78, 0xFF, 0xE7, 0xBC, 0x7C, 0xF3, 0xDE, 0x78,
  0x78, 0xEE, 0x3C, 0x3C, 0x7F, 0x1E, 0x1E, 0x3F, 0x8E, 0x0F, 0x1F, 0xC7,
  0x07, 0x9F, 0xE3, 0xC7, 0xCF, 0xF1, 0xE3, 0xE7, 0xBC, 0xFF, 0xFF, 0x9E,
  0x3F, 0xFF, 0x8F, 0x0F, 0x8F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x81,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x3F,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3E,
  0xFC, 0x1F, 0x7E, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0x01, 0xF8,
  0x03, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE3, 0xF8, 0x11, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x4F, 0xF1, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF9, 0xF8, 0x7F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80,
  0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC0, 0x47,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xF7, 0xE0, 0x7D, 0xFE, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFC, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x87, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC3, 0xF9, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xC0, 0xF8, 0x0F,
  0xFE, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F,
  0x8F, 0xC3, 0xE7, 0xE0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xE0, 0xF8, 0xFC,
  0x3E, 0x3F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF,
  0x81, 0xFB, 0xE0, 0x7F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0x81, 0xFF, 0xF7, 0x83,
  0xDF, 0xF7, 0x83, 0xDF, 0xF7, 0xC3, 0xDF, 0xF3, 0xC7, 0xDF, 0xF3, 0xC7,
  0x9F, 0xF3, 0xE7, 0x9F, 0xF3, 0xEF, 0x9F, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE,
  0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF7, 0xC1, 0xFE, 0xFC, 0x3F, 0xCF, 0x87,
  0xF9, 0xF8, 0xFF, 0x1F, 0x1F, 0xE3, 0xF3, 0xFC, 0x3E, 0x7F, 0x87, 0xEF,
  0xF0, 0x7D, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x01, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xE0, 0xFC, 0xFC,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xEF,
  0xC0, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xE7,
  0xFF, 0xCF, 0x81, 0xBF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7F, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x1F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07,
  0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x07,
  0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7F, 0xF0,
  0x3F, 0x01, 0xF7, 0xC0, 0xFC, 0x0F, 0xDF, 0x03, 0xF0, 0x3F, 0x7C, 0x0F,
  0xE0, 0xF9, 0xF0, 0x3F, 0x83, 0xE7, 0xE1, 0xFE, 0x0F, 0x8F, 0x87, 0xF8,
  0x7E, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8, 0x7F, 0xC7, 0xC3, 0xE3, 0xEF, 0x1F,
  0x07, 0xCF, 0x3C, 0x7C, 0x1F, 0x3C, 0xF3, 0xE0, 0x7C, 0xF3, 0xCF, 0x81,
  0xF3, 0xCF, 0xBE, 0x03, 0xDF, 0x1E, 0xF8, 0x0F, 0xF8, 0x7B, 0xE0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xF0, 0xFC, 0x1F,
  0x0F, 0xC1, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x1F, 0x9F,
  0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x3F, 0x07, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xF0, 0x0F, 0x3C, 0x07, 0x8F,
  0x81, 0xE1, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xE7, 0x80, 0x7B,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x10,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F,
  0xDF, 0x3F, 0x8F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFB, 0xFC, 0xF1, 0xF8, 0x07, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0xFE,
  0x7E, 0x09, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x37, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xEF, 0x0F, 0x8F, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFC, 0x0F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x3F, 0x7C,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF8, 0x1F, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9,
  0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFB,
  0xFF, 0xFE, 0x70, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x1F, 0x0F, 0xC7, 0xE3, 0xE0, 0xE0,
  0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xEB, 0xF7, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x3F, 0xF8, 0x3F, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x87,
  0xDF, 0x83, 0xEF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xBE,
  0x1F, 0x9F, 0x8F, 0x87, 0xE7, 0xC3, 0xF3, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xFC, 0x7F, 0x3E, 0xFF, 0xBF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE,
  0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07,
  0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F,
  0x07, 0xFE, 0x0F, 0xC1, 0xF0, 0xF1, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xF1, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0xCF, 0x3F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF1, 0xFF, 0xBE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x1F, 0xF3, 0xFF, 0xDF, 0xFD,
  0xFD, 0xEF, 0x81, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFE,
  0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE1, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x1F, 0x8F, 0xFC, 0x0F,
  0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x87, 0xEF, 0x87, 0xF0, 0xF9, 0xF0, 0xFE,
  0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xE3, 0xB8, 0xF8, 0x7C, 0xF7, 0x9F, 0x0F,
  0x9E, 0xF3, 0xE1, 0xF3, 0xDE, 0x7C, 0x3E, 0x7B, 0xCF, 0x03, 0xFE, 0x3B,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xDF, 0x87, 0xE3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xCF, 0x83,
  0xF3, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0xBF, 0x03, 0xF0, 0xFC, 0x0F, 0xDF,
  0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1,
  0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF1, 0xFC, 0x3E, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0xC0, 0xF8, 0x3F, 0x1F, 0xE3, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC0, 0x08, 0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0x80, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 24, 9, 2, -24 },
  { 19, 12, 9, 16, 2, -24 },
  { 33, 18, 24, 20, 1, -24 },
  { 87, 16, 27, 18, 1, -25 },
  { 141, 27, 24, 29, 1, -24 },
  { 222, 22, 24, 23, 1, -24 },
  { 288, 5, 9, 9, 2, -24 },
  { 294, 9, 29, 11, 1, -24 },
  { 327, 9, 29, 11, 1, -24 },
  { 360, 15, 15, 17, 1, -25 },
  { 389, 16, 16, 18, 1, -20 },
  { 421, 7, 8, 9, 1, -4 },
  { 428, 9, 4, 10, 1, -11 },
  { 433, 6, 5, 9, 2, -5 },
  { 437, 14, 24, 14, 0, -24 },
  { 479, 16, 24, 18, 1, -24 },
  { 527, 12, 24, 18, 2, -24 },
  { 563, 16, 24, 18, 1, -24 },
  { 611, 16, 24, 18, 1, -24 },
  { 659, 16, 24, 18, 1, -24 },
  { 707, 14, 24, 18, 2, -24 },
  { 749, 16, 24, 18, 1, -24 },
  { 797, 16, 24, 18, 1, -24 },
  { 845, 16, 24, 18, 1, -24 },
  { 893, 16, 24, 18, 1, -24 },
  { 941, 6, 18, 9, 2, -18 },
  { 955, 7, 22, 9, 1, -18 },
  { 975, 16, 17, 18, 1, -20 },
  { 1009, 16, 11, 18, 1, -17 },
  { 1031, 16, 17, 18, 1, -20 },
  { 1065, 14, 24, 15, 0, -24 },
  { 1107, 25, 27, 28, 1, -24 },
  { 1192, 21, 24, 21, 0, -24 },
  { 1255, 17, 24, 21, 2, -24 },
  { 1306, 17, 24, 19, 2, -24 },
  { 1357, 19, 24, 22, 2, -24 },
  { 1414, 12, 24, 17, 3, -24 },
  { 1450, 12, 24, 17, 3, -24 },
  { 1486, 18, 24, 22, 2, -24 },
  { 1540, 18, 24, 23, 3, -24 },
  { 1594, 11, 24, 13, 1, -24 },
  { 1627, 10, 31, 11, -2, -24 },
  { 1666, 18, 24, 21, 3, -24 },
  { 1720, 14, 24, 17, 2, -24 },
  { 1762, 24, 24, 29, 3, -24 },
  { 1834, 19, 24, 25, 3, -24 },
  { 1891, 20, 24, 24, 2, -24 },
  { 1951, 16, 24, 19, 2, -24 },
  { 1999, 20, 30, 24, 2, -24 },
  { 2074, 18, 24, 20, 2, -24 },
  { 2128, 15, 24, 17, 1, -24 },
  { 2173, 16, 24, 18, 1, -24 },
  { 2221, 18, 24, 23, 2, -24 },
  { 2275, 20, 24, 20, 0, -24 },
  { 2335, 30, 24, 30, 0, -24 },
  { 2425, 20, 24, 21, 0, -24 },
  { 2485, 19, 24, 19, 0, -24 },
  { 2542, 16, 24, 18, 1, -24 },
  { 2590, 8, 29, 11, 2, -24 },
  { 2619, 14, 24, 14, 0, -24 },
  { 2661, 8, 29, 11, 1, -24 },
  { 2690, 18, 16, 18, 0, -24 },
  { 2726, 15, 3, 15, 0, 3 },
  { 2732, 10, 5, 12, 1, -25 },
  { 2739, 16, 18, 19, 1, -18 },
  { 2775, 16, 25, 20, 2, -25 },
  { 2825, 14, 18, 16, 1, -18 },
  { 2857, 16, 25, 20, 1, -25 },
  { 2907, 16, 18, 18, 1, -18 },
  { 2943, 12, 25, 12, 1, -25 },
  { 2981, 16, 26, 20, 1, -18 },
  { 3033, 16, 25, 20, 2, -25 },
  { 3083, 6, 25, 10, 2, -25 },
  { 3102, 9, 33, 10, -1, -25 },
  { 3140, 17, 25, 19, 2, -25 },
  { 3194, 5, 25, 10, 2, -25 },
  { 3210, 26, 18, 30, 2, -18 },
  { 3269, 16, 18, 20, 2, -18 },
  { 3305, 17, 18, 19, 1, -18 },
  { 3344, 16, 26, 20, 2, -18 },
  { 3396, 16, 26, 20, 1, -18 },
  { 3448, 12, 18, 14, 2, -18 },
  { 3475, 13, 18, 15, 1, -18 },
  { 3505, 12, 22, 13, 1, -22 },
  { 3538, 16, 18, 20, 2, -18 },
  { 3574, 18, 18, 18, 0, -18 },
  { 3615, 27, 18, 27, 0, -18 },
  { 3676, 18, 18, 18, 0, -18 },
  { 3717, 18, 26, 18, 0, -18 },
  { 3776, 13, 18, 15, 1, -18 },
  { 3806, 11, 29, 13, 1, -24 },
  { 3846, 4, 32, 16, 6, -25 },
  { 3862, 11, 29, 13, 1, -24 },
  { 3902, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD33PT7B_H_
