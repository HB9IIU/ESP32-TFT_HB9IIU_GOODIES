#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xEF, 0xDF, 0xBF, 0x7C, 0xC0, 0x0D,
  0x81, 0xB0, 0x66, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xC0, 0xD8, 0xFF, 0xC6,
  0x60, 0xCC, 0x1B, 0x03, 0x60, 0x18, 0x18, 0x7F, 0xFE, 0xD9, 0xF8, 0xF8,
  0x7E, 0x1F, 0x1F, 0x9F, 0xFF, 0xFE, 0x18, 0x18, 0x38, 0x30, 0xF8, 0xE1,
  0xB1, 0x87, 0x67, 0x0E, 0xCC, 0x0D, 0xBB, 0x9F, 0x6F, 0x9D, 0xDB, 0x03,
  0x76, 0x0E, 0xEC, 0x19, 0xD8, 0x71, 0xF0, 0xC1, 0xC0, 0x3E, 0x07, 0xE0,
  0x67, 0x06, 0x70, 0x7E, 0x03, 0xE0, 0x7C, 0xEF, 0xEE, 0xEF, 0xCE, 0x7C,
  0xE7, 0x8F, 0xFC, 0x7E, 0xF0, 0xFF, 0xFC, 0x3B, 0x99, 0xCE, 0x73, 0x18,
  0xC6, 0x39, 0xCE, 0x31, 0xC7, 0xE3, 0x8C, 0x73, 0x8C, 0x63, 0x18, 0xC6,
  0x73, 0x99, 0xDC, 0x1C, 0x0E, 0x13, 0x2F, 0xFF, 0xF8, 0xF0, 0xD8, 0xEE,
  0x04, 0x00, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0xFF,
  0x60, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18,
  0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0x3C, 0x7E, 0xEE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0x7E, 0x3C, 0x0C, 0xF7, 0xFF, 0x6D, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7C, 0xFE, 0xEF, 0x47, 0x07, 0x0E, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0xCF, 0x07, 0x06, 0x7E,
  0x7C, 0x7E, 0x07, 0x07, 0x8F, 0xFE, 0xFC, 0x07, 0x07, 0x83, 0xC3, 0xE1,
  0xF1, 0xB9, 0xDC, 0xCE, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x70, 0xFE, 0xFE,
  0xFE, 0xE0, 0xE0, 0xFE, 0xFE, 0x0F, 0x07, 0x07, 0x8F, 0xFE, 0xFC, 0x1E,
  0x7E, 0x71, 0xE0, 0xC0, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C,
  0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0x3C, 0xFE, 0xE7, 0xE7, 0xEE, 0x7E, 0x7C, 0xFE, 0xE7, 0xC7, 0xE7,
  0xFF, 0x7E, 0x3C, 0xFE, 0xEF, 0xE7, 0xC7, 0xE7, 0xFF, 0xFF, 0x37, 0x07,
  0x0E, 0xFC, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x60,
  0x01, 0x07, 0x1E, 0x78, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x1E, 0x07, 0x1F, 0x7C, 0xE0, 0x80,
  0x7C, 0xFE, 0x6F, 0x07, 0x07, 0x1E, 0x1C, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x38, 0x0F, 0xC1, 0xFF, 0x1C, 0x0C, 0xC7, 0x3C, 0xFD, 0xEE, 0x6F, 0x63,
  0x7B, 0x1B, 0xD9, 0xDE, 0x7F, 0xF3, 0xDC, 0xC0, 0x07, 0x8E, 0x0F, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1B, 0x83, 0x98, 0x39, 0xC3, 0x9C,
  0x7F, 0xC7, 0xFE, 0x70, 0xEF, 0x0E, 0xE0, 0xF0, 0xFE, 0x7F, 0xF9, 0xFC,
  0x7E, 0x3F, 0xFB, 0xFD, 0xCF, 0xE3, 0xF1, 0xF9, 0xFF, 0xFF, 0xE0, 0x1F,
  0x1F, 0xDE, 0xDE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1E, 0x6F,
  0xF3, 0xF8, 0xFE, 0x3F, 0xCF, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xFE, 0xFB, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1F,
  0xFF, 0xFF, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x1F, 0x8F, 0xF7, 0xDB, 0xC0,
  0xE0, 0x38, 0x0E, 0x7F, 0x9F, 0xE1, 0xFC, 0x77, 0x9D, 0xFF, 0x1F, 0xC0,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9D,
  0xFF, 0x80, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF,
  0xE0, 0xE1, 0xF8, 0xEE, 0x7B, 0x9C, 0xEE, 0x3B, 0x8F, 0xE3, 0xF8, 0xE7,
  0x39, 0xCE, 0x3B, 0x8E, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xFC, 0xFF, 0xB3, 0x7E, 0xCD, 0xFB, 0x37, 0xEF, 0xDF, 0x9E,
  0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x1C, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xDC, 0xFB, 0x9F, 0x3B, 0xE7, 0x7C, 0x7F, 0x8F, 0xF0, 0xFE, 0x1E,
  0x1F, 0x0F, 0xF9, 0xEF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x1D, 0xEF, 0x3F, 0xE1, 0xF0, 0xFE, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x1F, 0xFD, 0xFE, 0xF8, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x1F, 0x0F, 0xF9,
  0xEF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xEF,
  0x3F, 0xE1, 0xF8, 0x07, 0x00, 0x70, 0x0F, 0xFE, 0x3F, 0xCE, 0xFB, 0x8E,
  0xE3, 0xB9, 0xEF, 0xF3, 0xF8, 0xEE, 0x39, 0xCE, 0x3B, 0x8E, 0xE1, 0xC0,
  0x3E, 0xFF, 0xFE, 0xE0, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xCF, 0xFE,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x3D, 0xFE, 0x3F, 0x00, 0xE0, 0xFC, 0x1D,
  0xC7, 0x38, 0xE7, 0x1C, 0x73, 0x8E, 0xE1, 0xDC, 0x1B, 0x83, 0x60, 0x7C,
  0x0F, 0x80, 0xE0, 0xE1, 0xC3, 0xE1, 0xC7, 0x63, 0xC7, 0x73, 0xC7, 0x73,
  0xE6, 0x73, 0x6E, 0x77, 0x6E, 0x37, 0x6E, 0x3E, 0x6E, 0x3E, 0x7C, 0x3E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0xF1, 0xEE, 0x38, 0xEF, 0x1D, 0xC1, 0xF0,
  0x3E, 0x03, 0x80, 0xF8, 0x1F, 0x07, 0x71, 0xEF, 0x38, 0xEF, 0x0E, 0xE1,
  0xEE, 0x39, 0xCE, 0x1D, 0xC3, 0xB0, 0x3E, 0x07, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x38, 0x1C, 0x1F, 0xFF, 0xF8, 0xFF, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x0E, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xFF, 0x0C, 0x07, 0x01, 0xE0, 0xF8, 0x37, 0x0C, 0xC6, 0x3B,
  0x87, 0xFF, 0xFF, 0xE3, 0x8E, 0x7E, 0x7F, 0x47, 0x07, 0x7F, 0xFF, 0xE7,
  0xE7, 0xFF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0xDF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFE, 0xFF, 0xF7, 0x70, 0x3E, 0xFF, 0xCF, 0x0E, 0x1C,
  0x38, 0x71, 0x7E, 0x7C, 0x03, 0x03, 0x03, 0x03, 0x7B, 0x7F, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0x7B, 0x3C, 0x7F, 0xE7, 0xE3, 0xFF, 0xFF,
  0xE0, 0xE1, 0x7F, 0x3F, 0x1E, 0x7C, 0xF9, 0x87, 0xDF, 0x8C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x00, 0x7B, 0x7F, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE7, 0xFF, 0x7B, 0x03, 0x87, 0xFF, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0xF7, 0xFB, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB9,
  0xCE, 0xF3, 0xB8, 0xFC, 0x3F, 0x8F, 0xE3, 0x9C, 0xE7, 0xB8, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF, 0x7B, 0xFF, 0xFF, 0x79, 0xF8, 0xE7,
  0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x70, 0xCF,
  0x7F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x3E,
  0x3F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCE, 0x7F, 0x1F, 0x00, 0xEE,
  0x7F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0x77, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x7B, 0x7F, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF,
  0x7B, 0x03, 0x03, 0x03, 0x03, 0xCF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3,
  0x80, 0x7F, 0xFB, 0x17, 0x0F, 0x8F, 0x87, 0xC7, 0xFD, 0xF8, 0x30, 0x61,
  0xFF, 0xF7, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xF9, 0xF0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0xBD, 0xC0, 0xE1, 0xF8, 0xE7,
  0x39, 0xCE, 0x33, 0x0D, 0xC3, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xE3, 0x8E,
  0xCF, 0x39, 0xDE, 0x73, 0xB6, 0xE7, 0x6D, 0x86, 0xDB, 0x0F, 0x3E, 0x1E,
  0x7C, 0x3C, 0x70, 0x38, 0xE0, 0xF3, 0xDC, 0xE3, 0xF0, 0xFC, 0x1E, 0x07,
  0x83, 0xF0, 0xFC, 0x73, 0xBC, 0xF0, 0xE1, 0xD8, 0xE7, 0x39, 0xCE, 0x33,
  0x0F, 0xC3, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x78, 0x1E, 0x00,
  0x7F, 0x7F, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xFF, 0xFF, 0x0C, 0x73,
  0x8E, 0x38, 0xE3, 0xBC, 0xF0, 0xE3, 0x8E, 0x38, 0xE1, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x0F, 0x3D,
  0xC7, 0x1C, 0x71, 0xCE, 0x38, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 11, 13, 11, 0, -13 },
  { 29, 8, 15, 10, 1, -14 },
  { 44, 15, 13, 16, 0, -13 },
  { 69, 12, 13, 13, 1, -13 },
  { 89, 3, 5, 5, 1, -13 },
  { 91, 5, 16, 6, 1, -13 },
  { 101, 5, 16, 6, 0, -13 },
  { 111, 9, 9, 9, 0, -14 },
  { 122, 8, 9, 10, 1, -11 },
  { 131, 3, 4, 5, 1, -2 },
  { 133, 5, 2, 6, 0, -6 },
  { 135, 3, 3, 5, 1, -3 },
  { 137, 8, 13, 8, 0, -13 },
  { 150, 8, 13, 10, 1, -13 },
  { 163, 6, 13, 10, 1, -13 },
  { 173, 8, 13, 10, 1, -13 },
  { 186, 8, 13, 10, 1, -13 },
  { 199, 9, 13, 10, 0, -13 },
  { 214, 8, 13, 10, 1, -13 },
  { 227, 8, 13, 10, 1, -13 },
  { 240, 8, 13, 10, 1, -13 },
  { 253, 8, 13, 10, 1, -13 },
  { 266, 8, 13, 10, 1, -13 },
  { 279, 3, 10, 5, 1, -10 },
  { 283, 3, 12, 5, 1, -10 },
  { 288, 8, 9, 10, 1, -11 },
  { 297, 8, 6, 10, 1, -9 },
  { 303, 8, 9, 10, 1, -11 },
  { 312, 8, 13, 8, 0, -13 },
  { 325, 13, 14, 15, 1, -13 },
  { 348, 12, 13, 12, 0, -13 },
  { 368, 9, 13, 11, 1, -13 },
  { 383, 9, 13, 11, 1, -13 },
  { 398, 10, 13, 12, 1, -13 },
  { 415, 7, 13, 9, 1, -13 },
  { 427, 7, 13, 9, 1, -13 },
  { 439, 10, 13, 12, 1, -13 },
  { 456, 10, 13, 13, 1, -13 },
  { 473, 5, 13, 7, 1, -13 },
  { 482, 5, 17, 6, -1, -13 },
  { 493, 10, 13, 11, 1, -13 },
  { 510, 8, 13, 9, 1, -13 },
  { 523, 14, 13, 16, 1, -13 },
  { 546, 11, 13, 14, 1, -13 },
  { 564, 11, 13, 13, 1, -13 },
  { 582, 9, 13, 10, 1, -13 },
  { 597, 11, 16, 13, 1, -13 },
  { 619, 10, 13, 11, 1, -13 },
  { 636, 8, 13, 9, 1, -13 },
  { 649, 9, 13, 10, 0, -13 },
  { 664, 10, 13, 12, 1, -13 },
  { 681, 11, 13, 11, 0, -13 },
  { 699, 16, 13, 17, 0, -13 },
  { 725, 11, 13, 11, 0, -13 },
  { 743, 11, 13, 11, 0, -13 },
  { 761, 9, 13, 10, 0, -13 },
  { 776, 4, 16, 6, 1, -13 },
  { 784, 8, 13, 8, 0, -13 },
  { 797, 5, 16, 6, 0, -13 },
  { 807, 10, 8, 10, 0, -13 },
  { 817, 8, 2, 8, 0, 1 },
  { 819, 5, 3, 7, 1, -14 },
  { 821, 8, 10, 10, 1, -10 },
  { 831, 9, 14, 11, 1, -14 },
  { 847, 7, 10, 9, 1, -10 },
  { 856, 8, 14, 11, 1, -14 },
  { 870, 8, 10, 10, 1, -10 },
  { 880, 7, 14, 7, 0, -14 },
  { 893, 8, 14, 11, 1, -10 },
  { 907, 9, 14, 11, 1, -14 },
  { 923, 3, 14, 5, 1, -14 },
  { 929, 5, 18, 5, -1, -14 },
  { 941, 10, 14, 11, 1, -14 },
  { 959, 3, 14, 5, 1, -14 },
  { 965, 14, 10, 16, 1, -10 },
  { 983, 9, 10, 11, 1, -10 },
  { 995, 9, 10, 11, 1, -10 },
  { 1007, 9, 14, 11, 1, -10 },
  { 1023, 8, 14, 11, 1, -10 },
  { 1037, 6, 10, 8, 1, -10 },
  { 1045, 7, 10, 8, 1, -10 },
  { 1054, 7, 12, 7, 0, -12 },
  { 1065, 9, 10, 11, 1, -10 },
  { 1077, 10, 10, 10, 0, -10 },
  { 1090, 15, 10, 15, 0, -10 },
  { 1109, 10, 10, 10, 0, -10 },
  { 1122, 10, 14, 10, 0, -10 },
  { 1140, 8, 10, 8, 0, -10 },
  { 1150, 6, 16, 7, 0, -13 },
  { 1162, 3, 18, 9, 3, -14 },
  { 1169, 6, 16, 7, 1, -13 },
  { 1181, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD18PT7B_H_
