#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0xFF, 0xF3,
  0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0x9E, 0x3E, 0x78,
  0xF9, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x87, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x9F, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE1, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFD, 0xFB,
  0x84, 0xFD, 0xC0, 0x7E, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xEF, 0xC0, 0x73,
  0xF0, 0x39, 0xF6, 0x1D, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xFC, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xC0, 0x1F, 0xF8, 0x1F,
  0x00, 0xF9, 0xE0, 0x78, 0x03, 0xE7, 0xC3, 0xE0, 0x0F, 0x1F, 0x0F, 0x00,
  0x3C, 0x7C, 0x7C, 0x00, 0xF1, 0xF1, 0xE0, 0x03, 0xC7, 0xCF, 0x80, 0x0F,
  0x9F, 0x3C, 0x3C, 0x3E, 0x7D, 0xF3, 0xF8, 0x7F, 0xE7, 0x9F, 0xF1, 0xFF,
  0xBE, 0x7F, 0xE3, 0xFC, 0xF3, 0xE7, 0x87, 0xE7, 0xCF, 0x1E, 0x00, 0x1E,
  0x3C, 0x7C, 0x00, 0xF8, 0xF1, 0xF0, 0x03, 0xC3, 0xC7, 0xC0, 0x1F, 0x0F,
  0x1F, 0x00, 0x78, 0x3C, 0x7C, 0x03, 0xE0, 0xF9, 0xE0, 0x0F, 0x03, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x20, 0xFF, 0x07, 0xE1, 0xFF, 0xC3, 0xF1, 0xFF, 0xF1, 0xF8, 0xFD,
  0xFD, 0xF8, 0xFE, 0x7F, 0xFC, 0x7E, 0x1F, 0xFE, 0x3F, 0x07, 0xFE, 0x1F,
  0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFE, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF,
  0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0x83, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x06, 0x3C,
  0x77, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0x03, 0xE7, 0xC1, 0xF3, 0xF0, 0x70, 0xE0, 0x08, 0x60,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x3E, 0x7D, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8,
  0x7C, 0xF8, 0x3F, 0x7C, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xBE, 0x0F,
  0xDF, 0x07, 0xEF, 0xC3, 0xF7, 0xE3, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xFF, 0x7D, 0xF9, 0xCF, 0xC8, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3,
  0xE1, 0xF8, 0xC0, 0x7E, 0x20, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF1, 0x81, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xE7, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xBE, 0x03, 0xFF, 0x81, 0xF7, 0xE0, 0x79, 0xF8, 0x3E, 0x7E, 0x1F, 0x1F,
  0x87, 0xC7, 0xE3, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFD, 0xC0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x20, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x1F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xEF, 0x83, 0xF7, 0xE1, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF3, 0xF3, 0xF0,
  0xFD, 0xF0, 0x7E, 0xFC, 0x3E, 0x7E, 0x3F, 0x1F, 0xBF, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFE, 0x7E, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xF7, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xDF, 0x0F, 0xCF, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xF1, 0x0F, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0xFD, 0xFB,
  0xE7, 0xCF, 0x9E, 0x7C, 0xF8, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x30,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC3, 0xE1, 0xFF, 0x1E, 0x3C, 0x3F, 0xF9,
  0xE7, 0xC7, 0xFF, 0x9E, 0x78, 0xF8, 0xF8, 0xF7, 0x8F, 0x0F, 0x8F, 0x79,
  0xF0, 0xF8, 0xF7, 0x9F, 0x0F, 0x8F, 0xF9, 0xF0, 0xF0, 0xFF, 0x9E, 0x0F,
  0x0F, 0xF9, 0xF0, 0xF1, 0xE7, 0x9F, 0x1F, 0x1E, 0x78, 0xFB, 0xFB, 0xE7,
  0x8F, 0xFB, 0xFC, 0x7C, 0x7F, 0xBF, 0x83, 0xC1, 0xE0, 0xF0, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x3E,
  0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0xCF,
  0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB,
  0xF0, 0xFE, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xE0, 0xE7, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xC7, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF,
  0xC1, 0xFC, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFC, 0x0C, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x1F,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F,
  0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0xF0, 0x3D, 0xFF, 0xBE, 0x1F, 0x7F, 0xEF, 0x87, 0xDF, 0xFB, 0xE1,
  0xE7, 0xFE, 0x7C, 0x79, 0xFF, 0x9F, 0x3E, 0x7F, 0xE7, 0xCF, 0x9F, 0xF8,
  0xF3, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xFC,
  0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xF0, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xDF, 0x87, 0xFE, 0xFC,
  0x3F, 0xF3, 0xF1, 0xFF, 0x9F, 0x8F, 0xFC, 0x7E, 0x7F, 0xE3, 0xF3, 0xFF,
  0x0F, 0xDF, 0xF8, 0x7E, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x1F,
  0xBF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7E,
  0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xE3, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x8F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xF0, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7F, 0x03, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF8, 0xFF, 0x3F, 0x0F, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x0E, 0x7E, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F,
  0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00,
  0xFC, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xCF, 0x80, 0xFE,
  0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xF8, 0xF8, 0x3F,
  0xE0, 0xFC, 0x7C, 0x1F, 0xF0, 0x7C, 0x3F, 0x0F, 0x78, 0x7E, 0x1F, 0x87,
  0xBC, 0x3F, 0x0F, 0xC7, 0xDE, 0x1F, 0x83, 0xE3, 0xEF, 0x8F, 0x81, 0xF1,
  0xF7, 0xC7, 0xC0, 0xFC, 0xFB, 0xE7, 0xE0, 0x7E, 0x78, 0xF3, 0xF0, 0x1F,
  0x7C, 0x7D, 0xF0, 0x0F, 0xBE, 0x3E, 0xF8, 0x07, 0xDF, 0x1F, 0x7C, 0x03,
  0xEF, 0x07, 0xBE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFD,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7F,
  0x1F, 0x80, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFE, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xF0, 0x0F, 0xBE, 0x01,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x07, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xE3, 0xF8, 0x80, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFB, 0xE3, 0xF8, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0xFD,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x07,
  0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xEF, 0xFB, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3E, 0x7F, 0x8F, 0x8F, 0xC0, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0x04, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x02,
  0x7F, 0x9E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x1F, 0x3F, 0x1F, 0xEF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7E, 0x1F, 0xDF, 0x83, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7,
  0xFB, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFD, 0xF0, 0xFC, 0x7C, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x83,
  0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x0E, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x80, 0x7F, 0xC7,
  0xFE, 0x3F, 0xF3, 0xFF, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF,
  0x7C, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFD, 0xFC, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE,
  0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF4, 0x00, 0xFD, 0xC0, 0xFE,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x05, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0xFD, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFC, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFB, 0xFC, 0x38, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0xFC, 0x7E,
  0x3F, 0x0F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xE7, 0xE1, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x1F, 0xDF, 0x81, 0xFB, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0xFC, 0x1F, 0x8F, 0x9F, 0xF3, 0xFE, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF,
  0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F,
  0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F,
  0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0xFC, 0x3E,
  0x7F, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0xBF, 0x9F, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F,
  0x7C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFC, 0xFC, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF0, 0xF8, 0xFC, 0x3E, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFB, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xDF, 0xE3, 0xF3, 0xF0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC7, 0xC7,
  0xF9, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFB, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0xFC, 0x3B, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x33, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE1, 0xFE, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFD, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0x7C, 0x7F, 0x1F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC3,
  0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x1F, 0xC1, 0xFB, 0xE0, 0xFE, 0x0F, 0xDF, 0x87, 0xF0, 0x7E,
  0xFC, 0x3F, 0xC3, 0xE7, 0xE1, 0xFE, 0x3F, 0x1F, 0x1E, 0xF1, 0xF8, 0xF8,
  0xF7, 0x8F, 0x87, 0xE7, 0xBC, 0x7C, 0x3F, 0x3D, 0xF3, 0xE0, 0xFB, 0xE7,
  0xBF, 0x07, 0xDF, 0x3D, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C,
  0x07, 0xFC, 0x7B, 0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xEF, 0xC0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF9, 0xF8, 0x3F, 0xFF,
  0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C,
  0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F,
  0x81, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xF8, 0xFF,
  0x0F, 0xC0, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0xFF, 0x0F,
  0xE1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0xBF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFA, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 14, 10, 18, 2, -26 },
  { 39, 20, 26, 22, 1, -26 },
  { 104, 17, 29, 19, 1, -27 },
  { 166, 30, 26, 32, 1, -26 },
  { 264, 25, 26, 25, 1, -26 },
  { 346, 6, 10, 10, 2, -26 },
  { 354, 10, 32, 12, 1, -26 },
  { 394, 10, 32, 12, 1, -26 },
  { 434, 17, 16, 18, 1, -27 },
  { 468, 17, 17, 20, 1, -21 },
  { 505, 7, 10, 10, 1, -5 },
  { 514, 9, 5, 11, 1, -12 },
  { 520, 6, 6, 10, 2, -6 },
  { 525, 15, 26, 15, 0, -26 },
  { 574, 17, 26, 19, 1, -26 },
  { 630, 13, 26, 19, 2, -26 },
  { 673, 17, 26, 19, 1, -26 },
  { 729, 17, 26, 19, 1, -26 },
  { 785, 18, 26, 19, 1, -26 },
  { 844, 16, 26, 19, 2, -26 },
  { 896, 17, 26, 19, 1, -26 },
  { 952, 17, 26, 19, 1, -26 },
  { 1008, 17, 26, 19, 1, -26 },
  { 1064, 17, 26, 19, 1, -26 },
  { 1120, 6, 20, 10, 2, -20 },
  { 1135, 7, 25, 10, 1, -20 },
  { 1157, 17, 18, 20, 1, -22 },
  { 1196, 17, 12, 20, 1, -19 },
  { 1222, 17, 18, 20, 1, -22 },
  { 1261, 16, 26, 16, 0, -26 },
  { 1313, 28, 29, 30, 1, -26 },
  { 1415, 23, 26, 23, 0, -26 },
  { 1490, 18, 26, 22, 3, -26 },
  { 1549, 18, 26, 21, 2, -26 },
  { 1608, 20, 26, 24, 3, -26 },
  { 1673, 14, 26, 18, 3, -26 },
  { 1719, 14, 26, 18, 3, -26 },
  { 1765, 20, 26, 24, 2, -26 },
  { 1830, 20, 26, 25, 3, -26 },
  { 1895, 12, 26, 14, 1, -26 },
  { 1934, 11, 34, 11, -2, -26 },
  { 1981, 20, 26, 22, 3, -26 },
  { 2046, 15, 26, 18, 3, -26 },
  { 2095, 26, 26, 32, 3, -26 },
  { 2180, 21, 26, 27, 3, -26 },
  { 2249, 22, 26, 26, 2, -26 },
  { 2321, 17, 26, 21, 3, -26 },
  { 2377, 22, 32, 26, 2, -26 },
  { 2465, 19, 26, 22, 3, -26 },
  { 2527, 16, 26, 19, 1, -26 },
  { 2579, 17, 26, 19, 1, -26 },
  { 2635, 19, 26, 25, 3, -26 },
  { 2697, 22, 26, 22, 0, -26 },
  { 2769, 33, 26, 33, 0, -26 },
  { 2877, 22, 26, 22, 0, -26 },
  { 2949, 21, 26, 21, 0, -26 },
  { 3018, 18, 26, 19, 1, -26 },
  { 3077, 9, 32, 12, 2, -26 },
  { 3113, 15, 26, 15, 0, -26 },
  { 3162, 8, 32, 12, 1, -26 },
  { 3194, 19, 17, 20, 0, -26 },
  { 3235, 16, 3, 16, 0, 3 },
  { 3241, 11, 6, 13, 1, -28 },
  { 3250, 17, 20, 20, 1, -20 },
  { 3293, 18, 27, 21, 2, -27 },
  { 3354, 16, 20, 18, 1, -20 },
  { 3394, 18, 27, 21, 1, -27 },
  { 3455, 18, 20, 20, 1, -20 },
  { 3500, 13, 28, 13, 1, -28 },
  { 3546, 18, 29, 21, 1, -20 },
  { 3612, 18, 27, 22, 2, -27 },
  { 3673, 6, 28, 10, 2, -28 },
  { 3694, 10, 37, 10, -2, -28 },
  { 3741, 19, 27, 21, 2, -27 },
  { 3806, 6, 27, 10, 2, -27 },
  { 3827, 28, 20, 33, 2, -20 },
  { 3897, 18, 20, 22, 2, -20 },
  { 3942, 18, 20, 21, 1, -20 },
  { 3987, 18, 29, 21, 2, -20 },
  { 4053, 18, 29, 21, 1, -20 },
  { 4119, 13, 20, 15, 2, -20 },
  { 4152, 14, 20, 17, 1, -20 },
  { 4187, 13, 24, 15, 1, -24 },
  { 4226, 18, 20, 22, 2, -20 },
  { 4271, 20, 20, 20, 0, -20 },
  { 4321, 29, 20, 29, 0, -20 },
  { 4394, 19, 20, 20, 0, -20 },
  { 4442, 20, 29, 20, 0, -20 },
  { 4515, 14, 20, 16, 1, -20 },
  { 4550, 12, 32, 14, 1, -26 },
  { 4598, 4, 35, 18, 7, -27 },
  { 4616, 12, 32, 14, 1, -26 },
  { 4664, 17, 7, 20, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD36PT7B_H_
