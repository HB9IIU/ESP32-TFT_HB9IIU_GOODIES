#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF,
  0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x01, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xC0, 0x0F,
  0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x07, 0xC7, 0x80, 0x1E, 0x3E, 0x00,
  0x78, 0xF8, 0x01, 0xE3, 0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xE0,
  0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x1F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFD, 0xC7, 0x3E, 0x70,
  0x4F, 0x9C, 0x03, 0xF7, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0x7E, 0x01,
  0xCF, 0xC0, 0x73, 0xFC, 0x1C, 0xFF, 0xE7, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0xF0,
  0x1F, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0xF9, 0xF0, 0x3E, 0x00, 0xF8, 0xF8,
  0x3E, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0x00, 0xF8, 0xF9,
  0xF1, 0xF8, 0x78, 0xF3, 0xE7, 0xFC, 0x7F, 0xF3, 0xE7, 0xFE, 0x7F, 0xF7,
  0xCF, 0xFE, 0x3F, 0xE7, 0xCF, 0x9F, 0x1F, 0xCF, 0x8F, 0x1F, 0x00, 0x0F,
  0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3E,
  0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x7C, 0x0F, 0x1F, 0x00, 0x7C,
  0x0F, 0x9F, 0x00, 0xF8, 0x0F, 0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0,
  0x07, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x04, 0x1F, 0xF0, 0x3F, 0x07, 0xFF, 0x07, 0xE1, 0xFF, 0xF1, 0xFC,
  0x7F, 0x7F, 0x3F, 0x0F, 0xC7, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC, 0x7F, 0x0F,
  0xFF, 0x0F, 0xE0, 0xFF, 0xE1, 0xFC, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE,
  0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D,
  0xF0, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x18, 0x78, 0x6F, 0xDE, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xF3, 0xE0, 0xFC, 0xFC, 0x0E, 0x1C, 0x01, 0x86, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFD, 0xF3, 0xF3, 0x8F, 0xC4, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x7F,
  0x8E, 0x07, 0xF0, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x7F, 0x84, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xB8, 0x0F, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xF0, 0x3E,
  0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0x60, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF3, 0xF8,
  0x3E, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x1F, 0xDF, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE3, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xBF, 0x8F, 0xE3, 0xF9, 0xF8, 0x3F, 0x7E, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x83, 0xFB, 0xFD, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x3F, 0xBF, 0x83, 0xF7,
  0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xF7, 0xC1,
  0xFC, 0xF8, 0x04, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x1C, 0x3E,
  0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF9, 0xC1, 0xFC, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0x87, 0xC1, 0xFE, 0x3E, 0x7C, 0x3F, 0xFC,
  0xF3, 0xC3, 0xFF, 0xE7, 0xFE, 0x3F, 0xFF, 0x3F, 0xF1, 0xF0, 0xF0, 0xFF,
  0x1F, 0x07, 0x87, 0xF8, 0xF8, 0x3C, 0x3F, 0xC7, 0xC1, 0xE1, 0xFE, 0x3E,
  0x0F, 0x0F, 0xF1, 0xF0, 0x78, 0x7F, 0x8F, 0x87, 0xC7, 0xFC, 0x7C, 0x3E,
  0x3D, 0xE3, 0xF3, 0xFB, 0xEF, 0x8F, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xF1,
  0xE0, 0xFE, 0x7F, 0x0F, 0x81, 0x80, 0x60, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x10, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC1, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x1C, 0x7F,
  0x80, 0x47, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x02, 0x3F, 0xC0, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F,
  0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0x7E, 0x07, 0xFB, 0xF0, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x81, 0xC7, 0xF8,
  0x01, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7F, 0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFC, 0x0F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFD, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0xFE, 0x1F,
  0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFB, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0,
  0x3F, 0xBF, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x7C, 0x07, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xEF, 0xFF, 0xFC, 0x1F, 0x7F, 0xFB, 0xE0, 0xFB, 0xFF, 0xDF,
  0x07, 0xDF, 0xFE, 0xF8, 0x7C, 0xFF, 0xF3, 0xE3, 0xE7, 0xFF, 0x9F, 0x1F,
  0x3F, 0xFC, 0xF9, 0xF1, 0xFF, 0xE7, 0xEF, 0x8F, 0xFF, 0x1F, 0x7C, 0x7F,
  0xF8, 0xFF, 0xC3, 0xFF, 0xC7, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF0,
  0xFF, 0x87, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x3F, 0xC1, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF8, 0x3F, 0x03, 0xF0, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFB, 0xF0, 0x3F,
  0xFB, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F, 0xFD, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F,
  0xFC, 0xFE, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0x3F,
  0xFC, 0x3F, 0xBF, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xC3, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE,
  0x7F, 0x80, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x1F,
  0xE3, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xCF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC,
  0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x07, 0xF0, 0x07,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0xF3,
  0xF0, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xC1, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFD, 0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x7E, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0xFE, 0x3F,
  0x03, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0xC0, 0xFC, 0x3F, 0x07, 0xFE, 0x0F,
  0xC3, 0xF0, 0x7F, 0xE1, 0xFC, 0x3F, 0x07, 0xFE, 0x1F, 0x81, 0xF8, 0xFB,
  0xE1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F,
  0x8F, 0x9F, 0x3F, 0x00, 0xF8, 0xF9, 0xF3, 0xF0, 0x0F, 0xDF, 0x1F, 0x3F,
  0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0x7D, 0xF0,
  0xFB, 0xE0, 0x07, 0xDF, 0x0F, 0xFE, 0x00, 0x7D, 0xE0, 0xFF, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07,
  0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xF1, 0xFC, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x18, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8,
  0xFE, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x7E, 0x3F, 0x87, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x3C, 0x1F, 0xDF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xDF, 0xF9, 0xF8, 0xFC, 0x00, 0x01,
  0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x9E, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x02, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x07, 0x8F, 0xE3, 0xFD, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFB, 0xF3, 0xFE, 0x7E, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x9F, 0xE3, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x8F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xFC, 0xFC, 0xFF,
  0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFE, 0xFE, 0x1F, 0x9F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xCC, 0x03, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x3E, 0x1F, 0xDF, 0xF3, 0xF7, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x3C, 0xFF, 0xFF, 0xF7,
  0xEF, 0x80, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x03,
  0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFD, 0xFF, 0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFE, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3E, 0x03, 0xC1, 0xF9, 0xFF, 0x1F, 0xF3, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFF, 0x3F, 0xFF, 0xC3,
  0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0x7E,
  0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0x03, 0xF0,
  0x3F, 0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0x81,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x0F,
  0xC0, 0x00, 0x3C, 0x1F, 0x9F, 0xF3, 0xF7, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x3C, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFC, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xFC, 0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFE, 0xFE, 0x1F, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7E, 0x0C, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x40, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB,
  0xF8, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xEF, 0x9F, 0xF9, 0xF0,
  0xFE, 0x3E, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x07,
  0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xF0, 0x7F, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1E,
  0xF8, 0xFC, 0x3F, 0x1E, 0xF8, 0xF8, 0x1F, 0xBE, 0x79, 0xF8, 0x1F, 0xBE,
  0x79, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBC, 0x7D, 0xF0, 0x0F, 0xBC,
  0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07,
  0xF9, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xFD, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x0F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xE0, 0x1F,
  0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x7F, 0xC3, 0xFF, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0xFF, 0xA0, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 15, 10, 19, 2, -28 },
  { 45, 22, 28, 24, 1, -28 },
  { 122, 18, 32, 21, 2, -30 },
  { 194, 32, 28, 34, 1, -28 },
  { 306, 27, 28, 28, 1, -28 },
  { 401, 6, 10, 10, 2, -28 },
  { 409, 10, 34, 13, 2, -28 },
  { 452, 11, 34, 13, 1, -28 },
  { 499, 18, 18, 20, 1, -30 },
  { 540, 18, 19, 21, 2, -23 },
  { 583, 8, 10, 11, 1, -5 },
  { 593, 10, 5, 12, 1, -13 },
  { 600, 7, 6, 11, 2, -6 },
  { 606, 16, 28, 16, 0, -28 },
  { 662, 19, 28, 21, 1, -28 },
  { 729, 14, 28, 21, 2, -28 },
  { 778, 19, 28, 21, 1, -28 },
  { 845, 19, 28, 21, 1, -28 },
  { 912, 20, 28, 21, 1, -28 },
  { 982, 17, 28, 21, 2, -28 },
  { 1042, 19, 28, 21, 1, -28 },
  { 1109, 19, 28, 21, 1, -28 },
  { 1176, 19, 28, 21, 1, -28 },
  { 1243, 19, 28, 21, 1, -28 },
  { 1310, 7, 22, 11, 2, -22 },
  { 1330, 8, 27, 11, 1, -22 },
  { 1357, 19, 20, 21, 1, -24 },
  { 1405, 18, 13, 21, 2, -20 },
  { 1435, 18, 20, 21, 2, -24 },
  { 1480, 17, 28, 18, 0, -28 },
  { 1540, 29, 31, 33, 2, -28 },
  { 1653, 25, 28, 25, 0, -28 },
  { 1741, 19, 28, 24, 3, -28 },
  { 1808, 20, 28, 23, 2, -28 },
  { 1878, 21, 28, 26, 3, -28 },
  { 1952, 15, 28, 20, 3, -28 },
  { 2005, 15, 28, 20, 3, -28 },
  { 2058, 22, 28, 26, 2, -28 },
  { 2135, 21, 28, 27, 3, -28 },
  { 2209, 13, 28, 15, 1, -28 },
  { 2255, 12, 36, 12, -3, -28 },
  { 2309, 21, 28, 24, 3, -28 },
  { 2383, 16, 28, 20, 3, -28 },
  { 2439, 29, 28, 35, 3, -28 },
  { 2541, 24, 28, 29, 3, -28 },
  { 2625, 24, 28, 28, 2, -28 },
  { 2709, 18, 28, 23, 3, -28 },
  { 2772, 24, 35, 28, 2, -28 },
  { 2877, 21, 28, 24, 3, -28 },
  { 2951, 17, 28, 20, 2, -28 },
  { 3011, 19, 28, 21, 1, -28 },
  { 3078, 21, 28, 27, 3, -28 },
  { 3152, 24, 28, 24, 0, -28 },
  { 3236, 36, 28, 36, 0, -28 },
  { 3362, 24, 28, 24, 0, -28 },
  { 3446, 23, 28, 23, 0, -28 },
  { 3527, 19, 28, 21, 1, -28 },
  { 3594, 10, 34, 12, 2, -28 },
  { 3637, 16, 28, 16, 0, -28 },
  { 3693, 9, 34, 12, 1, -28 },
  { 3732, 21, 18, 21, 0, -28 },
  { 3780, 18, 4, 18, 0, 3 },
  { 3789, 11, 6, 14, 2, -30 },
  { 3798, 19, 22, 22, 1, -22 },
  { 3851, 19, 30, 23, 2, -30 },
  { 3923, 16, 22, 19, 2, -22 },
  { 3967, 19, 30, 23, 2, -30 },
  { 4039, 18, 22, 22, 2, -22 },
  { 4089, 15, 30, 14, 1, -30 },
  { 4146, 19, 31, 23, 2, -22 },
  { 4220, 19, 30, 24, 2, -30 },
  { 4292, 7, 30, 11, 2, -30 },
  { 4319, 11, 39, 11, -2, -30 },
  { 4373, 20, 30, 23, 3, -30 },
  { 4448, 7, 30, 11, 2, -30 },
  { 4475, 31, 22, 35, 2, -22 },
  { 4561, 19, 22, 24, 2, -22 },
  { 4614, 19, 22, 23, 2, -22 },
  { 4667, 19, 31, 23, 2, -22 },
  { 4741, 19, 31, 23, 2, -22 },
  { 4815, 14, 22, 16, 2, -22 },
  { 4854, 16, 22, 18, 1, -22 },
  { 4898, 14, 26, 16, 1, -26 },
  { 4944, 19, 21, 24, 2, -21 },
  { 4994, 21, 21, 21, 0, -21 },
  { 5050, 32, 21, 32, 0, -21 },
  { 5134, 21, 21, 21, 0, -21 },
  { 5190, 21, 30, 21, 0, -21 },
  { 5269, 16, 21, 18, 1, -21 },
  { 5311, 13, 34, 15, 1, -28 },
  { 5367, 5, 39, 19, 7, -30 },
  { 5392, 14, 34, 15, 1, -28 },
  { 5452, 19, 7, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD39PT7B_H_
