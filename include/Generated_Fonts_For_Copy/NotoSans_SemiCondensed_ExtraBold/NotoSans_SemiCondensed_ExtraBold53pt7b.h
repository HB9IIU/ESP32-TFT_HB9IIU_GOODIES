#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x60, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE,
  0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F,
  0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x03, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x3F, 0xE7, 0x3F, 0x1F, 0xE3, 0x81, 0x8F, 0xF1, 0xC0, 0x07,
  0xF8, 0xE0, 0x03, 0xFC, 0x70, 0x01, 0xFF, 0x38, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0E, 0xFF, 0x80, 0x07, 0x3F, 0xE0, 0x03, 0x8F, 0xF0, 0x01,
  0xC7, 0xFE, 0x00, 0xE3, 0xFF, 0xE0, 0x73, 0xFD, 0xFF, 0x3F, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x80, 0x07, 0xF3, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x00,
  0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x7E,
  0x1F, 0xE0, 0x7F, 0x1F, 0x8F, 0xE3, 0xFF, 0x87, 0xF3, 0xF8, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xCF, 0xFF, 0xC3, 0xFF, 0xF1, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x3F, 0x9F, 0xEF, 0xE0, 0xFF, 0xE3, 0xF1, 0xFC, 0x7F, 0x07,
  0xF8, 0x7F, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x7F, 0x00, 0x00,
  0xFE, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x01, 0xFC,
  0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xCF, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xDF, 0xF8, 0xFF, 0x8F, 0xFC,
  0xFF, 0xDF, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x01, 0xC0, 0xF8, 0x1C, 0xFC, 0x7C, 0x7E, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F,
  0xC0, 0x3E, 0x0F, 0x80, 0x07, 0x03, 0x80, 0x01, 0x01, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0x87,
  0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xDF, 0xF0,
  0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF3, 0xFE, 0x7C, 0x7F, 0xC7,
  0x0F, 0xF8, 0x41, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xFE, 0x3E, 0x01,
  0xFF, 0x0E, 0x00, 0xFF, 0x82, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7C, 0x07, 0xFC, 0x18, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF4, 0x00, 0x0F, 0xFB, 0x80, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7E, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF7, 0xFC, 0x00, 0xFE, 0xFF,
  0x80, 0x3F, 0x9F, 0xF0, 0x07, 0xE3, 0xFE, 0x01, 0xFC, 0x7F, 0xC0, 0x7F,
  0x0F, 0xF8, 0x0F, 0xE1, 0xFF, 0x03, 0xF8, 0x3F, 0xE0, 0xFE, 0x07, 0xFC,
  0x1F, 0xC0, 0xFF, 0x87, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x68, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0xFF, 0xC1, 0xFE,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x07,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF,
  0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x3F, 0xE7, 0xFC, 0x1F, 0xE1, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F,
  0xF8, 0xFF, 0x87, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF9, 0xFF, 0x87, 0xFC, 0xFF, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFB, 0xFC,
  0x7F, 0xFD, 0xFC, 0x1F, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x60, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x0A, 0x00, 0x00, 0x08, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xF8, 0x20, 0x04, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x3F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF,
  0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0x01, 0xFF, 0x10, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x06, 0x00, 0xFC,
  0x1F, 0xC0, 0xFF, 0xF8, 0x7E, 0x3F, 0x81, 0xFF, 0xFC, 0x7E, 0x3F, 0x03,
  0xFF, 0xFC, 0x7F, 0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0x7F, 0x0F, 0xF9, 0xFC,
  0x3F, 0x7E, 0x1F, 0xE0, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xFC, 0x3F, 0x01, 0xFC, 0x3F,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xFC, 0x7E, 0xFE, 0x1F, 0xC7, 0xFC,
  0x7E, 0x7E, 0x1F, 0xFF, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0x07, 0xFF, 0x3F, 0xF8, 0x7F, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F,
  0xFE, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0,
  0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x7C, 0x3F, 0xF0,
  0x01, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0x0F, 0xFE, 0x01, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F,
  0xEF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xF3, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xC0, 0x3C, 0x3F, 0xF8, 0x00, 0x43, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xBF, 0xF8, 0x03, 0xFC,
  0xFF, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00,
  0xFF, 0xCF, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD,
  0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC,
  0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xBF, 0xFF, 0xDF,
  0xC0, 0x7F, 0x7F, 0xFF, 0xBF, 0x80, 0xFE, 0xFF, 0xFF, 0x7F, 0x01, 0xF9,
  0xFF, 0xFE, 0x7F, 0x07, 0xF3, 0xFF, 0xFC, 0xFE, 0x0F, 0xE7, 0xFF, 0xF9,
  0xFC, 0x1F, 0xCF, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0xFF, 0xE3, 0xF8, 0xFE,
  0x3F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0xFF, 0x8F, 0xE3, 0xF0, 0xFF, 0xFF,
  0x0F, 0xEF, 0xE1, 0xFF, 0xFE, 0x1F, 0xDF, 0xC3, 0xFF, 0xFC, 0x3F, 0xBF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF,
  0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF,
  0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xFC, 0xFF,
  0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0x03, 0xFE, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0xFE, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x05, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xE0, 0xFC, 0x7F, 0x80, 0x18, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0xFC, 0x07,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFD, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x7F, 0x07, 0xF8,
  0x07, 0xF8, 0x7F, 0x3F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0x8F, 0xC3, 0xFC,
  0x00, 0xFF, 0x1F, 0xC7, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE3, 0xF8, 0xFF,
  0x00, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x80, 0x07, 0xF3, 0xF8, 0x3F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x1F, 0xDF,
  0xE0, 0x01, 0xFE, 0xFE, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7E, 0x07, 0xF7,
  0xF8, 0x00, 0x7F, 0xBF, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1E, 0x03, 0xFE, 0x04,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xDF, 0xE7, 0xFF,
  0xEF, 0xF3, 0xFF, 0xE3, 0xF8, 0x7F, 0xC1, 0xFC, 0x04, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x18, 0x03, 0xFE,
  0x3F, 0xE0, 0xFF, 0x9F, 0xFC, 0x3F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xEF, 0xFC, 0x0F,
  0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFE,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xDF, 0xFF, 0x8F, 0xF3, 0xFF, 0xC3, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFE, 0x3C, 0x7F,
  0xE0, 0x11, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x17, 0xFE, 0x01, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x07, 0x07, 0xFC, 0x0F, 0xF9, 0xFF, 0x0F, 0xFF, 0x3F, 0xC7, 0xFF, 0xEF,
  0xF1, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFC,
  0xFF, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F,
  0xE0, 0xFF, 0xDF, 0xFC, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xF0, 0xFF, 0xF1, 0xFC, 0x0F, 0xF0,
  0x7F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFE, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x04, 0x7F, 0xE0, 0x1E, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x2C, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0x84, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0xF3, 0xFC, 0x7F,
  0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x1F,
  0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0xCF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFB, 0xFC, 0x3F, 0xFE, 0xFF, 0x0F, 0xFF, 0x7F, 0xC0,
  0xFF, 0x1F, 0xF0, 0x02, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF3, 0x00, 0x0F, 0xF8, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1C, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xBF, 0xFE, 0x3F, 0xEF, 0xFF, 0xCF, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF8, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xBF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x3F, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xE3, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFD, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x0F, 0xE3, 0xFF, 0xE3, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF3, 0xFF, 0xC3, 0xFC, 0xFF, 0xF8,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC7,
  0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFC, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF8, 0x08, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0xFF, 0xF3, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0x7F, 0xC0, 0xFF,
  0xDF, 0xF0, 0x1F, 0xF7, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFB, 0xFC, 0x7F,
  0xFE, 0xFF, 0x0F, 0xFF, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x02, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF7, 0xFD, 0xFE, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE0, 0x38,
  0xFF, 0x00, 0x47, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x05, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xDE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x04, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFB, 0xFC, 0x7F, 0xFC, 0x7F, 0x07, 0xFC,
  0x1F, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0x1F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFC,
  0x07, 0xF9, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xDF, 0x83, 0xFC, 0x1F, 0xE1,
  0xFB, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x7E, 0x1F, 0xE0, 0x7F, 0x87, 0xEF,
  0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x1F, 0x8F,
  0xF0, 0x1F, 0xE7, 0xE3, 0xF3, 0xFC, 0x03, 0xFC, 0xFC, 0x7E, 0x7F, 0x80,
  0x7F, 0x9F, 0x8F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0xFD, 0xFE, 0x00, 0xFE,
  0xFC, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x83, 0xF7, 0xF0, 0x03, 0xFF, 0xF0,
  0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x8F, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x08, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFD, 0x80, 0x1F, 0xFC, 0x80, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 39, 15, 3, -38 },
  { 45, 20, 14, 26, 3, -38 },
  { 80, 30, 38, 32, 1, -38 },
  { 223, 25, 43, 29, 2, -40 },
  { 358, 44, 38, 47, 1, -38 },
  { 567, 36, 39, 38, 2, -38 },
  { 743, 8, 14, 14, 3, -38 },
  { 757, 15, 46, 18, 2, -38 },
  { 844, 15, 46, 18, 1, -38 },
  { 931, 25, 24, 27, 1, -40 },
  { 1006, 25, 26, 29, 2, -32 },
  { 1088, 10, 14, 15, 2, -7 },
  { 1106, 14, 7, 17, 1, -18 },
  { 1119, 9, 10, 15, 3, -9 },
  { 1131, 22, 38, 22, 0, -38 },
  { 1236, 25, 39, 29, 2, -38 },
  { 1358, 19, 38, 29, 3, -38 },
  { 1449, 25, 38, 29, 2, -38 },
  { 1568, 25, 39, 29, 2, -38 },
  { 1690, 27, 38, 29, 1, -38 },
  { 1819, 23, 39, 29, 3, -38 },
  { 1932, 25, 39, 29, 2, -38 },
  { 2054, 25, 38, 29, 2, -38 },
  { 2173, 25, 39, 29, 2, -38 },
  { 2295, 25, 39, 29, 2, -38 },
  { 2417, 9, 31, 15, 3, -30 },
  { 2452, 10, 37, 15, 2, -30 },
  { 2499, 25, 28, 29, 2, -33 },
  { 2587, 25, 17, 29, 2, -27 },
  { 2641, 25, 28, 29, 2, -33 },
  { 2729, 23, 39, 24, 0, -38 },
  { 2842, 40, 42, 45, 2, -38 },
  { 3052, 34, 38, 34, 0, -38 },
  { 3214, 27, 38, 33, 4, -38 },
  { 3343, 27, 39, 31, 3, -38 },
  { 3475, 29, 38, 36, 4, -38 },
  { 3613, 20, 38, 27, 4, -38 },
  { 3708, 20, 38, 27, 4, -38 },
  { 3803, 29, 39, 36, 3, -38 },
  { 3945, 29, 38, 37, 4, -38 },
  { 4083, 17, 38, 20, 2, -38 },
  { 4164, 17, 50, 17, -4, -38 },
  { 4271, 29, 38, 33, 4, -38 },
  { 4409, 22, 38, 27, 4, -38 },
  { 4514, 39, 38, 47, 4, -38 },
  { 4700, 32, 38, 40, 4, -38 },
  { 4852, 33, 39, 38, 3, -38 },
  { 5013, 25, 38, 31, 4, -38 },
  { 5132, 33, 47, 38, 3, -38 },
  { 5326, 29, 38, 33, 4, -38 },
  { 5464, 24, 39, 27, 2, -38 },
  { 5581, 26, 38, 28, 1, -38 },
  { 5705, 29, 39, 37, 4, -38 },
  { 5847, 33, 38, 33, 0, -38 },
  { 6004, 49, 38, 49, 0, -38 },
  { 6237, 33, 38, 33, 0, -38 },
  { 6394, 31, 38, 31, 0, -38 },
  { 6542, 26, 38, 28, 1, -38 },
  { 6666, 13, 47, 17, 3, -38 },
  { 6743, 22, 38, 22, 0, -38 },
  { 6848, 13, 47, 17, 1, -38 },
  { 6925, 27, 25, 29, 1, -38 },
  { 7010, 24, 5, 24, 0, 4 },
  { 7025, 15, 9, 19, 2, -41 },
  { 7042, 25, 31, 30, 2, -30 },
  { 7139, 26, 41, 31, 3, -40 },
  { 7273, 22, 31, 26, 2, -30 },
  { 7359, 26, 41, 31, 2, -40 },
  { 7493, 25, 31, 29, 2, -30 },
  { 7590, 20, 41, 19, 1, -41 },
  { 7693, 26, 43, 31, 2, -30 },
  { 7833, 26, 40, 32, 3, -40 },
  { 7963, 9, 41, 15, 3, -41 },
  { 8010, 14, 54, 15, -2, -41 },
  { 8105, 28, 40, 31, 3, -40 },
  { 8245, 9, 40, 15, 3, -40 },
  { 8290, 42, 30, 48, 3, -30 },
  { 8448, 26, 30, 32, 3, -30 },
  { 8546, 27, 31, 31, 2, -30 },
  { 8651, 26, 43, 31, 3, -30 },
  { 8791, 26, 43, 31, 2, -30 },
  { 8931, 19, 30, 22, 3, -30 },
  { 9003, 21, 31, 25, 2, -30 },
  { 9085, 19, 36, 22, 1, -35 },
  { 9171, 26, 30, 32, 3, -29 },
  { 9269, 29, 29, 29, 0, -29 },
  { 9375, 43, 29, 43, 0, -29 },
  { 9531, 29, 29, 29, 0, -29 },
  { 9637, 29, 42, 29, 0, -29 },
  { 9790, 22, 29, 24, 1, -29 },
  { 9870, 18, 47, 21, 1, -38 },
  { 9976, 6, 52, 26, 10, -40 },
  { 10015, 18, 47, 21, 2, -38 },
  { 10121, 25, 9, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD53PT7B_H_
