#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x31, 0xEF, 0xFF, 0x78, 0xF3, 0xFE, 0x7B, 0xCF, 0x79, 0xEF, 0x3D,
  0xE7, 0xBC, 0xF7, 0x8E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38,
  0x0F, 0x38, 0x0F, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x70,
  0x1E, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0,
  0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0xFE, 0x0F, 0xFE, 0x7F, 0xFB, 0xFF, 0xCF, 0x31, 0x3C, 0xC0,
  0xFB, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x37,
  0xC0, 0xDF, 0xC3, 0x7B, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x3F, 0xC0, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0xFF, 0x83,
  0xC0, 0xF7, 0x87, 0x80, 0xF3, 0x87, 0x80, 0xE3, 0x8F, 0x00, 0xE3, 0x8F,
  0x00, 0xE3, 0x9E, 0x00, 0xE3, 0x9E, 0x30, 0xF7, 0xBC, 0xFC, 0x7F, 0xBD,
  0xFE, 0x7F, 0x79, 0xDE, 0x3E, 0x7B, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xF3,
  0xCF, 0x01, 0xE3, 0xCF, 0x01, 0xE3, 0xCF, 0x03, 0xC3, 0xCE, 0x03, 0xC1,
  0xFE, 0x07, 0x81, 0xFE, 0x07, 0x80, 0xFC, 0x07, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC3, 0xE7, 0xFE,
  0x7C, 0x7F, 0xF7, 0xCF, 0x9F, 0xFC, 0xF8, 0xFF, 0x8F, 0x87, 0xF0, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0x0F, 0x00, 0x38, 0x01,
  0xC1, 0x0E, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEE,
  0x0F, 0x78, 0xF1, 0xE1, 0x8C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7D, 0xE7, 0x9E, 0x7B, 0xCF,
  0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xEF, 0xFF, 0x78, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC,
  0x7C, 0xFB, 0xE3, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x1E, 0x78, 0xF9, 0xFF,
  0xE3, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xF3,
  0xFE, 0xFF, 0xFF, 0xF9, 0xDF, 0x23, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0xC0, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x70, 0xF8, 0x83, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xC1, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x20, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x3F, 0x80, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F,
  0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x1E, 0xF8, 0x3D, 0xF0, 0xF3, 0xE1, 0xC7, 0xC7,
  0x8F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0x77,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x20, 0xF7, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF,
  0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x78, 0x79, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x9F, 0x7E, 0x3F, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xFC, 0x7D, 0xFB, 0xE3, 0xEF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF3, 0xE7, 0xFF, 0x9F, 0xFC, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0x87, 0xFF,
  0x1F, 0xFC, 0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xBC, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x79, 0xE0, 0x07, 0x80, 0x3E, 0x01,
  0xF1, 0xBF, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x7B, 0xFF, 0xDE, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x7B, 0xFF, 0xDE, 0x79, 0xF7, 0xDE, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE7, 0x9E, 0x7B, 0xCF, 0x3C, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3E,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0x83, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE6, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0x78, 0xF0, 0x60,
  0xE7, 0x8F, 0xFB, 0xDC, 0x7F, 0xE7, 0x73, 0xE7, 0x1F, 0xCF, 0x1C, 0x7F,
  0x38, 0x71, 0xFC, 0xE1, 0xC7, 0xF3, 0x87, 0x1F, 0xCE, 0x1C, 0x7F, 0x3C,
  0xF3, 0xBC, 0xFF, 0xFE, 0x71, 0xFB, 0xF1, 0xE1, 0xC3, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x10, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE0, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0x80, 0x3E, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0xEF, 0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xF3, 0xF0, 0xCF, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x04, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0,
  0x23, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xF7, 0x87, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x3E, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xE0, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFE, 0xFF, 0x7F, 0x3F, 0x00,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF8,
  0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xF9, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x70, 0x7F, 0xFD, 0xE1, 0xFF,
  0xF7, 0x87, 0xFF, 0xDE, 0x1D, 0xFF, 0xBC, 0xF7, 0xFE, 0xF3, 0xDF, 0xFB,
  0xCE, 0x7F, 0xE7, 0x79, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x1F, 0xF9, 0xFC,
  0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8, 0x78, 0x7C,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xDF, 0x1F, 0xF7, 0xC7, 0xFC, 0xF9, 0xFF, 0x3E,
  0x7F, 0xE7, 0xDF, 0xF9, 0xF3, 0xFE, 0x3E, 0xFF, 0x87, 0xBF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xF8,
  0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xF0, 0xF8, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFB,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0x0F,
  0xE1, 0xFF, 0xDF, 0xFE, 0xFF, 0xEF, 0xC3, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x79,
  0xE0, 0x7C, 0x1F, 0x3C, 0x1F, 0x83, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8, 0x7F,
  0x0F, 0x0F, 0x0F, 0xE1, 0xE1, 0xE3, 0xFC, 0x7C, 0x3C, 0x7B, 0x8F, 0x87,
  0xCF, 0x79, 0xE0, 0xF9, 0xEF, 0x3C, 0x0F, 0x39, 0xE7, 0x81, 0xEF, 0x3D,
  0xF0, 0x3D, 0xE3, 0xBE, 0x07, 0xFC, 0x77, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0,
  0x3E, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xC7, 0x83,
  0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF,
  0xFC, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x70,
  0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x3E, 0x1E, 0x0F, 0x1F, 0xE1, 0xFF,
  0xC3, 0xFF, 0x8E, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0xFF, 0xCF, 0xFF, 0x7F,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF7, 0xFB, 0xCF,
  0xCF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x3E, 0x3D, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xBF, 0xFE,
  0xF7, 0xF3, 0xCF, 0x80, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFE, 0x7C, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC1, 0x7F, 0xF7,
  0xFF, 0x3F, 0xF0, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF1, 0xF3, 0xCF, 0xEF, 0x7F, 0xFD, 0xFF, 0xF7, 0xC7, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xF1, 0xF7,
  0xFF, 0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x9F, 0x1E, 0x78, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x7E, 0x18, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x07,
  0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x3F, 0xCF, 0xFC, 0xFF,
  0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x3C, 0xFE, 0xF7,
  0xFF, 0xDF, 0xFF, 0x7C, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xDF, 0x1F, 0x7E, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF,
  0x00, 0x3C, 0x01, 0xF4, 0x07, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF, 0xC3, 0xFC,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x3E, 0x3D, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF0, 0xF7, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F,
  0xFC, 0x3E, 0xF8, 0xF9, 0xF3, 0xE3, 0xEF, 0x87, 0xBE, 0x0F, 0x7C, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7,
  0xEF, 0x87, 0xDF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xE1, 0xF3, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xE1, 0xF0, 0xFF,
  0x87, 0xC3, 0xFE, 0x1F, 0x0F, 0xF8, 0x78, 0x3F, 0xE1, 0xE0, 0xFF, 0x87,
  0x83, 0xFE, 0x1E, 0x0F, 0xF8, 0x78, 0x3F, 0xE1, 0xE0, 0xFF, 0x87, 0x83,
  0xFE, 0x1E, 0x0F, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xF7, 0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xF3, 0xE3, 0xE7, 0xEF, 0xC7, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFB,
  0xFF, 0xEF, 0x7F, 0x3C, 0xF8, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF,
  0xFF, 0x7C, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xDF, 0x1F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xE3,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0xFC,
  0x6F, 0x81, 0xF8, 0x1F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFC, 0x0F, 0xC0, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFC, 0x1C, 0x0F, 0x03, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xCF, 0xCF, 0xF8, 0x1F, 0x78,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x7E, 0x1E, 0xF0, 0xFC, 0x3D, 0xE1,
  0xF8, 0xFB, 0xE3, 0xF1, 0xF7, 0xCF, 0xE3, 0xC7, 0x9D, 0xE7, 0x8F, 0x3B,
  0xDF, 0x1E, 0x73, 0xBE, 0x3F, 0xE7, 0x78, 0x3F, 0xCE, 0xF0, 0x7F, 0x1D,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8,
  0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x87, 0xC7, 0xE3, 0xF1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x9F, 0x8F, 0x87, 0xC3, 0xF8,
  0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7E, 0x3F, 0x0F, 0x80,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0xC3, 0xF0, 0xF8, 0x30,
  0x00, 0x3C, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 11, 8, 14, 2, -21 },
  { 28, 16, 21, 18, 1, -21 },
  { 70, 14, 24, 16, 1, -22 },
  { 112, 24, 21, 25, 1, -21 },
  { 175, 20, 21, 21, 1, -21 },
  { 228, 4, 8, 8, 2, -21 },
  { 232, 8, 26, 10, 1, -21 },
  { 258, 8, 26, 10, 1, -21 },
  { 284, 13, 13, 15, 1, -22 },
  { 306, 14, 14, 16, 1, -17 },
  { 331, 6, 8, 8, 1, -4 },
  { 337, 7, 4, 9, 1, -10 },
  { 341, 6, 5, 8, 1, -5 },
  { 345, 12, 21, 12, 0, -21 },
  { 377, 14, 21, 16, 1, -21 },
  { 414, 11, 21, 16, 1, -21 },
  { 443, 14, 21, 16, 1, -21 },
  { 480, 14, 21, 16, 1, -21 },
  { 517, 15, 21, 16, 0, -21 },
  { 557, 13, 21, 16, 1, -21 },
  { 592, 14, 21, 16, 1, -21 },
  { 629, 14, 21, 16, 1, -21 },
  { 666, 14, 21, 16, 1, -21 },
  { 703, 14, 21, 16, 1, -21 },
  { 740, 6, 16, 8, 1, -16 },
  { 752, 6, 20, 8, 1, -16 },
  { 767, 14, 15, 16, 1, -18 },
  { 794, 14, 9, 16, 1, -15 },
  { 810, 14, 15, 16, 1, -18 },
  { 837, 13, 21, 13, 0, -21 },
  { 872, 22, 23, 24, 1, -21 },
  { 936, 19, 21, 19, 0, -21 },
  { 986, 15, 21, 18, 2, -21 },
  { 1026, 15, 21, 17, 1, -21 },
  { 1066, 16, 21, 20, 2, -21 },
  { 1108, 11, 21, 15, 2, -21 },
  { 1137, 11, 21, 15, 2, -21 },
  { 1166, 17, 21, 20, 1, -21 },
  { 1211, 16, 21, 20, 2, -21 },
  { 1253, 9, 21, 11, 1, -21 },
  { 1277, 9, 27, 9, -2, -21 },
  { 1308, 16, 21, 18, 2, -21 },
  { 1350, 12, 21, 15, 2, -21 },
  { 1382, 22, 21, 26, 2, -21 },
  { 1440, 18, 21, 22, 2, -21 },
  { 1488, 19, 21, 21, 1, -21 },
  { 1538, 14, 21, 17, 2, -21 },
  { 1575, 19, 26, 21, 1, -21 },
  { 1637, 16, 21, 18, 2, -21 },
  { 1679, 13, 21, 15, 1, -21 },
  { 1714, 14, 21, 15, 1, -21 },
  { 1751, 16, 21, 20, 2, -21 },
  { 1793, 18, 21, 18, 0, -21 },
  { 1841, 27, 21, 27, 0, -21 },
  { 1912, 18, 21, 18, 0, -21 },
  { 1960, 17, 21, 17, 0, -21 },
  { 2005, 14, 21, 16, 1, -21 },
  { 2042, 7, 26, 9, 2, -21 },
  { 2065, 12, 21, 12, 0, -21 },
  { 2097, 7, 26, 9, 1, -21 },
  { 2120, 16, 14, 16, 0, -21 },
  { 2148, 13, 3, 13, 0, 2 },
  { 2153, 8, 4, 11, 1, -22 },
  { 2157, 14, 16, 16, 1, -16 },
  { 2185, 14, 22, 17, 2, -22 },
  { 2224, 12, 16, 14, 1, -16 },
  { 2248, 14, 22, 17, 1, -22 },
  { 2287, 14, 16, 16, 1, -16 },
  { 2315, 12, 22, 11, 0, -22 },
  { 2348, 14, 23, 17, 1, -16 },
  { 2389, 14, 22, 18, 2, -22 },
  { 2428, 5, 22, 8, 2, -22 },
  { 2442, 8, 29, 8, -1, -22 },
  { 2471, 15, 22, 17, 2, -22 },
  { 2513, 5, 22, 8, 2, -22 },
  { 2527, 22, 16, 26, 2, -16 },
  { 2571, 14, 16, 18, 2, -16 },
  { 2599, 15, 16, 17, 1, -16 },
  { 2629, 14, 23, 17, 2, -16 },
  { 2670, 14, 23, 17, 1, -16 },
  { 2711, 10, 16, 12, 2, -16 },
  { 2731, 11, 16, 13, 1, -16 },
  { 2753, 10, 19, 12, 1, -19 },
  { 2777, 14, 16, 18, 2, -16 },
  { 2805, 16, 16, 16, 0, -16 },
  { 2837, 23, 16, 24, 0, -16 },
  { 2883, 16, 16, 16, 0, -16 },
  { 2915, 16, 23, 16, 0, -16 },
  { 2961, 11, 16, 13, 1, -16 },
  { 2983, 9, 26, 11, 1, -21 },
  { 3013, 4, 29, 14, 5, -22 },
  { 3028, 10, 26, 11, 1, -21 },
  { 3061, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD29PT7B_H_
