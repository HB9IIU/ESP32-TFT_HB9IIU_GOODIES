#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x70, 0x6F, 0xFF, 0xF7, 0xFB, 0xB9,
  0xDC, 0xE6, 0x73, 0x38, 0x06, 0x60, 0x73, 0x03, 0x98, 0x1D, 0xC0, 0xCE,
  0x3F, 0xFD, 0xFF, 0xE3, 0x98, 0x1D, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1,
  0x98, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x0C, 0x03, 0x03, 0xF9, 0xFF, 0xFF,
  0xBB, 0x0E, 0xC3, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x37, 0x8D, 0xFF, 0xFF,
  0xFB, 0xFC, 0x0C, 0x03, 0x00, 0x78, 0x1C, 0x3F, 0x06, 0x0E, 0xE3, 0x83,
  0x38, 0xC0, 0xCE, 0x70, 0x33, 0x98, 0x0C, 0xEE, 0x63, 0xBB, 0x7E, 0xFD,
  0xDF, 0x8E, 0x66, 0x70, 0x3B, 0x9C, 0x0C, 0xE7, 0x07, 0x19, 0xC1, 0x87,
  0x60, 0xE1, 0xF8, 0x70, 0x3C, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x8E,
  0x07, 0x3C, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0x9E, 0x7F, 0x3D, 0xFF, 0x73,
  0xDF, 0xE7, 0x1F, 0x8F, 0x1F, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x9F, 0xFF,
  0xEE, 0x66, 0x1C, 0xE7, 0x9C, 0x73, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8F, 0x1C, 0x70, 0xE3, 0xC0, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x73, 0xC0, 0x0E, 0x01,
  0xC0, 0x38, 0x37, 0x67, 0xFF, 0xFF, 0xC7, 0xC0, 0xDC, 0x3B, 0xC3, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x7F, 0xFE, 0xEC, 0xFF, 0xFE, 0x6F, 0xFF, 0x03, 0x81, 0xC1,
  0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x83,
  0x81, 0xC1, 0xE0, 0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0xCF, 0xF3, 0xDF, 0xE7, 0xF8, 0xFC, 0x07,
  0x0F, 0x1F, 0x7F, 0xF7, 0x67, 0x4F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x3E, 0x1F, 0xEF, 0xF9, 0x8F, 0x43, 0xC0, 0xF0, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x3E,
  0x3F, 0xEF, 0xF9, 0x0F, 0x03, 0xC0, 0xE0, 0xF8, 0xF8, 0x3F, 0x81, 0xF0,
  0x3C, 0x0F, 0x83, 0xFF, 0xFF, 0xFB, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xBC, 0x73, 0xC7, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0,
  0x70, 0x3C, 0x0F, 0xF3, 0xFE, 0x7F, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xFF,
  0xEF, 0xFB, 0xF8, 0x0F, 0x8F, 0xE7, 0xF9, 0xE0, 0xF0, 0x38, 0x0E, 0xFB,
  0xFE, 0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF7, 0xF8, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0xEF, 0xFF, 0xCF,
  0xF3, 0xFC, 0xE7, 0xF8, 0xFC, 0x7F, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xFD,
  0xFF, 0xF8, 0xFC, 0x1E, 0x1F, 0xCF, 0xFB, 0xCF, 0xE3, 0xF8, 0x7E, 0x3F,
  0xCF, 0xFF, 0xDF, 0x71, 0x9C, 0x0F, 0x03, 0x9F, 0xE7, 0xF1, 0xF0, 0xFF,
  0xF6, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x07, 0xFF, 0xEE,
  0xC0, 0x00, 0x40, 0x30, 0x3C, 0x3E, 0x3E, 0x3E, 0x0F, 0x01, 0xF8, 0x1F,
  0x81, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x30, 0x0F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x7E, 0x7E,
  0x3E, 0x0E, 0x02, 0x00, 0x3E, 0x3F, 0xE7, 0xF9, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x08, 0x0F, 0x03, 0xC0, 0x70,
  0x03, 0xE0, 0x07, 0xFE, 0x07, 0x87, 0x87, 0x01, 0xC7, 0x1F, 0x73, 0x3F,
  0x9B, 0x9C, 0xCD, 0xDC, 0x67, 0xCE, 0x33, 0xE7, 0x39, 0xB3, 0x9C, 0xDD,
  0xFF, 0xEE, 0x7D, 0xE3, 0x88, 0x41, 0xC0, 0x00, 0x7C, 0xF0, 0x1F, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1E, 0xE0,
  0x7B, 0x81, 0xCE, 0x07, 0x3C, 0x3C, 0xF0, 0xF1, 0xC3, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF9, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xF3, 0xFF, 0x71,
  0xEE, 0x1D, 0xC3, 0xBF, 0xF7, 0xF8, 0xFF, 0x9C, 0x7B, 0x87, 0xF0, 0xFE,
  0x1F, 0xFF, 0xBF, 0xF7, 0xF8, 0x0F, 0xC3, 0xFC, 0xFF, 0xBE, 0x27, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x82, 0xFF,
  0xCF, 0xF8, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE1, 0xEE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xE3, 0xEF, 0xFC,
  0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07,
  0xE1, 0xFF, 0x3F, 0xF7, 0xC2, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF0, 0x77, 0x07, 0x78, 0x77, 0xFF, 0x3F, 0xF0, 0xFF, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xBF,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0xFF, 0xEF, 0x00, 0xE0, 0xFE, 0x1E, 0xE3,
  0xCE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xE7,
  0x8E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1F, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x37, 0xFC, 0x77, 0xEE, 0x77, 0xEE, 0x67, 0xEE, 0xE7, 0xE6, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8, 0xFD, 0xE7, 0xE7,
  0x3F, 0x3D, 0xF8, 0xEF, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F,
  0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x7B, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0E, 0x78, 0x79, 0xFF,
  0xE3, 0xFF, 0x03, 0xF0, 0xFC, 0x3F, 0xEF, 0xFB, 0x9F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x9F, 0xFF, 0xBF, 0xCF, 0xC3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x1E, 0x1E, 0x78, 0x7B, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0E, 0x78, 0x79, 0xFF,
  0xE3, 0xFF, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFC,
  0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCF, 0xF8, 0xFF,
  0x0F, 0xF0, 0xE7, 0x0E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFB, 0xC6, 0xF0, 0x3C, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xE0,
  0x7C, 0x0F, 0x83, 0xFF, 0xEF, 0xFB, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF1,
  0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0xF0, 0x3F, 0xC0, 0xE7, 0x07, 0x9E, 0x1E,
  0x78, 0x70, 0xE3, 0xC3, 0x8F, 0x0F, 0x38, 0x3C, 0xE0, 0x77, 0x81, 0xDE,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0xF0, 0xF0, 0x7F,
  0x0F, 0x0F, 0x70, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF8, 0xE7, 0x9F, 0x8E,
  0x79, 0xF9, 0xE3, 0x9D, 0x9E, 0x39, 0xDD, 0xC3, 0xB9, 0xDC, 0x3F, 0x9D,
  0xC1, 0xF9, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0xF8, 0xF0, 0x79, 0xE1, 0xE3, 0x8F, 0x0F, 0x38, 0x1D, 0xE0, 0x7F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0x78, 0x3C, 0xF1,
  0xE3, 0xC7, 0x87, 0xBC, 0x1F, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0x71, 0xC3,
  0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF, 0xE0, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x1E, 0x07, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1F, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F,
  0x81, 0x98, 0x39, 0xC3, 0x1C, 0x70, 0xEE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF1,
  0xE3, 0x83, 0x7F, 0x1F, 0xE3, 0x3C, 0x0F, 0x0F, 0xDF, 0xFF, 0xFF, 0x8F,
  0xE3, 0xFD, 0xFF, 0xFD, 0xF7, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xEF, 0x3F, 0xF7, 0xFF, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE3,
  0xFF, 0xFF, 0xFE, 0xE7, 0x80, 0x3F, 0xBF, 0xDF, 0xDE, 0x0F, 0x07, 0x03,
  0x81, 0xE0, 0xF0, 0xBF, 0xDF, 0xE7, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x7B, 0xDF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF,
  0x1F, 0xE3, 0xFF, 0xFB, 0xFF, 0x3C, 0xE0, 0x3F, 0x1F, 0xE7, 0x3F, 0xC7,
  0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x77, 0xFC, 0xFE, 0x0F, 0x0F,
  0xCF, 0xC7, 0x83, 0x83, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x3D, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1F,
  0x03, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xEF, 0xBF, 0xF7, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x7F, 0xF2, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1C, 0xF3, 0xC2, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB, 0xE0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x1F, 0xF1, 0xCF, 0x3C, 0xF7, 0x8F, 0xF0, 0xFF,
  0x0F, 0xF8, 0xFF, 0x8F, 0x3C, 0xF1, 0xCF, 0x1E, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xDF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7,
  0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xE7, 0xDF,
  0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xF0, 0x3F, 0x0F, 0xF9, 0xEF, 0x78, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x8F, 0xF1, 0xEF, 0xF9, 0xFE, 0x0F, 0x80, 0xE7, 0x9F, 0xFB, 0xFF,
  0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFF, 0xFF, 0xFF, 0x7B,
  0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x3D, 0xEF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD, 0xFF, 0x9E,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xE7, 0xEF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0xFF, 0xE3, 0xE0,
  0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xFF, 0xFF, 0xFE, 0x18, 0x18, 0x38, 0x7F,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xEF,
  0xFD, 0xFF, 0x9F, 0x70, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x9E, 0x39, 0xC3,
  0x9C, 0x3B, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xF1, 0xE3,
  0xDC, 0x78, 0xE7, 0x3E, 0x39, 0xCF, 0xCE, 0x7B, 0xF7, 0x8E, 0xCD, 0xC3,
  0xB3, 0x70, 0xFC, 0xDC, 0x3F, 0x3F, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78,
  0x78, 0xF0, 0xF7, 0x9E, 0x3F, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0xC3, 0x9C, 0x79, 0xEF, 0x0F, 0xF0, 0xF7, 0x0E, 0x70, 0xE7,
  0x9E, 0x39, 0xC3, 0x9C, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0x1F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x7C, 0xF8, 0xF8, 0x3C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1F, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE1, 0xE3, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3E, 0x3C, 0xF9,
  0xE3, 0x87, 0x0E, 0x1C, 0x79, 0xF3, 0xC6, 0x00, 0x70, 0x7F, 0xBF, 0xFE,
  0x1F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 13, 16, 13, 0, -16 },
  { 42, 10, 18, 12, 1, -17 },
  { 65, 18, 16, 19, 1, -16 },
  { 101, 15, 16, 16, 1, -16 },
  { 131, 4, 6, 6, 1, -16 },
  { 134, 6, 19, 7, 1, -16 },
  { 149, 7, 19, 7, 0, -16 },
  { 166, 11, 10, 11, 0, -17 },
  { 180, 10, 11, 12, 1, -13 },
  { 194, 4, 6, 6, 1, -3 },
  { 197, 5, 3, 7, 1, -7 },
  { 199, 4, 4, 6, 1, -4 },
  { 201, 9, 16, 9, 0, -16 },
  { 219, 10, 16, 12, 1, -16 },
  { 239, 8, 16, 12, 1, -16 },
  { 255, 10, 16, 12, 1, -16 },
  { 275, 10, 16, 12, 1, -16 },
  { 295, 12, 16, 12, 0, -16 },
  { 319, 10, 16, 12, 1, -16 },
  { 339, 10, 16, 12, 1, -16 },
  { 359, 10, 16, 12, 1, -16 },
  { 379, 10, 16, 12, 1, -16 },
  { 399, 10, 16, 12, 1, -16 },
  { 419, 4, 12, 6, 1, -12 },
  { 425, 4, 15, 6, 1, -12 },
  { 433, 10, 12, 12, 1, -14 },
  { 448, 10, 7, 12, 1, -11 },
  { 457, 10, 12, 12, 1, -14 },
  { 472, 10, 16, 10, 0, -16 },
  { 492, 17, 18, 19, 1, -16 },
  { 531, 14, 16, 14, 0, -16 },
  { 559, 11, 16, 14, 2, -16 },
  { 581, 11, 16, 13, 1, -16 },
  { 603, 12, 16, 15, 2, -16 },
  { 627, 8, 16, 11, 2, -16 },
  { 643, 8, 16, 11, 2, -16 },
  { 659, 12, 16, 15, 1, -16 },
  { 683, 12, 16, 15, 2, -16 },
  { 707, 7, 16, 8, 1, -16 },
  { 721, 7, 21, 7, -2, -16 },
  { 740, 12, 16, 14, 2, -16 },
  { 764, 9, 16, 11, 2, -16 },
  { 782, 16, 16, 20, 2, -16 },
  { 814, 13, 16, 17, 2, -16 },
  { 840, 14, 16, 16, 1, -16 },
  { 868, 10, 16, 13, 2, -16 },
  { 888, 14, 20, 16, 1, -16 },
  { 923, 12, 16, 14, 2, -16 },
  { 947, 10, 16, 11, 1, -16 },
  { 967, 11, 16, 12, 0, -16 },
  { 989, 12, 16, 15, 2, -16 },
  { 1013, 14, 16, 14, 0, -16 },
  { 1041, 20, 16, 20, 0, -16 },
  { 1081, 14, 16, 14, 0, -16 },
  { 1109, 13, 16, 13, 0, -16 },
  { 1135, 11, 16, 12, 0, -16 },
  { 1157, 6, 20, 7, 1, -16 },
  { 1172, 9, 16, 9, 0, -16 },
  { 1190, 6, 20, 7, 0, -16 },
  { 1205, 12, 10, 12, 0, -16 },
  { 1220, 10, 2, 10, 0, 2 },
  { 1223, 6, 4, 8, 1, -17 },
  { 1226, 10, 12, 12, 1, -12 },
  { 1241, 11, 17, 13, 1, -17 },
  { 1265, 9, 12, 11, 1, -12 },
  { 1279, 11, 17, 13, 1, -17 },
  { 1303, 10, 12, 12, 1, -12 },
  { 1318, 9, 17, 8, 0, -17 },
  { 1338, 11, 17, 13, 1, -12 },
  { 1362, 11, 17, 13, 1, -17 },
  { 1386, 4, 17, 6, 1, -17 },
  { 1395, 6, 22, 6, -1, -17 },
  { 1412, 12, 17, 13, 1, -17 },
  { 1438, 4, 17, 6, 1, -17 },
  { 1447, 18, 12, 20, 1, -12 },
  { 1474, 11, 12, 13, 1, -12 },
  { 1491, 11, 12, 13, 1, -12 },
  { 1508, 11, 17, 13, 1, -12 },
  { 1532, 11, 17, 13, 1, -12 },
  { 1556, 8, 12, 9, 1, -12 },
  { 1568, 8, 12, 10, 1, -12 },
  { 1580, 8, 15, 9, 0, -15 },
  { 1595, 11, 12, 13, 1, -12 },
  { 1612, 12, 12, 12, 0, -12 },
  { 1630, 18, 12, 18, 0, -12 },
  { 1657, 12, 12, 12, 0, -12 },
  { 1675, 12, 17, 12, 0, -12 },
  { 1701, 8, 12, 10, 1, -12 },
  { 1713, 8, 20, 9, 0, -16 },
  { 1733, 3, 22, 11, 4, -17 },
  { 1742, 7, 20, 9, 1, -16 },
  { 1760, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD22PT7B_H_
