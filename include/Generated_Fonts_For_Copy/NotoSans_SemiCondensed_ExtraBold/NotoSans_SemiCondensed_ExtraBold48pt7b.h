#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xBF, 0x82, 0x00, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFD, 0xE3, 0xCF, 0xE7, 0x81, 0x3F, 0x9E, 0x00,
  0xFE, 0x78, 0x03, 0xFD, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1E, 0xFF, 0x00, 0x79, 0xFC,
  0x01, 0xE7, 0xFC, 0x07, 0x9F, 0xFC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x3F, 0x01,
  0xF8, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x1F, 0x80,
  0x00, 0x7C, 0x3F, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x3F, 0x1F, 0xF8, 0x7E,
  0x7E, 0x3F, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x7E,
  0x7F, 0xFE, 0x1F, 0xFC, 0xFC, 0x7E, 0x7E, 0x0F, 0xF8, 0xFC, 0xFC, 0x3E,
  0x03, 0xC1, 0xF8, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x1F, 0x80,
  0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0x03, 0xFC, 0x3F, 0xFF,
  0x83, 0xFC, 0x7F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8, 0xFF, 0xBF,
  0xE7, 0xF8, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE7, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFB, 0xF7, 0xE0, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x06, 0x07, 0xC0, 0x9F, 0x1F, 0x3F, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0,
  0x3F, 0x3F, 0x81, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x07, 0x83, 0xC0, 0x04,
  0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x87,
  0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7,
  0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x7F, 0x8F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xF7,
  0xF3, 0xFC, 0xF8, 0xFF, 0x1C, 0x3F, 0xC2, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0x83, 0xFE, 0x1E, 0x03, 0xFC, 0x10, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0x03, 0xFE, 0x10, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF8,
  0x07, 0xE7, 0xF8, 0x07, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8,
  0x1F, 0x87, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x07, 0xF8, 0x7E, 0x07, 0xF8,
  0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xC1, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xBE, 0x07, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x04, 0x03, 0xF8, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xBF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x87, 0xFD,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7,
  0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x9F, 0xE1, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0xFE, 0x03,
  0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xDF, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xE1, 0xFF, 0x9F, 0xC1,
  0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x1C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xCF, 0xC1, 0x00, 0x0F, 0x0F, 0xE3,
  0xFC, 0xFF, 0x7F, 0xCF, 0xF3, 0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7,
  0x80, 0xFF, 0x10, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xF0,
  0x7E, 0x3F, 0x03, 0xFF, 0xE3, 0xE3, 0xF0, 0xFF, 0xFE, 0x3F, 0x7E, 0x1F,
  0xFF, 0xE3, 0xF7, 0xE1, 0xFF, 0xFE, 0x1F, 0x7C, 0x3F, 0x87, 0xE1, 0xFF,
  0xC3, 0xF0, 0x7E, 0x1F, 0xFC, 0x7E, 0x07, 0xE1, 0xFF, 0xC7, 0xE0, 0x7E,
  0x1F, 0xFC, 0x7E, 0x07, 0xE1, 0xFF, 0xC7, 0xE0, 0x7E, 0x1F, 0xF8, 0x7E,
  0x07, 0xE1, 0xFF, 0x87, 0xE0, 0x7E, 0x1F, 0xFC, 0x7E, 0x0F, 0xE3, 0xFF,
  0xC7, 0xE0, 0xFE, 0x3E, 0xFC, 0x3F, 0x1F, 0xE7, 0xEF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7C, 0x1F, 0xFD, 0xFF, 0xC7, 0xE1, 0xFF, 0xCF, 0xF8, 0x7E, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x08, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x07, 0xFE, 0xFE, 0x03, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC,
  0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0xFE, 0x07, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3C, 0x3F, 0xE0, 0x02, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x63, 0xFF, 0xC1,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xF3, 0xF8, 0x0F, 0xFC, 0xFE, 0x00,
  0xFF, 0xBF, 0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFB, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x7F, 0xCF, 0xE0, 0x3F, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x1C,
  0x3F, 0xF0, 0x00, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF7, 0xF8, 0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xDF,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xEF, 0xF8, 0x01,
  0xFC, 0xFF, 0x80, 0x3F, 0x9F, 0xF8, 0x07, 0xF1, 0xFF, 0x81, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xD0, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0x00,
  0x7F, 0xFF, 0xF7, 0xE0, 0x1F, 0xBF, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xEF,
  0xC0, 0x7E, 0xFF, 0xFD, 0xF8, 0x1F, 0xDF, 0xFF, 0xBF, 0x83, 0xF3, 0xFF,
  0xF7, 0xF0, 0x7E, 0x7F, 0xFE, 0x7E, 0x0F, 0xCF, 0xFF, 0xCF, 0xC3, 0xF1,
  0xFF, 0xF9, 0xFC, 0x7E, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7, 0xFF, 0xE3, 0xF3,
  0xF8, 0xFF, 0xFC, 0x7F, 0x7E, 0x1F, 0xFF, 0x8F, 0xEF, 0xC3, 0xFF, 0xF0,
  0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xC0, 0x7F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x7F, 0x81, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x7F,
  0xC3, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0xCF, 0xF8, 0x7F, 0xFE, 0x3F, 0xC3,
  0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0x87, 0xF8, 0xFF, 0xFC, 0x3F, 0xE7, 0xFF,
  0xE0, 0xFF, 0x3F, 0xFF, 0x07, 0xFD, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF,
  0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x07,
  0xFD, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F,
  0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFF, 0x0F, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFE,
  0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x8F, 0xE0, 0x1F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0xBF,
  0x80, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xF0, 0x3C,
  0xFF, 0x00, 0x27, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFF, 0x01, 0xFF,
  0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE7, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0x9F, 0x87,
  0xF8, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0x9F, 0x87, 0xF0,
  0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x9F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xF8, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x0F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF0, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0,
  0xFC, 0xFE, 0x00, 0x3F, 0x7E, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFC, 0xFF,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xF0, 0x7F, 0xC2, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFC, 0xFF, 0xE3, 0xF1, 0xFF,
  0x0F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0x03, 0xFC, 0xFF, 0x87, 0xFB, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFD, 0xFF, 0xE3, 0xF9, 0xFF, 0xC7, 0xE1, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xF7, 0xC7, 0xFC, 0x04, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x02,
  0x7F, 0xC0, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xC1, 0xFC, 0x1F,
  0xF3, 0xF8, 0xFF, 0xF7, 0xF1, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFD, 0xFC, 0x3F, 0xF1, 0xF8, 0x3F,
  0xC3, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x8F, 0xFE, 0x3F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x38,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF9, 0xFC, 0x7F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xF9, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFE, 0x1F, 0xF9, 0xFC, 0x1F,
  0xE3, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xD0, 0x00,
  0x7F, 0xB8, 0x01, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0x03, 0xFC, 0xFF, 0xC7, 0xFB, 0xFF, 0xCF,
  0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x3C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFF, 0x1F, 0xF0, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8,
  0x3F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x9F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xF7, 0xF8, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xEF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xBF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xC1,
  0xFE, 0xFF, 0x83, 0xFF, 0x07, 0xFB, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x81, 0xF8,
  0x7F, 0xE3, 0xF9, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0x81, 0xFC, 0x7F, 0xC3, 0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFE,
  0xFF, 0xE3, 0xFC, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF9, 0xFC, 0x7F, 0xFB,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF,
  0xBF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xFC,
  0x0F, 0xF7, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x1F, 0xFE, 0xFE, 0x1F, 0xF9, 0xFC, 0x1F, 0xE3, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0xDF, 0xEF, 0xEF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xE0,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x81, 0xE7,
  0xF0, 0x04, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x47, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0x1F, 0xFC, 0x7E, 0x1F, 0xF0, 0xFC, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xF9, 0xFE, 0x07,
  0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xF8, 0x3F,
  0xC7, 0xF0, 0x7F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFB, 0xE0, 0xFE, 0x1F, 0xE1,
  0xF7, 0xE3, 0xFC, 0x1F, 0xC7, 0xEF, 0xC7, 0xF8, 0x3F, 0x8F, 0xDF, 0x8F,
  0xE0, 0x7F, 0x1F, 0x9F, 0x1F, 0xC0, 0xFF, 0x3E, 0x3E, 0x3F, 0x80, 0xFE,
  0x7C, 0x7E, 0xFE, 0x01, 0xFD, 0xF8, 0xFD, 0xFC, 0x03, 0xFB, 0xF1, 0xFB,
  0xF8, 0x07, 0xF7, 0xE1, 0xF7, 0xF0, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0x0F,
  0xDF, 0x07, 0xDF, 0x80, 0x1F, 0xFE, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xF1, 0xFE, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07,
  0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x05,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xA0, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 18, 12, 23, 3, -34 },
  { 68, 27, 34, 29, 1, -34 },
  { 183, 22, 39, 26, 2, -36 },
  { 291, 40, 35, 42, 1, -35 },
  { 466, 32, 35, 34, 2, -35 },
  { 606, 7, 12, 13, 3, -34 },
  { 617, 13, 43, 16, 2, -35 },
  { 687, 13, 43, 16, 1, -35 },
  { 757, 22, 22, 24, 1, -37 },
  { 818, 22, 24, 26, 2, -29 },
  { 884, 10, 12, 14, 1, -6 },
  { 899, 13, 6, 15, 1, -16 },
  { 909, 9, 9, 13, 2, -8 },
  { 920, 20, 35, 20, 0, -35 },
  { 1008, 22, 35, 26, 2, -35 },
  { 1105, 18, 34, 26, 2, -34 },
  { 1182, 23, 35, 26, 1, -35 },
  { 1283, 22, 35, 26, 2, -35 },
  { 1380, 24, 34, 26, 1, -34 },
  { 1482, 22, 34, 26, 2, -34 },
  { 1576, 22, 35, 26, 2, -35 },
  { 1673, 23, 34, 26, 1, -34 },
  { 1771, 22, 35, 26, 2, -35 },
  { 1868, 23, 35, 26, 1, -35 },
  { 1969, 9, 28, 13, 2, -27 },
  { 2001, 10, 33, 14, 1, -27 },
  { 2043, 22, 25, 26, 2, -30 },
  { 2112, 22, 16, 26, 2, -25 },
  { 2156, 22, 25, 26, 2, -30 },
  { 2225, 21, 36, 22, 0, -35 },
  { 2320, 36, 39, 40, 2, -35 },
  { 2496, 31, 34, 31, 0, -34 },
  { 2628, 24, 34, 30, 4, -34 },
  { 2730, 25, 35, 28, 2, -35 },
  { 2840, 26, 34, 32, 4, -34 },
  { 2951, 18, 34, 25, 4, -34 },
  { 3028, 18, 34, 24, 4, -34 },
  { 3105, 27, 35, 32, 2, -35 },
  { 3224, 26, 34, 34, 4, -34 },
  { 3335, 16, 34, 18, 1, -34 },
  { 3403, 15, 44, 15, -3, -34 },
  { 3486, 26, 34, 30, 4, -34 },
  { 3597, 19, 34, 25, 4, -34 },
  { 3678, 35, 34, 43, 4, -34 },
  { 3827, 29, 34, 36, 4, -34 },
  { 3951, 30, 35, 35, 2, -35 },
  { 4083, 22, 34, 28, 4, -34 },
  { 4177, 31, 43, 35, 2, -35 },
  { 4344, 26, 34, 30, 4, -34 },
  { 4455, 21, 35, 25, 2, -35 },
  { 4547, 24, 34, 26, 1, -34 },
  { 4649, 27, 34, 33, 3, -34 },
  { 4764, 30, 34, 30, 0, -34 },
  { 4892, 44, 34, 44, 0, -34 },
  { 5079, 30, 34, 30, 0, -34 },
  { 5207, 28, 34, 28, 0, -34 },
  { 5326, 24, 34, 26, 1, -34 },
  { 5428, 11, 43, 15, 3, -35 },
  { 5488, 20, 35, 20, 0, -35 },
  { 5576, 12, 43, 15, 1, -35 },
  { 5641, 25, 22, 26, 1, -34 },
  { 5710, 22, 4, 22, 0, 4 },
  { 5721, 14, 8, 18, 2, -37 },
  { 5735, 22, 27, 27, 2, -27 },
  { 5810, 23, 36, 28, 3, -36 },
  { 5914, 20, 27, 23, 2, -27 },
  { 5982, 23, 36, 28, 2, -36 },
  { 6086, 23, 27, 27, 2, -27 },
  { 6164, 18, 37, 18, 1, -37 },
  { 6248, 23, 39, 28, 2, -27 },
  { 6361, 23, 36, 29, 3, -36 },
  { 6465, 8, 37, 14, 3, -37 },
  { 6502, 13, 49, 14, -2, -37 },
  { 6582, 25, 36, 28, 3, -36 },
  { 6695, 8, 36, 14, 3, -36 },
  { 6731, 38, 27, 43, 3, -27 },
  { 6860, 23, 27, 29, 3, -27 },
  { 6938, 24, 27, 28, 2, -27 },
  { 7019, 23, 39, 28, 3, -27 },
  { 7132, 23, 39, 28, 2, -27 },
  { 7245, 17, 27, 20, 3, -27 },
  { 7303, 19, 27, 22, 2, -27 },
  { 7368, 17, 32, 20, 1, -32 },
  { 7436, 23, 26, 29, 3, -26 },
  { 7511, 26, 26, 26, 0, -26 },
  { 7596, 39, 26, 39, 0, -26 },
  { 7723, 26, 26, 26, 0, -26 },
  { 7808, 26, 38, 26, 0, -26 },
  { 7932, 20, 26, 22, 1, -26 },
  { 7997, 16, 43, 19, 1, -35 },
  { 8083, 6, 48, 24, 9, -37 },
  { 8119, 16, 43, 19, 2, -35 },
  { 8205, 22, 8, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD48PT7B_H_
