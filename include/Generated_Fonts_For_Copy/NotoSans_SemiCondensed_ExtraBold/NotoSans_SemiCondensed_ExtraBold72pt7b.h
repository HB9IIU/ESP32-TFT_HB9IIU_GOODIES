#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFE, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0x07, 0xFE, 0x7F,
  0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC7, 0xC0, 0xF8, 0xFF, 0xE3, 0xE0, 0x0C, 0x7F, 0xE1,
  0xF0, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x1F, 0xF8, 0x7C, 0x00, 0x0F, 0xFE,
  0x3E, 0x00, 0x07, 0xFF, 0x9F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7D, 0xFF, 0xF0, 0x00, 0x3E, 0x7F, 0xF8, 0x00, 0x1F, 0x1F,
  0xFC, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x03, 0xE1,
  0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xFF, 0x80, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x80, 0x7C, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0x03, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xE7, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC7, 0xFC, 0x0F, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x40, 0x0F, 0xF0, 0x01, 0x3C, 0x03,
  0xF8, 0x07, 0x9F, 0xC1, 0xFC, 0x1F, 0xCF, 0xFC, 0xFE, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xCF, 0xFC, 0x3F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xF3,
  0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3E, 0x07,
  0xFF, 0x83, 0x80, 0xFF, 0xF0, 0x20, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0xF8, 0x7F, 0x80, 0x3F, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0x81, 0xC0, 0x01,
  0xFF, 0xE0, 0x20, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xF8, 0x1C, 0x00, 0x3F, 0xFE, 0x04, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFD, 0x80, 0x00, 0x3F, 0xFE, 0xF0, 0x00,
  0x3F, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xF8,
  0x1F, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xBF,
  0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x00,
  0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x07,
  0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x5F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0xC0, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x30, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xA0, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE3, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFB, 0xFF, 0xFC,
  0x7E, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC7,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xCF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xBF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0x00,
  0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFD, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0xF3, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xE7,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xCF, 0xF8, 0x3F, 0xF0, 0x7F, 0xF8,
  0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xC0,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF4, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1,
  0xFF, 0xF8, 0x00, 0x38, 0x3F, 0xFF, 0x00, 0x00, 0x83, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x43, 0xFF, 0xFC, 0x00, 0x3C, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x3F, 0xFF,
  0x80, 0x00, 0x10, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x1F, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xE1,
  0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x07, 0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFD,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xE0,
  0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFF, 0xFF,
  0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0x9F, 0xF0, 0x03, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFE, 0x01,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x7F, 0xC7, 0xFF, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x03,
  0xF8, 0xFF, 0xF8, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0x10, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xF1,
  0xFF, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F,
  0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x01, 0xFF,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xFC, 0x00, 0x03,
  0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x07,
  0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x8F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE3, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x1F, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xF0, 0x18, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xDF, 0xFE,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFD,
  0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0x07, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F,
  0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0x01, 0xFF,
  0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFD,
  0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0x81, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xC3, 0xFF, 0xE0, 0x06, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x09, 0xFF, 0xF0, 0x00, 0xE7, 0xFF, 0xF0, 0x0F, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0xFF,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0xEF,
  0xFF, 0x80, 0xFF, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF,
  0xC0, 0x3F, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x43, 0xFF,
  0xE0, 0x00, 0x70, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x08, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF,
  0x83, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFF,
  0x81, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x7F,
  0xF0, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xFC,
  0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x40, 0x00, 0x07, 0xFF, 0x8F, 0x00, 0x01, 0xFF,
  0xF1, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF,
  0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xC3, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x87, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xF8, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xF0,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFE, 0x00,
  0x1F, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF,
  0xE0, 0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F,
  0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xF0,
  0x0F, 0xFF, 0x3F, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF,
  0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xF0, 0x0F,
  0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF,
  0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF,
  0xDF, 0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xF0, 0xFF, 0xEF,
  0xF8, 0xFF, 0xF7, 0xFE, 0xFF, 0xFB, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x3F, 0x8F,
  0xFE, 0x00, 0x78, 0xFF, 0xE0, 0x01, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x04, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF,
  0x80, 0x3F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x03, 0xFD, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xBF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xC7, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xF8, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xE3,
  0xFC, 0x3F, 0xE7, 0xFF, 0x00, 0x3F, 0xF1, 0xFE, 0x0F, 0xF3, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0x07, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x83, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF,
  0xC0, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xE0, 0x3F, 0xDF, 0xF0, 0x00,
  0x3F, 0xEF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0xBF,
  0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF,
  0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x08, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x8F, 0xFF, 0x00, 0x00, 0x4F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xD0,
  0x00, 0x0F, 0xFF, 0x88, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 14, 52, 20, 3, -51 },
  { 92, 27, 18, 35, 4, -51 },
  { 153, 40, 51, 44, 2, -51 },
  { 408, 33, 59, 39, 3, -55 },
  { 652, 59, 53, 63, 2, -52 },
  { 1043, 49, 53, 51, 2, -52 },
  { 1368, 11, 18, 19, 4, -51 },
  { 1393, 20, 63, 24, 3, -52 },
  { 1551, 19, 63, 24, 2, -52 },
  { 1701, 33, 33, 37, 2, -55 },
  { 1838, 33, 35, 39, 3, -43 },
  { 1983, 14, 19, 20, 2, -9 },
  { 2017, 19, 10, 23, 2, -24 },
  { 2041, 13, 13, 20, 3, -12 },
  { 2063, 30, 53, 30, 0, -52 },
  { 2262, 33, 53, 39, 3, -52 },
  { 2481, 27, 51, 39, 3, -51 },
  { 2654, 34, 52, 39, 2, -52 },
  { 2875, 34, 53, 39, 2, -52 },
  { 3101, 37, 51, 39, 1, -51 },
  { 3337, 33, 52, 39, 3, -51 },
  { 3552, 35, 53, 39, 2, -52 },
  { 3784, 35, 51, 39, 2, -51 },
  { 4008, 35, 53, 39, 2, -52 },
  { 4240, 35, 53, 39, 2, -52 },
  { 4472, 12, 41, 20, 4, -40 },
  { 4534, 15, 50, 20, 2, -40 },
  { 4628, 33, 38, 39, 3, -45 },
  { 4785, 33, 23, 39, 3, -37 },
  { 4880, 33, 38, 39, 3, -45 },
  { 5037, 31, 53, 32, 0, -52 },
  { 5243, 55, 58, 61, 3, -52 },
  { 5642, 47, 52, 47, 0, -52 },
  { 5948, 36, 51, 45, 5, -51 },
  { 6178, 36, 53, 42, 4, -52 },
  { 6417, 40, 51, 49, 5, -51 },
  { 6672, 27, 51, 37, 6, -51 },
  { 6845, 27, 51, 36, 6, -51 },
  { 7018, 40, 53, 49, 4, -52 },
  { 7283, 39, 51, 51, 6, -51 },
  { 7532, 23, 51, 28, 2, -51 },
  { 7679, 22, 67, 23, -5, -51 },
  { 7864, 39, 51, 45, 6, -51 },
  { 8113, 30, 51, 37, 5, -51 },
  { 8305, 53, 51, 64, 6, -51 },
  { 8643, 43, 51, 54, 6, -51 },
  { 8918, 45, 53, 52, 4, -52 },
  { 9217, 34, 51, 42, 5, -51 },
  { 9434, 45, 64, 52, 4, -52 },
  { 9794, 40, 51, 44, 5, -51 },
  { 10049, 32, 53, 37, 3, -52 },
  { 10261, 36, 51, 38, 1, -51 },
  { 10491, 40, 52, 50, 5, -51 },
  { 10751, 45, 51, 45, 0, -51 },
  { 11038, 66, 51, 66, 0, -51 },
  { 11459, 45, 51, 45, 0, -51 },
  { 11746, 42, 51, 42, 0, -51 },
  { 12014, 35, 51, 39, 2, -51 },
  { 12238, 17, 64, 23, 4, -52 },
  { 12374, 30, 53, 30, 0, -52 },
  { 12573, 17, 64, 23, 2, -52 },
  { 12709, 38, 34, 39, 1, -52 },
  { 12871, 33, 6, 33, 0, 6 },
  { 12896, 20, 11, 26, 3, -55 },
  { 12924, 34, 41, 40, 2, -40 },
  { 13099, 35, 56, 43, 5, -55 },
  { 13344, 30, 41, 35, 3, -40 },
  { 13498, 35, 56, 43, 3, -55 },
  { 13743, 34, 41, 40, 3, -40 },
  { 13918, 28, 55, 26, 1, -55 },
  { 14111, 35, 57, 43, 3, -40 },
  { 14361, 34, 55, 44, 5, -55 },
  { 14595, 13, 55, 21, 4, -55 },
  { 14685, 20, 72, 21, -3, -55 },
  { 14865, 37, 55, 42, 5, -55 },
  { 15120, 11, 55, 21, 5, -55 },
  { 15196, 56, 40, 65, 5, -40 },
  { 15476, 34, 40, 44, 5, -40 },
  { 15646, 36, 41, 42, 3, -40 },
  { 15831, 35, 57, 43, 5, -40 },
  { 16081, 35, 57, 43, 3, -40 },
  { 16331, 25, 40, 30, 5, -40 },
  { 16456, 28, 41, 33, 3, -40 },
  { 16600, 26, 49, 29, 1, -48 },
  { 16760, 35, 41, 44, 4, -40 },
  { 16940, 39, 40, 39, 0, -40 },
  { 17135, 57, 40, 59, 1, -40 },
  { 17420, 39, 40, 39, 0, -40 },
  { 17615, 39, 57, 39, 0, -40 },
  { 17893, 29, 40, 33, 2, -40 },
  { 18038, 25, 64, 28, 1, -52 },
  { 18238, 9, 71, 36, 13, -55 },
  { 18318, 25, 64, 28, 2, -52 },
  { 18518, 33, 13, 39, 3, -32 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD72PT7B_H_
