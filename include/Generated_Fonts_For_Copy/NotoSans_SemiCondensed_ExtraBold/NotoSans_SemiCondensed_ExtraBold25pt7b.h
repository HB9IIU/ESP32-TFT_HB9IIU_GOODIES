#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xDF, 0xFB,
  0x80, 0xF3, 0xFC, 0xF7, 0x3D, 0xCF, 0x73, 0x9C, 0xE7, 0x38, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0x98, 0x0C, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x73, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xE7, 0x03, 0x98,
  0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x00, 0x06, 0x00, 0x60, 0x3F, 0xC7, 0xFE,
  0xFF, 0xEF, 0x64, 0xF6, 0x0F, 0x60, 0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0x7E,
  0x07, 0xF0, 0x6F, 0xC6, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x06, 0x00, 0x60,
  0x3C, 0x07, 0x07, 0xE0, 0xE0, 0xFE, 0x0E, 0x0E, 0x71, 0xC0, 0xE7, 0x1C,
  0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x77, 0x3C, 0xFE, 0x77, 0xE7, 0xEE,
  0xFF, 0x3C, 0xEE, 0x70, 0x1C, 0xE7, 0x01, 0xCE, 0x70, 0x38, 0xE7, 0x03,
  0x8E, 0x70, 0x70, 0xFF, 0x07, 0x07, 0xE0, 0xE0, 0x3E, 0x0F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0x0F, 0x3F, 0xC7, 0xBF, 0xF7, 0x9E, 0x7F, 0xCF, 0x1F,
  0xC7, 0x87, 0xE3, 0xE3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xCF, 0xC0,
  0xFF, 0x77, 0x77, 0x70, 0x1E, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xF1, 0xE1, 0xC1, 0xC3, 0xC0,
  0xE1, 0xC7, 0x9E, 0x38, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF,
  0x3C, 0xE7, 0x9E, 0xF3, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x67, 0x3F, 0xFF,
  0xFF, 0xC7, 0x81, 0xF8, 0x3B, 0x8F, 0x78, 0xC6, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x7B, 0xBD, 0xEE, 0x70, 0xFF, 0xFF, 0xC0, 0x77, 0xFE,
  0xE0, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x00,
  0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0xBE, 0xF1, 0xEF, 0x1E, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0x79, 0xE7, 0xFC,
  0x3F, 0xC1, 0xF8, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xFD, 0xDE, 0x4F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0xBE, 0x61, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFC, 0xFF, 0xE7, 0x3E, 0x01, 0xE0, 0x1E,
  0x03, 0xC3, 0xFC, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0xC3, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF, 0x1C, 0x79,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x80, 0xE0, 0x1C, 0x83, 0xFC, 0x7F,
  0xDF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xCF,
  0xE0, 0x07, 0xE1, 0xFE, 0x3F, 0xE7, 0xC0, 0x78, 0x0F, 0x00, 0xF3, 0x8F,
  0xFC, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xE7,
  0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0x87, 0xFC, 0x7F, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0x7B, 0xE3, 0xFC, 0x1F, 0x03, 0xFC, 0x7F, 0xEF,
  0x1E, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0x1F, 0x07,
  0xFC, 0x7F, 0xCF, 0xBE, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x1F, 0xFB, 0xFF,
  0xFF, 0x7E, 0xE3, 0xCE, 0x01, 0xE0, 0x1E, 0x03, 0xC7, 0xFC, 0x7F, 0x87,
  0xE0, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x77, 0xFE,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x7B, 0xDC, 0xE0, 0x00, 0x10, 0x03,
  0x00, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x0F, 0x00, 0xC0,
  0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0x39, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x7E, 0x1E, 0x01, 0xC3,
  0x80, 0x1C, 0xE3, 0xF9, 0x9C, 0xFF, 0x3F, 0x3C, 0xE7, 0xE7, 0x1C, 0xFC,
  0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x73, 0xDD, 0xCF, 0xFF, 0x9C,
  0xF9, 0xE3, 0x80, 0x00, 0x3C, 0x02, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0xFE, 0xFF, 0x8F, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x7E, 0xE7,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF8, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF,
  0x7F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0x8F, 0xCE,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF1, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0x0F, 0x78, 0x3D, 0xF0, 0xF7, 0xE3, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F,
  0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE,
  0xFE, 0xFC, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF,
  0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3C, 0xF0, 0xF3,
  0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xF0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFB, 0x87, 0x7F, 0xE1,
  0xDF, 0xFC, 0x77, 0xF7, 0x3D, 0xFD, 0xCE, 0x7F, 0x73, 0x9F, 0xDE, 0xE7,
  0xF3, 0xF1, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0xCF, 0xC7, 0xF1, 0xE1, 0xFC,
  0x78, 0x70, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFD,
  0xE3, 0xFB, 0xC7, 0xFB, 0xCF, 0xF7, 0x9F, 0xE7, 0xBF, 0xCF, 0x7F, 0x8F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7C,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x1E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x78, 0x1F, 0x7C, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E,
  0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C,
  0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0x07, 0xFE, 0x3F, 0xF9, 0xE7, 0xEF, 0x1F, 0x78, 0x7B, 0xC7, 0xDE, 0x3C,
  0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xEF, 0x8F, 0x3C, 0x79, 0xF3, 0xC7, 0x9E,
  0x1E, 0xF0, 0xFF, 0x83, 0xC0, 0x1F, 0x8F, 0xFD, 0xFF, 0xFC, 0xEF, 0x01,
  0xE0, 0x3E, 0x03, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x03,
  0xF8, 0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3,
  0xEF, 0xFE, 0x3F, 0xF0, 0xFE, 0x00, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC1, 0xE7, 0x83, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0xF0, 0x38, 0x1F, 0xE0, 0xF8, 0x3D, 0xE1, 0xF0,
  0xF3, 0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x1F, 0xC7, 0x8E, 0x3B, 0x8E,
  0x1E, 0x77, 0x3C, 0x3C, 0xEE, 0x78, 0x7B, 0xDC, 0xF0, 0xF7, 0xBD, 0xE0,
  0xEE, 0x3B, 0x81, 0xDC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0xF8, 0x78,
  0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xDF, 0x0F, 0x1E,
  0x3E, 0x1E, 0x78, 0x3F, 0xF0, 0x3C, 0xF8, 0x3E, 0xF0, 0x79, 0xE1, 0xF1,
  0xE3, 0xC3, 0xCF, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0,
  0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0xFF,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x00, 0xFC,
  0x0E, 0xE0, 0x73, 0x87, 0x1C, 0x38, 0x73, 0x83, 0x9C, 0x0F, 0xE0, 0x70,
  0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x70, 0x70, 0x1F, 0x87, 0xFC, 0x3F, 0xE3,
  0x1E, 0x01, 0xE0, 0x7F, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF7, 0xEF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x78, 0xFF, 0xCF, 0xFE, 0xFB, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xE7, 0x80, 0x0F, 0xA7, 0xF9,
  0xFF, 0x3E, 0x6F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE1,
  0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF1, 0xEF, 0x3F, 0xF7, 0xFF, 0xFD, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3E, 0x70, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x78, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7, 0xF3, 0xF8, 0xF0,
  0x3C, 0x0F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1E, 0x73, 0xFF, 0x7F, 0xF7,
  0xDF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7,
  0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x61, 0xF7, 0xFE, 0x7F, 0xC3,
  0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x78, 0xEF, 0xEF,
  0xFE, 0xF9, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x77, 0xDE, 0x40, 0x3D, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x1C, 0x7C, 0x78, 0x40, 0x03, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xF7, 0xFF, 0x7E, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x7B, 0xC7, 0xDE, 0x7C, 0xF3, 0xC7, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F, 0xBC, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x9D,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFD, 0xFF, 0x1F, 0x1F, 0xE3, 0xC3, 0xFC,
  0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8,
  0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xC0, 0xE7, 0x8E, 0xFE, 0xFF, 0xEF,
  0x9E, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0x9E, 0x3C, 0xFF, 0xC3,
  0xFE, 0x0F, 0xC0, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x9E, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0xFE, 0xEF, 0xCF, 0x78,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x73, 0xFF,
  0x7F, 0xF7, 0x9F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xE7, 0xEF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3F, 0x1F, 0xFF, 0xFB, 0xC2, 0xF0, 0x3F,
  0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x3F, 0xFE, 0xFF, 0xBF, 0xC0, 0x1C,
  0x07, 0x01, 0xC0, 0xFE, 0x7F, 0xBF, 0xE3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFC, 0x7F, 0x1F, 0xC0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9E,
  0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x78, 0x1D, 0xE0, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0xF8, 0xF7, 0x0F, 0x8F,
  0x79, 0xF8, 0xF7, 0x9F, 0x8E, 0x79, 0xF9, 0xE3, 0x9D, 0xDE, 0x3D, 0xDD,
  0xE3, 0xF9, 0xDC, 0x3F, 0x9D, 0xC1, 0xF9, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0xF8, 0x79, 0xE3, 0xE3, 0xCF, 0x0F,
  0x78, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x83,
  0xDE, 0x0F, 0x3C, 0x78, 0xFB, 0xE1, 0xF0, 0xF0, 0x7F, 0xE1, 0xE7, 0x87,
  0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0x78, 0x1F, 0xE0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x87, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x7F, 0x3F,
  0x1F, 0x0F, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xF0, 0xF8,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x1F, 0x1F, 0x3F,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0x7C, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 10, 7, 12, 1, -18 },
  { 22, 14, 18, 15, 1, -18 },
  { 54, 12, 20, 14, 1, -19 },
  { 84, 20, 18, 22, 1, -18 },
  { 129, 17, 18, 18, 1, -18 },
  { 168, 4, 7, 7, 1, -18 },
  { 172, 7, 22, 8, 1, -18 },
  { 192, 6, 22, 8, 1, -18 },
  { 209, 11, 11, 13, 1, -19 },
  { 225, 12, 12, 14, 1, -15 },
  { 243, 5, 6, 7, 1, -3 },
  { 247, 6, 3, 8, 1, -8 },
  { 250, 5, 4, 7, 1, -4 },
  { 253, 10, 18, 11, 0, -18 },
  { 276, 12, 18, 14, 1, -18 },
  { 303, 9, 18, 14, 1, -18 },
  { 324, 12, 18, 14, 1, -18 },
  { 351, 12, 18, 14, 1, -18 },
  { 378, 13, 18, 14, 0, -18 },
  { 408, 11, 18, 14, 1, -18 },
  { 433, 12, 18, 14, 1, -18 },
  { 460, 12, 18, 14, 1, -18 },
  { 487, 12, 18, 14, 1, -18 },
  { 514, 12, 18, 14, 1, -18 },
  { 541, 5, 14, 7, 1, -14 },
  { 550, 5, 17, 7, 1, -14 },
  { 561, 12, 13, 14, 1, -16 },
  { 581, 12, 8, 14, 1, -13 },
  { 593, 12, 13, 14, 1, -16 },
  { 613, 11, 18, 11, 0, -18 },
  { 638, 19, 20, 21, 1, -18 },
  { 686, 16, 18, 16, 0, -18 },
  { 722, 12, 18, 16, 2, -18 },
  { 749, 13, 18, 15, 1, -18 },
  { 779, 14, 18, 17, 2, -18 },
  { 811, 10, 18, 13, 2, -18 },
  { 834, 10, 18, 13, 2, -18 },
  { 857, 14, 18, 17, 1, -18 },
  { 889, 14, 18, 18, 2, -18 },
  { 921, 8, 18, 10, 1, -18 },
  { 939, 8, 23, 8, -2, -18 },
  { 962, 14, 18, 16, 2, -18 },
  { 994, 10, 18, 13, 2, -18 },
  { 1017, 18, 18, 22, 2, -18 },
  { 1058, 15, 18, 19, 2, -18 },
  { 1092, 16, 18, 18, 1, -18 },
  { 1128, 12, 18, 15, 2, -18 },
  { 1155, 16, 22, 18, 1, -18 },
  { 1199, 13, 18, 15, 2, -18 },
  { 1229, 11, 18, 13, 1, -18 },
  { 1254, 13, 18, 13, 0, -18 },
  { 1284, 13, 18, 17, 2, -18 },
  { 1314, 15, 18, 15, 0, -18 },
  { 1348, 23, 18, 23, 0, -18 },
  { 1400, 15, 18, 16, 0, -18 },
  { 1434, 15, 18, 15, 0, -18 },
  { 1468, 12, 18, 13, 1, -18 },
  { 1495, 6, 22, 8, 1, -18 },
  { 1512, 10, 18, 11, 0, -18 },
  { 1535, 6, 22, 8, 1, -18 },
  { 1552, 13, 12, 14, 0, -18 },
  { 1572, 11, 2, 11, 0, 2 },
  { 1575, 7, 4, 9, 1, -19 },
  { 1579, 12, 14, 14, 1, -14 },
  { 1600, 12, 19, 15, 2, -19 },
  { 1629, 11, 14, 12, 1, -14 },
  { 1649, 12, 19, 15, 1, -19 },
  { 1678, 12, 14, 14, 1, -14 },
  { 1699, 10, 19, 9, 0, -19 },
  { 1723, 12, 20, 15, 1, -14 },
  { 1753, 12, 19, 15, 2, -19 },
  { 1782, 5, 19, 7, 1, -19 },
  { 1794, 7, 25, 7, -1, -19 },
  { 1816, 13, 19, 15, 2, -19 },
  { 1847, 4, 19, 7, 2, -19 },
  { 1857, 19, 14, 23, 2, -14 },
  { 1891, 12, 14, 15, 2, -14 },
  { 1912, 13, 14, 15, 1, -14 },
  { 1935, 12, 20, 15, 2, -14 },
  { 1965, 12, 20, 15, 1, -14 },
  { 1995, 8, 14, 11, 2, -14 },
  { 2009, 10, 14, 12, 1, -14 },
  { 2027, 10, 17, 10, 0, -17 },
  { 2049, 12, 14, 15, 2, -14 },
  { 2070, 14, 14, 14, 0, -14 },
  { 2095, 20, 14, 20, 0, -14 },
  { 2130, 14, 14, 14, 0, -14 },
  { 2155, 14, 20, 14, 0, -14 },
  { 2190, 10, 14, 11, 1, -14 },
  { 2208, 9, 22, 10, 0, -18 },
  { 2233, 3, 25, 12, 5, -19 },
  { 2243, 8, 22, 10, 1, -18 },
  { 2265, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD25PT7B_H_
