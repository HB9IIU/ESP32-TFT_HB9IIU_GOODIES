#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x1B, 0xF0, 0xEF, 0x3C, 0xF3, 0x1D, 0x86, 0x61,
  0xB1, 0xFF, 0x7F, 0xC6, 0xC3, 0x33, 0xFE, 0xFF, 0x8D, 0x83, 0x60, 0xD8,
  0x10, 0x3C, 0xFE, 0xF6, 0xD0, 0xF0, 0x7C, 0x3E, 0x16, 0x97, 0xFE, 0xFC,
  0x10, 0x10, 0x78, 0x70, 0xF8, 0xC3, 0xB3, 0x07, 0x66, 0x06, 0xD8, 0x0D,
  0xB7, 0x9E, 0xDB, 0x01, 0xB6, 0x06, 0x6E, 0x0C, 0xD8, 0x31, 0xF0, 0xE1,
  0xC0, 0x3E, 0x0F, 0xC1, 0x98, 0x37, 0x07, 0xE0, 0xF1, 0xFF, 0x77, 0x7E,
  0xC7, 0x9C, 0xF3, 0xFF, 0x3E, 0xF0, 0xFB, 0x60, 0x36, 0x6E, 0xCC, 0xCC,
  0xCC, 0xEE, 0x67, 0x30, 0xE3, 0x8C, 0x73, 0x8C, 0x63, 0x19, 0xCE, 0x63,
  0x33, 0x80, 0x18, 0x18, 0x5B, 0xFF, 0x1C, 0x3E, 0x77, 0x14, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0xFF, 0x60, 0xFF, 0xFE, 0xDF, 0x80,
  0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x70, 0xE1, 0x87, 0x00, 0x7C,
  0xFE, 0xEE, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0xEE, 0x7E, 0x7C, 0x1C,
  0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3E, 0x7F, 0x99, 0xC0,
  0x60, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0xEF, 0xF0, 0xFC, 0xFE,
  0x8E, 0x0E, 0x0E, 0x78, 0x7E, 0x0E, 0x07, 0x8E, 0xFE, 0xFC, 0x07, 0x07,
  0x87, 0xC3, 0xE3, 0x71, 0xB9, 0x9D, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0,
  0xFF, 0xFF, 0x87, 0x0F, 0xDF, 0xD3, 0x83, 0x07, 0x1F, 0xFF, 0xE0, 0x3E,
  0x7E, 0xE0, 0xC0, 0xDC, 0xFE, 0xE7, 0xC7, 0xC7, 0xE6, 0xFE, 0x7C, 0xFF,
  0xFF, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x7C,
  0xFE, 0xE6, 0xE6, 0xFE, 0x7C, 0x7E, 0xEE, 0xC7, 0xC7, 0xFE, 0x7C, 0x7C,
  0xFE, 0xEE, 0xC6, 0xC7, 0xEF, 0xFF, 0x76, 0x06, 0x0E, 0xFC, 0xF8, 0xFD,
  0x00, 0x37, 0xE0, 0xFD, 0x00, 0x07, 0xFB, 0x00, 0x01, 0x07, 0x1F, 0x7C,
  0xF0, 0xF0, 0x7C, 0x0F, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xC0, 0xF0, 0x7C, 0x0F, 0x1F, 0x7C, 0xF0, 0x80, 0x7D, 0xFD, 0x18, 0x30,
  0xE3, 0x8E, 0x18, 0x00, 0x60, 0xE1, 0xC0, 0x1F, 0xC1, 0xC7, 0x18, 0x0D,
  0xDF, 0x6D, 0xD9, 0x6C, 0xCF, 0x66, 0x7B, 0x36, 0xDF, 0xF6, 0x77, 0x18,
  0x00, 0xF1, 0x81, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0x83, 0xB8,
  0x77, 0x0C, 0x63, 0xFE, 0x7F, 0xCE, 0x3B, 0x83, 0xF0, 0x70, 0xFE, 0x7F,
  0xB9, 0xFC, 0x6E, 0x77, 0xF3, 0xFD, 0xC7, 0xE3, 0xF3, 0xFF, 0xDF, 0xC0,
  0x3F, 0xBF, 0x9C, 0x5C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x9F,
  0xC7, 0xE0, 0xFE, 0x3F, 0xCE, 0x7B, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x86,
  0xE3, 0xB9, 0xEF, 0xF3, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0,
  0xE1, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0xE1,
  0xC3, 0x87, 0x00, 0x3F, 0xBF, 0xDC, 0x3C, 0x0E, 0x07, 0x3F, 0x9F, 0xC3,
  0xE1, 0xB8, 0xDF, 0xE7, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFF,
  0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xDC, 0xE7, 0x39,
  0xCE, 0x73, 0xBF, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0xFF, 0xDC, 0xE3, 0xF9, 0xEE, 0x73, 0xB8, 0xEE, 0x3F, 0x0F, 0xE3, 0xF8,
  0xE7, 0x39, 0xCE, 0x3B, 0x8F, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0xFF, 0xF0, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFE, 0xFF, 0xB6, 0xFD, 0xB7, 0xEF, 0xBF, 0x39, 0xF9, 0xCF, 0xCE, 0x70,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xDD, 0xFB, 0xBF, 0x3F, 0xE7,
  0xFC, 0x7F, 0x8F, 0xF0, 0xF0, 0x3F, 0x1F, 0xEF, 0x1F, 0x87, 0xE1, 0xF8,
  0x3E, 0x0F, 0x87, 0xE1, 0xDC, 0xF7, 0xF8, 0xFC, 0xFE, 0xFF, 0xE7, 0xE7,
  0xE7, 0xFF, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x0F, 0xF3, 0xC7,
  0x70, 0xEE, 0x1D, 0xC1, 0xB8, 0x37, 0x0E, 0xE1, 0xCE, 0x79, 0xFE, 0x1F,
  0x80, 0x78, 0x07, 0x00, 0x78, 0xFE, 0x3F, 0xCE, 0x73, 0x8C, 0xE7, 0x3F,
  0xCF, 0xE3, 0xB8, 0xE6, 0x39, 0xCE, 0x3B, 0x8F, 0x7F, 0xFF, 0x8F, 0x0F,
  0x0F, 0x8F, 0x87, 0x0F, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xBC, 0xE7, 0xF8, 0xFC,
  0xE1, 0xFC, 0x39, 0xC7, 0x38, 0xC7, 0x38, 0x67, 0x0E, 0xC1, 0xD8, 0x1F,
  0x03, 0xE0, 0x78, 0x07, 0x00, 0xE3, 0x87, 0xE3, 0x8E, 0x63, 0xCE, 0x73,
  0xCE, 0x77, 0xCE, 0x76, 0xCC, 0x36, 0xFC, 0x36, 0x7C, 0x36, 0x7C, 0x3E,
  0x78, 0x3C, 0x78, 0x1C, 0x78, 0xF1, 0xCE, 0x70, 0xEE, 0x1F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF8, 0x3B, 0x0E, 0x71, 0xC7, 0x70, 0xF0, 0xE1, 0xDC,
  0xE7, 0x38, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x7F, 0xBF, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38,
  0x3F, 0xFF, 0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0,
  0xC1, 0xC3, 0x83, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0xFF, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x08, 0x0E, 0x07, 0x06, 0xC3, 0x63,
  0x19, 0x8D, 0x83, 0xFF, 0xFF, 0xE3, 0x8E, 0x08, 0xFE, 0x7E, 0x06, 0x7F,
  0xFF, 0xC7, 0xC7, 0xFF, 0xF7, 0xE0, 0xE0, 0xE0, 0xE4, 0xFE, 0xFF, 0xE7,
  0xE3, 0xE3, 0xE7, 0xE7, 0xFF, 0xDE, 0x08, 0xFF, 0xF7, 0x0E, 0x18, 0x38,
  0x71, 0xFE, 0xF8, 0x07, 0x07, 0x07, 0x27, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7,
  0xE7, 0xE7, 0xFF, 0x7B, 0x10, 0x7E, 0xFE, 0xE7, 0xFF, 0xFF, 0xC0, 0xE1,
  0x7E, 0x3E, 0x1E, 0x78, 0xC1, 0x8F, 0xDF, 0x9C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x00, 0x20, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7, 0xE7, 0xE7, 0xFF, 0x7F,
  0x07, 0x87, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE4, 0xFF, 0xFF, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFD, 0x0F, 0xFF, 0xFF, 0xFE, 0x39, 0xC4,
  0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF0, 0xE0, 0x70, 0x38,
  0x1C, 0x1E, 0x77, 0x73, 0xB9, 0xF8, 0xFC, 0x7F, 0x3B, 0x9C, 0xEE, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x26, 0xFF, 0xFF, 0xFF, 0xCE, 0x7E,
  0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x38, 0xC0, 0x04, 0xDF,
  0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x10, 0x7E, 0xFF, 0xE7,
  0xE7, 0xC7, 0xE7, 0xE7, 0x7E, 0x3C, 0x04, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3,
  0xE7, 0xE7, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x20, 0x7F, 0xFF, 0xE7,
  0xE7, 0xC7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x7F,
  0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x13, 0xFE, 0xF0, 0xF1, 0xF1, 0xE3,
  0xFF, 0xE0, 0x30, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x70, 0xF3, 0xC0, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xB1, 0xDC, 0xCE,
  0xE3, 0x71, 0xB0, 0xF8, 0x3C, 0x1C, 0x00, 0xE7, 0x9D, 0x9E, 0x66, 0x7B,
  0x9D, 0xEE, 0x7D, 0xB0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3,
  0xBB, 0x8F, 0x87, 0xC1, 0xE1, 0xF0, 0xDC, 0xEE, 0xE3, 0x80, 0xE3, 0xB1,
  0xDC, 0xCE, 0xE3, 0x71, 0xF0, 0xF8, 0x3C, 0x1C, 0x0E, 0x07, 0x0F, 0x07,
  0x00, 0x7E, 0xFC, 0x30, 0xE3, 0x87, 0x1C, 0x7F, 0xFE, 0x1C, 0xF3, 0x8E,
  0x38, 0xEF, 0x38, 0x78, 0xE3, 0x8E, 0x38, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE7, 0x18, 0xC6, 0x39, 0xE7, 0x73, 0x18, 0xC6, 0x73, 0x00,
  0x01, 0xFF, 0xFF, 0x84,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 10, 12, 10, 0, -12 },
  { 24, 8, 14, 9, 1, -13 },
  { 38, 15, 12, 15, 0, -12 },
  { 61, 11, 12, 12, 1, -12 },
  { 78, 3, 4, 5, 1, -12 },
  { 80, 4, 15, 6, 1, -12 },
  { 88, 5, 15, 6, 0, -12 },
  { 98, 8, 8, 9, 0, -13 },
  { 106, 8, 8, 9, 1, -10 },
  { 114, 3, 4, 5, 1, -2 },
  { 116, 5, 3, 5, 0, -6 },
  { 118, 3, 3, 5, 1, -3 },
  { 120, 7, 12, 7, 0, -12 },
  { 131, 8, 12, 9, 1, -12 },
  { 143, 6, 12, 9, 1, -12 },
  { 152, 9, 12, 9, 0, -12 },
  { 166, 8, 12, 9, 1, -12 },
  { 178, 9, 12, 9, 0, -12 },
  { 192, 7, 12, 9, 1, -12 },
  { 203, 8, 12, 9, 1, -12 },
  { 215, 8, 12, 9, 1, -12 },
  { 227, 8, 12, 9, 1, -12 },
  { 239, 8, 12, 9, 1, -12 },
  { 251, 3, 9, 5, 1, -9 },
  { 255, 3, 11, 5, 1, -9 },
  { 260, 8, 9, 9, 1, -11 },
  { 269, 8, 6, 9, 1, -9 },
  { 275, 8, 9, 9, 1, -11 },
  { 284, 7, 12, 8, 0, -12 },
  { 295, 13, 13, 14, 1, -12 },
  { 317, 11, 12, 11, 0, -12 },
  { 334, 9, 12, 11, 1, -12 },
  { 348, 9, 12, 10, 1, -12 },
  { 362, 10, 12, 11, 1, -12 },
  { 377, 7, 12, 9, 1, -12 },
  { 388, 7, 12, 9, 1, -12 },
  { 399, 9, 12, 11, 1, -12 },
  { 413, 10, 12, 12, 1, -12 },
  { 428, 5, 12, 7, 1, -12 },
  { 436, 5, 16, 5, -1, -12 },
  { 446, 10, 12, 11, 1, -12 },
  { 461, 7, 12, 9, 1, -12 },
  { 472, 13, 12, 15, 1, -12 },
  { 492, 11, 12, 13, 1, -12 },
  { 509, 10, 12, 12, 1, -12 },
  { 524, 8, 12, 10, 1, -12 },
  { 536, 11, 15, 12, 1, -12 },
  { 557, 10, 12, 10, 1, -12 },
  { 572, 7, 12, 9, 1, -12 },
  { 583, 9, 12, 9, 0, -12 },
  { 597, 10, 12, 12, 1, -12 },
  { 612, 11, 12, 11, 0, -12 },
  { 629, 16, 12, 16, 0, -12 },
  { 653, 11, 12, 11, 0, -12 },
  { 670, 10, 12, 10, 0, -12 },
  { 685, 9, 12, 9, 0, -12 },
  { 699, 4, 15, 5, 1, -12 },
  { 707, 7, 12, 7, 0, -12 },
  { 718, 4, 15, 5, 0, -12 },
  { 726, 9, 8, 9, 0, -12 },
  { 735, 8, 2, 8, 0, 1 },
  { 737, 5, 3, 6, 1, -13 },
  { 739, 8, 10, 10, 1, -10 },
  { 749, 8, 13, 10, 1, -13 },
  { 762, 7, 10, 8, 1, -10 },
  { 771, 8, 13, 10, 1, -13 },
  { 784, 8, 10, 9, 1, -10 },
  { 794, 7, 13, 6, 0, -13 },
  { 806, 8, 14, 10, 1, -10 },
  { 820, 8, 13, 10, 1, -13 },
  { 833, 3, 13, 5, 1, -13 },
  { 838, 5, 17, 5, -1, -13 },
  { 849, 9, 13, 10, 1, -13 },
  { 864, 3, 13, 5, 1, -13 },
  { 869, 13, 10, 15, 1, -10 },
  { 886, 8, 10, 10, 1, -10 },
  { 896, 8, 10, 10, 1, -10 },
  { 906, 8, 14, 10, 1, -10 },
  { 920, 8, 14, 10, 1, -10 },
  { 934, 6, 10, 7, 1, -10 },
  { 942, 6, 10, 8, 1, -10 },
  { 950, 6, 11, 7, 0, -11 },
  { 959, 8, 9, 10, 1, -9 },
  { 968, 9, 9, 9, 0, -9 },
  { 979, 14, 9, 14, 0, -9 },
  { 995, 9, 9, 9, 0, -9 },
  { 1006, 9, 13, 9, 0, -9 },
  { 1021, 7, 9, 8, 0, -9 },
  { 1029, 6, 15, 7, 0, -12 },
  { 1041, 2, 17, 8, 3, -13 },
  { 1046, 5, 15, 7, 1, -12 },
  { 1056, 8, 4, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD17PT7B_H_
