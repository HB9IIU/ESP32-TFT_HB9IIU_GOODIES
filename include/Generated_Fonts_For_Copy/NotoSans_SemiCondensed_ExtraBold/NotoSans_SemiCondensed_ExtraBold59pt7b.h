#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F, 0xCF, 0xF0, 0x30,
  0x00, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F,
  0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0x7F, 0xCF, 0x0F, 0x8F, 0xF8, 0xF0, 0x18, 0xFF, 0x8F, 0x00, 0x0F, 0xF8,
  0xF0, 0x00, 0xFF, 0x8F, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xF3, 0xFE, 0x00, 0x0F, 0x1F, 0xF0, 0x00, 0xF1, 0xFF, 0x80, 0x0F,
  0x1F, 0xF6, 0x00, 0xF1, 0xFF, 0x7C, 0x0F, 0x3F, 0xE7, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0xFF, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0xF0,
  0xFF, 0x1F, 0xC7, 0xF8, 0xFF, 0xF8, 0x7F, 0xBF, 0xC7, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0x1F, 0xE3, 0xFD, 0xFE, 0x1F, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF,
  0x07, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x01, 0xF0, 0x3F, 0x87, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7,
  0xFF, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xBF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x16, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x01, 0xF8, 0x0E, 0x7E, 0x1F, 0x87, 0xE7, 0xFD,
  0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x1F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xE0, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xFC, 0xFF, 0xBF, 0xC7, 0xFC, 0xFC,
  0x3F, 0xE3, 0xC1, 0xFF, 0x0C, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xF7, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE,
  0x1E, 0x00, 0x7F, 0xE0, 0xC0, 0x07, 0xFE, 0x08, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xC3, 0xFF, 0xC1, 0xE0, 0x0F, 0xFC, 0x08, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE8, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0xFF, 0xEF, 0xE0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFB, 0xFE, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xE3,
  0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x20,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x41,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0x00,
  0x7F, 0x8F, 0xFC, 0x07, 0xF9, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F,
  0xE7, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF,
  0x9F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0x78, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x82, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7A, 0x00,
  0x00, 0x1F, 0x0F, 0xF3, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFE,
  0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7F, 0x8F,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xF3, 0xFE, 0x3F, 0x81, 0xC0,
  0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE,
  0x3F, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0x83, 0xFF, 0x87, 0x00, 0x3F, 0xE1, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0x0F,
  0xE0, 0x3F, 0xFF, 0xE3, 0xF8, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xC7, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xFF, 0xC3, 0xFB, 0xF8, 0x3F,
  0xE0, 0xFC, 0x1F, 0xDF, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0xFE, 0x1F, 0xE0,
  0x3F, 0x03, 0xF7, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x1F,
  0xC0, 0xFD, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xC3, 0xFC, 0x07, 0xF0,
  0x7F, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x1F,
  0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE7,
  0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x3F, 0x07, 0xF8, 0x3F, 0xC3, 0xF9, 0xFC,
  0x3F, 0xE3, 0xFF, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x07,
  0xFF, 0xF7, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xCF, 0xF0,
  0x7F, 0xF8, 0x03, 0xC3, 0xFF, 0x80, 0x02, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x63, 0xFF, 0xE0,
  0x07, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0xC0, 0x3F, 0xFC, 0x7F, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF,
  0x80, 0x0E, 0x0F, 0xFF, 0x00, 0x01, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xBF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF7, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xE0, 0x0F, 0xEF, 0xFF, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0x3F, 0x80,
  0x7F, 0xBF, 0xFF, 0xE7, 0xF8, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0x01, 0xFC,
  0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x9F, 0xFF, 0xF1, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8,
  0x7F, 0x0F, 0xF1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE,
  0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0x83, 0xFD, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xF9,
  0xFF, 0x81, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F,
  0xF9, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0xFC,
  0x07, 0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFD, 0xFF, 0x8F, 0xFC, 0x01, 0xE1, 0xFF, 0x80,
  0x0C, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0xC0, 0x00, 0x7F, 0xDE, 0x00, 0x1F, 0xFB, 0xF8, 0x07, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFB,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x0F, 0xFE, 0x07, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xF7,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0x3F, 0xFF, 0x8F, 0xF1, 0xFF, 0xF0, 0xFF, 0x0F, 0xFE, 0x07,
  0xF0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83,
  0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x0F, 0xFB, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0x0F, 0xF1,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8,
  0x0E, 0x3F, 0xF8, 0x01, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0x7F, 0xF0, 0x03, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0xC7, 0xFC, 0x1F,
  0xFF, 0x3F, 0xE1, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x83, 0xFF,
  0xBF, 0xF8, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF,
  0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC,
  0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0x7F, 0xC3, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x21, 0xFF, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0x9C, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xDF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00,
  0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFF,
  0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF,
  0x3F, 0xE0, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x80, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x90,
  0x00, 0x1F, 0xF8, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xF8, 0x0F, 0xF8, 0xFF,
  0xE0, 0xFF, 0x9F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3,
  0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFF, 0x3F, 0xE7, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFF, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xF1, 0xFF, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF,
  0xEF, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0xFF,
  0xF0, 0xFF, 0x1F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1,
  0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xEF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0x0F, 0xF9,
  0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x0C, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF,
  0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF,
  0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xF0,
  0x1F, 0xF9, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0x3F, 0xE0,
  0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x80, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE2, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xE0, 0x7C, 0xFF, 0x80, 0x19, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x02, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC3, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xF3, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0x8F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFB,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFD, 0xF8, 0x3F, 0xE0, 0xFF,
  0x87, 0xF3, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xE7, 0xF0, 0xFF, 0x81, 0xFF,
  0x1F, 0xCF, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0x9F, 0xC7, 0xFC, 0x07, 0xFC,
  0x7F, 0x1F, 0x8F, 0xF8, 0x07, 0xF9, 0xFC, 0x3F, 0x9F, 0xF0, 0x0F, 0xF3,
  0xF8, 0x7F, 0x3F, 0xC0, 0x1F, 0xF7, 0xF0, 0xFE, 0x7F, 0x80, 0x3F, 0xEF,
  0xE1, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xC1, 0xFB, 0xFE, 0x00, 0x7F, 0xBF,
  0x03, 0xF7, 0xF8, 0x00, 0xFF, 0x7E, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0,
  0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x0D, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF,
  0xC0, 0x03, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xC8, 0x00, 0x1F, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 43, 16, 3, -42 },
  { 61, 22, 15, 29, 3, -42 },
  { 103, 34, 42, 36, 1, -42 },
  { 282, 28, 48, 32, 2, -45 },
  { 450, 48, 43, 52, 2, -43 },
  { 708, 40, 44, 42, 2, -43 },
  { 928, 9, 15, 16, 3, -42 },
  { 945, 17, 52, 20, 2, -43 },
  { 1056, 17, 52, 20, 1, -43 },
  { 1167, 28, 27, 30, 1, -45 },
  { 1262, 28, 28, 32, 2, -35 },
  { 1360, 12, 16, 17, 2, -8 },
  { 1384, 15, 8, 19, 2, -20 },
  { 1399, 10, 11, 16, 3, -10 },
  { 1413, 25, 43, 25, 0, -43 },
  { 1548, 28, 44, 32, 2, -43 },
  { 1702, 21, 42, 32, 3, -42 },
  { 1813, 28, 43, 32, 2, -43 },
  { 1964, 28, 44, 32, 2, -43 },
  { 2118, 30, 42, 32, 1, -42 },
  { 2276, 26, 43, 32, 3, -42 },
  { 2416, 28, 44, 32, 2, -43 },
  { 2570, 28, 42, 32, 2, -42 },
  { 2717, 28, 44, 32, 2, -43 },
  { 2871, 28, 44, 32, 2, -43 },
  { 3025, 11, 34, 16, 3, -33 },
  { 3072, 12, 41, 17, 2, -33 },
  { 3134, 28, 31, 32, 2, -37 },
  { 3243, 28, 19, 32, 2, -30 },
  { 3310, 28, 31, 32, 2, -37 },
  { 3419, 26, 44, 27, 0, -43 },
  { 3562, 45, 48, 50, 2, -43 },
  { 3832, 38, 42, 38, 0, -42 },
  { 4032, 30, 42, 37, 4, -42 },
  { 4190, 30, 44, 35, 3, -43 },
  { 4355, 33, 42, 40, 4, -42 },
  { 4529, 22, 42, 30, 5, -42 },
  { 4645, 22, 42, 30, 5, -42 },
  { 4761, 33, 44, 40, 3, -43 },
  { 4943, 32, 42, 42, 5, -42 },
  { 5111, 19, 42, 23, 2, -42 },
  { 5211, 18, 55, 19, -4, -42 },
  { 5335, 32, 42, 37, 5, -42 },
  { 5503, 25, 42, 30, 4, -42 },
  { 5635, 43, 42, 53, 5, -42 },
  { 5861, 35, 42, 45, 5, -42 },
  { 6045, 37, 44, 43, 3, -43 },
  { 6249, 28, 42, 34, 4, -42 },
  { 6396, 37, 53, 43, 3, -43 },
  { 6642, 33, 42, 36, 4, -42 },
  { 6816, 27, 44, 31, 2, -43 },
  { 6965, 29, 42, 31, 1, -42 },
  { 7118, 33, 43, 41, 4, -42 },
  { 7296, 37, 42, 37, 0, -42 },
  { 7491, 54, 42, 54, 0, -42 },
  { 7775, 37, 42, 37, 0, -42 },
  { 7970, 35, 42, 35, 0, -42 },
  { 8154, 29, 42, 32, 1, -42 },
  { 8307, 15, 53, 19, 3, -43 },
  { 8407, 25, 43, 25, 0, -43 },
  { 8542, 14, 53, 19, 1, -43 },
  { 8635, 31, 27, 32, 1, -42 },
  { 8740, 27, 5, 27, 0, 5 },
  { 8757, 17, 9, 22, 2, -45 },
  { 8777, 28, 34, 33, 2, -33 },
  { 8896, 28, 46, 35, 4, -45 },
  { 9057, 25, 34, 29, 2, -33 },
  { 9164, 29, 46, 35, 2, -45 },
  { 9331, 29, 34, 33, 2, -33 },
  { 9455, 23, 45, 22, 1, -45 },
  { 9585, 29, 47, 35, 2, -33 },
  { 9756, 28, 45, 36, 4, -45 },
  { 9914, 11, 45, 17, 3, -45 },
  { 9976, 17, 59, 17, -3, -45 },
  { 10102, 31, 45, 35, 4, -45 },
  { 10277, 9, 45, 17, 4, -45 },
  { 10328, 46, 33, 53, 4, -33 },
  { 10518, 28, 33, 36, 4, -33 },
  { 10634, 30, 34, 34, 2, -33 },
  { 10762, 28, 47, 35, 4, -33 },
  { 10927, 29, 47, 35, 2, -33 },
  { 11098, 20, 33, 25, 4, -33 },
  { 11181, 23, 34, 27, 2, -33 },
  { 11279, 21, 40, 24, 1, -39 },
  { 11384, 28, 33, 36, 4, -32 },
  { 11500, 32, 32, 32, 0, -32 },
  { 11628, 47, 32, 48, 1, -32 },
  { 11816, 32, 32, 32, 0, -32 },
  { 11944, 32, 46, 32, 0, -32 },
  { 12128, 24, 32, 27, 1, -32 },
  { 12224, 20, 52, 23, 1, -42 },
  { 12354, 7, 58, 29, 11, -45 },
  { 12405, 20, 52, 23, 2, -42 },
  { 12535, 28, 10, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD59PT7B_H_
