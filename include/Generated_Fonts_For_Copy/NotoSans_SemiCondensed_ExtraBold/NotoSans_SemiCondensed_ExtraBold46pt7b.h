#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x1F, 0x8F, 0xEF, 0xF7, 0xFB, 0xFC,
  0xFE, 0x7E, 0x0C, 0x00, 0xFF, 0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xF8,
  0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFB, 0x8F, 0x3F, 0x9C, 0x09,
  0xF8, 0xE0, 0x0F, 0xE7, 0x00, 0x7F, 0xB8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xDF, 0xE0, 0x0E, 0x7F, 0x00, 0x71,
  0xFC, 0x03, 0x8F, 0xF8, 0x1C, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0x01, 0xF9,
  0xF8, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0x81, 0xF8,
  0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0xFC, 0x7F, 0x07, 0xC7, 0xE7, 0xE3, 0xFE, 0x1F, 0xFF,
  0x9F, 0x9F, 0xFC, 0x3F, 0xFC, 0xFC, 0xFF, 0xF8, 0xFF, 0xF3, 0xF3, 0xFF,
  0xE1, 0xFF, 0x9F, 0x9F, 0x8F, 0xC3, 0xF8, 0x7E, 0x7E, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x87,
  0xC0, 0x01, 0xF8, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0xFC, 0x00, 0x3F,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x7E, 0x3F,
  0x00, 0x3F, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0x83, 0xFC,
  0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xF7, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20,
  0x7C, 0x05, 0xE3, 0xE3, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0xCF, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF0,
  0x0E, 0x0E, 0x00, 0x10, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x18, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xDF, 0xCF, 0xE7, 0xCF,
  0xF1, 0xC7, 0xF8, 0x43, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xF0, 0xFF, 0x87, 0x80, 0xFE, 0x08, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF0, 0x3F, 0xC6,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0x7F, 0x80, 0x7E, 0xFF, 0x01, 0xF9, 0xFE,
  0x03, 0xF3, 0xFC, 0x0F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0x7E, 0x1F, 0xE1,
  0xF8, 0x3F, 0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x84, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xB8, 0x07, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x18, 0x0F, 0xE7, 0xF8, 0x7F, 0x7F, 0xF3, 0xF7,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F,
  0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF,
  0x0F, 0xFB, 0xFE, 0x7F, 0x87, 0xF9, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE1,
  0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xC0,
  0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0x0F, 0xF9,
  0xFC, 0x0F, 0x87, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x08, 0x3F,
  0x9F, 0xDF, 0xEF, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0F, 0xC7, 0xF7, 0xFB, 0xFF,
  0xFE, 0x7F, 0x3F, 0x02, 0x00, 0x04, 0x0F, 0xE3, 0xF9, 0xFF, 0x7F, 0xDF,
  0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3C, 0x0F,
  0xF3, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x87,
  0xE0, 0xFF, 0xF9, 0xF8, 0xF8, 0x3F, 0xFF, 0x1F, 0x3F, 0x0F, 0xFF, 0xE3,
  0xE7, 0xC3, 0xFF, 0xFC, 0x7C, 0xF8, 0x7E, 0x1F, 0x8F, 0xFF, 0x1F, 0x83,
  0xF0, 0xFF, 0xC3, 0xF0, 0x7E, 0x1F, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0x0F,
  0x81, 0xF8, 0x7F, 0xE3, 0xF0, 0x3E, 0x1F, 0xFC, 0x7E, 0x07, 0xC3, 0xEF,
  0x87, 0xC0, 0xF8, 0x7D, 0xF0, 0xF8, 0x3F, 0x0F, 0xBE, 0x1F, 0x87, 0xF3,
  0xF7, 0xE3, 0xFF, 0xFF, 0xFC, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0x83, 0xFF,
  0x7F, 0xE1, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00,
  0x7F, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0x07, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xF8, 0x3C, 0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x02, 0x3F, 0xF0, 0x1E, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xF3, 0xFC,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFF,
  0xCF, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0xF0, 0xFF, 0xC0, 0x04,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF8, 0x01,
  0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0xC0, 0x1F, 0xCF, 0xF8, 0x07, 0xF3, 0xFF,
  0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x8F,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x7F,
  0xCF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0xE1, 0xFC, 0x1F,
  0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xCF,
  0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xF1, 0xFF, 0x03, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xFC, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFF, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07,
  0xF9, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xF7, 0xFF, 0xDF, 0x80,
  0xFD, 0xFF, 0xF7, 0xE0, 0x3F, 0x7F, 0xFD, 0xF8, 0x0F, 0xDF, 0xFF, 0x7F,
  0x07, 0xE7, 0xFF, 0xCF, 0xC1, 0xF9, 0xFF, 0xF3, 0xF0, 0x7E, 0x7F, 0xFC,
  0xFC, 0x1F, 0x3F, 0xFF, 0x1F, 0x8F, 0xCF, 0xFF, 0xC7, 0xE3, 0xF3, 0xFF,
  0xF1, 0xF8, 0xFC, 0xFF, 0xFC, 0x7F, 0x7E, 0x3F, 0xFF, 0x0F, 0xDF, 0x8F,
  0xFF, 0xC3, 0xF7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0xF0,
  0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xDF, 0xE0, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF,
  0x1F, 0xC3, 0xFF, 0xE3, 0xFC, 0x7F, 0xFC, 0x3F, 0x8F, 0xFF, 0x87, 0xF8,
  0xFF, 0xF0, 0x7F, 0x1F, 0xFE, 0x0F, 0xF3, 0xFF, 0xC0, 0xFE, 0x7F, 0xF8,
  0x1F, 0xEF, 0xFF, 0x01, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFC,
  0x3F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3,
  0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF,
  0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0x83, 0xEF, 0xF0, 0x04, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xF0, 0x3F, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF7, 0xF0, 0x07, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x3F, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F,
  0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xFE, 0x07, 0xF0,
  0x7F, 0x07, 0xFF, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x07, 0xF0,
  0x7E, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x3F, 0x0F, 0xE0, 0x3F, 0x8F, 0xCF,
  0xC7, 0xF8, 0x0F, 0xE3, 0xF3, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F, 0x87, 0xE7, 0xF0, 0x07,
  0xF7, 0xE1, 0xF9, 0xF8, 0x01, 0xFD, 0xF8, 0x7E, 0xFE, 0x00, 0x7F, 0x7E,
  0x0F, 0xBF, 0x80, 0x1F, 0xDF, 0x03, 0xEF, 0xE0, 0x03, 0xF7, 0xC0, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xF7,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFE,
  0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x38, 0x1F, 0xE1, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0x3F, 0xF9, 0xF8, 0xFF, 0x07, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x3C, 0x0F, 0xE3, 0xFC, 0x3F, 0xBF, 0xF8, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xBF, 0xF3, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF3, 0xFF, 0x8F, 0xC3, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xF9, 0xF3, 0xFC, 0x04, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xBF, 0xC0, 0x67, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0x07, 0xF0, 0xFF, 0x9F, 0xC7, 0xFF, 0x7F, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xF3, 0xF0, 0x7F,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE,
  0xFF, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x04, 0x7F, 0xC0, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xE3, 0xF1, 0xFF,
  0xCF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F,
  0xDF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0x1F,
  0xFD, 0xFC, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFD, 0x00, 0x0F, 0xF7, 0x80, 0x7F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x3C, 0x0F, 0xE7, 0xFC, 0x3F, 0xBF, 0xFC, 0xFE, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x03,
  0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8,
  0x7F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0xFE,
  0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x0F, 0xC7,
  0xFE, 0x1F, 0xF8, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0x03, 0xF1, 0xFF, 0x8F, 0xCF, 0xFF, 0x3F,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F,
  0xC1, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x1F,
  0xE7, 0xFC, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x03, 0xF1, 0xFF, 0x0F,
  0xEF, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC,
  0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFC,
  0xFE, 0xFF, 0xE3, 0xF8, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xE3, 0xF1, 0xFF, 0xCF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0x7F, 0x1F, 0xFD, 0xFC, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xE0, 0x73, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xEF, 0xCF, 0xFF, 0x3F, 0x0F, 0xF0, 0xFC, 0xFF, 0x00, 0x7F, 0xBF,
  0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xF0, 0x1F,
  0xDF, 0xC0, 0xFF, 0x81, 0xFC, 0xFF, 0x07, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0xF0, 0x7F, 0x1F, 0xC3, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0x87,
  0xF0, 0xFB, 0xF1, 0xFC, 0x1F, 0xC7, 0xDF, 0x8F, 0xE0, 0xFE, 0x3E, 0x7C,
  0x7F, 0x07, 0xF3, 0xF3, 0xE7, 0xF0, 0x3F, 0x9F, 0x9F, 0x3F, 0x80, 0xFC,
  0xF8, 0xFD, 0xFC, 0x07, 0xF7, 0xC7, 0xEF, 0xE0, 0x3F, 0xBE, 0x1F, 0x7E,
  0x01, 0xFF, 0xF0, 0xFB, 0xF0, 0x07, 0xFF, 0x87, 0xDF, 0x80, 0x3F, 0xF8,
  0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x9F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x81,
  0xFE, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0x9F, 0xE0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xD0, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 34, 13, 2, -33 },
  { 40, 18, 12, 22, 2, -33 },
  { 67, 26, 33, 28, 1, -33 },
  { 175, 21, 38, 25, 2, -35 },
  { 275, 38, 33, 40, 1, -33 },
  { 432, 32, 33, 33, 1, -33 },
  { 564, 8, 12, 12, 2, -33 },
  { 576, 13, 40, 16, 2, -33 },
  { 641, 13, 40, 16, 1, -33 },
  { 706, 21, 21, 23, 1, -35 },
  { 762, 21, 22, 25, 2, -27 },
  { 820, 10, 12, 13, 1, -6 },
  { 835, 12, 6, 15, 1, -15 },
  { 844, 8, 9, 13, 2, -8 },
  { 853, 19, 33, 19, 0, -33 },
  { 932, 21, 33, 25, 2, -33 },
  { 1019, 17, 33, 25, 2, -33 },
  { 1090, 22, 33, 25, 1, -33 },
  { 1181, 21, 33, 25, 2, -33 },
  { 1268, 23, 33, 25, 1, -33 },
  { 1363, 21, 33, 25, 2, -33 },
  { 1450, 21, 33, 25, 2, -33 },
  { 1537, 22, 33, 25, 1, -33 },
  { 1628, 22, 33, 25, 1, -33 },
  { 1719, 22, 33, 25, 1, -33 },
  { 1810, 9, 27, 13, 2, -26 },
  { 1841, 10, 32, 13, 1, -26 },
  { 1881, 21, 24, 25, 2, -29 },
  { 1944, 21, 15, 25, 2, -24 },
  { 1984, 21, 24, 25, 2, -29 },
  { 2047, 20, 34, 21, 0, -33 },
  { 2132, 35, 37, 39, 2, -33 },
  { 2294, 30, 33, 30, 0, -33 },
  { 2418, 24, 33, 29, 3, -33 },
  { 2517, 24, 33, 27, 2, -33 },
  { 2616, 26, 33, 31, 3, -33 },
  { 2724, 17, 33, 24, 4, -33 },
  { 2795, 17, 33, 23, 4, -33 },
  { 2866, 26, 33, 31, 2, -33 },
  { 2974, 25, 33, 32, 4, -33 },
  { 3078, 15, 33, 18, 1, -33 },
  { 3140, 14, 43, 15, -3, -33 },
  { 3216, 25, 33, 29, 4, -33 },
  { 3320, 19, 33, 24, 3, -33 },
  { 3399, 34, 33, 41, 4, -33 },
  { 3540, 27, 33, 35, 4, -33 },
  { 3652, 29, 33, 33, 2, -33 },
  { 3772, 22, 33, 27, 3, -33 },
  { 3863, 29, 41, 33, 2, -33 },
  { 4012, 25, 33, 28, 3, -33 },
  { 4116, 20, 33, 24, 2, -33 },
  { 4199, 23, 33, 24, 1, -33 },
  { 4294, 25, 33, 32, 3, -33 },
  { 4398, 28, 33, 28, 0, -33 },
  { 4514, 42, 33, 42, 0, -33 },
  { 4688, 28, 33, 29, 0, -33 },
  { 4804, 27, 33, 27, 0, -33 },
  { 4916, 23, 33, 25, 1, -33 },
  { 5011, 11, 41, 15, 3, -33 },
  { 5068, 19, 33, 19, 0, -33 },
  { 5147, 11, 41, 15, 1, -33 },
  { 5204, 25, 21, 25, 0, -33 },
  { 5270, 21, 4, 21, 0, 4 },
  { 5281, 13, 7, 17, 2, -35 },
  { 5293, 21, 26, 26, 2, -26 },
  { 5362, 22, 35, 27, 3, -35 },
  { 5459, 19, 26, 22, 2, -26 },
  { 5521, 22, 35, 27, 2, -35 },
  { 5618, 22, 26, 26, 2, -26 },
  { 5690, 17, 35, 17, 1, -35 },
  { 5765, 22, 37, 27, 2, -26 },
  { 5867, 22, 35, 28, 3, -35 },
  { 5964, 8, 35, 13, 3, -35 },
  { 5999, 13, 46, 13, -2, -35 },
  { 6074, 24, 35, 27, 3, -35 },
  { 6179, 7, 35, 13, 3, -35 },
  { 6210, 36, 26, 42, 3, -26 },
  { 6327, 22, 26, 28, 3, -26 },
  { 6399, 23, 26, 27, 2, -26 },
  { 6474, 22, 37, 27, 3, -26 },
  { 6576, 22, 37, 27, 2, -26 },
  { 6678, 16, 26, 19, 3, -26 },
  { 6730, 18, 26, 21, 2, -26 },
  { 6789, 16, 31, 19, 1, -31 },
  { 6851, 22, 25, 28, 3, -25 },
  { 6920, 25, 25, 25, 0, -25 },
  { 6999, 37, 25, 38, 0, -25 },
  { 7115, 25, 25, 25, 0, -25 },
  { 7194, 25, 36, 25, 0, -25 },
  { 7307, 19, 25, 21, 1, -25 },
  { 7367, 15, 41, 18, 1, -33 },
  { 7444, 5, 45, 23, 9, -35 },
  { 7473, 15, 41, 18, 2, -33 },
  { 7550, 21, 8, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD46PT7B_H_
