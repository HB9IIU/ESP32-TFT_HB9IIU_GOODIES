#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x06, 0x7F,
  0xFE, 0xF0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3C, 0x07,
  0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xE0, 0x71, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9C, 0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE,
  0x00, 0x03, 0x00, 0x18, 0x07, 0xFC, 0xFF, 0xF7, 0xFF, 0x7D, 0xBB, 0xCC,
  0x1E, 0x60, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0D, 0xF0, 0x6F, 0xFB, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x3E, 0x03, 0xC0, 0xFE, 0x07, 0x03, 0xFC, 0x1E, 0x07,
  0xBC, 0x38, 0x0E, 0x78, 0xF0, 0x1C, 0x71, 0xC0, 0x38, 0xE7, 0x80, 0x73,
  0xCE, 0x00, 0xE7, 0xBC, 0xF9, 0xFE, 0x73, 0xF9, 0xFD, 0xEF, 0xF1, 0xF3,
  0x9C, 0xF0, 0x0F, 0x39, 0xE0, 0x1C, 0x73, 0xC0, 0x78, 0xE7, 0x80, 0xE1,
  0xCF, 0x03, 0xC3, 0x9E, 0x07, 0x07, 0xF8, 0x1E, 0x07, 0xF0, 0x38, 0x07,
  0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0x7C, 0x03, 0xC7,
  0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0xF9, 0xFF, 0x1F, 0x3F, 0xF3, 0xCF, 0x9F, 0xF9, 0xF3, 0xFF, 0x3E, 0x3F,
  0xC7, 0xC3, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xE3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF,
  0x1E, 0x78, 0x0F, 0x00, 0x78, 0x01, 0xC1, 0x8E, 0x6F, 0xFF, 0x7F, 0xFB,
  0xFF, 0xE3, 0xF0, 0x1F, 0xC1, 0xEF, 0x1E, 0x78, 0x31, 0x80, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x7B, 0xDE, 0xFF,
  0x7B, 0xDC, 0xFF, 0xFF, 0xF8, 0x33, 0xFF, 0xF7, 0x80, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0x8F, 0x7C,
  0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x7F, 0xE3, 0xEF, 0x1F, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80,
  0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFF, 0xFF, 0xDE, 0xF9, 0x9F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xE7, 0x0F,
  0x90, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xE2, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x1F, 0xE0, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0x7C, 0x1E, 0xF8, 0x79, 0xF0, 0xE3, 0xE3, 0xC7, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x8F, 0xFC, 0x7F, 0x27, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x7C, 0xF7, 0xF7,
  0xFF, 0xBF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0x7F,
  0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF9, 0xFF, 0x8F, 0xBC,
  0x7D, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0xFC, 0x0F, 0xF8, 0xFF, 0xEF, 0x8F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F, 0x80,
  0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF8, 0xFF, 0xEF, 0xDF, 0xFE, 0xFF, 0xF3, 0xF7, 0x80, 0x3C, 0x03,
  0xC0, 0x3E, 0x4F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x33, 0xFF, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x67, 0xFF, 0xEF, 0x33, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xBD, 0xEF, 0xF7, 0xBD, 0xC0, 0x00, 0x18, 0x03, 0xC0,
  0x7E, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x07,
  0xF0, 0xFE, 0x3F, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x3F, 0xCF, 0xFE,
  0x7F, 0xF7, 0xFF, 0x40, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFB, 0xF8, 0x3C,
  0x03, 0xE3, 0xC0, 0x07, 0x1C, 0x3F, 0x3D, 0xE7, 0xFC, 0xEE, 0x7F, 0xE7,
  0xF3, 0xC7, 0x3F, 0x9C, 0x79, 0xF9, 0xE3, 0xCF, 0xCF, 0x1E, 0x7E, 0x78,
  0xF3, 0xF1, 0xC7, 0x9F, 0xCF, 0xFF, 0xCE, 0x3F, 0x7C, 0x78, 0xF1, 0xC3,
  0xC0, 0x00, 0x0F, 0x80, 0x20, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7C, 0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFF, 0xBE, 0x7E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x07, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xE0, 0x4F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x02, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x02, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x78,
  0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7E, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7B, 0xFD, 0xFE, 0xFE, 0x7E, 0x00,
  0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0,
  0xFB, 0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFD, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xDC, 0x1D, 0xFE, 0xE1, 0xEF, 0xF7, 0x8F, 0x7F, 0xBC, 0x73,
  0xFC, 0xE3, 0x9F, 0xE7, 0xBC, 0xFF, 0x3D, 0xE7, 0xF9, 0xEE, 0x3F, 0xC7,
  0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F,
  0xE1, 0xE0, 0xF0, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xEF, 0x8F, 0xF7, 0xC7, 0xF9, 0xF3,
  0xFC, 0xF9, 0xFE, 0x3E, 0xFF, 0x0F, 0x7F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD,
  0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xCF, 0xFC, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0xF9, 0xF8, 0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0x9F, 0x0F,
  0x3E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F,
  0xBE, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF9, 0xF0, 0xFB, 0xE1,
  0xF7, 0xC1, 0xF0, 0x1F, 0xE1, 0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0x82, 0x7C,
  0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0x78, 0x03, 0xF8, 0x1E, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x0F, 0xFC, 0x1F, 0x7F, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xF8,
  0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF1, 0xE0, 0xF8,
  0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0xCF, 0x03, 0xEF,
  0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x0F, 0x81,
  0xE7, 0x83, 0xE0, 0x79, 0xE0, 0xFC, 0x3E, 0x78, 0x3F, 0x0F, 0x9F, 0x0F,
  0xC3, 0xC3, 0xC7, 0xF0, 0xF0, 0xF1, 0xFE, 0x3C, 0x3C, 0x77, 0x9F, 0x0F,
  0x9D, 0xE7, 0x83, 0xEF, 0x39, 0xE0, 0x7B, 0xCE, 0x78, 0x1E, 0xF3, 0xDE,
  0x07, 0xB8, 0xFF, 0x81, 0xEE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0xFC,
  0x0F, 0xBE, 0x0F, 0x8F, 0x87, 0x87, 0xC7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7D, 0xF0, 0x3E, 0x7C, 0x3E, 0x3E, 0x3E,
  0x0F, 0x9F, 0x07, 0xDF, 0x01, 0xF0, 0xF8, 0x1F, 0xBE, 0x0F, 0x9F, 0x07,
  0x87, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xE0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xFF, 0xFF, 0xFC, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x78, 0x70,
  0x71, 0xE0, 0xF3, 0xC0, 0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x3C, 0x1E, 0x0F, 0x03, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xF2, 0x0F,
  0x80, 0x7C, 0x1F, 0xE7, 0xFF, 0x7F, 0xFF, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFD, 0xE7, 0xC7, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0xC3, 0xDF, 0x9F, 0xFE, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xEF, 0x7E, 0x00, 0x03, 0x81, 0xFF, 0x3F, 0xE7, 0xFE, 0x7C,
  0x2F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0x7E,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x39, 0xF3, 0xF7, 0xDF, 0xFF, 0x7F, 0xFD, 0xF3, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xF3,
  0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0xFF,
  0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0xC1, 0xBF, 0xFC, 0xFF, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x7F,
  0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0xF7, 0xFE, 0xFF, 0xC7, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x0E, 0x00, 0xFE, 0xF3, 0xFB, 0xDF, 0xFF, 0x7C, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC7, 0xDF, 0x00, 0x7C, 0x01, 0xF4, 0x0F, 0x9F, 0xFE,
  0x7F, 0xF1, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0xE3, 0xDF, 0xDF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0x80, 0x27, 0xBF, 0xE6, 0x00, 0x1E, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x04, 0x3C, 0x78, 0xF0, 0xC0,
  0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xFF, 0xFF, 0xEF, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFC, 0x3E, 0xF1,
  0xF3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3E,
  0xF8, 0xF1, 0xF3, 0xC7, 0xCF, 0x0F, 0xBC, 0x1F, 0xF0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC1, 0xC3,
  0xDF, 0xDF, 0xCF, 0xFF, 0x7F, 0xBF, 0xFF, 0xFE, 0xF8, 0xFC, 0xFF, 0xE3,
  0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1,
  0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xFF,
  0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0x01, 0x87, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x03, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x87, 0xDE, 0x1F, 0x7C, 0xF8, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x01,
  0xC7, 0xBF, 0x3F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xDE,
  0xFC, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0xFE, 0xF3, 0xFB, 0xDF, 0xFF, 0x7C, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC7, 0xDF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF9, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBE, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x0E, 0x07, 0xFD, 0xFF, 0x7F, 0xEF, 0x05, 0xF0, 0x3F, 0x83,
  0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x80, 0xFE, 0x3F, 0xFF, 0xFF, 0xF7, 0xFC,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0xFF, 0xBF, 0xEF, 0xF9, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFB, 0x3F, 0xCF, 0xF1, 0xFC,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x3F, 0xFB, 0xFF, 0xFF, 0xBF, 0xFC, 0xFC,
  0xE0, 0xF8, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F,
  0x0F, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0xF0, 0xF8, 0x79,
  0xE3, 0xF8, 0xF3, 0xE7, 0xF3, 0xE7, 0xCE, 0xE7, 0x87, 0x9D, 0xCF, 0x0F,
  0x7B, 0x9E, 0x1E, 0xF7, 0xFC, 0x1D, 0xCF, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x7E, 0xF8, 0xF8, 0xFB, 0xE0, 0xF7, 0xC1, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7B, 0xE1, 0xF7,
  0xC3, 0xC7, 0xCF, 0x8F, 0xBE, 0x0F, 0x80, 0xF8, 0x3E, 0xF0, 0x7D, 0xF0,
  0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x07, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0,
  0x1D, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xCF, 0xE3,
  0xF0, 0xFC, 0x3F, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xF0, 0xFC, 0x1F, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7E, 0x3F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xE3, 0xF0, 0xF8, 0xFC,
  0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xE3, 0xF1, 0xF0, 0x80,
  0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 8, 1, -20 },
  { 14, 10, 7, 14, 2, -20 },
  { 23, 15, 20, 17, 1, -20 },
  { 61, 13, 23, 15, 1, -21 },
  { 99, 23, 20, 25, 1, -20 },
  { 157, 19, 20, 20, 1, -20 },
  { 205, 4, 7, 7, 2, -20 },
  { 209, 8, 24, 9, 1, -20 },
  { 233, 7, 24, 9, 1, -20 },
  { 254, 13, 12, 14, 1, -21 },
  { 274, 13, 14, 15, 1, -17 },
  { 297, 5, 8, 8, 1, -4 },
  { 302, 7, 3, 9, 1, -9 },
  { 305, 5, 5, 8, 1, -5 },
  { 309, 12, 20, 12, 0, -20 },
  { 339, 13, 20, 15, 1, -20 },
  { 372, 11, 20, 15, 1, -20 },
  { 400, 13, 20, 15, 1, -20 },
  { 433, 13, 20, 15, 1, -20 },
  { 466, 15, 20, 15, 0, -20 },
  { 504, 13, 20, 15, 1, -20 },
  { 537, 13, 20, 15, 1, -20 },
  { 570, 13, 20, 15, 1, -20 },
  { 603, 13, 20, 15, 1, -20 },
  { 636, 13, 20, 15, 1, -20 },
  { 669, 5, 16, 8, 1, -16 },
  { 679, 5, 20, 8, 1, -16 },
  { 692, 13, 14, 15, 1, -17 },
  { 715, 13, 9, 15, 1, -14 },
  { 730, 13, 14, 15, 1, -17 },
  { 753, 12, 20, 13, 0, -20 },
  { 783, 21, 22, 24, 1, -20 },
  { 841, 18, 20, 18, 0, -20 },
  { 886, 14, 20, 17, 2, -20 },
  { 921, 15, 20, 17, 1, -20 },
  { 959, 16, 20, 19, 2, -20 },
  { 999, 11, 20, 14, 2, -20 },
  { 1027, 11, 20, 14, 2, -20 },
  { 1055, 16, 20, 19, 1, -20 },
  { 1095, 16, 20, 20, 2, -20 },
  { 1135, 9, 20, 11, 1, -20 },
  { 1158, 9, 26, 9, -2, -20 },
  { 1188, 16, 20, 17, 2, -20 },
  { 1228, 12, 20, 14, 2, -20 },
  { 1258, 21, 20, 25, 2, -20 },
  { 1311, 17, 20, 21, 2, -20 },
  { 1354, 18, 20, 20, 1, -20 },
  { 1399, 13, 20, 16, 2, -20 },
  { 1432, 18, 25, 20, 1, -20 },
  { 1489, 15, 20, 17, 2, -20 },
  { 1527, 13, 20, 14, 1, -20 },
  { 1560, 13, 20, 15, 1, -20 },
  { 1593, 15, 20, 19, 2, -20 },
  { 1631, 17, 20, 17, 0, -20 },
  { 1674, 26, 20, 26, 0, -20 },
  { 1739, 17, 20, 17, 0, -20 },
  { 1782, 17, 20, 17, 0, -20 },
  { 1825, 13, 20, 15, 1, -20 },
  { 1858, 6, 25, 9, 2, -20 },
  { 1877, 12, 20, 12, 0, -20 },
  { 1907, 6, 25, 9, 1, -20 },
  { 1926, 15, 13, 15, 0, -20 },
  { 1951, 13, 3, 13, 0, 2 },
  { 1956, 8, 4, 10, 1, -21 },
  { 1960, 13, 16, 16, 1, -16 },
  { 1986, 13, 21, 17, 2, -21 },
  { 2021, 12, 16, 14, 1, -16 },
  { 2045, 14, 21, 17, 1, -21 },
  { 2082, 13, 16, 16, 1, -16 },
  { 2108, 11, 21, 10, 0, -21 },
  { 2137, 14, 23, 17, 1, -16 },
  { 2178, 13, 21, 17, 2, -21 },
  { 2213, 5, 22, 8, 2, -22 },
  { 2227, 7, 29, 8, -1, -22 },
  { 2253, 14, 21, 16, 2, -21 },
  { 2290, 4, 21, 8, 2, -21 },
  { 2301, 22, 16, 25, 2, -16 },
  { 2345, 13, 16, 17, 2, -16 },
  { 2371, 14, 16, 16, 1, -16 },
  { 2399, 13, 23, 17, 2, -16 },
  { 2437, 14, 23, 17, 1, -16 },
  { 2478, 10, 16, 12, 2, -16 },
  { 2498, 11, 16, 13, 1, -16 },
  { 2520, 10, 19, 11, 1, -19 },
  { 2544, 13, 15, 17, 2, -15 },
  { 2569, 15, 15, 15, 0, -15 },
  { 2598, 23, 15, 23, 0, -15 },
  { 2642, 15, 15, 15, 0, -15 },
  { 2671, 15, 22, 15, 0, -15 },
  { 2713, 11, 15, 13, 1, -15 },
  { 2734, 10, 25, 11, 0, -20 },
  { 2766, 4, 27, 14, 5, -21 },
  { 2780, 9, 25, 11, 1, -20 },
  { 2809, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD28PT7B_H_
