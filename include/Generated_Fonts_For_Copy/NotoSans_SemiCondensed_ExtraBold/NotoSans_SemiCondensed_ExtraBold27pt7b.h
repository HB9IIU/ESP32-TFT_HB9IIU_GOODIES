#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0F, 0xFF,
  0xDE, 0xFB, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x70, 0x07,
  0x38, 0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x87, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x8E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x00, 0x06,
  0x00, 0x30, 0x01, 0xE0, 0x7F, 0xE7, 0xFF, 0x7F, 0xFB, 0xD8, 0x9E, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x19, 0xF0,
  0xCF, 0xF6, 0xF7, 0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x01, 0xF8, 0x0E, 0x07, 0xF0, 0x70, 0x3D, 0xC1, 0xC0,
  0xE7, 0x8E, 0x03, 0x9E, 0x38, 0x0E, 0x79, 0xC0, 0x39, 0xE7, 0x00, 0xE7,
  0xB8, 0xE3, 0xDC, 0xEF, 0xE7, 0xF7, 0x3F, 0x9F, 0x9D, 0xEF, 0x08, 0xE7,
  0x1C, 0x03, 0x9C, 0x70, 0x1C, 0x71, 0xC0, 0x71, 0xC7, 0x03, 0x87, 0xBC,
  0x0E, 0x0F, 0xE0, 0x70, 0x3F, 0x83, 0xC0, 0x7C, 0x03, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF1, 0xE3, 0xF8, 0x79, 0xFF, 0x3E, 0xFB,
  0xEF, 0x3C, 0x7F, 0xCF, 0x0F, 0xF3, 0xE1, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0x3F, 0xFB, 0xDE, 0xE7, 0x39, 0xC0, 0x0F, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1F, 0xE1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x8F, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x38, 0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0xE6, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xFC, 0x79, 0xE3,
  0x9C, 0x11, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0x7B, 0xDE, 0xEF, 0x7B, 0xDC, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x78, 0x00, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7,
  0x9F, 0x7C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7B, 0xE3, 0xCF, 0x1E, 0x7D, 0xF3, 0xFF, 0x0F, 0xF8,
  0x3F, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x7F, 0xFE, 0xF3, 0x3C, 0x8F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x02, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xE7, 0x1F, 0x10, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02,
  0x03, 0xFE, 0x3F, 0xF8, 0xFF, 0xE6, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xF0,
  0x1E, 0xE3, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0,
  0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xFC, 0x7F, 0xE7, 0xFF, 0x21, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0xFF, 0x3F, 0xFF, 0xEF, 0xFE, 0x7F, 0x80, 0x00,
  0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x30,
  0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF,
  0x1F, 0x7D, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0x02, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F, 0x7C,
  0x79, 0xE3, 0xCF, 0xBE, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xCF, 0x9F,
  0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0x80,
  0x02, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF, 0x9F, 0x78, 0x7B, 0xC3, 0xDE,
  0x1F, 0xF0, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0xF3, 0xF7, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x47, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xFE, 0xF3,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xE0, 0x7F, 0xFE, 0xF3, 0x00, 0x00,
  0x00, 0x00, 0xF7, 0xBD, 0xFE, 0xF7, 0xB8, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00,
  0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x07, 0xF8,
  0xFE, 0x1F, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x04, 0x07, 0xFC, 0xFF,
  0xE7, 0xFE, 0x61, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F,
  0x83, 0xC0, 0x1E, 0x1C, 0x18, 0x79, 0xE3, 0xF9, 0xCE, 0x7F, 0xCE, 0x73,
  0xCE, 0x77, 0x3C, 0x71, 0xF9, 0xC3, 0x8F, 0xCE, 0x1C, 0xFE, 0x70, 0xE7,
  0x73, 0xCF, 0x3B, 0xCF, 0xFF, 0xCE, 0x7F, 0xFC, 0x71, 0xE3, 0xC3, 0xC0,
  0x00, 0x0F, 0x00, 0x40, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x81, 0xE1,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xF0, 0x3C,
  0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7C, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x7E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x80, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x3F, 0x19, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x01, 0x3F, 0xF8, 0xFF,
  0xE1, 0xFF, 0x81, 0xFE, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x8F, 0xEF,
  0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBC, 0x3F, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3,
  0xF0, 0xCF, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xEF, 0x03, 0xDF, 0x07, 0xBE, 0x0F, 0x3F, 0xBE,
  0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xC7, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0xFF, 0x7F, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF7, 0xFB, 0xF9, 0xFC, 0xF8, 0x00, 0xF0, 0x3F, 0xE0,
  0xFB, 0xC3, 0xE7, 0x8F, 0x8F, 0x1F, 0x1E, 0x7C, 0x3D, 0xF0, 0x7B, 0xE0,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x7C, 0xF0, 0x7D, 0xE0, 0xFB, 0xC0, 0xF8, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0x70, 0xEF, 0xF7, 0x9E, 0xFF, 0x79,
  0xEF, 0xF3, 0x9C, 0xFF, 0x39, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xF1,
  0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F,
  0xF7, 0x8F, 0xF7, 0xCF, 0xF3, 0xCF, 0xF3, 0xEF, 0xF1, 0xEF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0x01, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3,
  0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFD, 0xE7, 0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF3, 0xF7,
  0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xE3, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0xC7, 0x8F, 0xCF, 0x0F, 0x9E, 0x1F, 0x3C, 0x3E, 0x78,
  0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0x3E, 0x1E, 0x3C,
  0x3C, 0x7C, 0x78, 0x7C, 0xF0, 0xF9, 0xE0, 0xFB, 0xC1, 0xF8, 0x03, 0x03,
  0xFE, 0x7F, 0xF7, 0xFE, 0xF8, 0xEF, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80, 0xF8,
  0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0x9E, 0x0F,
  0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x87, 0xE1, 0xF3, 0xE3, 0xF8, 0xF0, 0xF1,
  0xDC, 0x78, 0x78, 0xEE, 0x3C, 0x3C, 0xF7, 0x1E, 0x1E, 0x7B, 0xDE, 0x07,
  0xBD, 0xEF, 0x03, 0xDC, 0x77, 0x81, 0xEE, 0x3B, 0xC0, 0xFF, 0x1D, 0xE0,
  0x7F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xCF,
  0x81, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x79, 0xF0,
  0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0xBE, 0x07, 0xE0, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x03, 0x80,
  0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7B, 0x81, 0xCF, 0x0F, 0x1C,
  0x38, 0x78, 0xE0, 0xE7, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3C, 0x1E, 0x07, 0x1F, 0xC3, 0xFF, 0x0F, 0xFC, 0x63, 0xE0,
  0x0F, 0x00, 0x7C, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x87, 0xFC, 0x3F, 0xF3,
  0xFF, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xCF, 0x1F, 0xFC, 0xFF, 0xF7, 0xEF, 0xBC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xCF, 0xBF,
  0xFD, 0xFF, 0xCE, 0x7C, 0x00, 0x0F, 0xC7, 0xFD, 0xFF, 0xBF, 0x67, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x77, 0xFE, 0x7F,
  0xC7, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x79, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xE7, 0xDF, 0xFE, 0x7F, 0xF1, 0xF3,
  0x80, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x87, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0xF8, 0x27, 0xFF, 0x1F, 0xF8,
  0x7F, 0x80, 0x03, 0x81, 0xFC, 0x7F, 0x0F, 0xE3, 0xE0, 0x7C, 0x0F, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x79, 0xFF, 0xDF, 0xFE,
  0xFB, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1E, 0xF9, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xE0, 0x0F, 0x00, 0x7B, 0x07,
  0xDF, 0xFC, 0xFF, 0xE7, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFE, 0xFF, 0xF7, 0xEF, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x6F, 0xFF, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x3C, 0x78, 0xF0, 0x80, 0x07, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x9F, 0xFF, 0xFB, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x07, 0xFC, 0x3E, 0xF1, 0xF3, 0xCF, 0x8F, 0x7C, 0x3D,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3E, 0xF0, 0xF3, 0xE3, 0xC7, 0xCF,
  0x0F, 0x3C, 0x3E, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC3, 0xE7, 0x7F, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x8F, 0x8F, 0xF8, 0x7C, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E,
  0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1, 0xE1, 0xFF,
  0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xE0, 0xE7, 0xC7, 0x7F, 0xBF,
  0xFD, 0xFB, 0xEF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xE0, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1F, 0x7E, 0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xEF, 0x87, 0x9F, 0x3E, 0x7F, 0xF0, 0xFF, 0xC0, 0xFC, 0x00,
  0xE7, 0xC7, 0xFF, 0x3F, 0xFD, 0xFB, 0xEF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xFB, 0xEF, 0xFF, 0x7F, 0xF3, 0xDF,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1F,
  0x79, 0xFF, 0xDF, 0xFE, 0xFB, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0xF9, 0xF7, 0xFF, 0x9F, 0xFC, 0x7D, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xE3, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0x3F, 0x8F, 0xFB, 0xFF, 0x78, 0x4F, 0x01, 0xF8, 0x1F,
  0xC3, 0xFC, 0x1F, 0xC0, 0xF8, 0x0F, 0xE1, 0xEF, 0xFD, 0xFF, 0xBF, 0xC0,
  0x1C, 0x1E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF2, 0xFF, 0x3F, 0x8F, 0xC0, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0, 0xF8, 0x3F,
  0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x3D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E,
  0x3F, 0x1E, 0x78, 0xFC, 0x78, 0xF7, 0xFB, 0xC3, 0xDC, 0xEF, 0x0F, 0x73,
  0xBC, 0x3D, 0xCE, 0xF0, 0x77, 0x3B, 0x81, 0xDC, 0xEE, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0xF8,
  0xF8, 0xF3, 0xE1, 0xF7, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC3, 0xCF, 0x8F, 0x8F, 0xBE,
  0x0F, 0x80, 0xF8, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xE3, 0xE3, 0xC7, 0x87,
  0x8F, 0x0F, 0x3E, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x0F, 0x8F, 0xE3, 0xE0, 0xFE, 0x0F, 0x81, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xC3, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7E, 0x3F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xE0, 0xF1, 0xF9, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x8F, 0xC7, 0xE3, 0xE0, 0x7C, 0x0F, 0xF9,
  0xFF, 0xFF, 0x9F, 0xF8, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 11, 7, 13, 1, -19 },
  { 23, 15, 19, 16, 1, -19 },
  { 59, 13, 23, 15, 1, -21 },
  { 97, 22, 20, 24, 1, -20 },
  { 152, 18, 20, 19, 1, -20 },
  { 197, 5, 7, 7, 1, -19 },
  { 202, 8, 24, 9, 1, -20 },
  { 226, 7, 24, 9, 1, -20 },
  { 247, 12, 13, 14, 1, -21 },
  { 267, 13, 13, 15, 1, -16 },
  { 289, 5, 8, 8, 1, -4 },
  { 294, 7, 4, 9, 1, -9 },
  { 298, 5, 4, 7, 1, -4 },
  { 301, 11, 20, 11, 0, -20 },
  { 329, 13, 20, 15, 1, -20 },
  { 362, 10, 19, 15, 1, -19 },
  { 386, 13, 20, 15, 1, -20 },
  { 419, 13, 20, 15, 1, -20 },
  { 452, 14, 19, 15, 0, -19 },
  { 486, 12, 19, 15, 1, -19 },
  { 515, 13, 20, 15, 1, -20 },
  { 548, 13, 19, 15, 1, -19 },
  { 579, 13, 20, 15, 1, -20 },
  { 612, 13, 20, 15, 1, -20 },
  { 645, 5, 15, 8, 1, -15 },
  { 655, 5, 19, 8, 1, -15 },
  { 667, 13, 14, 15, 1, -17 },
  { 690, 13, 9, 15, 1, -14 },
  { 705, 13, 14, 15, 1, -17 },
  { 728, 12, 20, 12, 0, -20 },
  { 758, 21, 22, 23, 1, -20 },
  { 816, 18, 19, 18, 0, -19 },
  { 859, 14, 19, 17, 2, -19 },
  { 893, 14, 20, 16, 1, -20 },
  { 928, 15, 19, 18, 2, -19 },
  { 964, 10, 19, 14, 2, -19 },
  { 988, 10, 19, 14, 2, -19 },
  { 1012, 15, 20, 18, 1, -20 },
  { 1050, 15, 19, 19, 2, -19 },
  { 1086, 9, 19, 10, 1, -19 },
  { 1108, 9, 25, 9, -2, -19 },
  { 1137, 15, 19, 17, 2, -19 },
  { 1173, 11, 19, 14, 2, -19 },
  { 1200, 20, 19, 24, 2, -19 },
  { 1248, 16, 19, 20, 2, -19 },
  { 1286, 17, 20, 20, 1, -20 },
  { 1329, 13, 19, 16, 2, -19 },
  { 1360, 17, 25, 20, 1, -20 },
  { 1414, 15, 19, 17, 2, -19 },
  { 1450, 12, 20, 14, 1, -20 },
  { 1480, 13, 19, 14, 1, -19 },
  { 1511, 15, 19, 19, 2, -19 },
  { 1547, 17, 19, 17, 0, -19 },
  { 1588, 25, 19, 25, 0, -19 },
  { 1648, 17, 19, 17, 0, -19 },
  { 1689, 16, 19, 16, 0, -19 },
  { 1727, 13, 19, 15, 1, -19 },
  { 1758, 6, 24, 9, 2, -20 },
  { 1776, 11, 20, 11, 0, -20 },
  { 1804, 6, 24, 9, 1, -20 },
  { 1822, 14, 12, 15, 0, -19 },
  { 1843, 12, 3, 12, 0, 2 },
  { 1848, 8, 5, 10, 1, -21 },
  { 1853, 13, 15, 15, 1, -15 },
  { 1878, 13, 21, 16, 2, -21 },
  { 1913, 11, 15, 13, 1, -15 },
  { 1934, 13, 21, 16, 1, -21 },
  { 1969, 13, 15, 15, 1, -15 },
  { 1994, 11, 21, 10, 0, -21 },
  { 2023, 13, 21, 16, 1, -15 },
  { 2058, 13, 21, 16, 2, -21 },
  { 2093, 4, 21, 8, 2, -21 },
  { 2104, 7, 27, 8, -1, -21 },
  { 2128, 14, 21, 16, 2, -21 },
  { 2165, 4, 21, 8, 2, -21 },
  { 2176, 21, 15, 24, 2, -15 },
  { 2216, 13, 15, 16, 2, -15 },
  { 2241, 14, 15, 16, 1, -15 },
  { 2268, 13, 21, 16, 2, -15 },
  { 2303, 13, 21, 16, 1, -15 },
  { 2338, 9, 15, 11, 2, -15 },
  { 2355, 11, 15, 13, 1, -15 },
  { 2376, 9, 18, 11, 1, -18 },
  { 2397, 13, 15, 16, 2, -15 },
  { 2422, 15, 15, 15, 0, -15 },
  { 2451, 22, 15, 22, 0, -15 },
  { 2493, 15, 15, 15, 0, -15 },
  { 2522, 15, 21, 15, 0, -15 },
  { 2562, 11, 15, 12, 1, -15 },
  { 2583, 10, 23, 11, 0, -19 },
  { 2612, 3, 27, 13, 5, -21 },
  { 2623, 9, 23, 11, 1, -19 },
  { 2649, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD27PT7B_H_
