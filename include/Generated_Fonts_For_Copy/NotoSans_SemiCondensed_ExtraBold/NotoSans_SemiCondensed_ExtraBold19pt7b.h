#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7E, 0x60,
  0x0C, 0xC1, 0x98, 0x36, 0x0E, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xDC, 0xFF,
  0xFF, 0xFC, 0xCC, 0x19, 0x83, 0x30, 0x6E, 0x00, 0x18, 0x3F, 0xBF, 0xDF,
  0x6D, 0x87, 0xC1, 0xF0, 0x7E, 0x1F, 0x0D, 0xE6, 0xDF, 0xEF, 0xE0, 0xC0,
  0x60, 0x38, 0x38, 0x7C, 0x30, 0x6E, 0x30, 0x6E, 0x60, 0xEE, 0x60, 0x6E,
  0xC0, 0x6E, 0xDE, 0x7D, 0xBF, 0x39, 0xB3, 0x03, 0x33, 0x03, 0x33, 0x06,
  0x33, 0x06, 0x3F, 0x0C, 0x1E, 0x1C, 0x07, 0xF0, 0x77, 0x07, 0x30, 0x77,
  0x07, 0xF0, 0x3E, 0x07, 0xC7, 0xEE, 0xEE, 0x7E, 0xE3, 0xCF, 0x7C, 0xFF,
  0xE7, 0xEF, 0xFF, 0xFE, 0x39, 0x9C, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x31, 0xCE, 0x38, 0xE1, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x1C, 0x71, 0xC6,
  0x38, 0xE3, 0x1C, 0xE0, 0x0C, 0x06, 0x1B, 0xEF, 0xF9, 0xC1, 0xF1, 0xDC,
  0x64, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x00,
  0xFF, 0xEC, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0x1C, 0x3F, 0x3F, 0xDC,
  0xEE, 0x77, 0x3F, 0x8F, 0xC7, 0xE3, 0xF3, 0xB9, 0xDE, 0xE7, 0xE1, 0xF0,
  0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC0, 0x3C, 0x7F, 0x3F, 0xC8, 0xE0, 0x70, 0x38, 0x3C, 0x3C, 0x1C, 0x1C,
  0x1C, 0x1F, 0xFF, 0xFF, 0xFC, 0x3C, 0x7F, 0x3F, 0xC8, 0xE0, 0x70, 0x78,
  0xF0, 0x7C, 0x0F, 0x03, 0x81, 0xF9, 0xEF, 0xF7, 0xF0, 0x03, 0x81, 0xE0,
  0xF8, 0x3E, 0x1B, 0x8E, 0xE3, 0x79, 0xDE, 0x67, 0xBF, 0xFF, 0xFC, 0x1E,
  0x07, 0x81, 0xE0, 0x7F, 0x7F, 0xFF, 0xE0, 0xE0, 0xFC, 0xFE, 0xFF, 0x07,
  0x07, 0x07, 0xCF, 0xFF, 0xFC, 0x0F, 0x1F, 0x9F, 0xDE, 0x0E, 0x07, 0x73,
  0x7D, 0xFE, 0xE3, 0xF1, 0xF8, 0xFE, 0xE7, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x83,
  0x80, 0x3C, 0x3F, 0xBF, 0xDC, 0xEE, 0x73, 0xF9, 0xF8, 0xFC, 0xFF, 0x73,
  0xF0, 0xFC, 0xFF, 0xF3, 0xF0, 0x38, 0x3F, 0x3F, 0xDC, 0xEE, 0x7F, 0x1F,
  0x9F, 0xFF, 0x7B, 0x01, 0x81, 0xC1, 0xEF, 0xE7, 0xC0, 0x5F, 0xB0, 0x00,
  0xFF, 0x80, 0x5F, 0xB0, 0x00, 0x1F, 0xFD, 0x80, 0x00, 0x81, 0xC3, 0xE7,
  0xCF, 0x87, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x80, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0xFD, 0xF0,
  0xE0, 0x40, 0x00, 0x3C, 0xFF, 0x7F, 0x47, 0x07, 0x0F, 0x1E, 0x1C, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0x80, 0x7F, 0xC3, 0x83, 0x9C, 0x06,
  0x67, 0xEF, 0x3F, 0x3C, 0xCC, 0xF7, 0x33, 0xDC, 0xCF, 0x73, 0x3C, 0xFF,
  0xB9, 0xCC, 0x60, 0x00, 0xE1, 0x81, 0xFE, 0x00, 0x0F, 0x00, 0xF0, 0x1F,
  0x81, 0xF8, 0x1D, 0x81, 0xDC, 0x39, 0xC3, 0x9C, 0x3F, 0xE7, 0xFE, 0x7F,
  0xE7, 0x0F, 0xF0, 0x7F, 0x07, 0xFC, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC,
  0xEF, 0xF3, 0xFE, 0xF3, 0xFC, 0x7F, 0x1F, 0xDF, 0xFF, 0xBF, 0xC0, 0x0F,
  0x0F, 0xF7, 0xF9, 0xC2, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x01, 0xE6, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0xF3, 0xFF, 0x79, 0xEF, 0x1F,
  0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0x7F, 0xEF, 0xF9, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFE, 0xFE, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFE, 0xFE, 0xFE,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x87, 0xF9, 0xFF, 0x3C, 0x2F, 0x01,
  0xC0, 0x39, 0xFF, 0x3F, 0xE7, 0xFC, 0x1F, 0xC3, 0xBC, 0xF3, 0xFE, 0x3F,
  0x80, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xC0, 0xFF, 0xFF, 0x9C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xBE, 0xFB, 0xC0, 0xF1, 0xFE,
  0x3B, 0xCE, 0x7B, 0xCF, 0x71, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1E, 0xE3,
  0xCE, 0x79, 0xEF, 0x1D, 0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFD, 0x8D, 0xFB, 0x1B, 0xF7, 0x77, 0xEE,
  0xCF, 0xCD, 0x9F, 0x9F, 0x3F, 0x3C, 0x7E, 0x38, 0xFC, 0x71, 0xC0, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E, 0x77, 0xE7,
  0x7E, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0x0F, 0x03, 0xFC, 0x7F,
  0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xF0,
  0xE7, 0xBE, 0x3F, 0xC1, 0xF8, 0xFC, 0x7F, 0xBF, 0xFE, 0x7F, 0x3F, 0x9F,
  0xDF, 0xFF, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xFC,
  0x7F, 0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xF0, 0xE7, 0xBE, 0x3F, 0xC1, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xFC,
  0x1F, 0xE3, 0xFE, 0x79, 0xCF, 0x39, 0xE7, 0x3F, 0xE7, 0xF8, 0xFF, 0x1E,
  0xE3, 0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xC0, 0x1C, 0x7F, 0xFF, 0xE1, 0xE0,
  0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x87, 0xEF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xC7, 0xBD, 0xE7, 0xFC, 0x3F, 0x00, 0xE0,
  0x7F, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x3B,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xC3, 0xF0, 0xE1,
  0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x3E, 0x73, 0x9F, 0x39, 0xCD, 0x9C, 0x76,
  0xEE, 0x3B, 0x77, 0x1F, 0x9B, 0x0F, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE0,
  0xF0, 0xE0, 0xF0, 0xE7, 0x1E, 0x79, 0xC3, 0xBC, 0x1F, 0x81, 0xF8, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3B, 0xC7, 0x9C, 0x71, 0xEF, 0x0F, 0xE0,
  0xEE, 0x3D, 0xC7, 0x3C, 0xE3, 0xB8, 0x7F, 0x07, 0xC0, 0xF8, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E,
  0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8,
  0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x06, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF,
  0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0C, 0xC7, 0x39, 0x86, 0xE1,
  0xC0, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x1C, 0x3F, 0x9F, 0xC0, 0xE0, 0xFB,
  0xFF, 0x9F, 0xCF, 0xE7, 0xFF, 0xDE, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0xCE,
  0xF7, 0xFF, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0x7F, 0xFF, 0x78, 0x1C,
  0x7F, 0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E, 0x3E, 0x03, 0x81,
  0xC0, 0xE6, 0x77, 0xFF, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0xF7,
  0xFB, 0xDC, 0x1C, 0x3F, 0x9F, 0xDC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xF1,
  0x3F, 0x8F, 0xC0, 0x0C, 0x3F, 0x3E, 0x38, 0x38, 0xFE, 0xFE, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xF7, 0xBF, 0xDE, 0xE0, 0x78, 0x3F, 0xFB, 0xFC, 0x30,
  0xE0, 0x70, 0x38, 0x1C, 0xCF, 0xFF, 0xFF, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1C, 0x5F, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x11, 0xCE,
  0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFE, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xE3, 0xB9, 0xCE, 0xF3, 0xB8, 0xFE, 0x3F, 0x8F,
  0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x19, 0xFF, 0xFB, 0xFF, 0xFF, 0x9E, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3,
  0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x38, 0x06, 0x7F, 0xFF, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x1C, 0x3F, 0x9F,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xBF, 0x8F, 0x80, 0x06, 0x77,
  0xBF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xFB, 0xDC, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x30, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xF7, 0xBF, 0xDE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xDF,
  0xFF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x39, 0xFF, 0xFF, 0x0F,
  0x1F, 0x8F, 0x87, 0x8F, 0xFF, 0xF0, 0x18, 0x70, 0xE7, 0xFF, 0xE7, 0x0E,
  0x1C, 0x38, 0x70, 0xE9, 0xF3, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xEF, 0x7F, 0xBE, 0xC0, 0xE1, 0xDC, 0x77, 0x39, 0xCE, 0x3B,
  0x8F, 0xC3, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE3, 0xCE, 0xE7, 0x9D, 0xDF,
  0x3B, 0xB6, 0xE7, 0x6D, 0xC6, 0xDF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78,
  0x38, 0xF0, 0xF3, 0xDE, 0xE3, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xF0, 0xEE,
  0x73, 0xBC, 0x70, 0xE1, 0xDC, 0x77, 0x39, 0xCE, 0x3B, 0x8F, 0xC1, 0xF0,
  0x7C, 0x1E, 0x03, 0x80, 0xE0, 0x70, 0x7C, 0x1E, 0x06, 0x00, 0x7F, 0x7F,
  0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xFF, 0xFF, 0x06, 0x3C, 0x78, 0xC1,
  0x83, 0x0E, 0x3C, 0xF1, 0xF0, 0xE0, 0xC1, 0x83, 0x07, 0x0F, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x1C, 0xF7,
  0x1C, 0x71, 0xC7, 0x3C, 0xE0, 0xF9, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 11, 14, 12, 0, -14 },
  { 32, 9, 15, 10, 1, -14 },
  { 49, 16, 14, 17, 0, -14 },
  { 77, 12, 14, 13, 1, -14 },
  { 98, 3, 5, 5, 1, -14 },
  { 100, 5, 17, 6, 1, -14 },
  { 111, 6, 17, 6, 0, -14 },
  { 124, 9, 8, 10, 0, -14 },
  { 133, 9, 9, 10, 1, -11 },
  { 144, 3, 5, 5, 1, -2 },
  { 146, 6, 2, 6, 0, -6 },
  { 148, 3, 3, 5, 1, -3 },
  { 150, 8, 14, 8, 0, -14 },
  { 164, 9, 14, 10, 1, -14 },
  { 180, 7, 14, 10, 1, -14 },
  { 193, 9, 14, 10, 1, -14 },
  { 209, 9, 14, 10, 1, -14 },
  { 225, 10, 14, 10, 0, -14 },
  { 243, 8, 14, 10, 1, -14 },
  { 257, 9, 14, 10, 1, -14 },
  { 273, 9, 14, 10, 1, -14 },
  { 289, 9, 14, 10, 1, -14 },
  { 305, 9, 14, 10, 1, -14 },
  { 321, 3, 11, 5, 1, -11 },
  { 326, 3, 14, 5, 1, -11 },
  { 332, 9, 10, 10, 1, -12 },
  { 344, 9, 6, 10, 1, -10 },
  { 351, 9, 10, 10, 1, -12 },
  { 363, 8, 14, 9, 0, -14 },
  { 377, 14, 15, 16, 1, -14 },
  { 404, 12, 14, 12, 0, -14 },
  { 425, 10, 14, 12, 1, -14 },
  { 443, 10, 14, 11, 1, -14 },
  { 461, 11, 14, 13, 1, -14 },
  { 481, 8, 14, 10, 1, -14 },
  { 495, 8, 14, 10, 1, -14 },
  { 509, 11, 14, 13, 1, -14 },
  { 529, 11, 14, 13, 1, -14 },
  { 549, 6, 14, 7, 1, -14 },
  { 560, 6, 18, 6, -1, -14 },
  { 574, 11, 14, 12, 1, -14 },
  { 594, 8, 14, 10, 1, -14 },
  { 608, 15, 14, 17, 1, -14 },
  { 635, 12, 14, 14, 1, -14 },
  { 656, 12, 14, 14, 1, -14 },
  { 677, 9, 14, 11, 1, -14 },
  { 693, 12, 17, 14, 1, -14 },
  { 719, 11, 14, 12, 1, -14 },
  { 739, 8, 14, 10, 1, -14 },
  { 753, 10, 14, 10, 0, -14 },
  { 771, 11, 14, 13, 1, -14 },
  { 791, 12, 14, 12, 0, -14 },
  { 812, 17, 14, 17, 0, -14 },
  { 842, 12, 14, 12, 0, -14 },
  { 863, 11, 14, 11, 0, -14 },
  { 883, 10, 14, 10, 0, -14 },
  { 901, 5, 17, 6, 1, -14 },
  { 912, 8, 14, 8, 0, -14 },
  { 926, 5, 17, 6, 0, -14 },
  { 937, 10, 9, 10, 0, -14 },
  { 949, 9, 2, 9, 0, 1 },
  { 952, 5, 3, 7, 1, -15 },
  { 954, 9, 11, 11, 1, -11 },
  { 967, 9, 14, 11, 1, -14 },
  { 983, 8, 11, 9, 1, -11 },
  { 994, 9, 14, 11, 1, -14 },
  { 1010, 9, 11, 11, 1, -11 },
  { 1023, 8, 15, 7, 0, -15 },
  { 1038, 9, 16, 11, 1, -11 },
  { 1056, 9, 14, 12, 1, -14 },
  { 1072, 3, 15, 6, 1, -15 },
  { 1078, 5, 20, 5, -1, -15 },
  { 1091, 10, 14, 11, 1, -14 },
  { 1109, 3, 14, 5, 1, -14 },
  { 1115, 15, 11, 17, 1, -11 },
  { 1136, 9, 11, 12, 1, -11 },
  { 1149, 9, 11, 11, 1, -11 },
  { 1162, 9, 16, 11, 1, -11 },
  { 1180, 9, 16, 11, 1, -11 },
  { 1198, 7, 11, 8, 1, -11 },
  { 1208, 7, 11, 9, 1, -11 },
  { 1218, 7, 13, 8, 0, -13 },
  { 1230, 9, 10, 12, 1, -10 },
  { 1242, 10, 10, 10, 0, -10 },
  { 1255, 15, 10, 16, 0, -10 },
  { 1274, 10, 10, 10, 0, -10 },
  { 1287, 10, 15, 10, 0, -10 },
  { 1306, 8, 10, 9, 0, -10 },
  { 1316, 7, 17, 7, 0, -14 },
  { 1331, 2, 18, 9, 4, -14 },
  { 1336, 6, 17, 7, 1, -14 },
  { 1349, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD19PT7B_H_
