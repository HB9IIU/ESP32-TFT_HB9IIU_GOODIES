#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB0, 0x5F, 0x00, 0xDF, 0x3C, 0xF3, 0x1B, 0x0D, 0x86,
  0xCF, 0xF1, 0x21, 0xB3, 0xFF, 0xFF, 0x36, 0x13, 0x19, 0x00, 0x10, 0xFB,
  0xFE, 0x9D, 0x1F, 0x1F, 0x0F, 0x17, 0xFF, 0xF0, 0x81, 0x00, 0x30, 0x21,
  0xE3, 0x06, 0xCC, 0x33, 0x60, 0xCD, 0x81, 0xBD, 0xE7, 0xB7, 0x8D, 0xB3,
  0x06, 0xCC, 0x33, 0x30, 0xC7, 0x86, 0x1E, 0x18, 0x1F, 0x06, 0xE3, 0xB8,
  0x6C, 0x1F, 0x0F, 0x9F, 0xF6, 0xCF, 0xB1, 0xCF, 0xF9, 0xF7, 0xFF, 0x36,
  0x6E, 0xCC, 0xCC, 0xCC, 0xCE, 0x66, 0x30, 0xE3, 0x1C, 0x63, 0x1C, 0xE7,
  0x39, 0xCC, 0x67, 0x33, 0x80, 0x18, 0x18, 0x7F, 0xFF, 0x3C, 0x7E, 0x24,
  0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x76, 0x6E, 0xFF, 0xC0, 0x5F,
  0x80, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x87, 0x00,
  0x30, 0xFB, 0xF6, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xDF, 0xF3, 0xC0, 0x3D,
  0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x18, 0x7E, 0xFF, 0x47,
  0x07, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0x7F, 0x7F, 0x31, 0xFB, 0xF8, 0x70,
  0xCF, 0x1F, 0x07, 0x0F, 0x1F, 0xFF, 0xC0, 0x0E, 0x0E, 0x1E, 0x36, 0x36,
  0x66, 0xE6, 0xFF, 0xFF, 0x06, 0x06, 0xFD, 0xFB, 0x86, 0x0F, 0xDF, 0xC3,
  0x87, 0x8F, 0xFB, 0xE0, 0x0C, 0xF9, 0xF7, 0x0C, 0x9F, 0xBF, 0xE3, 0xC7,
  0xDF, 0xFB, 0xE0, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x18,
  0x38, 0x30, 0x11, 0xFB, 0xBE, 0x7E, 0xEF, 0x9F, 0x77, 0xC7, 0x8F, 0xFB,
  0xE0, 0x18, 0x7E, 0x7F, 0x67, 0xE3, 0x67, 0x7F, 0x3B, 0x07, 0x06, 0x7E,
  0x7C, 0xDF, 0x00, 0x17, 0xE0, 0x67, 0x60, 0x00, 0x07, 0x66, 0xE0, 0x02,
  0x1C, 0xF7, 0x8E, 0x0F, 0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81,
  0xC3, 0xE0, 0xF0, 0xE7, 0xBC, 0x60, 0x19, 0xF9, 0xF8, 0x70, 0xE3, 0x8E,
  0x18, 0x00, 0x60, 0xE1, 0x80, 0x06, 0x03, 0xFC, 0x70, 0xE6, 0x76, 0xDF,
  0xBD, 0x9B, 0xD9, 0xBD, 0x9B, 0xDB, 0xED, 0xEE, 0xE0, 0x07, 0x18, 0x3F,
  0x80, 0x1E, 0x07, 0x81, 0xF0, 0xEC, 0x3B, 0x0C, 0xE7, 0xF9, 0xFE, 0x7F,
  0xF8, 0x7E, 0x1C, 0xFE, 0xFF, 0xE7, 0xE7, 0xFE, 0xFE, 0xE7, 0xE3, 0xE7,
  0xFF, 0xFE, 0x0C, 0x3F, 0x7E, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0, 0xF1,
  0x7F, 0x3F, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7,
  0x7F, 0xBF, 0x00, 0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xC0,
  0xFF, 0xFE, 0x38, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x00, 0x0C, 0x1F, 0xDF,
  0xDC, 0x0E, 0x07, 0x7F, 0xBF, 0xDF, 0xE3, 0xF9, 0xDF, 0xE7, 0xF0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0,
  0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xFF, 0xC0, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF8, 0xE3, 0xF3, 0xBB, 0x9D, 0x8F, 0xC7,
  0xE3, 0xF9, 0xDC, 0xE7, 0x73, 0xB8, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x9B, 0xF9,
  0xBF, 0x9B, 0xEF, 0x3E, 0xF3, 0xEF, 0x3E, 0xF3, 0xE6, 0x30, 0xF1, 0xFC,
  0x7F, 0x9F, 0x67, 0xFD, 0xFB, 0xBE, 0xEF, 0x9F, 0xE7, 0xF8, 0xFE, 0x3C,
  0x0C, 0x1F, 0xC7, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0xE7, 0xF8, 0xFC, 0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0,
  0xE0, 0xE0, 0x0C, 0x1F, 0xC7, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xFC, 0xE7, 0xF8, 0xFC, 0x07, 0x00, 0xE0, 0x3C, 0xFE, 0x7F, 0xB9,
  0xDC, 0xEE, 0xE7, 0xF3, 0xF1, 0xDC, 0xE6, 0x73, 0xB8, 0xE0, 0x18, 0xFF,
  0xF6, 0x0E, 0x1F, 0x1F, 0x0F, 0x0F, 0x1F, 0xF7, 0xC0, 0xFF, 0xFF, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xBF, 0x8F, 0x80, 0xE1, 0xD8, 0x67,
  0x39, 0xCE, 0x73, 0x0C, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xE3,
  0x8F, 0xC7, 0x19, 0x9E, 0x73, 0x3C, 0xE7, 0x6D, 0xCE, 0xDB, 0x0D, 0xB6,
  0x1E, 0x7C, 0x3C, 0xF8, 0x78, 0xE0, 0x71, 0xC0, 0xF3, 0xDC, 0xE3, 0xF0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0xFC, 0x73, 0x1C, 0xEE, 0x1C, 0xE3, 0xB9,
  0xDD, 0xC6, 0xE3, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF,
  0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x0E,
  0x0C, 0x18, 0x38, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xF0, 0x18, 0x0E, 0x0F, 0x06, 0xC6, 0x63, 0x1B, 0x0E, 0xFF, 0xFC, 0xE7,
  0xFC, 0xFD, 0x38, 0x7F, 0xF9, 0xF3, 0xFF, 0xF6, 0xE0, 0xE0, 0xE0, 0xFC,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xDE, 0x3D, 0xFE, 0x70, 0xC3,
  0x0E, 0x7F, 0x7C, 0x06, 0x0C, 0x1B, 0xBF, 0xFD, 0xF1, 0xE3, 0xC7, 0xCF,
  0xFB, 0xB0, 0x3D, 0xFF, 0x9E, 0x3F, 0xF8, 0x38, 0x7F, 0x7E, 0x3C, 0xF7,
  0x1F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x77, 0xFF, 0x9E, 0x3C, 0x78,
  0xF9, 0xFF, 0x76, 0x0E, 0x3F, 0xF7, 0x80, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0,
  0x39, 0xC0, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xDC, 0xE0, 0xE0,
  0xE0, 0xE7, 0xEE, 0xEC, 0xFC, 0xFC, 0xFC, 0xEE, 0xE6, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xDE, 0xE7, 0xFF, 0xB9, 0xCD, 0xCE, 0x7E, 0x73, 0xF3,
  0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x38, 0xDE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x3C, 0xFE, 0xE6, 0xC7, 0xC7, 0xC7, 0xE6, 0xFE, 0x7C,
  0xDC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0x77, 0xFF, 0x9E, 0x3C, 0x78, 0xF9, 0xFF, 0x76, 0x0C, 0x18, 0x30,
  0x60, 0xDF, 0x6F, 0xB8, 0xE3, 0x8E, 0x38, 0xE0, 0x7B, 0xFC, 0x78, 0xF8,
  0xF9, 0xFF, 0xF8, 0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xF3, 0xC0,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xF1, 0x99,
  0xCE, 0xE7, 0x61, 0xB0, 0xF8, 0x38, 0x1C, 0x00, 0xE7, 0x3F, 0x39, 0xD9,
  0x4C, 0xDB, 0x67, 0xDF, 0x3E, 0xF8, 0xF7, 0x87, 0x1C, 0x38, 0xE0, 0xE3,
  0xBB, 0x8D, 0x87, 0xC1, 0xC1, 0xF0, 0xF8, 0xEE, 0xE3, 0x80, 0xE3, 0xF1,
  0x99, 0xCE, 0xE3, 0x61, 0xB0, 0xF8, 0x38, 0x1C, 0x0E, 0x0E, 0x0F, 0x06,
  0x00, 0x7E, 0xFC, 0x30, 0xE3, 0x86, 0x1C, 0x7F, 0xFE, 0x04, 0xF3, 0x8C,
  0x30, 0xC7, 0x38, 0xF0, 0xC3, 0x0C, 0x38, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0x38, 0xC6, 0x31, 0xC3, 0x7B, 0x18, 0xC6, 0x72, 0x00, 0xF3,
  0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 9, 11, 10, 0, -11 },
  { 22, 7, 13, 9, 1, -12 },
  { 34, 14, 12, 14, 0, -12 },
  { 55, 10, 12, 11, 1, -12 },
  { 70, 2, 4, 4, 1, -11 },
  { 71, 4, 15, 5, 1, -12 },
  { 79, 5, 15, 5, 0, -12 },
  { 89, 8, 7, 8, 0, -12 },
  { 96, 7, 8, 9, 1, -10 },
  { 103, 4, 4, 5, 0, -2 },
  { 105, 5, 2, 5, 0, -5 },
  { 107, 3, 3, 4, 1, -3 },
  { 109, 7, 12, 7, 0, -12 },
  { 120, 7, 12, 9, 1, -12 },
  { 131, 6, 11, 9, 1, -11 },
  { 140, 8, 12, 9, 0, -12 },
  { 152, 7, 12, 9, 1, -12 },
  { 163, 8, 11, 9, 0, -11 },
  { 174, 7, 11, 9, 1, -11 },
  { 184, 7, 12, 9, 1, -12 },
  { 195, 8, 11, 9, 0, -11 },
  { 206, 7, 12, 9, 1, -12 },
  { 217, 8, 12, 9, 0, -12 },
  { 229, 3, 9, 4, 1, -9 },
  { 233, 4, 11, 5, 0, -9 },
  { 239, 7, 8, 9, 1, -10 },
  { 246, 7, 5, 9, 1, -8 },
  { 251, 7, 8, 9, 1, -10 },
  { 258, 7, 12, 7, 0, -12 },
  { 269, 12, 13, 13, 1, -12 },
  { 289, 10, 11, 10, 0, -11 },
  { 303, 8, 11, 10, 1, -11 },
  { 314, 8, 12, 9, 1, -12 },
  { 326, 9, 11, 11, 1, -11 },
  { 339, 6, 11, 8, 1, -11 },
  { 348, 6, 11, 8, 1, -11 },
  { 357, 9, 12, 11, 1, -12 },
  { 371, 9, 11, 11, 1, -11 },
  { 384, 6, 11, 6, 0, -11 },
  { 393, 5, 14, 5, -1, -11 },
  { 402, 9, 11, 10, 1, -11 },
  { 415, 7, 11, 8, 1, -11 },
  { 425, 12, 11, 14, 1, -11 },
  { 442, 10, 11, 12, 1, -11 },
  { 456, 10, 12, 12, 1, -12 },
  { 471, 8, 11, 9, 1, -11 },
  { 482, 10, 15, 12, 1, -12 },
  { 501, 9, 11, 10, 1, -11 },
  { 514, 7, 12, 8, 1, -12 },
  { 525, 8, 11, 9, 0, -11 },
  { 536, 9, 11, 11, 1, -11 },
  { 549, 10, 11, 10, 0, -11 },
  { 563, 15, 11, 15, 0, -11 },
  { 584, 10, 11, 10, 0, -11 },
  { 598, 9, 11, 9, 0, -11 },
  { 611, 8, 11, 9, 0, -11 },
  { 622, 4, 15, 5, 1, -12 },
  { 630, 7, 12, 7, 0, -12 },
  { 641, 4, 15, 5, 0, -12 },
  { 649, 9, 7, 9, 0, -11 },
  { 657, 7, 2, 7, 0, 1 },
  { 659, 4, 2, 6, 1, -12 },
  { 660, 7, 9, 9, 1, -9 },
  { 668, 8, 12, 9, 1, -12 },
  { 680, 6, 9, 8, 1, -9 },
  { 687, 7, 12, 9, 1, -12 },
  { 698, 7, 9, 9, 1, -9 },
  { 706, 6, 12, 6, 0, -12 },
  { 715, 7, 13, 9, 1, -9 },
  { 727, 8, 12, 10, 1, -12 },
  { 739, 3, 12, 5, 1, -12 },
  { 744, 5, 16, 5, -1, -12 },
  { 754, 8, 12, 9, 1, -12 },
  { 766, 3, 12, 5, 1, -12 },
  { 771, 13, 9, 15, 1, -9 },
  { 786, 8, 9, 10, 1, -9 },
  { 795, 8, 9, 9, 1, -9 },
  { 804, 8, 13, 9, 1, -9 },
  { 817, 7, 13, 9, 1, -9 },
  { 829, 6, 9, 7, 1, -9 },
  { 836, 6, 9, 7, 1, -9 },
  { 843, 6, 11, 7, 0, -11 },
  { 852, 8, 9, 10, 1, -9 },
  { 861, 9, 9, 9, 0, -9 },
  { 872, 13, 9, 13, 0, -9 },
  { 887, 9, 9, 9, 0, -9 },
  { 898, 9, 13, 9, 0, -9 },
  { 913, 7, 9, 7, 0, -9 },
  { 921, 6, 15, 6, 0, -12 },
  { 933, 2, 16, 8, 3, -12 },
  { 937, 5, 15, 6, 1, -12 },
  { 947, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD16PT7B_H_
