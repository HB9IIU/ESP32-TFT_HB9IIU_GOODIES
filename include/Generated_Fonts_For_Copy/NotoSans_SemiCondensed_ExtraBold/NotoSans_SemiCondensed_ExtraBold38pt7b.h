#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xF9,
  0xF0, 0xFC, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF7,
  0xC7, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F,
  0x1F, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7C, 0xE1, 0x3F, 0x38, 0x07, 0xCE, 0x01, 0xFB, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xBF, 0x00, 0xE7, 0xD0, 0x39, 0xF7, 0x8E, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x00,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF0, 0x07, 0xFF, 0x03, 0xE0, 0x1F,
  0x3E, 0x07, 0x80, 0x3E, 0x3C, 0x1F, 0x00, 0x7C, 0x7C, 0x3C, 0x00, 0xF8,
  0xF8, 0xF8, 0x01, 0xF1, 0xF1, 0xE0, 0x03, 0xE3, 0xE7, 0xC0, 0x07, 0xC7,
  0x8F, 0x0F, 0x0F, 0x9F, 0x3E, 0x7F, 0x8F, 0xBE, 0x79, 0xFF, 0x9F, 0xF9,
  0xF3, 0xFF, 0x1F, 0xF3, 0xCF, 0xDF, 0x1F, 0xCF, 0x9F, 0x3E, 0x04, 0x1E,
  0x3E, 0x3C, 0x00, 0x7C, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xE1,
  0xE1, 0xE0, 0x07, 0x83, 0xE3, 0xC0, 0x1F, 0x07, 0xCF, 0x80, 0x3C, 0x0F,
  0x9F, 0x00, 0xF8, 0x0F, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0x87,
  0xFE, 0x0F, 0xE3, 0xFF, 0xC3, 0xF1, 0xFF, 0xF8, 0xFC, 0x7E, 0x7F, 0x7F,
  0x3F, 0x8F, 0xFF, 0x8F, 0xE1, 0xFF, 0xE3, 0xF8, 0x3F, 0xF0, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xE0, 0x7F, 0xC3, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xDE, 0x79, 0xE0, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x81, 0xE0, 0x9C, 0x79, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0x7C,
  0x07, 0xDF, 0x83, 0xF3, 0xE0, 0x78, 0xF8, 0x06, 0x18, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFB,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x40,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE7,
  0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xE7,
  0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0x7C, 0xFC, 0xE7, 0xF1, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x40, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE3, 0xC1, 0xF8, 0x40, 0x7F, 0x10, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x0F, 0x9F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x60, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFB, 0x8F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x1F, 0x07, 0xDF, 0xF3, 0xF7,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F,
  0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E, 0x7F, 0x1F, 0x8F, 0xEF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7F, 0x3F, 0x9F, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF7, 0xF1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0x87, 0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0x7F, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xDF, 0x1F, 0xEF, 0xC1, 0xE3, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E, 0x7E, 0x7F,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x30,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x0F,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC1, 0xFF, 0x9E, 0x7C,
  0x7F, 0xF9, 0xF7, 0x8F, 0xFF, 0x8F, 0xF8, 0xF8, 0xF8, 0xFF, 0x1F, 0x0F,
  0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1E, 0x0F, 0x8F, 0xF1, 0xE0, 0xF8, 0xFF,
  0x1E, 0x0F, 0x8F, 0xF1, 0xE0, 0xF8, 0xFF, 0x1E, 0x0F, 0x8F, 0xF1, 0xF1,
  0xF9, 0xEF, 0x1F, 0xFF, 0xFE, 0xF8, 0xFF, 0xBF, 0xCF, 0x87, 0xF1, 0xF8,
  0x7C, 0x1C, 0x0E, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xF8, 0x07,
  0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF1, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE1, 0xFE, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xE0, 0x33, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x31, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0, 0x3F, 0xDF,
  0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0xFE,
  0x7E, 0x1F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0x01, 0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7,
  0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFE, 0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF,
  0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC,
  0x1F, 0x8F, 0xE0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0xFC, 0x0F, 0xE7,
  0xE0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0,
  0xFB, 0xFF, 0x9F, 0x0F, 0xBF, 0xF9, 0xF0, 0xFB, 0xFF, 0xDF, 0x0F, 0x3F,
  0xFD, 0xF9, 0xF3, 0xFF, 0xCF, 0x9F, 0x3F, 0xFC, 0xF9, 0xF3, 0xFF, 0xCF,
  0xBE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x7F, 0xC3,
  0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC,
  0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF0, 0x7F,
  0xF7, 0xF0, 0xFF, 0xE7, 0xE1, 0xFF, 0xCF, 0xE3, 0xFF, 0x8F, 0xC7, 0xFF,
  0x1F, 0xCF, 0xFF, 0x1F, 0x9F, 0xFE, 0x3F, 0xBF, 0xFC, 0x3F, 0x7F, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7E, 0x1F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x01, 0xFE, 0x00, 0x40,
  0x03, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xF9, 0xFC,
  0x1C, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x83, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x01, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x0F, 0xF8, 0x3F, 0x8F, 0xC1, 0xFF,
  0x07, 0xE1, 0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0x07, 0xBC, 0x1F, 0x87, 0xE1,
  0xF7, 0x83, 0xF0, 0x7C, 0x3E, 0xF8, 0xFC, 0x0F, 0xC7, 0xDF, 0x1F, 0x81,
  0xF8, 0xFB, 0xE3, 0xF0, 0x3F, 0x3F, 0x7C, 0x7E, 0x07, 0xE7, 0xC7, 0xCF,
  0x80, 0x7C, 0xF8, 0xFB, 0xF0, 0x0F, 0xDF, 0x1F, 0x7E, 0x01, 0xFB, 0xE3,
  0xEF, 0xC0, 0x3F, 0x78, 0x7D, 0xF8, 0x03, 0xFF, 0x07, 0xBE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC,
  0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0,
  0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x8F,
  0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xF3,
  0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xE0, 0x07, 0x9F, 0x00, 0xF8, 0xF0,
  0x0F, 0x0F, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0xC3, 0xE0, 0x3C, 0x3E, 0x03,
  0xE7, 0xC0, 0x3E, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x07, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x3F, 0xC2, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xDF,
  0xFF, 0xF7, 0xFF, 0x7C, 0xFF, 0x9F, 0x1F, 0xC7, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0xBF, 0xE3, 0xF7, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7E, 0xFF, 0x8F, 0x8F, 0xE0, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xDF, 0xC0, 0xBF, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x03,
  0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xCF, 0xCF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0x9F, 0x1F, 0xC7, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0x3F, 0xBF, 0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x02, 0x7F, 0x07, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC7, 0xCF, 0xF9, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x60, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x7E,
  0x1F, 0xBF, 0xF3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E,
  0x7D, 0xFF, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xDF,
  0xFB, 0xFF, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F,
  0xC7, 0xF1, 0xF9, 0xFC, 0x3F, 0x7F, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFD, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0x7F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7E, 0x0F, 0xE3, 0xF7, 0xFE,
  0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F,
  0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF,
  0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F,
  0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0,
  0xFC, 0xF8, 0x7E, 0x1F, 0xBF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7E, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF9, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x03, 0xF7, 0xF0, 0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFC, 0x7E, 0x1F, 0xBF, 0xE3, 0xF7, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x1F, 0xBF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7E, 0xFF, 0x8F, 0xCF, 0xE1, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xCF, 0xFB, 0xF3, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0xF8, 0x7F, 0xE3, 0xEF, 0xDF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xE3, 0xDF,
  0x80, 0xBF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xF8, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFB, 0xF1, 0xFE,
  0x3E, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xFD, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0,
  0x7E, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0x83, 0xF3, 0xF0, 0xFF, 0x87,
  0xE7, 0xE1, 0xFF, 0x0F, 0xC7, 0xE3, 0xDE, 0x1F, 0x0F, 0xC7, 0xBC, 0x7E,
  0x1F, 0x8F, 0x78, 0xFC, 0x3F, 0x3E, 0xF9, 0xF8, 0x3E, 0x7D, 0xF3, 0xE0,
  0x7E, 0xF1, 0xEF, 0xC0, 0xFD, 0xE3, 0xDF, 0x81, 0xFB, 0xC7, 0xBF, 0x01,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF3, 0xF8, 0x3F,
  0x8F, 0xC3, 0xF8, 0x7F, 0x1F, 0x81, 0xF9, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB,
  0xF0, 0x1F, 0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC,
  0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0,
  0xFC, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 27, 11, 2, -27 },
  { 25, 14, 10, 18, 2, -27 },
  { 43, 21, 27, 23, 1, -27 },
  { 114, 18, 31, 21, 1, -29 },
  { 184, 31, 28, 33, 1, -28 },
  { 293, 26, 27, 27, 1, -27 },
  { 381, 6, 10, 10, 2, -27 },
  { 389, 10, 34, 13, 2, -28 },
  { 432, 10, 34, 13, 1, -28 },
  { 475, 18, 17, 19, 1, -29 },
  { 514, 18, 19, 21, 1, -23 },
  { 557, 8, 10, 11, 1, -5 },
  { 567, 10, 5, 12, 1, -13 },
  { 574, 7, 6, 11, 2, -6 },
  { 580, 16, 27, 16, 0, -27 },
  { 634, 18, 28, 21, 1, -28 },
  { 697, 14, 27, 21, 2, -27 },
  { 745, 18, 28, 21, 1, -28 },
  { 808, 18, 28, 21, 1, -28 },
  { 871, 19, 27, 21, 1, -27 },
  { 936, 17, 27, 21, 2, -27 },
  { 994, 18, 27, 21, 1, -27 },
  { 1055, 18, 27, 21, 1, -27 },
  { 1116, 18, 27, 21, 1, -27 },
  { 1177, 18, 27, 21, 1, -27 },
  { 1238, 7, 21, 11, 2, -21 },
  { 1257, 8, 26, 11, 1, -21 },
  { 1283, 18, 20, 21, 1, -24 },
  { 1328, 18, 13, 21, 1, -20 },
  { 1358, 18, 20, 21, 1, -24 },
  { 1403, 16, 28, 17, 0, -28 },
  { 1459, 28, 30, 32, 2, -27 },
  { 1564, 25, 27, 25, 0, -27 },
  { 1649, 19, 27, 24, 3, -27 },
  { 1714, 19, 28, 22, 2, -28 },
  { 1781, 21, 27, 26, 3, -27 },
  { 1852, 15, 27, 19, 3, -27 },
  { 1903, 14, 27, 19, 3, -27 },
  { 1951, 21, 28, 26, 2, -28 },
  { 2025, 21, 27, 27, 3, -27 },
  { 2096, 12, 27, 15, 1, -27 },
  { 2137, 12, 35, 12, -3, -27 },
  { 2190, 21, 27, 24, 3, -27 },
  { 2261, 16, 27, 20, 3, -27 },
  { 2315, 28, 27, 34, 3, -27 },
  { 2410, 23, 27, 29, 3, -27 },
  { 2488, 24, 28, 28, 2, -28 },
  { 2572, 18, 27, 22, 3, -27 },
  { 2633, 24, 34, 28, 2, -28 },
  { 2735, 21, 27, 23, 3, -27 },
  { 2806, 17, 28, 20, 1, -28 },
  { 2866, 18, 27, 20, 1, -27 },
  { 2927, 21, 27, 26, 3, -27 },
  { 2998, 24, 27, 24, 0, -27 },
  { 3079, 35, 27, 35, 0, -27 },
  { 3198, 24, 27, 24, 0, -27 },
  { 3279, 22, 27, 22, 0, -27 },
  { 3354, 19, 27, 20, 1, -27 },
  { 3419, 9, 34, 12, 2, -28 },
  { 3458, 16, 27, 16, 0, -27 },
  { 3512, 9, 34, 12, 1, -28 },
  { 3551, 20, 17, 21, 0, -27 },
  { 3594, 17, 3, 17, 0, 3 },
  { 3601, 10, 6, 14, 2, -29 },
  { 3609, 18, 21, 21, 1, -21 },
  { 3657, 19, 29, 22, 2, -29 },
  { 3726, 15, 21, 18, 2, -21 },
  { 3766, 18, 29, 22, 2, -29 },
  { 3832, 18, 21, 21, 2, -21 },
  { 3880, 14, 29, 14, 1, -29 },
  { 3931, 18, 30, 22, 2, -21 },
  { 3999, 19, 29, 23, 2, -29 },
  { 4068, 7, 29, 11, 2, -29 },
  { 4094, 11, 38, 11, -2, -29 },
  { 4147, 19, 29, 22, 3, -29 },
  { 4216, 7, 29, 11, 2, -29 },
  { 4242, 30, 21, 34, 2, -21 },
  { 4321, 19, 21, 23, 2, -21 },
  { 4371, 19, 21, 22, 2, -21 },
  { 4421, 19, 30, 22, 2, -21 },
  { 4493, 18, 30, 22, 2, -21 },
  { 4561, 14, 21, 16, 2, -21 },
  { 4598, 15, 21, 18, 1, -21 },
  { 4638, 13, 25, 15, 1, -25 },
  { 4679, 19, 21, 23, 2, -21 },
  { 4729, 21, 21, 21, 0, -21 },
  { 4785, 31, 21, 31, 0, -21 },
  { 4867, 21, 21, 21, 0, -21 },
  { 4923, 21, 30, 21, 0, -21 },
  { 5002, 15, 21, 17, 1, -21 },
  { 5042, 13, 33, 15, 1, -27 },
  { 5096, 5, 38, 19, 7, -29 },
  { 5120, 13, 33, 15, 1, -27 },
  { 5174, 18, 7, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD38PT7B_H_
