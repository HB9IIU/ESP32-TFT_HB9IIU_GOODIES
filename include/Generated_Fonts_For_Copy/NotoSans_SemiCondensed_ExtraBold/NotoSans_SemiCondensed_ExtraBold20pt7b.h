#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFE, 0xEF, 0xE7, 0xE6, 0xE6,
  0xE6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xDC, 0x7F, 0xF7, 0xFF, 0x19, 0x81,
  0x98, 0xFF, 0xEF, 0xFE, 0x3B, 0x83, 0x30, 0x33, 0x03, 0x30, 0x08, 0x1F,
  0x1F, 0xFF, 0xEE, 0x97, 0x43, 0xE0, 0xFC, 0x1F, 0x07, 0xC2, 0xF9, 0x7F,
  0xF7, 0xF0, 0x20, 0x10, 0x78, 0x38, 0xFC, 0x70, 0xCC, 0x60, 0xCC, 0xE0,
  0xCC, 0xC0, 0xCD, 0xDC, 0xFD, 0xBE, 0x7B, 0xB7, 0x03, 0x73, 0x07, 0x73,
  0x06, 0x73, 0x0E, 0x37, 0x0C, 0x3E, 0x1C, 0x1E, 0x3F, 0x03, 0xFC, 0x1C,
  0xE0, 0xE7, 0x07, 0x70, 0x1F, 0x80, 0xF1, 0xFF, 0xCE, 0xEF, 0x77, 0x3F,
  0x38, 0xF9, 0xFF, 0xCF, 0xFF, 0x3F, 0xBC, 0xFF, 0xFE, 0x3B, 0x9C, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xC6, 0x38, 0xF0, 0xC3, 0x8E, 0x18,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x9C, 0xF0, 0x0C, 0x03, 0x04,
  0xC9, 0xFF, 0xFF, 0xC7, 0x83, 0xF1, 0xCE, 0x12, 0x00, 0x1C, 0x0E, 0x07,
  0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0xFE, 0xEE, 0xCC,
  0xFF, 0xFE, 0xEF, 0xE0, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xE7, 0xF1, 0xF0, 0x0E, 0x7D,
  0xFF, 0xF6, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7E,
  0x7F, 0xB9, 0xE8, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0x91, 0xE0, 0xF0, 0x71, 0xF8, 0xF0, 0x7E,
  0x07, 0x81, 0xC1, 0xF9, 0xFF, 0xF7, 0xF0, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC1, 0xB8, 0x77, 0x0C, 0xE3, 0x9C, 0xE3, 0x9F, 0xFF, 0xFF, 0x81, 0xC0,
  0x38, 0x07, 0x00, 0x7F, 0x3F, 0xBF, 0xDC, 0x0E, 0x07, 0xF3, 0xFC, 0x9F,
  0x07, 0x81, 0xC1, 0xFD, 0xFF, 0xF7, 0xF0, 0x1F, 0x3F, 0x9E, 0x1C, 0x0E,
  0x07, 0xFB, 0xFF, 0xEF, 0xE3, 0xF1, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xFF,
  0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07,
  0x03, 0x83, 0xC0, 0x7F, 0x7F, 0xB8, 0xFC, 0x7F, 0x73, 0xF8, 0xF0, 0xFE,
  0xF7, 0xF1, 0xF8, 0xFC, 0x7F, 0xF3, 0xF0, 0x7E, 0x7F, 0xB9, 0xFC, 0x7E,
  0x3F, 0x1F, 0xDF, 0xFF, 0x7B, 0x81, 0xC1, 0xD3, 0xEF, 0xE7, 0xE0, 0xEF,
  0xE0, 0x00, 0x00, 0xEF, 0xE0, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xEE, 0xCC,
  0x01, 0x83, 0xC7, 0xCF, 0x8F, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0x80, 0x40,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x78, 0x3F, 0x03, 0xE0,
  0x78, 0x7C, 0xF9, 0xF0, 0xE0, 0x40, 0x00, 0x7F, 0x7F, 0x99, 0xE0, 0x70,
  0x70, 0x78, 0x78, 0x38, 0x18, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xC0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xC0, 0x73, 0x1E, 0x6E, 0x7E, 0xF9, 0xCC, 0xF3, 0x19,
  0xE6, 0x33, 0xCC, 0xE7, 0x99, 0xDB, 0x3F, 0xF7, 0x19, 0xC7, 0x00, 0x07,
  0x8E, 0x07, 0xFC, 0x01, 0xC0, 0x0F, 0x80, 0x7C, 0x07, 0x60, 0x3B, 0x81,
  0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x3F, 0xE3, 0xFF, 0x9F, 0xFC, 0xE0,
  0xEF, 0x07, 0xF8, 0x3C, 0xFF, 0x9F, 0xFB, 0xCF, 0x78, 0xEF, 0x1D, 0xFF,
  0xBF, 0xC7, 0xFE, 0xF1, 0xDE, 0x3F, 0xC7, 0x7F, 0xEF, 0xFD, 0xFE, 0x00,
  0x1F, 0xCF, 0xF7, 0x89, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xFF, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xFC, 0xF3, 0xEF, 0x1E,
  0xF0, 0xEF, 0x0E, 0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF1, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE1, 0xC3,
  0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x1F, 0xE7, 0xFD, 0xF1, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0xFF, 0x1F, 0xF3, 0xFE, 0x1D, 0xC3, 0xBF, 0xF3, 0xFE, 0x3F,
  0xC0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xC0, 0xFF, 0xF7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0xFF, 0xF0, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xEF, 0xFB, 0xC0, 0xE3, 0xFC,
  0x73, 0x9E, 0x77, 0x8E, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFF, 0x1C, 0xE3,
  0x9E, 0x71, 0xCE, 0x3D, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3F,
  0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xD8, 0xFF, 0x73, 0xFD, 0xCD, 0xF3, 0x37,
  0xED, 0xDF, 0xBF, 0x7E, 0xF9, 0xF9, 0xE7, 0xE7, 0x9F, 0x9C, 0x70, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xDC, 0x7D, 0xE7, 0xCE, 0x7C, 0xF7, 0xE7,
  0x7E, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0x02, 0x00, 0xFE, 0x1F,
  0xF8, 0xF3, 0xEF, 0x0F, 0x78, 0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x83,
  0xBC, 0x1C, 0xE1, 0xE7, 0xFE, 0x1F, 0xF0, 0x7E, 0x00, 0xFF, 0x3F, 0xEF,
  0x7F, 0xC7, 0xF1, 0xFC, 0xFF, 0xFB, 0xFE, 0xFF, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0x02, 0x00, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF, 0x0F, 0x78,
  0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x83, 0xBC, 0x1C, 0xE1, 0xE7, 0xFE,
  0x1F, 0xF0, 0x7F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0xFF, 0x1F, 0xF3,
  0xCF, 0x78, 0xEF, 0x1D, 0xE7, 0xBF, 0xE7, 0xF8, 0xFF, 0x1E, 0xF3, 0xCE,
  0x79, 0xEF, 0x1D, 0xE3, 0xC0, 0x7F, 0xFF, 0xBC, 0xDC, 0x0F, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0x03, 0xE1, 0xFF, 0xEF, 0xF7, 0xF0, 0xFF, 0xFF, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC3, 0xBF, 0xF3, 0xFC, 0x3F, 0x00, 0xF0,
  0x77, 0x07, 0x70, 0xF7, 0x0E, 0x78, 0xE3, 0x9E, 0x39, 0xC3, 0x9C, 0x1D,
  0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xE0, 0xE1, 0xFC, 0x78,
  0x77, 0x1E, 0x1D, 0xC7, 0xCE, 0x71, 0xF3, 0x9C, 0xFC, 0xE3, 0xBB, 0x38,
  0xEE, 0xDE, 0x3B, 0x3F, 0x0E, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0x7C, 0x1E,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0xF7, 0x8E, 0x39, 0xC3, 0xDC, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x3D, 0xC7, 0x9E, 0x70, 0xEF,
  0x0F, 0xF0, 0xF7, 0x0E, 0x79, 0xC3, 0x9C, 0x3F, 0x81, 0xF8, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xDF,
  0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xF8, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x1C,
  0x0E, 0x0E, 0x06, 0x07, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFF, 0xF8, 0x0C, 0x01, 0xC0, 0x78, 0x0F, 0x83, 0xB0, 0x67,
  0x1C, 0x63, 0x0E, 0xE0, 0xE0, 0xFF, 0x80, 0xF0, 0xE1, 0xC0, 0x7F, 0x3F,
  0x99, 0xE0, 0x73, 0xFF, 0xFF, 0x8F, 0xC7, 0xE7, 0xFF, 0xDE, 0x60, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF, 0xBF, 0xCF, 0xF1, 0xF8, 0x7F,
  0x1F, 0xCF, 0xFB, 0xFF, 0xEE, 0xF0, 0x3F, 0x7F, 0xFA, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFB, 0x7F, 0x3F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x3F, 0xDF,
  0xFF, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF7, 0xDF, 0xF3, 0xDC,
  0x3E, 0x3F, 0xBC, 0xFC, 0x7F, 0xFF, 0xFF, 0x81, 0xC0, 0xF1, 0xBF, 0xCF,
  0xE0, 0x1F, 0x3F, 0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3D, 0xDF, 0xFF, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xF7, 0xDF, 0xF3, 0xFC, 0x0F, 0x83, 0xBF, 0xEF, 0xF0, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0xBF, 0xEF, 0xBF, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0xF1, 0x80, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3B, 0xEF, 0xBC, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x1F, 0xE7, 0x3D, 0xE7, 0x78, 0xEE, 0x1F, 0xC3, 0xFC, 0x7B, 0xCF, 0x39,
  0xE7, 0xBC, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0xBE, 0xFF,
  0xFE, 0xFF, 0xEF, 0xF3, 0xC7, 0xF3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xEF, 0xBF, 0xEF, 0xBF, 0xC7,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x3F, 0x1F, 0xEF,
  0x3B, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF3, 0x9F, 0xE3, 0xF0, 0xEF,
  0x3F, 0xEF, 0xBF, 0xCF, 0xF1, 0xF8, 0x7F, 0x1F, 0xCF, 0xFB, 0xFF, 0xEE,
  0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3D, 0xDF, 0xFF, 0x7F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF7, 0xDF, 0xF3, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xEF, 0xDF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC0, 0x7E, 0xFE, 0xE2, 0xE0, 0xF8, 0x7E, 0x1E, 0x0F, 0xCE, 0xFE, 0xFC,
  0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F,
  0x1F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xF7,
  0xDF, 0xF3, 0xDC, 0xE1, 0xEE, 0x39, 0xC7, 0x38, 0xE3, 0xB8, 0x77, 0x0E,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0xE3, 0xC7, 0x73, 0xC7, 0x73,
  0xCF, 0x73, 0xEE, 0x77, 0x6E, 0x3F, 0x6E, 0x3E, 0x6C, 0x3E, 0x6C, 0x3E,
  0x7C, 0x1E, 0x3C, 0x1E, 0x38, 0xF1, 0xEF, 0x78, 0xEE, 0x1F, 0xC1, 0xF0,
  0x3E, 0x07, 0xC1, 0xFC, 0x3B, 0x8E, 0x7B, 0xC7, 0x80, 0xF1, 0xEE, 0x39,
  0xC7, 0x38, 0xE3, 0xB8, 0x77, 0x0E, 0xE0, 0xD8, 0x1F, 0x03, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0xF8, 0x1E, 0x03, 0x80, 0x7F, 0x3F, 0x9F, 0xC1, 0xC0,
  0xE0, 0xE0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xE0, 0x1E, 0x3C, 0x70, 0xC1,
  0x83, 0x0E, 0x7C, 0xE1, 0xF0, 0xE0, 0xC1, 0x83, 0x07, 0x0F, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x1C, 0xF7,
  0x1C, 0x71, 0xC7, 0x3C, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 12, 14, 12, 0, -14 },
  { 34, 9, 16, 11, 1, -15 },
  { 52, 16, 14, 18, 1, -14 },
  { 80, 13, 14, 14, 1, -14 },
  { 103, 3, 5, 5, 1, -14 },
  { 105, 5, 17, 7, 1, -14 },
  { 116, 6, 17, 7, 0, -14 },
  { 129, 10, 9, 10, 0, -15 },
  { 141, 9, 10, 11, 1, -12 },
  { 153, 4, 6, 6, 1, -3 },
  { 156, 5, 3, 6, 1, -7 },
  { 158, 4, 3, 6, 1, -3 },
  { 160, 8, 14, 8, 0, -14 },
  { 174, 9, 14, 11, 1, -14 },
  { 190, 7, 14, 11, 1, -14 },
  { 203, 9, 14, 11, 1, -14 },
  { 219, 9, 14, 11, 1, -14 },
  { 235, 11, 14, 11, 0, -14 },
  { 255, 9, 14, 11, 1, -14 },
  { 271, 9, 14, 11, 1, -14 },
  { 287, 9, 14, 11, 1, -14 },
  { 303, 9, 14, 11, 1, -14 },
  { 319, 9, 14, 11, 1, -14 },
  { 335, 4, 11, 6, 1, -11 },
  { 341, 4, 14, 6, 1, -11 },
  { 348, 9, 10, 11, 1, -12 },
  { 360, 9, 6, 11, 1, -10 },
  { 367, 9, 10, 11, 1, -12 },
  { 379, 9, 14, 9, 0, -14 },
  { 395, 15, 16, 17, 1, -14 },
  { 425, 13, 14, 13, 0, -14 },
  { 448, 11, 14, 12, 1, -14 },
  { 468, 10, 14, 12, 1, -14 },
  { 486, 12, 14, 13, 1, -14 },
  { 507, 7, 14, 10, 2, -14 },
  { 520, 7, 14, 10, 2, -14 },
  { 533, 11, 14, 14, 1, -14 },
  { 553, 11, 14, 14, 2, -14 },
  { 573, 6, 14, 8, 1, -14 },
  { 584, 6, 18, 6, -1, -14 },
  { 598, 11, 14, 12, 2, -14 },
  { 618, 9, 14, 10, 1, -14 },
  { 634, 14, 14, 18, 2, -14 },
  { 659, 12, 14, 15, 2, -14 },
  { 680, 13, 15, 15, 1, -15 },
  { 705, 10, 14, 12, 1, -14 },
  { 723, 13, 18, 15, 1, -15 },
  { 753, 11, 14, 12, 1, -14 },
  { 773, 9, 14, 10, 1, -14 },
  { 789, 10, 14, 11, 0, -14 },
  { 807, 11, 14, 14, 1, -14 },
  { 827, 12, 14, 12, 0, -14 },
  { 848, 18, 14, 18, 0, -14 },
  { 880, 12, 14, 12, 0, -14 },
  { 901, 12, 14, 12, 0, -14 },
  { 922, 10, 14, 11, 0, -14 },
  { 940, 5, 17, 6, 1, -14 },
  { 951, 8, 14, 8, 0, -14 },
  { 965, 5, 17, 6, 0, -14 },
  { 976, 11, 9, 11, 0, -14 },
  { 989, 9, 1, 9, 0, 2 },
  { 991, 6, 3, 7, 1, -15 },
  { 994, 9, 11, 11, 1, -11 },
  { 1007, 10, 15, 12, 1, -15 },
  { 1026, 8, 11, 10, 1, -11 },
  { 1037, 10, 15, 12, 1, -15 },
  { 1056, 9, 11, 11, 1, -11 },
  { 1069, 8, 15, 7, 0, -15 },
  { 1084, 10, 16, 12, 1, -11 },
  { 1104, 10, 15, 12, 1, -15 },
  { 1123, 4, 15, 6, 1, -15 },
  { 1131, 6, 20, 6, -1, -15 },
  { 1146, 11, 15, 12, 1, -15 },
  { 1167, 3, 15, 6, 1, -15 },
  { 1173, 16, 11, 18, 1, -11 },
  { 1195, 10, 11, 12, 1, -11 },
  { 1209, 10, 11, 12, 1, -11 },
  { 1223, 10, 16, 12, 1, -11 },
  { 1243, 10, 16, 12, 1, -11 },
  { 1263, 7, 11, 8, 1, -11 },
  { 1273, 8, 11, 9, 1, -11 },
  { 1284, 8, 13, 8, 0, -13 },
  { 1297, 10, 11, 12, 1, -11 },
  { 1311, 11, 11, 11, 0, -11 },
  { 1327, 16, 11, 16, 0, -11 },
  { 1349, 11, 11, 11, 0, -11 },
  { 1365, 11, 16, 11, 0, -11 },
  { 1387, 9, 11, 9, 0, -11 },
  { 1400, 7, 17, 8, 0, -14 },
  { 1415, 2, 20, 10, 4, -15 },
  { 1420, 6, 17, 8, 1, -14 },
  { 1433, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD20PT7B_H_
