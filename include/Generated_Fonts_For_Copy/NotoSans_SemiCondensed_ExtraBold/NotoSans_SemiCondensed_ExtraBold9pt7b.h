#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF5, 0x3F, 0xD5, 0xF5, 0x28, 0x23, 0xB8, 0xC3, 0x7D,
  0x84, 0x40, 0xE4, 0xA8, 0xEE, 0x55, 0x15, 0x26, 0x21, 0xC5, 0x1D, 0xFF,
  0x67, 0xC0, 0xD0, 0x29, 0x6D, 0x93, 0x89, 0x36, 0xD6, 0x2B, 0x65, 0x27,
  0xC8, 0x40, 0x70, 0xE0, 0xC0, 0x32, 0x26, 0x44, 0xC0, 0x23, 0xB5, 0xBD,
  0xA9, 0xC0, 0x7F, 0x33, 0x33, 0x27, 0x84, 0x62, 0x23, 0xE0, 0x27, 0x84,
  0xC1, 0x4F, 0xC0, 0x33, 0x95, 0x2F, 0x88, 0x74, 0x71, 0x9F, 0x13, 0x91,
  0xED, 0xED, 0xC0, 0xF8, 0x8C, 0x42, 0x30, 0x23, 0xB4, 0xED, 0x6D, 0xC0,
  0x23, 0xB5, 0xB7, 0x09, 0x80, 0xD0, 0xC0, 0xD0, 0x70, 0x09, 0xF8, 0xE1,
  0x80, 0xF8, 0x3E, 0x87, 0x0E, 0xEC, 0x00, 0x4F, 0x36, 0x40, 0x60, 0x18,
  0xC9, 0x6D, 0x5A, 0xAF, 0xD1, 0x1C, 0x31, 0xC5, 0x9E, 0xFB, 0x30, 0xF9,
  0xE9, 0x9F, 0x13, 0xD1, 0x8C, 0x25, 0xE0, 0xF4, 0xA7, 0x3B, 0x70, 0xF3,
  0xC9, 0xC0, 0xF3, 0xF9, 0x00, 0x13, 0xD1, 0xBD, 0xA5, 0xE0, 0x9C, 0xFF,
  0x39, 0xCC, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4F, 0xBD, 0x39, 0xCB, 0x4C,
  0x92, 0x49, 0xC0, 0xCF, 0x3F, 0xED, 0xB6, 0xD0, 0xCF, 0x6B, 0x79, 0xCC,
  0x11, 0xF4, 0xF1, 0xCD, 0x37, 0x80, 0xFB, 0xBE, 0x88, 0x11, 0xF4, 0xF1,
  0xCD, 0x37, 0x82, 0x0C, 0xF5, 0xBD, 0xCB, 0x4C, 0x27, 0xC6, 0x39, 0xF0,
  0xF9, 0x08, 0x42, 0x10, 0x9C, 0xE7, 0x39, 0x78, 0xCD, 0x25, 0x9C, 0x70,
  0xC0, 0xD9, 0xDB, 0x5B, 0x5E, 0x76, 0x66, 0xD9, 0xC3, 0x1C, 0x5B, 0x30,
  0xDA, 0x9C, 0x42, 0x10, 0xF9, 0x88, 0xC4, 0x7C, 0xFA, 0xAB, 0x8C, 0x44,
  0x22, 0x30, 0xF5, 0x57, 0x22, 0x95, 0x10, 0xF0, 0xC4, 0x70, 0x9F, 0xB7,
  0x80, 0x88, 0xEB, 0xBB, 0xE0, 0x74, 0xCD, 0x70, 0x18, 0xDF, 0xBD, 0xED,
  0xE0, 0x72, 0xFF, 0x87, 0x00, 0x74, 0xE4, 0x44, 0x40, 0x7E, 0xF7, 0xB7,
  0x8D, 0xC0, 0x88, 0xFB, 0xBB, 0xB0, 0xFE, 0x55, 0x55, 0xC0, 0x88, 0xBE,
  0xEA, 0xB0, 0xFE, 0xFD, 0x6E, 0xDD, 0xBB, 0x60, 0xFB, 0xBB, 0xB0, 0x72,
  0xF6, 0xB7, 0x00, 0xEB, 0xBB, 0xE8, 0x80, 0x7E, 0xF7, 0xB7, 0x8C, 0x60,
  0xFA, 0x48, 0x7C, 0x63, 0xF0, 0x5D, 0x24, 0xC0, 0xBB, 0xBB, 0xD0, 0xDA,
  0x94, 0xE2, 0x00, 0xDB, 0xB5, 0xBB, 0x66, 0xC0, 0xDB, 0x98, 0xED, 0x80,
  0xDA, 0x94, 0xE2, 0x13, 0x80, 0xF2, 0x64, 0xF0, 0x69, 0x64, 0x98, 0xFF,
  0x80, 0xC9, 0x14, 0xB0, 0xEC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 3, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 8, 7, 8, 0, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 2, 2, 2, 0, -6 },
  { 27, 3, 8, 3, 0, -7 },
  { 30, 3, 8, 3, 0, -7 },
  { 33, 4, 4, 5, 0, -7 },
  { 35, 5, 4, 5, 0, -5 },
  { 38, 2, 2, 3, 0, -1 },
  { 39, 3, 1, 3, 0, -3 },
  { 40, 2, 1, 3, 0, -1 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 5, 7, 5, 0, -7 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 0, -6 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 2, 5, 3, 0, -5 },
  { 91, 2, 6, 3, 0, -5 },
  { 93, 5, 5, 5, 0, -6 },
  { 97, 5, 3, 5, 0, -5 },
  { 99, 5, 5, 5, 0, -6 },
  { 103, 4, 7, 4, 0, -7 },
  { 107, 7, 8, 8, 0, -7 },
  { 114, 6, 6, 6, 0, -6 },
  { 119, 4, 6, 6, 1, -6 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 5, 6, 6, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 5, 7, 6, 0, -7 },
  { 142, 5, 6, 6, 1, -6 },
  { 146, 3, 6, 3, 0, -6 },
  { 149, 3, 8, 3, -1, -6 },
  { 152, 5, 6, 6, 1, -6 },
  { 156, 3, 6, 5, 1, -6 },
  { 159, 6, 6, 8, 1, -6 },
  { 164, 5, 6, 7, 1, -6 },
  { 168, 6, 7, 7, 0, -7 },
  { 174, 4, 6, 5, 1, -6 },
  { 177, 6, 9, 7, 0, -7 },
  { 184, 5, 6, 6, 1, -6 },
  { 188, 4, 7, 5, 0, -7 },
  { 192, 5, 6, 5, 0, -6 },
  { 196, 5, 6, 6, 1, -6 },
  { 200, 6, 6, 6, 0, -6 },
  { 205, 8, 6, 8, 0, -6 },
  { 211, 6, 6, 6, 0, -6 },
  { 216, 5, 6, 5, 0, -6 },
  { 220, 5, 6, 5, 0, -6 },
  { 224, 2, 8, 3, 1, -7 },
  { 226, 4, 7, 4, 0, -7 },
  { 230, 2, 8, 3, 0, -7 },
  { 232, 5, 4, 5, 0, -6 },
  { 235, 4, 1, 4, 0, 1 },
  { 236, 3, 2, 3, 0, -7 },
  { 237, 5, 5, 5, 0, -5 },
  { 241, 4, 7, 5, 1, -7 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 5, 7, 5, 0, -7 },
  { 253, 5, 5, 5, 0, -5 },
  { 257, 4, 7, 3, 0, -7 },
  { 261, 5, 7, 5, 0, -5 },
  { 266, 4, 7, 5, 1, -7 },
  { 270, 1, 7, 3, 1, -7 },
  { 271, 2, 9, 3, 0, -7 },
  { 274, 4, 7, 5, 1, -7 },
  { 278, 1, 7, 3, 1, -7 },
  { 279, 7, 5, 8, 1, -5 },
  { 284, 4, 5, 5, 1, -5 },
  { 287, 5, 5, 5, 0, -5 },
  { 291, 4, 7, 5, 1, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 3, 5, 4, 1, -5 },
  { 302, 4, 5, 4, 0, -5 },
  { 305, 3, 6, 4, 0, -6 },
  { 308, 4, 5, 5, 1, -5 },
  { 311, 5, 5, 5, 0, -5 },
  { 315, 7, 5, 7, 0, -5 },
  { 320, 5, 5, 5, 0, -5 },
  { 324, 5, 7, 5, 0, -5 },
  { 329, 4, 5, 4, 0, -5 },
  { 332, 3, 7, 4, 0, -6 },
  { 335, 1, 9, 4, 2, -7 },
  { 337, 3, 7, 4, 0, -6 },
  { 340, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD9PT7B_H_
