#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC3, 0xC0,
  0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xFC,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xEF, 0x9F, 0x9C, 0x13,
  0xF3, 0x80, 0x7E, 0x70, 0x0F, 0xEE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xCF, 0xC0, 0x39, 0xFC, 0x07, 0x3F, 0xE0, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xFC,
  0x03, 0xE0, 0x07, 0xCF, 0x80, 0xF8, 0x01, 0xF9, 0xF8, 0x1F, 0x00, 0x3E,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x3E,
  0x00, 0x0F, 0xCF, 0xCF, 0x8F, 0xE0, 0xF9, 0xF1, 0xF3, 0xFE, 0x1F, 0xFE,
  0x7C, 0xFF, 0xE1, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF3, 0xE7, 0xE7, 0xC1,
  0xFC, 0x7C, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x87, 0xC0, 0x07, 0xC1,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x3F, 0x00, 0x3E, 0x07, 0xC7, 0xC0, 0x07,
  0xC0, 0xFC, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0xC0,
  0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x08,
  0x3F, 0xF0, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0x0F, 0xE3, 0xFF,
  0xFC, 0xFE, 0x1F, 0xCF, 0xF7, 0xF0, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0, 0xFF,
  0xF8, 0x7F, 0x03, 0xFF, 0xC3, 0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC7, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0x87, 0xFC, 0xFF, 0xFF,
  0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x06, 0x1F, 0x0E, 0x7C, 0xF7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xD0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x3F, 0x1F, 0xC0, 0xF0, 0xF0, 0x02,
  0x0C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x7E, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF9, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E,
  0xFC, 0xFC, 0xF3, 0xF8, 0xC7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFB, 0xFE, 0x3C, 0x0F, 0xE1, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xE1, 0xFE, 0x18, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC,
  0x7F, 0x07, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xE0, 0xFE, 0x3F, 0x07, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFE, 0x30, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFE, 0xF8, 0x7F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x02, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1C, 0x07, 0xE7, 0xF8, 0x7E,
  0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x3F, 0xCF, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xF0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0xFE,
  0x3F, 0x9F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7F,
  0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xBF, 0x0F,
  0xF3, 0xF0, 0x3C, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x3F, 0x3F, 0x9F, 0xEF, 0xF7, 0xF9, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F,
  0x8F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x0F, 0xF3,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0xC0, 0x7C, 0x3E, 0x0F, 0xFE, 0x3E, 0x7C, 0x1F, 0xFE, 0x3E,
  0x7C, 0x3F, 0xFE, 0x3E, 0x7C, 0x7E, 0x3E, 0x1E, 0xF8, 0xFC, 0x3E, 0x1E,
  0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3E, 0x3E,
  0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0xFF, 0xFF, 0xFC,
  0xF8, 0x7F, 0xEF, 0xF8, 0x7C, 0x3F, 0xEF, 0xF8, 0x7C, 0x1F, 0x83, 0xE0,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x80,
  0x1F, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01,
  0xFB, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0x1F, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF0,
  0x7F, 0xBF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF,
  0xC7, 0xC3, 0xFC, 0x03, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x04, 0x3F, 0xF9, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0xFF, 0x7F, 0x07, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xE0, 0x08, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F,
  0xF9, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF,
  0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8,
  0x0F, 0xF7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x03, 0xF9, 0xFC,
  0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFE, 0x07,
  0xF1, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB,
  0xE0, 0x3F, 0xFF, 0xF7, 0xE0, 0x7D, 0xFF, 0xEF, 0xC0, 0xFB, 0xFF, 0xCF,
  0x83, 0xF7, 0xFF, 0x9F, 0x07, 0xCF, 0xFF, 0x3F, 0x0F, 0x9F, 0xFE, 0x7E,
  0x3F, 0x3F, 0xFC, 0x7C, 0x7C, 0x7F, 0xF8, 0xFC, 0xF8, 0xFF, 0xF1, 0xF9,
  0xF1, 0xFF, 0xE3, 0xF7, 0xE3, 0xFF, 0xC3, 0xEF, 0x87, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xC0, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x7F, 0x07, 0xFF, 0xDF, 0xC1, 0xFF, 0xF3, 0xF8, 0x7F,
  0xFC, 0xFE, 0x1F, 0xFF, 0x1F, 0xC7, 0xFF, 0xC7, 0xF1, 0xFF, 0xF0, 0xFE,
  0x7F, 0xFC, 0x3F, 0x9F, 0xFF, 0x07, 0xF7, 0xFF, 0xC1, 0xFD, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFC, 0x0F, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3, 0xFC, 0x07, 0xF9, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3,
  0xFC, 0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xFB,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xCF, 0xFE, 0x3F, 0x83,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xE7, 0xF0,
  0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xFF,
  0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xEF, 0xEF, 0xE0, 0x33,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0x80, 0xFE, 0x7F, 0xEF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF8,
  0x07, 0xF7, 0xE0, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x80, 0x7F, 0x7F,
  0x01, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x03, 0xF8, 0xFE,
  0x0F, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0xF8, 0x7F, 0x07, 0xE0, 0xFB, 0xE1,
  0xFC, 0x1F, 0x87, 0xEF, 0x87, 0xF0, 0x7F, 0x1F, 0xBE, 0x1F, 0x81, 0xFC,
  0x7C, 0xFC, 0x7E, 0x03, 0xF1, 0xF3, 0xF3, 0xF8, 0x0F, 0xCF, 0xC7, 0xCF,
  0xE0, 0x3F, 0x3F, 0x1F, 0x3F, 0x00, 0xFE, 0xFC, 0x7C, 0xFC, 0x01, 0xFB,
  0xE1, 0xFB, 0xF0, 0x07, 0xEF, 0x87, 0xEF, 0xC0, 0x1F, 0xBE, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F,
  0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF3, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x1F, 0x0F, 0xC0, 0x7E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFB, 0xF3, 0xFF, 0x1F, 0x1F, 0xE1, 0xF0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0xFD, 0xFF, 0x8F,
  0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFD,
  0xFF, 0x8F, 0x8F, 0xF0, 0x00, 0x30, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFE, 0x1D, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x5F, 0xE1, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0x07, 0xF0, 0xFE, 0x7F, 0x1F, 0xF3, 0xF3, 0xFF,
  0xBF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3,
  0xF0, 0xFE, 0x1F, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xDF, 0xE7, 0xF0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0C,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xC4, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0x00, 0x00, 0xFE, 0x3F, 0x1F, 0xFB,
  0xF3, 0xFF, 0xBF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF,
  0x1F, 0xF7, 0xF0, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF4, 0x00, 0xFF, 0x7E, 0x3F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0xCF, 0xDF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0x7E, 0x7E, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0xDF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0xEF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x1F,
  0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03,
  0xF7, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0xFF,
  0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7F, 0xBF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x40, 0xF8, 0xFF, 0x07,
  0xF8, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xF0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x08, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x0F, 0x87,
  0xF0, 0xFD, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFD, 0xFF, 0x8F, 0xC7, 0xF0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0xFE, 0x3F, 0x1F, 0xFB, 0xF3, 0xFF, 0xBF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF7, 0xF0, 0xFE, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0B,
  0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x80, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0x7E, 0xFC, 0x04, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x8F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE3, 0xF0, 0xFE, 0x00, 0xFE, 0xFC, 0x03,
  0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xDF, 0x81, 0xFE, 0x07, 0xF7, 0xF0,
  0x7F, 0x81, 0xF9, 0xFC, 0x1F, 0xF0, 0x7E, 0x3F, 0x0F, 0xFC, 0x3F, 0x8F,
  0xC3, 0xFF, 0x0F, 0xE3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFE, 0x3E, 0xF8, 0xFC,
  0x1F, 0x8F, 0x3E, 0x7F, 0x07, 0xE7, 0xCF, 0x9F, 0x81, 0xF9, 0xF3, 0xE7,
  0xE0, 0x7E, 0x7C, 0xF9, 0xF8, 0x0F, 0xDF, 0x1E, 0x7E, 0x03, 0xF7, 0x87,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0x80, 0xFE,
  0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0,
  0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0xC7,
  0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0xFE,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x2F, 0xF0, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xF4, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 12, 2, -30 },
  { 32, 16, 11, 20, 2, -30 },
  { 54, 24, 30, 25, 1, -30 },
  { 144, 19, 34, 23, 2, -32 },
  { 225, 35, 30, 37, 1, -30 },
  { 357, 29, 30, 30, 1, -30 },
  { 466, 7, 11, 11, 2, -30 },
  { 476, 11, 37, 14, 2, -30 },
  { 527, 11, 37, 14, 1, -30 },
  { 578, 20, 19, 21, 1, -32 },
  { 626, 19, 20, 23, 2, -25 },
  { 674, 9, 11, 12, 1, -5 },
  { 687, 11, 6, 13, 1, -14 },
  { 696, 8, 8, 12, 2, -7 },
  { 704, 18, 30, 18, 0, -30 },
  { 772, 20, 30, 23, 1, -30 },
  { 847, 15, 30, 23, 2, -30 },
  { 904, 20, 30, 23, 1, -30 },
  { 979, 20, 30, 23, 1, -30 },
  { 1054, 21, 30, 23, 1, -30 },
  { 1133, 19, 30, 23, 2, -30 },
  { 1205, 20, 30, 23, 1, -30 },
  { 1280, 20, 30, 23, 1, -30 },
  { 1355, 20, 30, 23, 1, -30 },
  { 1430, 20, 30, 23, 1, -30 },
  { 1505, 8, 24, 12, 2, -23 },
  { 1529, 9, 29, 12, 1, -23 },
  { 1562, 19, 22, 23, 2, -26 },
  { 1615, 19, 14, 23, 2, -22 },
  { 1649, 19, 22, 23, 2, -26 },
  { 1702, 18, 31, 19, 0, -30 },
  { 1772, 32, 33, 35, 2, -30 },
  { 1904, 27, 30, 27, 0, -30 },
  { 2006, 21, 30, 26, 3, -30 },
  { 2085, 22, 30, 25, 2, -30 },
  { 2168, 23, 30, 28, 3, -30 },
  { 2255, 16, 30, 22, 3, -30 },
  { 2315, 16, 30, 21, 3, -30 },
  { 2375, 24, 30, 28, 2, -30 },
  { 2465, 23, 30, 30, 3, -30 },
  { 2552, 14, 30, 16, 1, -30 },
  { 2605, 13, 39, 13, -3, -30 },
  { 2669, 23, 30, 26, 3, -30 },
  { 2756, 17, 30, 22, 3, -30 },
  { 2820, 31, 30, 38, 3, -30 },
  { 2937, 26, 30, 32, 3, -30 },
  { 3035, 26, 30, 30, 2, -30 },
  { 3133, 20, 30, 24, 3, -30 },
  { 3208, 26, 37, 30, 2, -30 },
  { 3329, 23, 30, 26, 3, -30 },
  { 3416, 18, 30, 22, 2, -30 },
  { 3484, 21, 30, 22, 1, -30 },
  { 3563, 23, 30, 29, 3, -30 },
  { 3650, 26, 30, 26, 0, -30 },
  { 3748, 38, 30, 39, 0, -30 },
  { 3891, 26, 30, 26, 0, -30 },
  { 3989, 25, 30, 25, 0, -30 },
  { 4083, 21, 30, 23, 1, -30 },
  { 4162, 11, 37, 13, 2, -30 },
  { 4213, 18, 30, 18, 0, -30 },
  { 4281, 10, 37, 13, 1, -30 },
  { 4328, 22, 19, 23, 0, -30 },
  { 4381, 19, 4, 19, 0, 3 },
  { 4391, 12, 7, 15, 2, -32 },
  { 4402, 20, 23, 24, 1, -23 },
  { 4460, 20, 32, 25, 3, -32 },
  { 4540, 17, 24, 20, 2, -24 },
  { 4591, 20, 32, 25, 2, -32 },
  { 4671, 20, 23, 23, 2, -23 },
  { 4729, 16, 32, 15, 1, -32 },
  { 4793, 20, 34, 25, 2, -24 },
  { 4878, 20, 32, 25, 3, -32 },
  { 4958, 8, 32, 12, 2, -32 },
  { 4990, 12, 42, 12, -2, -32 },
  { 5053, 22, 32, 25, 3, -32 },
  { 5141, 6, 32, 12, 3, -32 },
  { 5165, 32, 24, 38, 3, -24 },
  { 5261, 20, 24, 25, 3, -24 },
  { 5321, 21, 24, 24, 2, -24 },
  { 5384, 20, 34, 25, 3, -24 },
  { 5469, 20, 34, 25, 2, -24 },
  { 5554, 14, 24, 18, 3, -24 },
  { 5596, 16, 24, 19, 2, -24 },
  { 5644, 15, 28, 17, 1, -28 },
  { 5697, 20, 23, 25, 3, -23 },
  { 5755, 23, 23, 23, 0, -23 },
  { 5822, 34, 23, 34, 0, -23 },
  { 5920, 23, 23, 23, 0, -23 },
  { 5987, 23, 33, 23, 0, -23 },
  { 6082, 17, 23, 19, 1, -23 },
  { 6131, 14, 37, 16, 1, -30 },
  { 6196, 5, 41, 21, 8, -32 },
  { 6222, 15, 37, 16, 1, -30 },
  { 6292, 19, 8, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD42PT7B_H_
