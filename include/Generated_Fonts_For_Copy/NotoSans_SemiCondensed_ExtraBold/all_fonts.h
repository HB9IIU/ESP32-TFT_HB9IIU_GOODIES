#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_ExtraBold
// Headers: 67

#include "NotoSans_SemiCondensed_ExtraBold6pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold7pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold8pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold9pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold10pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold11pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold12pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold13pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold14pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold15pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold16pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold17pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold18pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold19pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold20pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold21pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold22pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold23pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold24pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold25pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold26pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold27pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold28pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold29pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold30pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold31pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold32pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold33pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold34pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold35pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold36pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold37pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold38pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold39pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold40pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold41pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold42pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold43pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold44pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold45pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold46pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold47pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold48pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold49pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold50pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold51pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold52pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold53pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold54pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold55pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold56pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold57pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold58pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold59pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold60pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold61pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold62pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold63pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold64pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold65pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold66pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold67pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold68pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold69pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold70pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold71pt7b.h"
#include "NotoSans_SemiCondensed_ExtraBold72pt7b.h"
