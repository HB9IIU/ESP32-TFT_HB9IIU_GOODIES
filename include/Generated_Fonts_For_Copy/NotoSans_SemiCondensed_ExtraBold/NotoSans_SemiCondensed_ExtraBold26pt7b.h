#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x00, 0x0E, 0xFF,
  0xDE, 0xF3, 0xFC, 0xF7, 0x3D, 0xCF, 0x73, 0xDC, 0x77, 0x1C, 0x0E, 0x30,
  0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x38, 0x00, 0x06, 0x00, 0x60, 0x1F,
  0xC7, 0xFF, 0x7F, 0xEF, 0xEE, 0xF6, 0x0F, 0x60, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x6F, 0x86, 0xFE, 0x6F, 0xFF, 0xEF, 0xFE, 0x3F,
  0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x07, 0x83, 0xF0, 0x38, 0x3F, 0xC3,
  0xC1, 0xCE, 0x1C, 0x0E, 0x71, 0xE0, 0x73, 0x8E, 0x03, 0x9C, 0xF0, 0x1C,
  0xE7, 0x00, 0xE7, 0x7B, 0xE7, 0xFB, 0xBF, 0x9F, 0xBD, 0xDE, 0x79, 0xCE,
  0x70, 0x1E, 0x73, 0x80, 0xE3, 0x9C, 0x0F, 0x1C, 0xE0, 0x70, 0xE7, 0x07,
  0x87, 0xF8, 0x38, 0x1F, 0x83, 0xC0, 0xF8, 0x07, 0x80, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC7, 0xDF, 0xF3, 0xDF, 0x79, 0xEF, 0x3F, 0xF7, 0x8F,
  0xF3, 0xC3, 0xF1, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xF3, 0xE0,
  0xFF, 0x77, 0x77, 0x70, 0x1E, 0x38, 0xF1, 0xC7, 0x8F, 0x1C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xC3, 0xC3, 0x87,
  0x80, 0xE1, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF3, 0xC7, 0x8E, 0x3C, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x08, 0xE2, 0xFF, 0xEF, 0xFE, 0xFF, 0xF1, 0xF0, 0x3F, 0x87,
  0xBC, 0x79, 0xC1, 0x10, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7B, 0xFD, 0xEF, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFE, 0xF0, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0x79, 0xEF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9,
  0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0xC1, 0xF0, 0xFC, 0x7F,
  0x7F, 0xFE, 0xF7, 0x7C, 0x9F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0xFC, 0xFF, 0xEF,
  0xFE, 0x61, 0xF4, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x07, 0xFC, 0xFF, 0xE7, 0xFE, 0x41, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x1F, 0x81, 0xF8, 0x1F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x01, 0xFC, 0x3F,
  0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xE3, 0xC7, 0x8F,
  0x1C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80,
  0x78, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x77, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x01, 0xFE, 0x3E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x03, 0xE0, 0xFE, 0x3F,
  0xE3, 0xFE, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFF, 0xF9,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xE3, 0xFE, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0xFF,
  0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x7F, 0xC7, 0xBE,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0x0F,
  0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x1C, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x7F,
  0xC7, 0xF8, 0x7E, 0x00, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xBC, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xBB, 0xDE, 0xE0,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0x87, 0xE0, 0xF8, 0x0F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC,
  0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x0F, 0xFB, 0xFF, 0xBF, 0xF4, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xE7, 0x8F, 0xCE, 0x71, 0xFE,
  0xE7, 0x3D, 0xE7, 0xE7, 0x8E, 0x7E, 0x70, 0xE7, 0xE7, 0x1E, 0x7E, 0x71,
  0xC7, 0xE7, 0x1C, 0xEE, 0x7B, 0xEE, 0xF3, 0xF7, 0xC7, 0x1E, 0x78, 0x78,
  0x00, 0x03, 0xC0, 0x10, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x7B,
  0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0x3E, 0x78, 0x0F,
  0x7C, 0x07, 0xBE, 0x03, 0xE0, 0xFC, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xDE, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0x3F, 0xE0,
  0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7C, 0x11, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x8E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xE7, 0xE0, 0x4F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x07,
  0x9F, 0x9F, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFF, 0xFE,
  0xFC, 0x70, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xBC, 0x3C, 0xF1, 0xF3, 0xCF,
  0x8F, 0x3C, 0x3D, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xF3,
  0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xF7, 0x1D,
  0xFE, 0xE3, 0xBF, 0xDE, 0xF7, 0xFB, 0xDE, 0xFF, 0x3B, 0x9F, 0xE7, 0xF3,
  0xFC, 0xFE, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0x87,
  0x80, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1,
  0xEF, 0xF1, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7,
  0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0x7C, 0xFE,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFE, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xEF, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0x7C, 0xFE, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF1, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF3, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xF3,
  0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xFB, 0xC3, 0xEF, 0x07, 0xC0,
  0x0F, 0x83, 0xFF, 0x7F, 0xEF, 0xFE, 0xF8, 0x4F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x1F, 0x81, 0xEF, 0x3E,
  0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87,
  0xFF, 0x3F, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x0F, 0xF8, 0x1F,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E,
  0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x3C, 0x3C, 0xFE, 0x3C, 0x3C, 0xFF,
  0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x1C, 0xE7, 0x78, 0x1F, 0xE7,
  0x78, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x7C, 0x3E, 0x3C,
  0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E,
  0x78, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF0,
  0x7D, 0xE0, 0xF3, 0xE3, 0xE3, 0xC7, 0x87, 0xCF, 0x07, 0xBC, 0x0F, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xFF,
  0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0xC0, 0x7F, 0x01, 0xCE, 0x07, 0x38, 0x38, 0x70, 0xE1, 0xC7, 0x03,
  0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF0, 0x70, 0x03, 0x07, 0xFC,
  0x3F, 0xE3, 0xFF, 0x20, 0xF0, 0x0F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x7E, 0x70, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x10, 0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFE, 0xFF,
  0xEE, 0x7C, 0x02, 0x03, 0xFC, 0xFF, 0xBF, 0xE7, 0x85, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x37, 0xFE, 0x7F, 0xC7, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x82, 0x3C, 0xFD, 0xEF, 0xFF,
  0x7F, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF,
  0x1F, 0x78, 0xFB, 0xFF, 0xDF, 0xDE, 0x7C, 0xF0, 0x02, 0x01, 0xFC, 0x3F,
  0xE7, 0xDF, 0x78, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x07, 0x81, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0x07, 0xC7, 0xF1, 0xFC, 0xFB,
  0x3E, 0x0F, 0x07, 0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0C, 0x01, 0xFB, 0xDF,
  0xFE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFE, 0x3F, 0xF1, 0xF7, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0, 0x0F, 0x00, 0xFB,
  0x0F, 0x9F, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x10, 0xF7, 0xEF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x3C, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xFF, 0xFD, 0xF0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xFE, 0x3E, 0xF3,
  0xE7, 0x9E, 0x3D, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1E, 0x7C,
  0xF1, 0xE7, 0x8F, 0xBC, 0x3D, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x01, 0x0E, 0xFE, 0xFE, 0xEF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0x01, 0x0E, 0xFE, 0xEF, 0xEF,
  0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xFF,
  0xE7, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3E,
  0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x01, 0x0E, 0x7C, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFE, 0xF7, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x04, 0x01, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xF1, 0xF7, 0xFF,
  0xBF, 0xBC, 0xF9, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0x73, 0xFB, 0xFF, 0xEF, 0xF7, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x0E, 0x1F, 0xFF, 0xFF, 0xFE,
  0xF0, 0xBE, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF,
  0xEF, 0xF0, 0x1C, 0x07, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x93, 0xFC, 0x7F, 0x0F, 0xC0,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xE7, 0xF8, 0x3D, 0xE1,
  0xF7, 0x87, 0x9E, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x07, 0x38, 0x1F,
  0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0xF8,
  0x7B, 0xC7, 0xC3, 0xDE, 0x3F, 0x3C, 0xF3, 0xB9, 0xE7, 0x9D, 0xCF, 0x1E,
  0xEE, 0x78, 0xF7, 0x77, 0x87, 0xBB, 0xFC, 0x3D, 0x8F, 0xE0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0x83, 0xC0, 0xF8,
  0x7D, 0xF3, 0xE3, 0xCF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xEF, 0x0F, 0x3E, 0x7C, 0x7B, 0xE1, 0xF0,
  0xF8, 0x3D, 0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF,
  0x07, 0xBC, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x87, 0xC3, 0xE3, 0xF1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x3F, 0x9F, 0x0F, 0xC3, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xF8, 0x7C, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x07, 0xE1, 0xF1, 0xF9, 0xF8, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x8F, 0xC7, 0xC3, 0xC0, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3E,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 13, 1, -19 },
  { 22, 14, 19, 16, 1, -19 },
  { 56, 12, 22, 14, 1, -20 },
  { 89, 21, 19, 23, 1, -19 },
  { 139, 17, 19, 18, 1, -19 },
  { 180, 4, 7, 7, 1, -19 },
  { 184, 7, 23, 9, 1, -19 },
  { 205, 7, 23, 9, 1, -19 },
  { 226, 12, 12, 13, 1, -20 },
  { 244, 12, 13, 14, 1, -16 },
  { 264, 5, 6, 7, 1, -3 },
  { 268, 7, 4, 8, 1, -9 },
  { 272, 5, 4, 7, 1, -4 },
  { 275, 11, 19, 11, 0, -19 },
  { 302, 12, 19, 14, 1, -19 },
  { 331, 10, 19, 14, 1, -19 },
  { 355, 12, 19, 14, 1, -19 },
  { 384, 12, 19, 14, 1, -19 },
  { 413, 14, 19, 14, 0, -19 },
  { 447, 12, 19, 14, 1, -19 },
  { 476, 12, 19, 14, 1, -19 },
  { 505, 12, 19, 14, 1, -19 },
  { 534, 12, 19, 14, 1, -19 },
  { 563, 12, 19, 14, 1, -19 },
  { 592, 5, 14, 7, 1, -14 },
  { 601, 5, 17, 7, 1, -14 },
  { 612, 12, 13, 14, 1, -16 },
  { 632, 12, 8, 14, 1, -13 },
  { 644, 12, 13, 14, 1, -16 },
  { 664, 11, 19, 12, 0, -19 },
  { 691, 20, 21, 22, 1, -19 },
  { 744, 17, 19, 17, 0, -19 },
  { 785, 13, 19, 16, 2, -19 },
  { 816, 14, 19, 15, 1, -19 },
  { 850, 14, 19, 18, 2, -19 },
  { 884, 10, 19, 13, 2, -19 },
  { 908, 10, 19, 13, 2, -19 },
  { 932, 15, 19, 18, 1, -19 },
  { 968, 14, 19, 18, 2, -19 },
  { 1002, 8, 19, 10, 1, -19 },
  { 1021, 8, 25, 8, -2, -19 },
  { 1046, 14, 19, 16, 2, -19 },
  { 1080, 11, 19, 13, 2, -19 },
  { 1107, 19, 19, 23, 2, -19 },
  { 1153, 16, 19, 20, 2, -19 },
  { 1191, 17, 19, 19, 1, -19 },
  { 1232, 12, 19, 15, 2, -19 },
  { 1261, 17, 23, 19, 1, -19 },
  { 1310, 14, 19, 16, 2, -19 },
  { 1344, 12, 19, 13, 1, -19 },
  { 1373, 12, 19, 14, 1, -19 },
  { 1402, 14, 19, 18, 2, -19 },
  { 1436, 16, 19, 16, 0, -19 },
  { 1474, 24, 19, 24, 0, -19 },
  { 1531, 16, 19, 16, 0, -19 },
  { 1569, 15, 19, 15, 0, -19 },
  { 1605, 12, 19, 14, 1, -19 },
  { 1634, 6, 23, 8, 2, -19 },
  { 1652, 11, 19, 11, 0, -19 },
  { 1679, 6, 23, 8, 1, -19 },
  { 1697, 14, 12, 14, 0, -19 },
  { 1718, 12, 2, 12, 0, 2 },
  { 1721, 7, 4, 9, 1, -20 },
  { 1725, 12, 15, 15, 1, -15 },
  { 1748, 12, 20, 15, 2, -20 },
  { 1778, 11, 15, 13, 1, -15 },
  { 1799, 13, 20, 15, 1, -20 },
  { 1832, 12, 15, 14, 1, -15 },
  { 1855, 10, 20, 10, 0, -20 },
  { 1880, 13, 21, 15, 1, -15 },
  { 1915, 12, 20, 16, 2, -20 },
  { 1945, 4, 20, 8, 2, -20 },
  { 1955, 7, 26, 8, -1, -20 },
  { 1978, 13, 20, 15, 2, -20 },
  { 2011, 4, 20, 7, 2, -20 },
  { 2021, 20, 15, 24, 2, -15 },
  { 2059, 12, 15, 16, 2, -15 },
  { 2082, 13, 15, 15, 1, -15 },
  { 2107, 12, 21, 15, 2, -15 },
  { 2139, 13, 21, 15, 1, -15 },
  { 2174, 9, 15, 11, 2, -15 },
  { 2191, 10, 15, 12, 1, -15 },
  { 2210, 10, 17, 11, 0, -17 },
  { 2232, 12, 14, 16, 2, -14 },
  { 2253, 14, 14, 14, 0, -14 },
  { 2278, 21, 14, 21, 0, -14 },
  { 2315, 14, 14, 14, 0, -14 },
  { 2340, 14, 20, 14, 0, -14 },
  { 2375, 10, 14, 12, 1, -14 },
  { 2393, 9, 23, 10, 0, -19 },
  { 2419, 3, 26, 13, 5, -20 },
  { 2429, 9, 23, 10, 1, -19 },
  { 2455, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD26PT7B_H_
