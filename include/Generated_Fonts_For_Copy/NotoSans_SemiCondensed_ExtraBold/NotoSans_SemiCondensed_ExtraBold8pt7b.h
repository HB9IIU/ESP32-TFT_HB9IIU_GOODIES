#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x30, 0xEC, 0x32, 0xBE, 0xAE, 0x30, 0x2F, 0xC3, 0xB6, 0x49,
  0x52, 0xD2, 0xD2, 0xA5, 0xC0, 0x61, 0x47, 0x1A, 0xD9, 0xF0, 0xD0, 0x6B,
  0x4C, 0x98, 0x95, 0x5C, 0x6F, 0x67, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25,
  0xA5, 0x00, 0x6D, 0xDD, 0xD6, 0x3D, 0x92, 0x40, 0x6B, 0x32, 0x4F, 0x6B,
  0x37, 0x1F, 0x33, 0x7B, 0xF3, 0x74, 0x6B, 0x1E, 0x34, 0xAD, 0xD7, 0xF1,
  0x32, 0x64, 0x6D, 0x77, 0x97, 0x6D, 0xD7, 0x16, 0xC3, 0xC1, 0x80, 0x16,
  0xC3, 0xFF, 0x86, 0x3C, 0xF4, 0xA0, 0x80, 0x39, 0x1B, 0xEB, 0xBD, 0x13,
  0x80, 0x33, 0x94, 0xAF, 0xE4, 0xEA, 0xAE, 0xBE, 0x3A, 0xB1, 0x84, 0x38,
  0xEB, 0x99, 0xBE, 0xF3, 0xF9, 0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x71, 0xB4,
  0xBC, 0x99, 0xFF, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x5E, 0xBA, 0xEE,
  0xAB, 0x92, 0x49, 0xC0, 0x8F, 0x7D, 0xF7, 0xBE, 0xB0, 0x9D, 0xDB, 0xB9,
  0x32, 0x73, 0x94, 0xBC, 0xF6, 0xF9, 0x00, 0x32, 0x73, 0x94, 0xBC, 0x60,
  0xEA, 0xAC, 0xAB, 0x7D, 0xC7, 0x9E, 0xF6, 0x66, 0x66, 0x99, 0x99, 0x9E,
  0x8E, 0xD4, 0xA5, 0x10, 0x93, 0xB5, 0x6B, 0x76, 0xCD, 0x80, 0xDA, 0x9C,
  0xC5, 0x6C, 0x9A, 0x9C, 0x42, 0x10, 0xF3, 0x26, 0x4F, 0xFF, 0xFC, 0x89,
  0x22, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xF0, 0xE0, 0x77, 0xDF, 0x93, 0xDB,
  0xC0, 0x7C, 0xC7, 0x11, 0x7D, 0xD7, 0x7F, 0xC7, 0x6B, 0xA4, 0x80, 0x7D,
  0xD7, 0x17, 0x93, 0xDB, 0x40, 0xC5, 0x50, 0xC5, 0x5E, 0x89, 0xAC, 0xEB,
  0xFC, 0xFE, 0xBA, 0xEB, 0xF6, 0xD0, 0x7D, 0xD7, 0xF6, 0xF9, 0x00, 0x7D,
  0xD7, 0x11, 0xEA, 0xFC, 0xF0, 0x5D, 0x26, 0xDD, 0xD7, 0xD7, 0x66, 0xF5,
  0xD6, 0xDA, 0xF6, 0x6D, 0xD7, 0x66, 0x6C, 0xED, 0x70, 0x69, 0x64, 0x98,
  0xFF, 0xC9, 0x34, 0xB0, 0x5B,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 2, 7, 3, 0, -6 },
  { 28, 4, 4, 4, 0, -6 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 2, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 2, 1, 2, 0, -1 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 3, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 2, 5, 2, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 4, 2, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -5 },
  { 76, 3, 6, 4, 0, -6 },
  { 79, 6, 7, 7, 0, -6 },
  { 85, 5, 6, 5, 0, -6 },
  { 89, 4, 6, 5, 1, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 3, 6, 4, 1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 4, 6, 6, 1, -6 },
  { 112, 3, 6, 3, 0, -6 },
  { 115, 3, 8, 3, -1, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 3, 6, 4, 1, -6 },
  { 124, 6, 6, 7, 1, -6 },
  { 129, 4, 6, 6, 1, -6 },
  { 132, 5, 6, 6, 0, -6 },
  { 136, 3, 6, 5, 1, -6 },
  { 139, 5, 7, 6, 0, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 4, 6, 6, 1, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 7, 6, 7, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 4, 6, 4, 0, -6 },
  { 177, 2, 7, 3, 0, -6 },
  { 179, 3, 6, 3, 0, -6 },
  { 182, 2, 7, 3, 0, -6 },
  { 184, 4, 4, 4, 0, -6 },
  { 186, 4, 1, 4, 0, 0 },
  { 187, 3, 1, 3, 0, -6 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 3, 6, 5, 1, -6 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 6, 5, 0, -6 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 3, 6, 3, 0, -6 },
  { 203, 4, 6, 5, 0, -4 },
  { 206, 3, 6, 5, 1, -6 },
  { 209, 2, 6, 2, 0, -6 },
  { 211, 2, 8, 2, 0, -6 },
  { 213, 4, 6, 5, 1, -6 },
  { 216, 1, 6, 2, 1, -6 },
  { 217, 6, 4, 7, 1, -4 },
  { 220, 3, 4, 5, 1, -4 },
  { 222, 4, 4, 5, 0, -4 },
  { 224, 3, 6, 5, 1, -4 },
  { 227, 4, 6, 5, 0, -4 },
  { 230, 2, 4, 3, 1, -4 },
  { 231, 3, 4, 4, 0, -4 },
  { 233, 3, 5, 3, 0, -5 },
  { 235, 4, 4, 5, 0, -4 },
  { 237, 4, 4, 4, 0, -4 },
  { 239, 6, 4, 7, 0, -4 },
  { 242, 4, 4, 4, 0, -4 },
  { 244, 4, 6, 4, 0, -4 },
  { 247, 3, 4, 4, 0, -4 },
  { 249, 3, 7, 3, 0, -6 },
  { 252, 1, 8, 4, 1, -6 },
  { 253, 3, 7, 3, 0, -6 },
  { 256, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD8PT7B_H_
