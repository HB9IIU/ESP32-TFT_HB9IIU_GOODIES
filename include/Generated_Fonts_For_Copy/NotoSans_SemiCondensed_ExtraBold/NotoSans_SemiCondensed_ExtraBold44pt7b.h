#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0xFE, 0x3F, 0xBF,
  0x1F, 0xDF, 0x8F, 0xEF, 0xC7, 0xF7, 0xE3, 0xFB, 0xF0, 0xFD, 0xF8, 0x7C,
  0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x87, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xF7, 0xCF, 0xCF, 0x04, 0xFC,
  0xF0, 0x0F, 0xCF, 0x00, 0xFE, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0x7F, 0x00, 0xF3, 0xF0, 0x0F, 0x3F, 0xC0, 0xF3,
  0xFF, 0x8F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x0F,
  0x80, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFF,
  0xC0, 0x7E, 0x00, 0x3E, 0x3E, 0x03, 0xE0, 0x03, 0xF1, 0xF0, 0x3F, 0x00,
  0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0xF8, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x7C, 0x00, 0x0F,
  0xC7, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x3E, 0x1F, 0xC1, 0xF1, 0xF3, 0xF3,
  0xFF, 0x0F, 0xFF, 0x9F, 0x1F, 0xFC, 0x3F, 0xF9, 0xF9, 0xFF, 0xE1, 0xFF,
  0xCF, 0x8F, 0xDF, 0x87, 0xFC, 0xFC, 0xFC, 0x7C, 0x0F, 0x87, 0xC7, 0xE3,
  0xE0, 0x00, 0x7E, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0x7C, 0x3F, 0x00, 0x1F, 0x83, 0xE1, 0xF0,
  0x00, 0xF8, 0x1F, 0x8F, 0x80, 0x0F, 0xC0, 0xFC, 0x7C, 0x00, 0x7C, 0x03,
  0xE7, 0xE0, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0x07, 0xF8,
  0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xFC, 0x7F, 0x1F, 0xEF, 0xFB, 0xFC, 0x7F,
  0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x8F, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0,
  0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0x0F, 0x8F, 0x7E, 0xF7, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x81, 0xF9, 0xFC, 0x3F, 0x8F, 0xC0, 0xF0,
  0xF8, 0x07, 0x06, 0x00, 0x10, 0x40, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7,
  0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F,
  0x18, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFC, 0x3F, 0xC7, 0x80,
  0xFE, 0x18, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x78, 0x3F, 0xC3, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xF3,
  0xF8, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x3E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xEF, 0xEF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x1C, 0x07, 0xE7, 0xFC, 0x3F, 0x7F,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xFC, 0x3F, 0xCF, 0xFB, 0xFE, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x9F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x9F, 0xE7, 0xF0, 0x7F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC,
  0x1F, 0xEF, 0xFB, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0x7E,
  0x3F, 0xF3, 0xF0, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x08, 0x1F, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x08, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0x04, 0x1F, 0x8F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0x07, 0xF9, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x01, 0xF0, 0x3F, 0x1F, 0x03, 0xFF, 0xCF, 0x9F, 0x87, 0xFF,
  0xE7, 0xCF, 0x87, 0xFF, 0xF1, 0xF7, 0xC3, 0xF9, 0xF8, 0xFF, 0xE3, 0xF0,
  0xF8, 0x7F, 0xE1, 0xF0, 0x7C, 0x3F, 0xF1, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8,
  0x1F, 0x0F, 0xFC, 0x7C, 0x0F, 0x87, 0xFE, 0x3E, 0x07, 0xC3, 0xFF, 0x1F,
  0x03, 0xE1, 0xFF, 0x8F, 0x81, 0xF0, 0xFF, 0xC7, 0xE1, 0xF8, 0xFB, 0xE1,
  0xF9, 0xFE, 0x7D, 0xF0, 0xFF, 0xFF, 0xFC, 0xFC, 0x3F, 0xF7, 0xFE, 0x3E,
  0x0F, 0xF1, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x3F, 0xC0, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFB,
  0xF8, 0x7F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0x3E, 0x1F,
  0xF0, 0x0C, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x38, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xF9, 0xFC, 0x03, 0xFC,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x07, 0xF9, 0xFC,
  0x07, 0xFC, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0xF8, 0x7F, 0xC0,
  0x08, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFE,
  0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xF0, 0x1F, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xED, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE0, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0,
  0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F,
  0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xDF, 0x81, 0xF7, 0xFF, 0xEF, 0xC1, 0xFB, 0xFF, 0xF7, 0xE0, 0xFD,
  0xFF, 0xF9, 0xF0, 0x7C, 0xFF, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE, 0x7E, 0x3F,
  0x3F, 0xFF, 0x3F, 0x1F, 0x1F, 0xFF, 0x8F, 0xCF, 0x8F, 0xFF, 0xC7, 0xEF,
  0xC7, 0xFF, 0xE3, 0xF7, 0xE3, 0xFF, 0xF0, 0xFB, 0xE1, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xF8, 0x3F,
  0xFF, 0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x8F,
  0xE3, 0xFF, 0xF1, 0xFE, 0x7F, 0xFE, 0x1F, 0xCF, 0xFF, 0xC3, 0xFC, 0xFF,
  0xF8, 0x3F, 0x9F, 0xFF, 0x07, 0xFB, 0xFF, 0xE0, 0x7F, 0x7F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xE3, 0xF7, 0xF8, 0x0C, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x80,
  0xFE, 0x7F, 0x00, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x3F,
  0x81, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x81, 0xFF,
  0xC1, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xF7, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF7, 0xC3, 0xF8, 0x1F, 0xC3, 0xE7, 0xE3, 0xF8, 0x0F, 0xC3,
  0xE7, 0xE3, 0xF8, 0x0F, 0xC7, 0xE7, 0xE3, 0xF8, 0x0F, 0xE7, 0xE7, 0xE3,
  0xF0, 0x0F, 0xE7, 0xE3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC3, 0xF7, 0xF0, 0x07,
  0xEF, 0xC3, 0xF7, 0xF0, 0x07, 0xEF, 0xC3, 0xF7, 0xF0, 0x07, 0xEF, 0xC1,
  0xF7, 0xE0, 0x07, 0xFF, 0xC1, 0xF7, 0xE0, 0x03, 0xFF, 0x81, 0xF7, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xCF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3,
  0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x38, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF,
  0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE,
  0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xF7, 0xE7, 0xFF,
  0x3F, 0x0F, 0xF0, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x0C, 0x07, 0xF3, 0xFC, 0x3F, 0xBF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xF7,
  0xFF, 0x9F, 0x9F, 0xF8, 0xFC, 0x7F, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFC, 0x39, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x0D, 0xFF, 0x1F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0x83, 0xF8, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFE, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xF7, 0xE3, 0xFF, 0x3F, 0x0F, 0xF1, 0xF8, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x04, 0xFF, 0x00, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0x70, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFE, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF4, 0x00, 0x7F, 0xBE, 0x0F, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0C,
  0x07, 0xF3, 0xFC, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xF8, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0x18, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFB, 0xF8,
  0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x8F,
  0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xBF, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x70, 0x3E, 0x1F, 0xF0, 0xFF, 0x8F, 0xDF, 0xFE, 0x7F, 0xF3, 0xF7,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE,
  0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x0E, 0x07,
  0xC3, 0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0,
  0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFB, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x0C, 0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xDF, 0xF8, 0xFE, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFE, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0x7F, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1D,
  0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xF0, 0x19,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8,
  0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE7, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFF,
  0xE7, 0xE3, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xEF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xC0,
  0xFE, 0x7F, 0x07, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0xE0, 0xFE, 0x3F, 0x07,
  0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFB, 0xF1, 0xFC, 0x1F, 0x8F, 0x9F, 0x1F, 0x81, 0xFC, 0xF9, 0xF3,
  0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0x81, 0xFC, 0xF9, 0xF3, 0xF8, 0x0F, 0xDF,
  0x9F, 0x3F, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00,
  0xFD, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE7,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3,
  0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x27, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 17, 11, 21, 2, -31 },
  { 57, 25, 31, 27, 1, -31 },
  { 154, 20, 36, 24, 2, -33 },
  { 244, 37, 32, 39, 1, -32 },
  { 392, 30, 32, 31, 1, -32 },
  { 512, 7, 11, 12, 2, -31 },
  { 522, 12, 39, 15, 2, -32 },
  { 581, 12, 39, 15, 1, -32 },
  { 640, 20, 20, 22, 1, -33 },
  { 690, 20, 21, 24, 2, -26 },
  { 743, 9, 12, 12, 1, -6 },
  { 757, 12, 6, 14, 1, -15 },
  { 766, 8, 8, 12, 2, -7 },
  { 774, 18, 32, 19, 0, -32 },
  { 846, 20, 32, 24, 2, -32 },
  { 926, 16, 31, 24, 2, -31 },
  { 988, 21, 32, 24, 1, -32 },
  { 1072, 21, 32, 24, 1, -32 },
  { 1156, 22, 31, 24, 1, -31 },
  { 1242, 20, 31, 24, 2, -31 },
  { 1320, 21, 32, 24, 1, -32 },
  { 1404, 21, 31, 24, 1, -31 },
  { 1486, 21, 32, 24, 1, -32 },
  { 1570, 21, 32, 24, 1, -32 },
  { 1654, 8, 26, 12, 2, -25 },
  { 1680, 9, 31, 12, 1, -25 },
  { 1715, 20, 23, 24, 2, -27 },
  { 1773, 20, 15, 24, 2, -23 },
  { 1811, 20, 23, 24, 2, -27 },
  { 1869, 19, 33, 20, 0, -32 },
  { 1948, 33, 35, 37, 2, -32 },
  { 2093, 29, 32, 29, 0, -32 },
  { 2209, 22, 31, 27, 3, -31 },
  { 2295, 23, 32, 26, 2, -32 },
  { 2387, 25, 31, 30, 3, -31 },
  { 2484, 17, 31, 23, 3, -31 },
  { 2550, 17, 31, 22, 3, -31 },
  { 2616, 25, 32, 30, 2, -32 },
  { 2716, 25, 31, 31, 3, -31 },
  { 2813, 15, 31, 17, 1, -31 },
  { 2872, 14, 41, 14, -3, -31 },
  { 2944, 25, 31, 27, 3, -31 },
  { 3041, 18, 31, 23, 3, -31 },
  { 3111, 33, 31, 39, 3, -31 },
  { 3239, 27, 31, 33, 3, -31 },
  { 3344, 28, 32, 32, 2, -32 },
  { 3456, 21, 31, 26, 3, -31 },
  { 3538, 28, 39, 32, 2, -32 },
  { 3675, 24, 31, 27, 3, -31 },
  { 3768, 19, 32, 23, 2, -32 },
  { 3844, 22, 31, 23, 1, -31 },
  { 3930, 24, 31, 30, 3, -31 },
  { 4023, 27, 31, 27, 0, -31 },
  { 4128, 40, 31, 40, 0, -31 },
  { 4283, 27, 31, 27, 0, -31 },
  { 4388, 26, 31, 26, 0, -31 },
  { 4489, 22, 31, 24, 1, -31 },
  { 4575, 10, 39, 14, 3, -32 },
  { 4624, 18, 32, 19, 0, -32 },
  { 4696, 11, 39, 14, 1, -32 },
  { 4750, 24, 21, 24, 0, -32 },
  { 4813, 20, 4, 20, 0, 3 },
  { 4823, 12, 7, 16, 2, -34 },
  { 4834, 21, 25, 25, 1, -25 },
  { 4900, 21, 33, 26, 3, -33 },
  { 4987, 18, 25, 21, 2, -25 },
  { 5044, 21, 33, 26, 2, -33 },
  { 5131, 21, 25, 24, 2, -25 },
  { 5197, 17, 34, 16, 1, -34 },
  { 5270, 21, 36, 26, 2, -25 },
  { 5365, 21, 33, 27, 3, -33 },
  { 5452, 7, 34, 13, 3, -34 },
  { 5482, 12, 45, 13, -2, -34 },
  { 5550, 23, 33, 26, 3, -33 },
  { 5645, 7, 33, 13, 3, -33 },
  { 5674, 34, 25, 40, 3, -25 },
  { 5781, 21, 25, 27, 3, -25 },
  { 5847, 22, 25, 26, 2, -25 },
  { 5916, 21, 36, 26, 3, -25 },
  { 6011, 21, 36, 26, 2, -25 },
  { 6106, 15, 25, 19, 3, -25 },
  { 6153, 17, 25, 20, 2, -25 },
  { 6207, 16, 29, 18, 1, -29 },
  { 6265, 21, 24, 27, 3, -24 },
  { 6328, 24, 24, 24, 0, -24 },
  { 6400, 36, 24, 36, 0, -24 },
  { 6508, 24, 24, 24, 0, -24 },
  { 6580, 24, 35, 24, 0, -24 },
  { 6685, 18, 24, 20, 1, -24 },
  { 6739, 15, 39, 17, 1, -32 },
  { 6813, 6, 44, 22, 8, -34 },
  { 6846, 15, 39, 17, 1, -32 },
  { 6920, 20, 7, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD44PT7B_H_
