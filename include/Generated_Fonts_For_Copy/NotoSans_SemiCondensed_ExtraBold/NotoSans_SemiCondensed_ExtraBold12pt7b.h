#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xFB, 0xB9, 0x14, 0x68, 0xD3, 0xF2, 0xDF, 0xFF,
  0xB4, 0x78, 0x11, 0xFD, 0x5C, 0x78, 0x79, 0xDF, 0x30, 0x40, 0x61, 0x1C,
  0xCD, 0x23, 0x58, 0x75, 0xDB, 0xD0, 0xB4, 0x6D, 0x31, 0xC0, 0x38, 0x3E,
  0x1B, 0x0F, 0x83, 0x33, 0xDB, 0x38, 0xFC, 0x7B, 0x80, 0xEA, 0x36, 0x64,
  0x4C, 0x44, 0x66, 0x30, 0xC6, 0x62, 0x33, 0x32, 0x66, 0xC0, 0x32, 0xDF,
  0xCC, 0x78, 0x10, 0x4F, 0xC4, 0x10, 0x40, 0x6D, 0x60, 0xFC, 0xF0, 0x18,
  0xC4, 0x62, 0x31, 0x88, 0xC0, 0x31, 0xE6, 0xF3, 0xCF, 0x34, 0xDF, 0x38,
  0x37, 0xFB, 0x33, 0x33, 0x30, 0x33, 0xF4, 0xC3, 0x18, 0xC7, 0x1F, 0xFC,
  0x33, 0xF4, 0xC2, 0x30, 0x70, 0xF7, 0xF8, 0x08, 0x63, 0x8E, 0x7B, 0x6F,
  0xC6, 0x18, 0xF7, 0xB1, 0xCF, 0x8C, 0x77, 0xF0, 0x1D, 0xF6, 0x16, 0xFF,
  0x3C, 0xDB, 0x38, 0xFF, 0xF0, 0xC6, 0x18, 0x63, 0x0C, 0x60, 0x31, 0xF4,
  0xDF, 0x31, 0xFC, 0xFB, 0x78, 0x31, 0xEC, 0xF3, 0x7D, 0xF0, 0xD6, 0x70,
  0xB0, 0x3C, 0x4C, 0x00, 0xDA, 0xC0, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xFC,
  0x0F, 0xFF, 0xC1, 0xC1, 0xCE, 0xE2, 0x00, 0x77, 0xE6, 0x33, 0x10, 0x0C,
  0x60, 0x0E, 0x0E, 0xC6, 0x09, 0x7A, 0x52, 0xF4, 0xB5, 0xE9, 0x24, 0x71,
  0x07, 0x80, 0x18, 0x38, 0x3C, 0x3C, 0x64, 0x7E, 0x7E, 0xE6, 0xC3, 0xF3,
  0xEC, 0xF3, 0xF3, 0x7C, 0xFF, 0xF8, 0x39, 0xFC, 0x30, 0xC3, 0x0C, 0x3E,
  0x78, 0xE1, 0xF3, 0x36, 0x6C, 0xF9, 0xB3, 0x7E, 0xF8, 0xFF, 0xF1, 0x8F,
  0x63, 0x1F, 0xF8, 0xFF, 0xF1, 0x8F, 0x7B, 0x18, 0xC0, 0x39, 0xFC, 0x30,
  0xDF, 0x7C, 0xFF, 0x7C, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3, 0xC6,
  0xFF, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xEC, 0xCF,
  0x9B, 0x67, 0x8F, 0x1F, 0x36, 0x66, 0xCE, 0xC6, 0x31, 0x8C, 0x63, 0x1F,
  0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF, 0x5F, 0xAF, 0x77, 0xBB, 0xD9, 0x80,
  0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCE, 0x39, 0xFB, 0x1E, 0x3C,
  0x78, 0xF1, 0xFE, 0x7C, 0xE3, 0xED, 0xB3, 0xFB, 0xEC, 0x30, 0xC0, 0x39,
  0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0x7C, 0x18, 0x38, 0xE3, 0xED, 0xF3,
  0xFB, 0xCD, 0xB7, 0xCC, 0x39, 0xF6, 0x58, 0x78, 0x70, 0xFF, 0xF8, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0x78, 0xC7, 0x8D, 0x9B, 0x26, 0xC5, 0x8F, 0x1C, 0x38, 0xC4, 0x79, 0xCD,
  0x39, 0xB5, 0x66, 0xAC, 0xF7, 0x9E, 0xF1, 0xDC, 0x31, 0x80, 0xC6, 0xCD,
  0xB1, 0xE3, 0x87, 0x1F, 0x37, 0xC6, 0xC6, 0xCD, 0xB3, 0x63, 0x87, 0x06,
  0x0C, 0x18, 0xFF, 0xF0, 0xC6, 0x30, 0xC6, 0x3F, 0xFC, 0xFE, 0x49, 0x24,
  0x93, 0x80, 0xC6, 0x18, 0xC2, 0x18, 0xC2, 0x18, 0xFD, 0xB6, 0xDB, 0x6F,
  0x80, 0x10, 0xC3, 0x9A, 0x4F, 0x10, 0xF8, 0xE3, 0x39, 0xF0, 0xDF, 0xCF,
  0xB7, 0xC0, 0xC3, 0x0F, 0x3E, 0xDB, 0x3C, 0xF6, 0xB8, 0x3D, 0xE6, 0x30,
  0x61, 0xA7, 0x80, 0x0C, 0x33, 0xDF, 0x6F, 0x34, 0xDB, 0x74, 0x39, 0xF6,
  0xFF, 0x41, 0x93, 0xC0, 0x7B, 0x1D, 0xE6, 0x31, 0x8C, 0x60, 0x35, 0xF6,
  0xF3, 0x6D, 0xB7, 0xC3, 0x7D, 0xE0, 0xC3, 0x0F, 0x3E, 0xCF, 0x3C, 0xF3,
  0xCC, 0xEF, 0xFF, 0xC0, 0x32, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0x0C,
  0xF6, 0xF3, 0xCF, 0xB6, 0xCC, 0xFF, 0xFF, 0xC0, 0xB3, 0x7F, 0xF7, 0x7B,
  0x3D, 0x9E, 0xCF, 0x66, 0xB3, 0xEC, 0xF3, 0xCF, 0x3C, 0xC0, 0x39, 0xF6,
  0xF1, 0x6D, 0xB3, 0x80, 0xB3, 0xED, 0xB3, 0xCF, 0x6F, 0xB0, 0xC3, 0x00,
  0x35, 0xF6, 0xF3, 0x6D, 0xB7, 0xC3, 0x0C, 0x30, 0x9F, 0xCC, 0xCC, 0xC0,
  0x33, 0xF8, 0xE1, 0xEF, 0xE0, 0x63, 0xBC, 0xC6, 0x31, 0xAF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x7E, 0xC0, 0xCF, 0x99, 0xB3, 0x47, 0x87, 0x0C, 0x00, 0xCC,
  0xF3, 0x25, 0xD9, 0xFE, 0x77, 0x9C, 0xC3, 0x30, 0xCD, 0xB7, 0x8E, 0x79,
  0xBC, 0xC0, 0xC7, 0x99, 0xB3, 0x47, 0x87, 0x0C, 0x18, 0xF1, 0xC0, 0xFF,
  0xCC, 0x66, 0x3F, 0xE0, 0x13, 0x22, 0x6E, 0x62, 0x23, 0x30, 0xFF, 0xFF,
  0xFF, 0xCE, 0x66, 0x63, 0x36, 0x66, 0xE0, 0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 10, 6, 0, -9 },
  { 22, 10, 9, 11, 0, -9 },
  { 34, 9, 9, 9, 0, -9 },
  { 45, 2, 4, 3, 1, -9 },
  { 46, 4, 11, 4, 0, -9 },
  { 52, 4, 11, 4, 0, -9 },
  { 58, 6, 5, 6, 0, -9 },
  { 62, 6, 6, 7, 0, -7 },
  { 67, 3, 4, 3, 0, -2 },
  { 69, 3, 2, 4, 0, -4 },
  { 70, 2, 2, 3, 1, -2 },
  { 71, 5, 9, 5, 0, -9 },
  { 77, 6, 9, 6, 0, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 5, 9, 6, 1, -9 },
  { 116, 6, 9, 6, 0, -9 },
  { 123, 6, 9, 6, 0, -9 },
  { 130, 6, 9, 6, 0, -9 },
  { 137, 6, 9, 6, 0, -9 },
  { 144, 2, 7, 3, 1, -7 },
  { 146, 3, 9, 3, 0, -7 },
  { 150, 6, 6, 7, 0, -7 },
  { 155, 6, 4, 7, 0, -6 },
  { 158, 6, 6, 7, 0, -7 },
  { 163, 5, 9, 5, 0, -9 },
  { 169, 10, 10, 10, 0, -9 },
  { 182, 8, 9, 8, 0, -9 },
  { 191, 6, 9, 7, 1, -9 },
  { 198, 6, 9, 7, 1, -9 },
  { 205, 7, 9, 8, 1, -9 },
  { 213, 5, 9, 6, 1, -9 },
  { 219, 5, 9, 6, 1, -9 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 7, 9, 8, 1, -9 },
  { 240, 4, 9, 5, 0, -9 },
  { 245, 4, 12, 4, -1, -9 },
  { 251, 7, 9, 7, 1, -9 },
  { 259, 5, 9, 6, 1, -9 },
  { 265, 9, 9, 11, 1, -9 },
  { 276, 7, 9, 9, 1, -9 },
  { 284, 7, 9, 9, 1, -9 },
  { 292, 6, 9, 7, 1, -9 },
  { 299, 7, 11, 9, 1, -9 },
  { 309, 6, 9, 7, 1, -9 },
  { 316, 6, 9, 6, 0, -9 },
  { 323, 6, 9, 6, 0, -9 },
  { 330, 6, 9, 8, 1, -9 },
  { 337, 7, 9, 7, 0, -9 },
  { 345, 11, 9, 11, 0, -9 },
  { 358, 7, 9, 7, 0, -9 },
  { 366, 7, 9, 7, 0, -9 },
  { 374, 6, 9, 6, 0, -9 },
  { 381, 3, 11, 4, 1, -9 },
  { 386, 5, 9, 5, 0, -9 },
  { 392, 3, 11, 4, 0, -9 },
  { 397, 6, 6, 7, 0, -9 },
  { 402, 5, 1, 5, 0, 1 },
  { 403, 4, 2, 4, 0, -9 },
  { 404, 6, 7, 7, 0, -7 },
  { 410, 6, 9, 7, 1, -9 },
  { 417, 6, 7, 6, 0, -7 },
  { 423, 6, 9, 7, 0, -9 },
  { 430, 6, 7, 7, 0, -7 },
  { 436, 5, 9, 4, 0, -9 },
  { 442, 6, 10, 7, 0, -7 },
  { 450, 6, 9, 7, 1, -9 },
  { 457, 2, 9, 3, 1, -9 },
  { 460, 4, 12, 3, -1, -9 },
  { 466, 6, 9, 7, 1, -9 },
  { 473, 2, 9, 3, 1, -9 },
  { 476, 9, 7, 11, 1, -7 },
  { 484, 6, 7, 7, 1, -7 },
  { 490, 6, 7, 7, 0, -7 },
  { 496, 6, 10, 7, 1, -7 },
  { 504, 6, 10, 7, 0, -7 },
  { 512, 4, 7, 5, 1, -7 },
  { 516, 5, 7, 6, 0, -7 },
  { 521, 5, 8, 5, 0, -8 },
  { 526, 6, 7, 7, 1, -7 },
  { 532, 7, 7, 7, 0, -7 },
  { 539, 10, 7, 10, 0, -7 },
  { 548, 6, 7, 7, 0, -7 },
  { 554, 7, 10, 7, 0, -7 },
  { 563, 5, 7, 5, 0, -7 },
  { 568, 4, 11, 5, 0, -9 },
  { 574, 2, 12, 6, 2, -9 },
  { 577, 4, 11, 5, 0, -9 },
  { 583, 6, 2, 7, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD12PT7B_H_
