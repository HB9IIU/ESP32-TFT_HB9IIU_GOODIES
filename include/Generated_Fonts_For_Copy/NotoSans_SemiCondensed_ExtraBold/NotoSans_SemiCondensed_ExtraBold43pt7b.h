#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xFE, 0x3F, 0xFF,
  0x1F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC,
  0xFC, 0x7E, 0x7C, 0x3F, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0,
  0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xEE, 0x1C, 0xFC, 0xE0, 0x0F, 0xCE, 0x00,
  0xFC, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0E,
  0xFE, 0x00, 0xE7, 0xF0, 0x0E, 0x3F, 0x80, 0xE7, 0xFF, 0x0E, 0x7E, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0xFC, 0x07, 0xC0, 0x07, 0xC7,
  0xC0, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x0F, 0xC7, 0xC1, 0xF8, 0x00,
  0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x3E,
  0x00, 0x0F, 0xC7, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x7C, 0x3E, 0x07, 0xC7,
  0xCF, 0xCF, 0xF8, 0x7E, 0xFC, 0xF9, 0xFF, 0xC7, 0xFF, 0x9F, 0x9F, 0xFC,
  0x3F, 0xF9, 0xF3, 0xFF, 0xE1, 0xFF, 0x3F, 0x3E, 0x3E, 0x0F, 0xC3, 0xE3,
  0xE3, 0xE0, 0x00, 0x7E, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x3F,
  0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x03, 0xF0, 0x3E, 0x3E, 0x00, 0x3E, 0x03,
  0xF7, 0xE0, 0x07, 0xE0, 0x3F, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x0F,
  0xC0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0x07, 0xF0,
  0xFF, 0xFE, 0x3F, 0x87, 0xFB, 0xFC, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F,
  0x0F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F,
  0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7C, 0xF9, 0xF0, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x04, 0x0F, 0x02,
  0x78, 0xF1, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9,
  0xF8, 0x3F, 0x9F, 0xC1, 0xF0, 0xF8, 0x07, 0x0E, 0x00, 0x20, 0x40, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0,
  0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xF7, 0xF0, 0x3F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F,
  0x87, 0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xF8, 0x3F, 0xC3, 0x80, 0xFE, 0x10, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x70, 0x3F,
  0xC2, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0xC0, 0x0F, 0xF7,
  0xE1, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3,
  0xF0, 0x0F, 0xDF, 0xC0, 0x3E, 0x7F, 0x01, 0xF9, 0xFC, 0x0F, 0xC7, 0xF0,
  0x3E, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE2, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x07, 0xEF, 0xFC, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF7, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xF7, 0xE0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F,
  0x87, 0xF1, 0xFE, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0xBF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xF7, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x7F,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F,
  0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFE, 0xFC, 0x1F, 0xE7, 0xE0, 0x08, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE1, 0x03, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xF9, 0xFC, 0xFC, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3,
  0xF9, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8E, 0x07, 0xF9, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x07, 0xFC, 0x3E, 0x3E, 0x0F,
  0xFF, 0x3E, 0x7C, 0x3F, 0xFF, 0x1F, 0x7C, 0x3F, 0xFF, 0x1F, 0xFC, 0x7E,
  0x1F, 0x1F, 0xF8, 0x7C, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F, 0x0F, 0xF8, 0xF8,
  0x1F, 0x0F, 0xF8, 0xF8, 0x1F, 0x0F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8,
  0x3F, 0x1F, 0xF8, 0xF8, 0x3F, 0x1F, 0xF8, 0xF8, 0x3F, 0x1F, 0xF8, 0xFC,
  0x7F, 0x3E, 0xF8, 0x7F, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFC, 0x7C, 0x3F,
  0xE7, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0x07,
  0x0F, 0xF0, 0x04, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x18, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFE, 0x0F, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xF0,
  0x0C, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0xE0, 0x7F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xF0, 0x0F, 0xBF, 0xFD, 0xF8, 0x0F,
  0xBF, 0xFD, 0xF8, 0x1F, 0xBF, 0xFE, 0xF8, 0x1F, 0x3F, 0xFE, 0xFC, 0x1F,
  0x3F, 0xFE, 0xFC, 0x3F, 0x3F, 0xFE, 0xFC, 0x3F, 0x3F, 0xFE, 0x7C, 0x3E,
  0x3F, 0xFE, 0x7E, 0x7E, 0x3F, 0xFE, 0x7E, 0x7E, 0x3F, 0xFE, 0x3E, 0x7C,
  0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x0F, 0xF0,
  0x3F, 0xFE, 0x0F, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x7F, 0x03, 0xFF, 0xDF, 0xC0, 0xFF, 0xF3, 0xF8, 0x3F,
  0xFC, 0xFE, 0x0F, 0xFF, 0x9F, 0xC3, 0xFF, 0xE7, 0xF0, 0xFF, 0xF8, 0xFE,
  0x3F, 0xFE, 0x3F, 0x8F, 0xFF, 0x87, 0xF3, 0xFF, 0xE1, 0xFC, 0xFF, 0xF8,
  0x3F, 0xBF, 0xFE, 0x0F, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xC0, 0xE7, 0xF0, 0x04, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0x8F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0x81,
  0xFC, 0x7F, 0x07, 0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0x7C, 0x1F, 0xC1, 0xF8, 0x3E, 0xFC, 0x3F, 0x83, 0xF8, 0x7D, 0xF8,
  0x7E, 0x07, 0xF1, 0xF9, 0xF1, 0xFC, 0x07, 0xE3, 0xF3, 0xE3, 0xF8, 0x0F,
  0xC7, 0xE7, 0xE7, 0xF0, 0x1F, 0x8F, 0x8F, 0xCF, 0xC0, 0x3F, 0xBF, 0x1F,
  0x9F, 0x80, 0x3F, 0x7E, 0x1F, 0x7F, 0x00, 0x7E, 0xFC, 0x3E, 0xFE, 0x00,
  0xFD, 0xF0, 0x7D, 0xFC, 0x01, 0xFB, 0xE0, 0xFF, 0xF0, 0x03, 0xF7, 0xC0,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x3F, 0xCF, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1,
  0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF8, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80,
  0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF9, 0xF8,
  0x01, 0xF7, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0x87, 0xF8, 0x20, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xF1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xDF, 0xC3, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFE, 0xFC,
  0xFF, 0xE7, 0xE1, 0xFC, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF1, 0xF0, 0x3F, 0xBF, 0xE1, 0xFB, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xBF, 0xC1, 0xFD, 0xFF, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xBF, 0xF0, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF8, 0x13,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x27, 0xFC, 0x79, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x1F, 0xC7, 0xFC, 0xFE, 0x7F, 0xF7, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFE, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0x3F, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x02, 0x7F, 0x80, 0x67, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE1, 0xF8, 0xFF, 0x8F, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xE3,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFD, 0xFC, 0x7F, 0xEF, 0xE1,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x80, 0x0F,
  0xE7, 0xE1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0xFC, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xF9, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE,
  0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F,
  0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x7F, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0x83, 0xF8,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x7F, 0xE3, 0xFF, 0x3F, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x0F, 0x8F, 0xFC, 0xFD, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xEF, 0xF9, 0xFC, 0x1F, 0xDF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFB, 0xF8, 0x3F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xF8, 0x3E, 0x07, 0xE7,
  0xFC, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB,
  0xFC, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xE7, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7E, 0xFF, 0xE3, 0xF3, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE1, 0xF8, 0xFF, 0x9F, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0xDF, 0xE3, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFD, 0xFC,
  0x7F, 0xEF, 0xE1, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0x3F, 0xF1, 0xFF,
  0xF7, 0xF7, 0xEF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x1E, 0xFC, 0x02, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xF1, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xBF, 0x3F, 0xF9, 0xF1, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE,
  0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xEF, 0xC0, 0x7F, 0x81, 0xF9, 0xFC, 0x1F, 0xF0, 0x3F, 0x3F, 0x83,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xC1, 0xFC, 0x7E, 0x0F, 0xF8, 0x3F, 0x0F,
  0xE3, 0xEF, 0x87, 0xE1, 0xFC, 0x7D, 0xF1, 0xFC, 0x3F, 0x8F, 0xBE, 0x3F,
  0x83, 0xF1, 0xF7, 0xC7, 0xE0, 0x7E, 0x7E, 0xFC, 0xFC, 0x0F, 0xEF, 0x8F,
  0xBF, 0x81, 0xFD, 0xF1, 0xF7, 0xF0, 0x1F, 0xBE, 0x3E, 0xFC, 0x03, 0xF7,
  0xC7, 0xDF, 0x80, 0x7E, 0xF8, 0xFB, 0xF0, 0x0F, 0xDE, 0x0F, 0x7E, 0x00,
  0xFB, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0xFF, 0x03, 0xF8,
  0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xFC, 0xFE, 0x03,
  0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x9F,
  0xC0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F,
  0x7F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x02,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF8,
  0xFF, 0xC3, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x17, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xC8,
  0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 17, 11, 21, 2, -31 },
  { 57, 24, 31, 26, 1, -31 },
  { 150, 20, 36, 23, 2, -33 },
  { 240, 36, 31, 38, 1, -31 },
  { 380, 30, 31, 30, 1, -31 },
  { 497, 7, 11, 11, 2, -31 },
  { 507, 12, 38, 15, 2, -31 },
  { 564, 12, 38, 15, 1, -31 },
  { 621, 20, 20, 22, 1, -33 },
  { 671, 20, 21, 23, 2, -26 },
  { 724, 9, 12, 12, 1, -6 },
  { 738, 12, 5, 14, 1, -14 },
  { 746, 8, 8, 12, 2, -7 },
  { 754, 18, 31, 18, 0, -31 },
  { 824, 21, 31, 23, 1, -31 },
  { 906, 16, 31, 23, 2, -31 },
  { 968, 21, 31, 23, 1, -31 },
  { 1050, 21, 31, 23, 1, -31 },
  { 1132, 22, 31, 23, 1, -31 },
  { 1218, 19, 31, 23, 2, -31 },
  { 1292, 21, 31, 23, 1, -31 },
  { 1374, 21, 31, 23, 1, -31 },
  { 1456, 21, 31, 23, 1, -31 },
  { 1538, 21, 31, 23, 1, -31 },
  { 1620, 8, 25, 12, 2, -24 },
  { 1645, 9, 30, 12, 1, -24 },
  { 1679, 20, 23, 23, 2, -27 },
  { 1737, 20, 14, 23, 2, -22 },
  { 1772, 20, 23, 23, 2, -27 },
  { 1830, 19, 32, 19, 0, -31 },
  { 1906, 32, 34, 36, 2, -31 },
  { 2042, 28, 31, 28, 0, -31 },
  { 2151, 22, 31, 27, 3, -31 },
  { 2237, 22, 31, 25, 2, -31 },
  { 2323, 24, 31, 29, 3, -31 },
  { 2416, 17, 31, 22, 3, -31 },
  { 2482, 17, 31, 22, 3, -31 },
  { 2548, 24, 31, 29, 2, -31 },
  { 2641, 24, 31, 30, 3, -31 },
  { 2734, 14, 31, 16, 1, -31 },
  { 2789, 13, 40, 14, -3, -31 },
  { 2854, 24, 31, 27, 3, -31 },
  { 2947, 18, 31, 22, 3, -31 },
  { 3017, 32, 31, 38, 3, -31 },
  { 3141, 26, 31, 33, 3, -31 },
  { 3242, 27, 31, 31, 2, -31 },
  { 3347, 20, 31, 25, 3, -31 },
  { 3425, 27, 38, 31, 2, -31 },
  { 3554, 24, 31, 26, 3, -31 },
  { 3647, 19, 31, 22, 2, -31 },
  { 3721, 21, 31, 23, 1, -31 },
  { 3803, 24, 31, 30, 3, -31 },
  { 3896, 27, 31, 27, 0, -31 },
  { 4001, 39, 31, 39, 0, -31 },
  { 4153, 27, 31, 27, 0, -31 },
  { 4258, 25, 31, 25, 0, -31 },
  { 4355, 21, 31, 23, 1, -31 },
  { 4437, 10, 38, 14, 3, -31 },
  { 4485, 18, 31, 18, 0, -31 },
  { 4555, 10, 38, 14, 1, -31 },
  { 4603, 23, 20, 23, 0, -31 },
  { 4661, 20, 4, 19, 0, 3 },
  { 4671, 12, 7, 16, 2, -33 },
  { 4682, 21, 24, 24, 1, -24 },
  { 4745, 21, 33, 25, 3, -33 },
  { 4832, 18, 24, 21, 2, -24 },
  { 4886, 21, 33, 25, 2, -33 },
  { 4973, 20, 24, 24, 2, -24 },
  { 5033, 16, 33, 16, 1, -33 },
  { 5099, 21, 34, 25, 2, -24 },
  { 5189, 20, 33, 26, 3, -33 },
  { 5272, 7, 33, 12, 3, -33 },
  { 5301, 12, 43, 12, -2, -33 },
  { 5366, 22, 33, 25, 3, -33 },
  { 5457, 7, 33, 12, 3, -33 },
  { 5486, 33, 24, 39, 3, -24 },
  { 5585, 20, 24, 26, 3, -24 },
  { 5645, 21, 24, 25, 2, -24 },
  { 5708, 21, 34, 25, 3, -24 },
  { 5798, 21, 34, 25, 2, -24 },
  { 5888, 15, 24, 18, 3, -24 },
  { 5933, 16, 24, 20, 2, -24 },
  { 5981, 15, 29, 18, 1, -29 },
  { 6036, 20, 24, 26, 3, -24 },
  { 6096, 23, 24, 23, 0, -24 },
  { 6165, 35, 24, 35, 0, -24 },
  { 6270, 23, 24, 23, 0, -24 },
  { 6339, 23, 34, 23, 0, -24 },
  { 6437, 17, 24, 20, 1, -24 },
  { 6488, 14, 38, 17, 1, -31 },
  { 6555, 5, 43, 21, 8, -33 },
  { 6582, 15, 38, 17, 1, -31 },
  { 6654, 20, 8, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD43PT7B_H_
