#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xDF, 0xE7, 0xF8, 0xFC, 0x0C, 0x00,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0xFE, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xBD, 0xFC, 0xFF, 0x3C, 0x18, 0xFE, 0x3C, 0x00, 0xFE, 0x3C, 0x00,
  0xFF, 0x3C, 0x00, 0xFF, 0xBC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE,
  0x00, 0x3C, 0xFF, 0x00, 0x3C, 0xFF, 0x80, 0x3C, 0xFF, 0xE0, 0x3C, 0xFE,
  0xFE, 0x3F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0,
  0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x3F,
  0x80, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x81, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x7E,
  0x1F, 0xE0, 0x7E, 0x3F, 0x9F, 0xC7, 0xFE, 0x0F, 0xEF, 0xE3, 0xF1, 0xFF,
  0xE0, 0xFF, 0xFC, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0x1F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0x1F, 0xF0, 0xFC, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x01, 0xFC,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xE0,
  0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0x87, 0xFD, 0xFF, 0xBF, 0xE3, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x60, 0x7E,
  0x06, 0x7C, 0x7E, 0x3E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xC1, 0xE0, 0x01, 0x81,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x8F, 0xF3, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x1F, 0xE7, 0xFB,
  0xFF, 0xFF, 0xDF, 0xE7, 0xF8, 0xFC, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x83,
  0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xEF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7F, 0x9F, 0xCF, 0xF1, 0xE1, 0xFE, 0x18,
  0x3F, 0xC2, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0x01, 0xFF, 0x06, 0x00,
  0xFF, 0x82, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E,
  0x07, 0xFC, 0x18, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0xC0, 0x07, 0xFE, 0xFC, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xEF, 0xF0, 0x03,
  0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7E, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0,
  0x0F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x80, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0xFF, 0x3F,
  0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFE, 0x7F, 0xE7,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3,
  0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0x1F, 0xFE,
  0xFE, 0x0F, 0xF8, 0xFE, 0x00, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x20, 0x3F,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x1F,
  0xE7, 0xFB, 0xFF, 0x7F, 0xDF, 0xE7, 0xF8, 0xFC, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x1F, 0xE7, 0xF9, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFC, 0x0C, 0x00, 0x3F,
  0x1F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFC, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE3, 0xFC, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0x18,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7E,
  0x03, 0xFF, 0xC7, 0xE1, 0xFC, 0x1F, 0xFF, 0xC7, 0xE3, 0xF0, 0x7F, 0xFF,
  0x8F, 0xCF, 0xE1, 0xFF, 0xFF, 0x1F, 0x9F, 0x87, 0xF8, 0x7E, 0x1F, 0x3F,
  0x0F, 0xE0, 0xFC, 0x3F, 0x7E, 0x3F, 0x81, 0xF8, 0x7F, 0xF8, 0x7E, 0x03,
  0xF0, 0xFF, 0xF0, 0xFC, 0x07, 0xE1, 0xFF, 0xE1, 0xF8, 0x1F, 0x83, 0xFF,
  0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0x7E, 0x0F, 0xFF, 0x0F, 0xC0,
  0xFC, 0x1F, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0xFC, 0x3F, 0x03, 0xF0, 0xFD,
  0xF8, 0x7F, 0x0F, 0xF1, 0xF3, 0xF0, 0x7F, 0xFF, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xE0, 0xFF, 0xF7, 0xFF, 0x0F, 0xC0, 0xFF, 0xC7, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38,
  0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F,
  0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x1F, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xF7, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x1F,
  0xF8, 0x03, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x04, 0x7F, 0xF0,
  0x07, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFC, 0xFF, 0x00, 0xFF,
  0xCF, 0xF0, 0x07, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFE,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7C, 0x3F,
  0xF0, 0x00, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xE0, 0x0F,
  0xF3, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xCF, 0xF0,
  0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x8F, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFE,
  0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xFF,
  0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xFF, 0xBF, 0x80,
  0x7E, 0xFF, 0xFE, 0xFE, 0x01, 0xFB, 0xFF, 0xFB, 0xF8, 0x0F, 0xEF, 0xFF,
  0xE7, 0xE0, 0x3F, 0x3F, 0xFF, 0x9F, 0xC0, 0xFC, 0xFF, 0xFE, 0x7F, 0x07,
  0xF3, 0xFF, 0xF8, 0xFC, 0x1F, 0xCF, 0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0xFF,
  0x8F, 0xE3, 0xF8, 0xFF, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7E, 0x3F,
  0x0F, 0xFF, 0xE1, 0xFC, 0xFC, 0x3F, 0xFF, 0x87, 0xF7, 0xF0, 0xFF, 0xFE,
  0x0F, 0xDF, 0x83, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0xEF, 0xF8, 0x1F, 0xFF, 0xCF,
  0xF0, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0x1F, 0xE0, 0xFF, 0xFE, 0x3F,
  0xE1, 0xFF, 0xFC, 0x3F, 0xC3, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xF0, 0x7F,
  0xCF, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0x81, 0xFF,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0,
  0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F,
  0xEF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x3F, 0xF0, 0xFC, 0xFF, 0x80, 0x31, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xDF, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xEF, 0xC0,
  0xFF, 0x03, 0xFC, 0x1F, 0xDF, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0xBF, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFC, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF1, 0xF8, 0x7F,
  0x00, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7E, 0x0F, 0xCF, 0xE0,
  0x01, 0xFD, 0xFC, 0x1F, 0x9F, 0xC0, 0x03, 0xFB, 0xF8, 0x3F, 0xFF, 0x80,
  0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0E, 0x03, 0xFE, 0x08, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFE, 0x7F, 0x3F, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0x01, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x40, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF3, 0xFF, 0x87, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xBF, 0xF0, 0x7F,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xF7, 0xFF, 0xC7, 0xF1, 0xFF, 0xC3,
  0xF8, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFE, 0x1E, 0x7F, 0xC0, 0x23, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x0D, 0xFF, 0xC3, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x18, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0xFF, 0xE7, 0xF8, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0xDF, 0xF0, 0x3F,
  0xEF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFD, 0xFE,
  0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xE3, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xF8, 0x7F, 0xF1, 0xFC,
  0x0F, 0xF0, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0xF7, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x02,
  0x7F, 0xE0, 0x0E, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFE, 0x1F, 0xC3, 0xFF, 0x8F, 0xE3, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0,
  0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xE1, 0xFF, 0xCF,
  0xF0, 0x3F, 0xC7, 0xF8, 0x02, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x40, 0x00, 0xFF, 0x38, 0x00, 0xFF, 0x9F, 0xE3, 0xFF, 0xCF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x40, 0x1F, 0xE3, 0xFE, 0x0F, 0xF3, 0xFF, 0xC7, 0xFB,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF1, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xEF, 0xF7, 0xFB, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0xDF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFC,
  0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0x81,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0x80, 0x7F, 0x0F, 0xF8, 0x3F, 0x8F, 0xFF, 0x1F,
  0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x7F,
  0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x7F, 0x0F, 0xF8, 0x3F, 0x8F, 0xFE, 0x1F, 0xEF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFE,
  0xFF, 0xC1, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0x8F, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xDF, 0xFF, 0x1F,
  0xE7, 0xFF, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x18, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xFE, 0x1F, 0xC3, 0xFF, 0x8F, 0xE3, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0, 0xFF,
  0xBF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xE1, 0xFF, 0xCF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x02, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x3F, 0x83, 0xFF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xCF, 0xCF, 0xF0, 0x1C, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x14, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE3, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0x80, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0x9F, 0xC7, 0xFF, 0x8F, 0xE0, 0xFF, 0x87,
  0xF0, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xBF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xF0, 0x1F, 0xEF, 0xF0, 0x1F,
  0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x7F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF7, 0xE1, 0xFE, 0x0F, 0xF1, 0xFB, 0xF0, 0xFF, 0x07, 0xF8, 0xFC,
  0xFC, 0x7F, 0x83, 0xFC, 0x7E, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x3F, 0x3F,
  0xC0, 0x7F, 0x3F, 0x1F, 0x9F, 0xE0, 0x3F, 0xDF, 0x8F, 0xCF, 0xE0, 0x1F,
  0xEF, 0xC3, 0xF7, 0xF0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x03, 0xFB, 0xF0,
  0xFD, 0xFC, 0x01, 0xFD, 0xF0, 0x7F, 0xFC, 0x00, 0xFE, 0xF8, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x01,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 37, 14, 2, -36 },
  { 48, 19, 13, 25, 3, -36 },
  { 79, 29, 36, 31, 1, -36 },
  { 210, 24, 42, 28, 2, -39 },
  { 336, 43, 37, 45, 1, -37 },
  { 535, 34, 38, 36, 2, -37 },
  { 697, 8, 13, 14, 3, -36 },
  { 710, 14, 45, 17, 2, -37 },
  { 789, 14, 45, 17, 1, -37 },
  { 868, 24, 23, 26, 1, -39 },
  { 937, 24, 24, 28, 2, -30 },
  { 1009, 10, 14, 14, 2, -7 },
  { 1027, 14, 7, 16, 1, -17 },
  { 1040, 10, 9, 14, 2, -8 },
  { 1052, 21, 37, 22, 0, -37 },
  { 1150, 24, 38, 28, 2, -37 },
  { 1264, 19, 36, 28, 2, -36 },
  { 1350, 25, 37, 28, 1, -37 },
  { 1466, 24, 38, 28, 2, -37 },
  { 1580, 26, 36, 28, 1, -36 },
  { 1697, 23, 37, 28, 2, -36 },
  { 1804, 24, 38, 28, 2, -37 },
  { 1918, 24, 36, 28, 2, -36 },
  { 2026, 24, 38, 28, 2, -37 },
  { 2140, 24, 38, 28, 2, -37 },
  { 2254, 10, 29, 14, 2, -28 },
  { 2291, 10, 35, 14, 2, -28 },
  { 2335, 24, 27, 28, 2, -32 },
  { 2416, 24, 16, 28, 2, -26 },
  { 2464, 24, 27, 28, 2, -32 },
  { 2545, 22, 38, 23, 0, -37 },
  { 2650, 39, 41, 43, 2, -37 },
  { 2850, 33, 37, 33, 0, -37 },
  { 3003, 25, 36, 32, 4, -36 },
  { 3116, 27, 38, 30, 2, -37 },
  { 3245, 28, 36, 34, 4, -36 },
  { 3371, 20, 36, 26, 4, -36 },
  { 3461, 19, 36, 26, 4, -36 },
  { 3547, 28, 38, 34, 3, -37 },
  { 3680, 28, 36, 36, 4, -36 },
  { 3806, 16, 36, 20, 2, -36 },
  { 3878, 16, 47, 16, -4, -36 },
  { 3972, 28, 36, 32, 4, -36 },
  { 4098, 21, 36, 26, 4, -36 },
  { 4193, 38, 36, 46, 4, -36 },
  { 4364, 31, 36, 39, 4, -36 },
  { 4504, 32, 38, 37, 2, -37 },
  { 4656, 24, 36, 30, 4, -36 },
  { 4764, 33, 46, 37, 2, -37 },
  { 4954, 28, 36, 31, 4, -36 },
  { 5080, 23, 38, 26, 2, -37 },
  { 5190, 25, 36, 27, 1, -36 },
  { 5303, 28, 37, 35, 4, -36 },
  { 5433, 32, 36, 32, 0, -36 },
  { 5577, 47, 36, 47, 0, -36 },
  { 5789, 32, 36, 32, 0, -36 },
  { 5933, 30, 36, 30, 0, -36 },
  { 6068, 25, 36, 27, 1, -36 },
  { 6181, 12, 45, 16, 3, -37 },
  { 6249, 21, 37, 22, 0, -37 },
  { 6347, 12, 45, 16, 1, -37 },
  { 6415, 26, 24, 28, 1, -37 },
  { 6493, 23, 5, 23, 0, 4 },
  { 6508, 15, 8, 19, 2, -39 },
  { 6523, 24, 30, 29, 2, -29 },
  { 6613, 25, 40, 30, 3, -39 },
  { 6738, 21, 30, 25, 2, -29 },
  { 6817, 25, 40, 30, 2, -39 },
  { 6942, 24, 30, 28, 2, -29 },
  { 7032, 19, 39, 19, 1, -39 },
  { 7125, 25, 41, 30, 2, -29 },
  { 7254, 25, 39, 31, 3, -39 },
  { 7376, 9, 39, 15, 3, -39 },
  { 7420, 14, 51, 15, -2, -39 },
  { 7510, 27, 39, 30, 3, -39 },
  { 7642, 8, 39, 15, 3, -39 },
  { 7681, 40, 29, 46, 3, -29 },
  { 7826, 25, 29, 31, 3, -29 },
  { 7917, 26, 30, 30, 2, -29 },
  { 8015, 25, 41, 30, 3, -29 },
  { 8144, 25, 41, 30, 2, -29 },
  { 8273, 18, 29, 22, 3, -29 },
  { 8339, 20, 30, 24, 2, -29 },
  { 8414, 18, 35, 21, 1, -34 },
  { 8493, 25, 29, 31, 3, -28 },
  { 8584, 28, 28, 28, 0, -28 },
  { 8682, 41, 28, 42, 0, -28 },
  { 8826, 28, 28, 28, 0, -28 },
  { 8924, 28, 40, 28, 0, -28 },
  { 9064, 21, 28, 23, 1, -28 },
  { 9138, 17, 45, 20, 1, -37 },
  { 9234, 6, 51, 25, 10, -39 },
  { 9273, 17, 45, 20, 2, -37 },
  { 9369, 24, 9, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD51PT7B_H_
