#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x00, 0x6F, 0xFF, 0xF7, 0xFB, 0xFC,
  0xEE, 0x76, 0x3B, 0x18, 0x06, 0x70, 0x19, 0xC0, 0xE6, 0x03, 0x98, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x1C, 0xC3, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x19, 0xC0, 0x67, 0x03, 0x98, 0x0E, 0xE0, 0x0C, 0x03, 0xE1, 0xFF,
  0x7F, 0xEE, 0xC9, 0xD8, 0x3F, 0x03, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x06,
  0xF8, 0xDF, 0xFF, 0xBF, 0xF3, 0xF8, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x0F,
  0x83, 0x83, 0xF8, 0x70, 0x77, 0x1C, 0x0C, 0xE3, 0x81, 0x9C, 0xE0, 0x33,
  0x9C, 0x07, 0x77, 0x3C, 0xFE, 0xEF, 0xCF, 0xBB, 0xB8, 0xE7, 0x73, 0x81,
  0xCE, 0x70, 0x39, 0xCE, 0x0E, 0x39, 0xC1, 0xC7, 0x70, 0x70, 0x7E, 0x0E,
  0x07, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xCE, 0x07, 0x9C, 0x0F,
  0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x1E, 0xFE, 0x7B, 0xDE, 0xF7, 0x9F,
  0xCF, 0x1F, 0x9E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xBE, 0xFF, 0xF7,
  0x66, 0x1C, 0xF3, 0x9E, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F,
  0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x0F,
  0x1E, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x8F, 0x00,
  0x1C, 0x07, 0x00, 0xC2, 0x31, 0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x77, 0x1C,
  0xE1, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x77, 0xFE, 0xEE, 0xFF, 0xFF, 0xC0,
  0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x00,
  0x0E, 0x07, 0xE1, 0xFE, 0x3D, 0xEF, 0x3D, 0xE3, 0xBC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xEF, 0x1D, 0xE7, 0x9F, 0xF3, 0xFC, 0x3F, 0x00,
  0x0F, 0x8F, 0xCF, 0xEF, 0xFF, 0x7B, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0E, 0x0F, 0xF3, 0xFF, 0x7F, 0xE4,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x1F, 0xF3, 0xFF, 0x3B, 0xE4,
  0x3C, 0x07, 0x80, 0xE1, 0xFC, 0x3E, 0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x1F,
  0x07, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC,
  0x0F, 0xC1, 0xDC, 0x1D, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70,
  0x1F, 0x8F, 0xFB, 0xFF, 0x67, 0xC0, 0xF0, 0x1C, 0x07, 0x83, 0xFF, 0xFF,
  0xFB, 0xFC, 0x03, 0x83, 0xF8, 0xFF, 0x3E, 0x27, 0x01, 0xE0, 0x39, 0xC7,
  0x7E, 0xFF, 0xDE, 0x7B, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0x9F, 0xF3, 0xFC,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x0E, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xE3, 0x9F, 0xF1, 0xFC, 0x3F,
  0x0F, 0xF3, 0xCF, 0x70, 0xFE, 0x1F, 0xC3, 0xFF, 0xF3, 0xFE, 0x3F, 0x80,
  0x0C, 0x07, 0xE1, 0xFE, 0x7D, 0xEF, 0x1D, 0xC3, 0xB8, 0x7F, 0x8F, 0xFF,
  0xFF, 0xFD, 0xF7, 0x00, 0xE0, 0x1C, 0x07, 0x9F, 0xE3, 0xF8, 0x7E, 0x00,
  0x6F, 0xF7, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0x00, 0x00,
  0x77, 0xFE, 0xEE, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xE1, 0xE0, 0x3E,
  0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC1, 0xF8, 0xFC, 0xFE, 0x1F, 0x03, 0x00, 0x40, 0x00,
  0x1E, 0x1F, 0xEF, 0xFD, 0xCF, 0x43, 0xC0, 0xF0, 0x3C, 0x3E, 0x1F, 0x07,
  0x81, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0, 0xF8, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0xFE, 0x07, 0xFF, 0x87, 0x80, 0xE7, 0x00, 0x33, 0x9F, 0xDD, 0x9F,
  0xE7, 0xCE, 0x73, 0xEE, 0x39, 0xF7, 0x1C, 0xFB, 0x8E, 0x7D, 0xC7, 0x7E,
  0x7F, 0xF7, 0x3E, 0xF9, 0xC0, 0x00, 0xF0, 0x08, 0x3F, 0x3C, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0x77, 0x01, 0xEE,
  0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x78, 0x7F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x0F, 0xFF, 0x9F, 0xFB,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xF7, 0xFC, 0xFF, 0xDC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xF7, 0xF8, 0x03, 0x81, 0xFF, 0x3F, 0xF7,
  0xFE, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC2, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC,
  0xFF, 0xEE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE3, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xFE,
  0xFF, 0x7F, 0xBC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x03, 0xC0, 0x7F,
  0xCF, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE0, 0xF7, 0x87, 0xBE, 0x3C, 0xFF, 0xE7, 0xFF, 0x0F,
  0xF0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xFF, 0xFD, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x8F, 0xBF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0xFE, 0xFC, 0xF8,
  0xF0, 0xFF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xFF, 0x0F,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x71, 0xFF, 0xB8, 0xFF, 0xDC, 0xEF, 0xEE,
  0x77, 0xF3, 0xBB, 0xF9, 0xF9, 0xFC, 0xFC, 0xFE, 0x7E, 0x7F, 0x1E, 0x3F,
  0x8F, 0x1F, 0xC7, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE,
  0x3F, 0xB8, 0xFE, 0xF3, 0xF9, 0xEF, 0xE7, 0xBF, 0x8F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0x07, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81, 0xE7, 0x83, 0xCF, 0x8F, 0x8F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0x9F, 0xFB, 0xFF, 0x71, 0xEE, 0x1F, 0xC3,
  0xF8, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0x83, 0xDF,
  0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81,
  0xE7, 0x83, 0xCF, 0x8F, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0x8F, 0xFC, 0xFF, 0xCE, 0x1E,
  0xE1, 0xEE, 0x1E, 0xE3, 0xCF, 0xFC, 0xFF, 0x0F, 0xF0, 0xE7, 0x8E, 0x3C,
  0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0x0E, 0x0F, 0xF7, 0xFF, 0xFE, 0xF0,
  0xBC, 0x0F, 0x81, 0xF8, 0x7F, 0x07, 0xE0, 0x7C, 0x0F, 0x03, 0xF0, 0xFF,
  0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFE, 0x7F, 0xE3, 0xF8, 0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x78,
  0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xF0, 0x7B, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0xF0, 0x70, 0x7F, 0x87,
  0xC3, 0xDC, 0x3E, 0x1C, 0xF1, 0xF0, 0xE7, 0x8F, 0x8F, 0x3C, 0xEE, 0x78,
  0xE7, 0x73, 0x87, 0x3B, 0x9C, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x01,
  0xE0, 0xF0, 0xF8, 0x7D, 0xE1, 0xE3, 0xCF, 0x07, 0x3C, 0x1F, 0xE0, 0x3F,
  0x80, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xBC, 0x3C,
  0xF1, 0xF1, 0xE7, 0x87, 0xBC, 0x0F, 0xF0, 0x7D, 0xE1, 0xE7, 0x8F, 0x0F,
  0x3C, 0x3D, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xFF, 0xFE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0x83, 0x9C, 0x38, 0xC7, 0x0E,
  0x70, 0x6E, 0x07, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0xC7, 0x1F, 0x0F, 0xF9,
  0xFF, 0x10, 0xE0, 0x1C, 0x7F, 0xDF, 0xFF, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF7, 0xCE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x8F, 0xFC,
  0xFF, 0xEF, 0x9E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E,
  0xFF, 0xEF, 0xFC, 0xF7, 0xC0, 0x0F, 0x0F, 0xF7, 0xFB, 0xE2, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x27, 0xF9, 0xFE, 0x1F, 0x80, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF1, 0xDE, 0xFD, 0xDF, 0xFF, 0xCF, 0xF1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xDF, 0xFB, 0xFF, 0x3E, 0xE0, 0x1F, 0x07,
  0xF1, 0xFF, 0x78, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x05,
  0xFF, 0x3F, 0xE1, 0xFC, 0x06, 0x0F, 0xCF, 0xE7, 0x93, 0xC1, 0xFB, 0xFD,
  0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x00, 0x1C, 0xEF, 0xDD, 0xFF, 0xFC, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3D, 0xFF, 0xBF, 0x73, 0xDE, 0x03, 0xC0, 0x7B, 0xBF, 0x7F,
  0xCF, 0xF0, 0x20, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x8F,
  0xFE, 0xFF, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x6F, 0xF7, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x18, 0xF3, 0xC7, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0x90, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x3C, 0xE3, 0xCE, 0x78, 0xEF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xF7, 0x8E, 0x78, 0xE3, 0xCE, 0x1E, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x87, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xCF, 0xF1, 0xF1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F,
  0xC3, 0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xF0,
  0xE1, 0xC0, 0xE3, 0x8F, 0xFE, 0xFF, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F, 0x07,
  0xF9, 0xFF, 0x78, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3D,
  0xFF, 0x9F, 0xE1, 0xF8, 0xF3, 0x8F, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xEF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E, 0xFF, 0xEF, 0xFC, 0xF7, 0xCF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0xEF, 0xDD,
  0xFF, 0xFC, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3D, 0xFF,
  0xBF, 0x73, 0xDE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE3, 0xF7, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x3E, 0x3F, 0xFF, 0xDC, 0x2F, 0x07, 0xE1, 0xFC, 0x7F, 0x07, 0xC3,
  0xFF, 0xFF, 0xEF, 0xE0, 0x1C, 0x0E, 0x0F, 0xEF, 0xFF, 0xF9, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xF9, 0xFC, 0x7E, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3D, 0xFF,
  0xBF, 0xF3, 0xEE, 0xF0, 0x7F, 0x0F, 0x70, 0xF7, 0x8E, 0x79, 0xE3, 0x9E,
  0x3D, 0xC3, 0xDC, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF1,
  0xE1, 0xFE, 0x3E, 0x39, 0xC7, 0xC7, 0x3C, 0xF9, 0xE7, 0xBB, 0x3C, 0x77,
  0x77, 0x0E, 0xEE, 0xE1, 0xDD, 0xFC, 0x3B, 0x3F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0xF0, 0xF7, 0x8F, 0x39, 0xE3, 0xDC,
  0x1F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0xFC, 0x39, 0xE7, 0x8F,
  0xF0, 0xF0, 0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0x8E, 0x38, 0xE3, 0x9E, 0x3D,
  0xC1, 0xDC, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0,
  0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0x0F,
  0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC, 0xF0, 0xFC, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0xF0, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3F, 0x0F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF0,
  0xE0, 0x78, 0x3F, 0xFF, 0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 14, 16, 14, 0, -16 },
  { 44, 11, 18, 12, 1, -17 },
  { 69, 19, 17, 20, 1, -17 },
  { 110, 15, 17, 16, 1, -17 },
  { 142, 4, 6, 6, 1, -16 },
  { 145, 6, 21, 8, 1, -17 },
  { 161, 7, 21, 8, 0, -17 },
  { 180, 10, 11, 12, 1, -18 },
  { 194, 11, 11, 12, 1, -14 },
  { 210, 4, 6, 6, 1, -3 },
  { 213, 6, 3, 7, 1, -8 },
  { 216, 4, 4, 6, 1, -4 },
  { 218, 10, 17, 10, 0, -17 },
  { 240, 11, 17, 12, 1, -17 },
  { 264, 9, 16, 12, 1, -16 },
  { 282, 11, 17, 12, 1, -17 },
  { 306, 11, 17, 12, 1, -17 },
  { 330, 12, 16, 12, 0, -16 },
  { 354, 10, 16, 12, 1, -16 },
  { 374, 11, 17, 12, 1, -17 },
  { 398, 11, 16, 12, 1, -16 },
  { 420, 11, 17, 12, 1, -17 },
  { 444, 11, 17, 12, 1, -17 },
  { 468, 4, 13, 6, 1, -13 },
  { 475, 4, 16, 7, 1, -13 },
  { 483, 11, 12, 12, 1, -14 },
  { 500, 11, 8, 12, 1, -12 },
  { 511, 11, 12, 12, 1, -14 },
  { 528, 10, 17, 10, 0, -17 },
  { 550, 17, 19, 19, 1, -17 },
  { 591, 15, 16, 15, 0, -16 },
  { 621, 11, 16, 14, 2, -16 },
  { 643, 12, 17, 14, 1, -17 },
  { 669, 12, 16, 16, 2, -16 },
  { 693, 9, 16, 12, 2, -16 },
  { 711, 9, 16, 12, 2, -16 },
  { 729, 13, 17, 16, 1, -17 },
  { 757, 12, 16, 16, 2, -16 },
  { 781, 7, 16, 9, 1, -16 },
  { 795, 8, 21, 7, -2, -16 },
  { 816, 12, 16, 14, 2, -16 },
  { 840, 9, 16, 12, 2, -16 },
  { 858, 17, 16, 21, 2, -16 },
  { 892, 14, 16, 17, 2, -16 },
  { 920, 15, 17, 17, 1, -17 },
  { 952, 11, 16, 13, 2, -16 },
  { 974, 15, 21, 17, 1, -17 },
  { 1014, 12, 16, 14, 2, -16 },
  { 1038, 10, 17, 12, 1, -17 },
  { 1060, 12, 16, 12, 0, -16 },
  { 1084, 12, 16, 16, 2, -16 },
  { 1108, 14, 16, 14, 0, -16 },
  { 1136, 21, 16, 21, 0, -16 },
  { 1178, 14, 16, 14, 0, -16 },
  { 1206, 14, 16, 14, 0, -16 },
  { 1234, 11, 16, 12, 1, -16 },
  { 1256, 6, 21, 7, 1, -17 },
  { 1272, 10, 17, 10, 0, -17 },
  { 1294, 5, 21, 7, 1, -17 },
  { 1308, 12, 10, 13, 0, -16 },
  { 1323, 10, 2, 10, 0, 2 },
  { 1326, 6, 4, 8, 1, -18 },
  { 1329, 11, 13, 13, 1, -13 },
  { 1347, 12, 17, 14, 1, -17 },
  { 1373, 10, 13, 11, 1, -13 },
  { 1390, 11, 17, 14, 1, -17 },
  { 1414, 11, 13, 13, 1, -13 },
  { 1432, 9, 18, 8, 0, -18 },
  { 1453, 11, 19, 14, 1, -13 },
  { 1480, 12, 17, 14, 1, -17 },
  { 1506, 4, 18, 7, 1, -18 },
  { 1515, 6, 24, 7, -1, -18 },
  { 1533, 12, 17, 14, 2, -17 },
  { 1559, 4, 17, 7, 1, -17 },
  { 1568, 18, 13, 21, 1, -13 },
  { 1598, 12, 13, 14, 1, -13 },
  { 1618, 11, 13, 13, 1, -13 },
  { 1636, 12, 19, 14, 1, -13 },
  { 1665, 11, 19, 14, 1, -13 },
  { 1692, 8, 13, 10, 1, -13 },
  { 1705, 9, 13, 11, 1, -13 },
  { 1720, 9, 15, 9, 0, -15 },
  { 1737, 11, 13, 14, 1, -13 },
  { 1755, 12, 13, 13, 0, -13 },
  { 1775, 19, 13, 19, 0, -13 },
  { 1806, 12, 13, 13, 0, -13 },
  { 1826, 12, 19, 13, 0, -13 },
  { 1855, 9, 13, 10, 1, -13 },
  { 1870, 8, 21, 9, 0, -17 },
  { 1891, 3, 23, 11, 4, -18 },
  { 1900, 8, 21, 9, 1, -17 },
  { 1921, 11, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD23PT7B_H_
