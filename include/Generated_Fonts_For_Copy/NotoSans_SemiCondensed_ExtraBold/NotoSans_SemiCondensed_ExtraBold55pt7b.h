#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE1, 0xFE, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE7, 0xF0, 0x30, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFF, 0x78, 0xF8, 0xFF, 0x1E, 0x06, 0x3F, 0xC7, 0x80, 0x0F, 0xF1, 0xE0,
  0x03, 0xFE, 0x78, 0x00, 0xFF, 0xDE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7B, 0xFE, 0x00, 0x1E, 0x7F, 0xC0, 0x07,
  0x8F, 0xF8, 0x01, 0xE3, 0xFF, 0x80, 0x79, 0xFF, 0xFC, 0x1E, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xC3, 0xF0, 0x7F, 0x01, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0x07, 0xF1,
  0xFC, 0x7E, 0x3F, 0xFE, 0x0F, 0xFF, 0xF3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0x1F, 0xFF, 0xE0, 0xFF, 0xF1,
  0xF8, 0xFE, 0x3F, 0x81, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x01, 0xF0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x0F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF,
  0xC7, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x04, 0x03, 0xF0, 0x09, 0xE0, 0xFC,
  0x1E, 0x7F, 0x3F, 0x3F, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7E,
  0x0F, 0xC0, 0x0F, 0x03, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x03, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9,
  0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF9, 0xFF, 0x7F, 0x1F, 0xF3, 0xE1, 0xFF, 0x1C, 0x1F, 0xF0, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0x83, 0xFF, 0x8F, 0x80, 0x7F, 0xE1, 0xC0, 0x0F, 0xF8, 0x20,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1E,
  0x01, 0xFF, 0x06, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFB, 0x00, 0x07, 0xFE, 0xF0, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xDF, 0xF0,
  0x03, 0xF9, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0xFE,
  0x1F, 0xF0, 0x0F, 0xE1, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x18, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x1C, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x7E, 0x03, 0xFC, 0x7F, 0xE0, 0xFF, 0x3F, 0xFC, 0x3F,
  0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFE,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F,
  0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF,
  0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0,
  0x7F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFB, 0xFC, 0x7F, 0xFE, 0xFE, 0x0F, 0xFF, 0x7F,
  0x81, 0xFF, 0x1F, 0xE0, 0x07, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x7F, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xF0, 0x30, 0x0E, 0x07, 0xF1,
  0xFF, 0x3F, 0xE7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0xC3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE7,
  0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0x10, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x70, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0xFC, 0x1F, 0x81, 0xFF,
  0xFE, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x87, 0xE3, 0xF0, 0x7F, 0xFF, 0xE1,
  0xF9, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xF0, 0x7E, 0x0F, 0xDF,
  0x87, 0xF8, 0x1F, 0x83, 0xF7, 0xE1, 0xFC, 0x07, 0xE0, 0xFD, 0xF8, 0x7F,
  0x01, 0xF8, 0x3F, 0xFE, 0x1F, 0x80, 0xFE, 0x0F, 0xFF, 0x87, 0xE0, 0x3F,
  0x83, 0xFF, 0xE1, 0xF8, 0x0F, 0xE0, 0xFF, 0xF8, 0x7E, 0x03, 0xF8, 0x3F,
  0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xFF, 0x87, 0xE0, 0x3F, 0x87, 0xEF, 0xE1,
  0xFC, 0x1F, 0xE1, 0xFB, 0xF8, 0x7F, 0x07, 0xF8, 0xFE, 0x7E, 0x1F, 0xF7,
  0xFF, 0x7F, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFD, 0xFF,
  0xE1, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0x81, 0xFF, 0x0F, 0xF8, 0x0F,
  0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0x7F,
  0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80,
  0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xC3, 0xFF, 0x80, 0x08, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x0C, 0x3F, 0xFE, 0x07, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x02, 0xA0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xF3, 0xFE, 0x00, 0xFF, 0xEF,
  0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE,
  0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x00,
  0xF0, 0xFF, 0xE0, 0x00, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0x00, 0x3F, 0xCF,
  0xFE, 0x00, 0xFF, 0x3F, 0xFE, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF,
  0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xE3, 0xFE,
  0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81,
  0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7,
  0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F,
  0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFB, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xEF, 0xE0, 0x0F,
  0xEF, 0xFF, 0xF7, 0xF0, 0x07, 0xF7, 0xFF, 0xFB, 0xF8, 0x03, 0xFB, 0xFF,
  0xFD, 0xFE, 0x03, 0xF9, 0xFF, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0xFF, 0x9F, 0xC0, 0xFE, 0x3F, 0xFF, 0xCF, 0xF0, 0x7F,
  0x3F, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0xFF,
  0xF8, 0xFF, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0x87, 0xFB, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFD, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF7, 0xFC,
  0x07, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xC7, 0xFF, 0xF8,
  0x3F, 0xF3, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF,
  0x01, 0xFF, 0x7F, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3,
  0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xE0, 0x7C, 0x3F, 0xE0, 0x06, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFD,
  0xF0, 0x03, 0xFE, 0xFF, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0x28, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xF7, 0xFE, 0x01, 0xFF, 0x9F, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xA0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFE, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x3F, 0x83, 0xFE, 0x03, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF3, 0xFC, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFC, 0x7F, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x1F, 0xC7, 0xFC, 0x01,
  0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xE1, 0xFC, 0x7F, 0x80,
  0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFE, 0x0F, 0xEF, 0xF8,
  0x00, 0xFF, 0x7F, 0x83, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0xFE, 0xFF,
  0x00, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xEF,
  0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1E, 0x07, 0xFE, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF,
  0x3F, 0xC7, 0xFF, 0x87, 0xF0, 0xFF, 0xC1, 0xFC, 0x02, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x0F, 0x00, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xFF, 0x0F, 0xF7, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F,
  0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC,
  0x3F, 0x87, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x7F, 0xF0, 0x18, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0x3F, 0xF8, 0x0E, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7C, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F,
  0xFF, 0x7F, 0xC3, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFC,
  0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x81,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF7, 0xF8, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x06, 0x3F,
  0xF8, 0x0F, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0x84, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFC, 0x1F,
  0xFE, 0x7F, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8,
  0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x90, 0x00, 0x3F, 0xE3, 0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0x00,
  0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xFF, 0x8F, 0xF7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE0, 0x01, 0xF8, 0x07, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x47,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x1F, 0xF8, 0xFF,
  0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF7, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xEF, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF,
  0x8F, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xE7,
  0xFF, 0xE3, 0xFF, 0xF3, 0xF9, 0xFF, 0xFD, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x87,
  0xFE, 0x0F, 0xE3, 0xFF, 0xE3, 0xF9, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC,
  0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x87, 0xFE, 0x0F, 0xE3,
  0xFF, 0xC3, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0x7F, 0xFE, 0x3F, 0xCF, 0xFF, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x04, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xE3, 0xFC, 0x1F, 0xFE,
  0x7F, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8,
  0x03, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDF, 0x81,
  0xFF, 0xF8, 0xFF, 0x7F, 0x3F, 0xEF, 0xE7, 0xFD, 0xFD, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xE0, 0x38, 0xFF, 0x80, 0x23, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF8, 0x01, 0xFE, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0x14, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x10, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0xEF, 0xF0, 0xFF, 0xF8,
  0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF7, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x3F,
  0xC0, 0x7F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF, 0x81, 0xFE, 0x3F, 0xE0,
  0xFF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xDF, 0x83, 0xFC, 0x1F, 0xE0, 0xFD,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xDF, 0x83, 0xFC, 0x1F, 0xF1, 0xFD, 0xFC,
  0x7F, 0xC1, 0xFF, 0x1F, 0x9F, 0xC7, 0xF8, 0x0F, 0xF1, 0xF8, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0x8F, 0xC7, 0xF8, 0x0F, 0xF3, 0xF8, 0xFC, 0x7F, 0x80,
  0xFF, 0xBF, 0x8F, 0xEF, 0xF0, 0x07, 0xFB, 0xF0, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0x07, 0xEF, 0xF0, 0x07, 0xFB, 0xF0, 0x7E, 0xFF, 0x00, 0x3F, 0xBF,
  0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x07,
  0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xCF, 0xFC,
  0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xCF, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x20, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x80, 0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 40, 15, 3, -39 },
  { 51, 21, 14, 27, 3, -39 },
  { 88, 31, 39, 33, 1, -39 },
  { 240, 26, 45, 30, 2, -42 },
  { 387, 46, 40, 48, 1, -40 },
  { 617, 37, 41, 39, 2, -40 },
  { 807, 9, 14, 15, 3, -39 },
  { 823, 15, 49, 19, 2, -40 },
  { 915, 15, 49, 19, 1, -40 },
  { 1007, 26, 25, 28, 1, -42 },
  { 1089, 26, 27, 30, 2, -33 },
  { 1177, 11, 14, 16, 2, -7 },
  { 1197, 15, 7, 17, 1, -18 },
  { 1211, 10, 10, 15, 3, -9 },
  { 1224, 23, 40, 23, 0, -40 },
  { 1339, 26, 41, 30, 2, -40 },
  { 1473, 20, 39, 30, 3, -39 },
  { 1571, 26, 40, 30, 2, -40 },
  { 1701, 26, 41, 30, 2, -40 },
  { 1835, 28, 39, 30, 1, -39 },
  { 1972, 24, 40, 30, 3, -39 },
  { 2092, 26, 41, 30, 2, -40 },
  { 2226, 26, 39, 30, 2, -39 },
  { 2353, 26, 41, 30, 2, -40 },
  { 2487, 26, 41, 30, 2, -40 },
  { 2621, 10, 32, 15, 3, -31 },
  { 2661, 11, 38, 16, 2, -31 },
  { 2714, 26, 28, 30, 2, -34 },
  { 2805, 26, 18, 30, 2, -28 },
  { 2864, 26, 28, 30, 2, -34 },
  { 2955, 24, 41, 25, 0, -40 },
  { 3078, 42, 44, 46, 2, -40 },
  { 3309, 36, 39, 36, 0, -39 },
  { 3485, 28, 39, 34, 4, -39 },
  { 3622, 28, 41, 32, 3, -40 },
  { 3766, 30, 39, 37, 4, -39 },
  { 3913, 21, 39, 28, 4, -39 },
  { 4016, 21, 39, 28, 4, -39 },
  { 4119, 30, 41, 37, 3, -40 },
  { 4273, 30, 39, 39, 4, -39 },
  { 4420, 17, 39, 21, 2, -39 },
  { 4503, 17, 51, 18, -4, -39 },
  { 4612, 30, 39, 34, 4, -39 },
  { 4759, 23, 39, 28, 4, -39 },
  { 4872, 41, 39, 49, 4, -39 },
  { 5072, 33, 39, 42, 4, -39 },
  { 5233, 34, 41, 40, 3, -40 },
  { 5408, 26, 39, 32, 4, -39 },
  { 5535, 34, 49, 40, 3, -40 },
  { 5744, 30, 39, 34, 4, -39 },
  { 5891, 25, 41, 28, 2, -40 },
  { 6020, 27, 39, 29, 1, -39 },
  { 6152, 30, 40, 38, 4, -39 },
  { 6302, 34, 39, 34, 0, -39 },
  { 6468, 50, 39, 50, 0, -39 },
  { 6712, 34, 39, 34, 0, -39 },
  { 6878, 32, 39, 32, 0, -39 },
  { 7034, 27, 39, 30, 1, -39 },
  { 7166, 13, 49, 18, 3, -40 },
  { 7246, 23, 40, 23, 0, -40 },
  { 7361, 13, 49, 18, 1, -40 },
  { 7441, 28, 25, 30, 1, -39 },
  { 7529, 25, 5, 25, 0, 4 },
  { 7545, 16, 9, 20, 2, -42 },
  { 7563, 26, 32, 31, 2, -31 },
  { 7667, 26, 43, 33, 4, -42 },
  { 7807, 23, 32, 27, 2, -31 },
  { 7899, 27, 43, 33, 2, -42 },
  { 8045, 26, 32, 31, 2, -31 },
  { 8149, 21, 42, 20, 1, -42 },
  { 8260, 27, 44, 33, 2, -31 },
  { 8409, 26, 42, 33, 4, -42 },
  { 8546, 10, 42, 16, 3, -42 },
  { 8599, 15, 55, 16, -2, -42 },
  { 8703, 28, 42, 32, 4, -42 },
  { 8850, 8, 42, 16, 4, -42 },
  { 8892, 42, 31, 50, 4, -31 },
  { 9055, 26, 31, 33, 4, -31 },
  { 9156, 28, 32, 32, 2, -31 },
  { 9268, 26, 44, 33, 4, -31 },
  { 9411, 27, 44, 33, 2, -31 },
  { 9560, 19, 31, 23, 4, -31 },
  { 9634, 22, 32, 25, 2, -31 },
  { 9722, 20, 37, 22, 1, -36 },
  { 9815, 27, 31, 33, 3, -30 },
  { 9920, 30, 30, 30, 0, -30 },
  { 10033, 44, 30, 45, 0, -30 },
  { 10198, 30, 30, 30, 0, -30 },
  { 10311, 30, 43, 30, 0, -30 },
  { 10473, 23, 30, 25, 1, -30 },
  { 10560, 19, 49, 22, 1, -40 },
  { 10677, 7, 54, 27, 10, -42 },
  { 10725, 19, 49, 22, 2, -40 },
  { 10842, 26, 9, 30, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD55PT7B_H_
