#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0x9F, 0xBF, 0x7E, 0xFC, 0xF8,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87,
  0x9E, 0x1E, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x3F, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xFB, 0x3C, 0xFC, 0xC1, 0x3F, 0x30, 0x07,
  0xCC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0C, 0xFC, 0x03, 0x3F, 0x40, 0xCF,
  0xDC, 0x33, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x00,
  0x3E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x3E, 0x01, 0xFF, 0x80, 0x78, 0x03, 0xFF, 0x01, 0xF0,
  0x0F, 0x9F, 0x03, 0xC0, 0x1F, 0x3E, 0x0F, 0x80, 0x3E, 0x3C, 0x1E, 0x00,
  0x7C, 0x78, 0x7C, 0x00, 0xF8, 0xF0, 0xF0, 0x01, 0xF1, 0xE3, 0xE0, 0x03,
  0xE3, 0xC7, 0x80, 0x07, 0xCF, 0x9F, 0x3F, 0x07, 0x9F, 0x3C, 0xFF, 0x8F,
  0xFC, 0xFB, 0xFF, 0x0F, 0xF9, 0xE7, 0xFF, 0x1F, 0xE7, 0xCF, 0x3E, 0x0F,
  0x0F, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0xF8, 0x01,
  0xF1, 0xF1, 0xF0, 0x03, 0xC3, 0xE3, 0xC0, 0x0F, 0x87, 0xC7, 0x80, 0x1E,
  0x07, 0x9F, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0xF0, 0x1F, 0xF8, 0x03, 0xE0,
  0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC1, 0xF8, 0xFF, 0xF0, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0xFE, 0x7E, 0x7F,
  0x3F, 0xFF, 0x3F, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0x8F, 0xE0, 0xFF, 0x87,
  0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xBF, 0x83, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFB, 0xE7,
  0x9E, 0x78, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3C,
  0x17, 0xCE, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xF3, 0xF0, 0xF8, 0xF8, 0x1C, 0x70,
  0x04, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x7D, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3E, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xF9,
  0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xBF, 0x79, 0xF9,
  0x8F, 0xC8, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0x9F, 0xE3, 0x81, 0xF8, 0x40, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x0F, 0xE1, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xB0, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xBF, 0x03, 0xEF, 0xC1, 0xF3, 0xF0, 0x78, 0xFC, 0x3E, 0x3F, 0x1F,
  0x0F, 0xC7, 0xC3, 0xF3, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xCF, 0xC3, 0xF7, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFB, 0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0xCF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F,
  0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xCF, 0xEF,
  0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xEF,
  0x83, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0xC3,
  0x3F, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x33,
  0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0x7C, 0x08, 0x7E, 0x7E, 0x7F, 0x7E, 0x7E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0,
  0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7C, 0x7F, 0x20, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0xFC, 0x3C, 0x7C, 0x3F, 0xF3, 0xE7,
  0x87, 0xFF, 0x1E, 0xF8, 0xFF, 0xF1, 0xEF, 0x1F, 0x0F, 0x1E, 0xF1, 0xE0,
  0xF1, 0xFF, 0x1E, 0x0F, 0x1F, 0xF3, 0xE0, 0xF1, 0xFF, 0x3E, 0x0F, 0x1E,
  0xF3, 0xE0, 0xF1, 0xEF, 0x1E, 0x1F, 0x1E, 0xF1, 0xF1, 0xF3, 0xEF, 0x1F,
  0xFF, 0xFC, 0xF0, 0xFF, 0xFF, 0xCF, 0x87, 0xF3, 0xF8, 0x78, 0x1C, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xBF, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x8F, 0x1F, 0xC0, 0x23, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFE, 0xFC, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFE, 0x3E, 0x7F, 0x80, 0x27, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF7,
  0xE0, 0x1F, 0x7F, 0x01, 0xF7, 0xF8, 0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0xFE,
  0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC,
  0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xDF, 0xFB, 0xE0, 0xFB, 0xFF, 0x7C, 0x1F, 0x7F, 0xEF,
  0x83, 0xCF, 0xFC, 0xF0, 0xF9, 0xFF, 0x9F, 0x1F, 0x3F, 0xF3, 0xE3, 0xE7,
  0xFE, 0x7C, 0x78, 0xFF, 0xC7, 0xDF, 0x1F, 0xF8, 0xFB, 0xE3, 0xFF, 0x1F,
  0x78, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F,
  0xF0, 0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x3F,
  0x03, 0xFF, 0x07, 0xE0, 0x7C, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFB, 0xF0, 0x7F, 0xEF, 0xC1, 0xFF, 0x9F, 0x87, 0xFE,
  0x7E, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF9, 0xFF, 0x87, 0xE7, 0xFE, 0x1F,
  0xDF, 0xF8, 0x3F, 0x7F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xC0,
  0x7F, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB,
  0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF, 0xE0, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0xFF,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFC, 0xFF, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x01,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFD, 0xF9,
  0xF8, 0x08, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xFC, 0x03,
  0xE7, 0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8,
  0x1F, 0x9F, 0x81, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0x83, 0xF0, 0xFC, 0x3F,
  0xE0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x0F, 0xC1, 0xF0,
  0xFF, 0xC3, 0xE0, 0x7C, 0x7C, 0xF1, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07,
  0xE7, 0xCF, 0x9F, 0x80, 0xF9, 0xF3, 0xE7, 0xC0, 0x3E, 0x7C, 0xF9, 0xF0,
  0x0F, 0xBE, 0x1E, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x7E, 0x03,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFC,
  0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0x7E, 0x3F, 0x01, 0xFC, 0x7F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x01,
  0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x79, 0xE0,
  0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0x9F,
  0x1F, 0xC7, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xE0, 0xFC, 0xFE, 0x3F,
  0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xDF, 0xF3, 0xE3, 0xF8, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0xDF, 0xE3, 0xBF, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x02,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x1C, 0x3F, 0x1F, 0xCF, 0xCF, 0xFB, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0xFC, 0x7F,
  0x1F, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF7,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x02, 0x7F,
  0x07, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFC,
  0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0x98, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0x00, 0x07, 0xF3, 0xF3, 0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF,
  0x7F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0xE0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0xE0, 0xFC, 0xFF, 0x3F, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7D, 0xFB,
  0xFF, 0xE7, 0xC0, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x07,
  0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F,
  0x8F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xEF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF,
  0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x7E, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07,
  0x07, 0xCF, 0xF8, 0xFF, 0x3F, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0,
  0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0,
  0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC,
  0x1F, 0x80, 0x00, 0x38, 0x3E, 0x3F, 0xCF, 0x9F, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0xBF, 0x8F, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7E, 0x7F, 0x3F, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x38, 0x3E, 0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF7, 0xFC, 0xFC,
  0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xF3, 0xF3, 0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0xC7, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0xDF, 0x81, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0x9F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x0F, 0xF8, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFD, 0xF3, 0xFF, 0x7C, 0x7F, 0x1F, 0xFC,
  0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0xFD, 0xF8, 0x7F, 0x83, 0xE7, 0xE1, 0xFE, 0x1F,
  0x9F, 0x87, 0xF8, 0x7E, 0x3E, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0xC7, 0xC3,
  0xF3, 0xEF, 0x1F, 0x0F, 0xCF, 0x3C, 0xFC, 0x1F, 0x3C, 0xF3, 0xF0, 0x7C,
  0xF3, 0xCF, 0x81, 0xF3, 0xCF, 0xBE, 0x07, 0xFF, 0x1E, 0xF8, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC1,
  0xF9, 0xFC, 0x1F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xDF, 0x81, 0xF9, 0xF8, 0x3F, 0x8F, 0xC3, 0xF0,
  0xFE, 0x7F, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF8, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x3F,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xF8, 0x00, 0x3F,
  0x80, 0x5F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xA0, 0x1F,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 26, 10, 2, -26 },
  { 24, 14, 9, 18, 2, -26 },
  { 40, 21, 26, 22, 1, -26 },
  { 109, 18, 30, 20, 1, -28 },
  { 177, 31, 27, 33, 1, -27 },
  { 282, 25, 27, 26, 1, -27 },
  { 367, 6, 9, 10, 2, -26 },
  { 374, 10, 33, 13, 2, -27 },
  { 416, 10, 33, 13, 1, -27 },
  { 458, 17, 17, 19, 1, -28 },
  { 495, 18, 18, 20, 1, -22 },
  { 536, 7, 10, 10, 1, -5 },
  { 545, 10, 5, 12, 1, -12 },
  { 552, 6, 6, 10, 2, -6 },
  { 557, 15, 27, 16, 0, -27 },
  { 608, 18, 27, 20, 1, -27 },
  { 669, 13, 26, 20, 2, -26 },
  { 712, 18, 27, 20, 1, -27 },
  { 773, 18, 27, 20, 1, -27 },
  { 834, 18, 26, 20, 1, -26 },
  { 893, 16, 26, 20, 2, -26 },
  { 945, 18, 27, 20, 1, -27 },
  { 1006, 18, 26, 20, 1, -26 },
  { 1065, 18, 27, 20, 1, -27 },
  { 1126, 18, 27, 20, 1, -27 },
  { 1187, 6, 21, 10, 2, -21 },
  { 1203, 8, 26, 10, 1, -21 },
  { 1229, 18, 19, 20, 1, -23 },
  { 1272, 18, 12, 20, 1, -19 },
  { 1299, 18, 19, 20, 1, -23 },
  { 1342, 16, 27, 17, 0, -27 },
  { 1396, 28, 30, 31, 2, -27 },
  { 1501, 24, 26, 24, 0, -26 },
  { 1579, 18, 26, 23, 3, -26 },
  { 1638, 19, 27, 22, 2, -27 },
  { 1703, 20, 26, 25, 3, -26 },
  { 1768, 14, 26, 19, 3, -26 },
  { 1814, 14, 26, 19, 3, -26 },
  { 1860, 20, 27, 25, 2, -27 },
  { 1928, 20, 26, 26, 3, -26 },
  { 1993, 12, 26, 14, 1, -26 },
  { 2032, 12, 34, 12, -3, -26 },
  { 2083, 20, 26, 23, 3, -26 },
  { 2148, 15, 26, 19, 3, -26 },
  { 2197, 27, 26, 33, 3, -26 },
  { 2285, 22, 26, 28, 3, -26 },
  { 2357, 23, 27, 27, 2, -27 },
  { 2435, 17, 26, 22, 3, -26 },
  { 2491, 23, 33, 27, 2, -27 },
  { 2586, 20, 26, 23, 3, -26 },
  { 2651, 17, 27, 19, 1, -27 },
  { 2709, 18, 26, 20, 1, -26 },
  { 2768, 20, 26, 26, 3, -26 },
  { 2833, 23, 26, 23, 0, -26 },
  { 2908, 34, 26, 34, 0, -26 },
  { 3019, 23, 26, 23, 0, -26 },
  { 3094, 22, 26, 22, 0, -26 },
  { 3166, 18, 26, 20, 1, -26 },
  { 3225, 9, 33, 12, 2, -27 },
  { 3263, 15, 27, 16, 0, -27 },
  { 3314, 9, 33, 12, 1, -27 },
  { 3352, 20, 17, 20, 0, -26 },
  { 3395, 17, 3, 17, 0, 3 },
  { 3402, 11, 6, 14, 1, -28 },
  { 3411, 18, 21, 21, 1, -21 },
  { 3459, 18, 28, 22, 2, -28 },
  { 3522, 15, 21, 18, 2, -21 },
  { 3562, 18, 28, 22, 2, -28 },
  { 3625, 17, 21, 21, 2, -21 },
  { 3670, 14, 28, 14, 1, -28 },
  { 3719, 18, 30, 22, 2, -21 },
  { 3787, 18, 28, 22, 2, -28 },
  { 3850, 7, 28, 11, 2, -28 },
  { 3875, 11, 37, 11, -2, -28 },
  { 3926, 20, 28, 22, 2, -28 },
  { 3996, 6, 28, 11, 2, -28 },
  { 4017, 29, 21, 34, 2, -21 },
  { 4094, 18, 21, 22, 2, -21 },
  { 4142, 18, 21, 22, 2, -21 },
  { 4190, 18, 30, 22, 2, -21 },
  { 4258, 18, 30, 22, 2, -21 },
  { 4326, 13, 21, 16, 2, -21 },
  { 4361, 15, 21, 17, 1, -21 },
  { 4401, 13, 25, 15, 1, -25 },
  { 4442, 18, 20, 22, 2, -20 },
  { 4487, 20, 20, 20, 0, -20 },
  { 4537, 30, 20, 30, 0, -20 },
  { 4612, 20, 20, 20, 0, -20 },
  { 4662, 20, 29, 20, 0, -20 },
  { 4735, 15, 20, 17, 1, -20 },
  { 4773, 12, 33, 14, 1, -27 },
  { 4823, 4, 36, 18, 7, -28 },
  { 4841, 13, 33, 14, 1, -27 },
  { 4895, 18, 6, 20, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD37PT7B_H_
