#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0xB0, 0x1A, 0x16, 0x16, 0x7F, 0x34,
  0x34, 0xFF, 0x2C, 0x2C, 0x6C, 0x20, 0xCF, 0xF9, 0xE3, 0xC3, 0xCB, 0xAF,
  0xE2, 0x08, 0x70, 0x85, 0x98, 0xD9, 0x0D, 0xB0, 0x5A, 0xE7, 0x7B, 0x05,
  0xB0, 0xDB, 0x08, 0xB1, 0x8E, 0x3C, 0x1F, 0x86, 0x60, 0xF0, 0x3C, 0x5F,
  0x66, 0xFB, 0x9C, 0x7F, 0x8F, 0x70, 0xFF, 0x6F, 0x6D, 0xB6, 0xDB, 0x30,
  0xE6, 0x33, 0x33, 0x33, 0x33, 0x6E, 0x18, 0x21, 0x5F, 0xF3, 0x8D, 0x8A,
  0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x61,
  0x86, 0x30, 0xC6, 0x18, 0x63, 0x00, 0x3C, 0xF9, 0x9B, 0x3E, 0x7C, 0xD9,
  0xB3, 0x7C, 0x78, 0x3B, 0xFF, 0xB3, 0x9C, 0xE7, 0x39, 0xC0, 0x7D, 0xFD,
  0x18, 0x70, 0xC3, 0x8E, 0x38, 0xFF, 0xFC, 0xFC, 0xFC, 0x38, 0x63, 0x87,
  0x81, 0x83, 0xFF, 0xF8, 0x0C, 0x38, 0x71, 0xE6, 0xCD, 0xBF, 0xFF, 0x0C,
  0x18, 0xFB, 0xEC, 0x30, 0xFA, 0x70, 0xC3, 0xFF, 0xE0, 0x1E, 0x7D, 0x83,
  0x47, 0xFC, 0xD9, 0xB3, 0x7E, 0x78, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x86,
  0x1C, 0x30, 0xE0, 0x3C, 0xFD, 0x9B, 0x73, 0xCF, 0x99, 0xF3, 0x7E, 0xF8,
  0x3C, 0xFB, 0x9F, 0x36, 0xEF, 0xCD, 0x87, 0x7C, 0xF0, 0xFC, 0x0F, 0x6D,
  0x80, 0x1B, 0x78, 0x04, 0x33, 0xB8, 0xE1, 0xE0, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0x0F, 0x07, 0x1F, 0xCC, 0x20, 0x7B, 0xF0, 0xC7, 0x38, 0xC3, 0x00,
  0x70, 0xC0, 0x1F, 0x1C, 0x6C, 0x4F, 0x7B, 0xB2, 0x6C, 0x9B, 0x2E, 0x7E,
  0xC0, 0x18, 0x43, 0xF0, 0x1C, 0x0E, 0x0D, 0x86, 0xC3, 0x63, 0xB9, 0xFC,
  0xFE, 0xE3, 0xF1, 0xC0, 0xFD, 0xFF, 0x3E, 0x7F, 0xDF, 0xF1, 0xE3, 0xFF,
  0xF8, 0x3E, 0xFF, 0x86, 0x0C, 0x18, 0x30, 0x70, 0x7C, 0x78, 0xFC, 0xFE,
  0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xFE, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF,
  0x18, 0xFF, 0xC0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00, 0x3E, 0x7E,
  0xE0, 0xC0, 0xCF, 0xCF, 0xC7, 0xE7, 0x7F, 0x3F, 0xC7, 0xC7, 0xC7, 0xC7,
  0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xFB, 0x8C, 0x63, 0x18, 0xC6, 0x77,
  0xC0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC7, 0xCE, 0xCC, 0xD8,
  0xF8, 0xF8, 0xDC, 0xCC, 0xCE, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xFF, 0xF0, 0xE1, 0xFC, 0x7F, 0x1F, 0xCF, 0xD3, 0xF6, 0xBD, 0xEF, 0x7B,
  0xCE, 0xF3, 0x30, 0xE3, 0xF9, 0xFC, 0xFF, 0x7D, 0xBE, 0xFF, 0x37, 0x9F,
  0xC7, 0xE3, 0xC0, 0x3E, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F,
  0x3E, 0xF9, 0xFB, 0x3E, 0x7C, 0xDF, 0xBC, 0x60, 0xC1, 0x80, 0x3E, 0x7F,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x3E, 0x0E, 0x07, 0xF8, 0xFC,
  0xCE, 0xCE, 0xFC, 0xF8, 0xDC, 0xCC, 0xCE, 0xC7, 0x7F, 0xEC, 0x30, 0xF1,
  0xE1, 0xE7, 0xFB, 0xE0, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0xE3,
  0xF1, 0x98, 0xCC, 0xE7, 0x61, 0xB0, 0xD8, 0x78, 0x1C, 0x0E, 0x00, 0xC7,
  0x3F, 0x39, 0x99, 0xCC, 0xCE, 0x66, 0xD3, 0x36, 0xF8, 0xF7, 0x87, 0xBC,
  0x38, 0xE1, 0xC7, 0x00, 0xE3, 0x33, 0x8D, 0x87, 0x81, 0xC0, 0xE0, 0xF8,
  0xEC, 0x67, 0x71, 0xC0, 0xE3, 0x67, 0x76, 0x3E, 0x3C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x30, 0xFF, 0xFC, 0xFB,
  0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30,
  0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x70, 0xE1, 0x66, 0x78, 0xC0,
  0xFC, 0xC6, 0x30, 0x3C, 0xFC, 0x19, 0xF7, 0xFC, 0xDF, 0xBB, 0xC1, 0x83,
  0x06, 0xCF, 0xD9, 0xF3, 0xE7, 0xCF, 0xFB, 0xF0, 0x7F, 0xF1, 0x8C, 0x63,
  0xEF, 0x0C, 0x30, 0xDB, 0xFF, 0x3C, 0xF3, 0xCF, 0xF7, 0xC0, 0x7B, 0xFC,
  0xFF, 0xFF, 0x0F, 0xDF, 0x3D, 0xE7, 0x1E, 0xF9, 0x86, 0x18, 0x61, 0x86,
  0x00, 0x6F, 0xFC, 0xF3, 0xCF, 0x3F, 0xDF, 0x0F, 0x7F, 0x80, 0xC1, 0x83,
  0x06, 0xCF, 0xD9, 0xF3, 0xE7, 0xCF, 0x9F, 0x38, 0xF3, 0xFF, 0xFC, 0x33,
  0x03, 0x33, 0x33, 0x33, 0x33, 0xFF, 0xC1, 0x83, 0x06, 0x7C, 0xDB, 0x3E,
  0x7C, 0xDD, 0x9B, 0x38, 0xFF, 0xFF, 0xFC, 0xD9, 0xDF, 0xFF, 0x3B, 0xE7,
  0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xDD, 0xFB, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0x79, 0xFB, 0x36, 0x7C, 0xF9, 0xBF, 0x3C, 0xD9, 0xFB, 0x3E, 0x7C,
  0xF9, 0xFF, 0x7E, 0xC1, 0x83, 0x00, 0x6F, 0xFC, 0xF3, 0xCF, 0x3F, 0xDF,
  0x0C, 0x30, 0xC0, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0x77, 0xF1, 0xE7, 0x8F,
  0xFE, 0x23, 0xFE, 0xC6, 0x31, 0x8F, 0x38, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xFF, 0xBB, 0xC7, 0xE6, 0x66, 0x6E, 0x6C, 0x3C, 0x38, 0x38, 0xCE, 0x7D,
  0xCD, 0xB9, 0xB5, 0xE6, 0xBC, 0xF7, 0x8E, 0x71, 0xCC, 0xE6, 0x6E, 0x7C,
  0x3C, 0x3C, 0x3C, 0x6E, 0xE7, 0xC7, 0xE6, 0x66, 0x6E, 0x3C, 0x3C, 0x38,
  0x18, 0x18, 0x70, 0x70, 0xFF, 0xF1, 0x8E, 0x31, 0x8F, 0xFF, 0x39, 0xCC,
  0x63, 0x7B, 0x86, 0x31, 0x8C, 0x70, 0xFF, 0xFC, 0xE7, 0x8C, 0x63, 0x1C,
  0xE6, 0x31, 0x9D, 0xC0, 0xF7, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 12, 10, 12, 0, -10 },
  { 41, 10, 10, 10, 0, -10 },
  { 54, 2, 4, 4, 1, -10 },
  { 55, 3, 12, 5, 1, -10 },
  { 60, 4, 12, 5, 0, -10 },
  { 66, 7, 7, 7, 0, -11 },
  { 73, 6, 6, 8, 1, -8 },
  { 78, 3, 4, 4, 0, -2 },
  { 80, 4, 2, 4, 0, -5 },
  { 81, 2, 2, 4, 1, -2 },
  { 82, 6, 10, 6, 0, -10 },
  { 90, 7, 10, 8, 0, -10 },
  { 99, 5, 10, 8, 1, -10 },
  { 106, 7, 10, 8, 0, -10 },
  { 115, 7, 10, 8, 0, -10 },
  { 124, 7, 10, 8, 0, -10 },
  { 133, 6, 10, 8, 1, -10 },
  { 141, 7, 10, 8, 0, -10 },
  { 150, 7, 10, 8, 0, -10 },
  { 159, 7, 10, 8, 0, -10 },
  { 168, 7, 10, 8, 0, -10 },
  { 177, 2, 8, 4, 1, -8 },
  { 179, 3, 10, 4, 0, -8 },
  { 183, 6, 8, 8, 1, -9 },
  { 189, 6, 4, 8, 1, -7 },
  { 192, 6, 8, 8, 1, -9 },
  { 198, 6, 10, 6, 0, -10 },
  { 206, 10, 11, 12, 1, -10 },
  { 220, 9, 10, 9, 0, -10 },
  { 232, 7, 10, 9, 1, -10 },
  { 241, 7, 10, 8, 1, -10 },
  { 250, 8, 10, 9, 1, -10 },
  { 260, 5, 10, 7, 1, -10 },
  { 267, 5, 10, 7, 1, -10 },
  { 274, 8, 10, 9, 1, -10 },
  { 284, 8, 10, 10, 1, -10 },
  { 294, 5, 10, 5, 0, -10 },
  { 301, 4, 13, 4, -1, -10 },
  { 308, 8, 10, 9, 1, -10 },
  { 318, 6, 10, 7, 1, -10 },
  { 326, 10, 10, 13, 1, -10 },
  { 339, 9, 10, 11, 1, -10 },
  { 351, 8, 10, 10, 1, -10 },
  { 361, 7, 10, 8, 1, -10 },
  { 370, 8, 12, 10, 1, -10 },
  { 382, 8, 10, 9, 1, -10 },
  { 392, 6, 10, 7, 1, -10 },
  { 400, 7, 10, 7, 0, -10 },
  { 409, 8, 10, 10, 1, -10 },
  { 419, 9, 10, 9, 0, -10 },
  { 431, 13, 10, 13, 0, -10 },
  { 448, 9, 10, 9, 0, -10 },
  { 460, 8, 10, 8, 0, -10 },
  { 470, 7, 10, 8, 0, -10 },
  { 479, 3, 12, 4, 1, -10 },
  { 484, 6, 10, 6, 0, -10 },
  { 492, 4, 12, 4, 0, -10 },
  { 498, 7, 6, 8, 0, -10 },
  { 504, 6, 1, 6, 0, 1 },
  { 505, 4, 3, 5, 1, -11 },
  { 507, 7, 8, 8, 0, -8 },
  { 514, 7, 11, 8, 1, -11 },
  { 524, 5, 8, 7, 1, -8 },
  { 529, 6, 11, 8, 1, -11 },
  { 538, 6, 8, 8, 1, -8 },
  { 544, 6, 11, 5, 0, -11 },
  { 553, 6, 11, 8, 1, -8 },
  { 562, 7, 11, 8, 1, -11 },
  { 572, 2, 11, 4, 1, -11 },
  { 575, 4, 14, 4, -1, -11 },
  { 582, 7, 11, 8, 1, -11 },
  { 592, 2, 11, 4, 1, -11 },
  { 595, 11, 8, 13, 1, -8 },
  { 606, 7, 8, 8, 1, -8 },
  { 613, 7, 8, 8, 1, -8 },
  { 620, 7, 11, 8, 1, -8 },
  { 630, 6, 11, 8, 1, -8 },
  { 639, 5, 8, 6, 1, -8 },
  { 644, 5, 8, 6, 1, -8 },
  { 649, 5, 9, 6, 0, -9 },
  { 655, 7, 8, 8, 1, -8 },
  { 662, 8, 8, 8, 0, -8 },
  { 670, 11, 8, 11, 0, -8 },
  { 681, 8, 8, 8, 0, -8 },
  { 689, 8, 11, 8, 0, -8 },
  { 700, 6, 8, 6, 0, -8 },
  { 706, 5, 12, 5, 0, -10 },
  { 714, 1, 14, 7, 3, -11 },
  { 716, 5, 12, 5, 0, -10 },
  { 724, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD14PT7B_H_
