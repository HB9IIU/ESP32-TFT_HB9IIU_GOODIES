#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3F, 0x82, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xEF, 0xC1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7C,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE7, 0x06, 0x3F, 0x9C,
  0x00, 0xFE, 0x70, 0x03, 0xF9, 0xC0, 0x0F, 0xF7, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1D, 0xFE, 0x00, 0x71,
  0xFC, 0x01, 0xC7, 0xF8, 0x07, 0x1F, 0xFC, 0x1C, 0xFE, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0xFC, 0x00, 0x7E, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x7C, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE3, 0xE0, 0xF0,
  0x1F, 0x0F, 0x8F, 0xC7, 0xF8, 0x3F, 0x3F, 0x1F, 0x1F, 0xF8, 0x7F, 0xFE,
  0x7E, 0x7F, 0xF8, 0x7F, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF3, 0xF3, 0xFB,
  0xF0, 0xFF, 0xC7, 0xC7, 0xE3, 0xF0, 0x7E, 0x1F, 0x8F, 0xC7, 0xE0, 0x00,
  0x3E, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0xFC, 0x00,
  0x3F, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x0F,
  0xC7, 0xE0, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x01, 0xFE, 0x0F, 0xFF,
  0x81, 0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0xE3, 0xFC, 0x7F, 0xDF,
  0xF3, 0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF8, 0x7F, 0x03,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0x7F, 0x80,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF3, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0x07, 0x83, 0x9F, 0x9E, 0x7E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F,
  0x03, 0xE1, 0xF0, 0x03, 0x03, 0x00, 0x04, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC,
  0xFE, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F,
  0xE1, 0xFC, 0x7F, 0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0,
  0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03,
  0xFB, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xEF, 0xE7, 0xE7, 0xF1, 0xC3, 0xF8, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0x01, 0xFE, 0x1C, 0x03, 0xFC, 0x10, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xF1, 0xFF,
  0x8E, 0x01, 0xFE, 0x20, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE8, 0x00, 0x7F, 0xB8, 0x03, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xF7, 0xF0,
  0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xC7, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0x81, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x83, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xE1, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFE,
  0x1F, 0xC1, 0xFE, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0xC3, 0xFC, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF,
  0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7,
  0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xFB, 0xFC, 0x07,
  0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F,
  0xBF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF7, 0xF1, 0xFF, 0xCF, 0xC0, 0xFF, 0x3F, 0x80, 0x38, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x0F, 0xE7, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F,
  0x82, 0x00, 0x1F, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xCF, 0xF3, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0x1F, 0xF3, 0x80, 0x7F, 0x20, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0xF8,
  0x7C, 0x3F, 0x07, 0xFF, 0xC7, 0xE7, 0xE0, 0xFF, 0xFC, 0x7E, 0x7E, 0x1F,
  0xFF, 0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0x3E, 0x7C, 0x3F, 0x07, 0xC3, 0xEF,
  0xC7, 0xE0, 0x7C, 0x3F, 0xFC, 0x7E, 0x07, 0xC3, 0xFF, 0x87, 0xC0, 0x7C,
  0x3F, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0x87, 0xC0, 0xFC, 0x3E, 0xF8, 0x7C,
  0x0F, 0xC3, 0xEF, 0x87, 0xC0, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F, 0xC7, 0xEF,
  0xC7, 0xE1, 0xFC, 0x7C, 0xFC, 0x3F, 0xFF, 0xFF, 0xCF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7C, 0x1F, 0xF9, 0xFF, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x01,
  0xC0, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0xFF,
  0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFE, 0x3F, 0xF0,
  0x0C, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x3F, 0xF8,
  0x1E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE8, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFC, 0xFF, 0x00, 0xFF,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xE0, 0xFF, 0xC0, 0x18, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC,
  0xFF, 0x80, 0x7F, 0x9F, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F,
  0xE1, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F,
  0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8, 0x07, 0xF7, 0xFC, 0x03, 0xFB,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x03,
  0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xFC,
  0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F,
  0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0x80,
  0x7F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFD, 0xF8, 0x0F, 0xDF, 0xFF, 0x3F,
  0x03, 0xF7, 0xFF, 0xCF, 0xC0, 0xFD, 0xFF, 0xF3, 0xF0, 0x3E, 0x7F, 0xFE,
  0xFE, 0x1F, 0x9F, 0xFF, 0x9F, 0x87, 0xE7, 0xFF, 0xE7, 0xE1, 0xF9, 0xFF,
  0xF9, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0x3F, 0x1F, 0xFF, 0x8F, 0xCF, 0xC7,
  0xFF, 0xE3, 0xF7, 0xE1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF,
  0x81, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xE0, 0x7F, 0xFD, 0xFE,
  0x07, 0xFF, 0xCF, 0xF0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xC7, 0xF8, 0x7F,
  0xFC, 0x7F, 0x87, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1,
  0xFE, 0x7F, 0xFE, 0x0F, 0xE7, 0xFF, 0xE0, 0xFF, 0x7F, 0xFE, 0x07, 0xF7,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE,
  0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x00, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xE0, 0x1C, 0xFF, 0x00, 0x27, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFD, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0xFF,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x3F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xFC, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF1, 0xFC,
  0x07, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7D, 0xF8,
  0x3F, 0xC1, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0x3F, 0x83, 0xF7, 0xE0, 0xFE,
  0x07, 0xF8, 0x7E, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xDF, 0x87, 0xF8, 0x0F,
  0xE3, 0xF9, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xC7, 0xE3, 0xF8, 0x03, 0xF9, 0xF8, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x1F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xE1, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x3F, 0x7F,
  0x00, 0x3F, 0xBF, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x00,
  0x7F, 0xFC, 0x0F, 0xBF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF7,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFB,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x3F,
  0xE0, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x7F, 0x3F, 0xF8, 0xFC, 0x7F, 0x83, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x7E, 0x07, 0xF3, 0xFF, 0x0F, 0xEF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0x87, 0xFD, 0xFE, 0x07, 0xFB,
  0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xF0, 0x7F, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFD, 0xFF, 0xE3, 0xF9, 0xFF,
  0x87, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xC0, 0xC7, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x27, 0xFC, 0x0E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0xEF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFD, 0xFC, 0x3F,
  0xF3, 0xF8, 0x3F, 0xC3, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0x1F, 0xE7, 0xF8, 0x3F,
  0xDF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x06,
  0x7F, 0xE0, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x08, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x1F, 0xF9, 0xFC, 0x7F, 0xFB, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFD, 0xFE, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE8, 0x00, 0x7F, 0x9E, 0x01, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x07, 0xF3, 0xFF, 0x8F,
  0xEF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xC3, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F,
  0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF,
  0xF0, 0x1F, 0xCF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xBF, 0xFE, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x1F, 0xFC, 0x3F, 0xDF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0x03, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xFE,
  0x03, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC, 0x3F, 0xC1, 0xF8,
  0xFF, 0xE3, 0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xF0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xE3, 0xFE, 0xFF, 0xC7,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0xFC, 0x3F, 0xC1, 0xFC, 0xFF, 0xC3, 0xFB, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0x81,
  0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xFC, 0x3F, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0x7F, 0xF8, 0xFE,
  0x7F, 0xE1, 0xFC, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0xFE, 0x1F, 0xF9, 0xFC, 0x7F, 0xFB, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFD,
  0xFE, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFC, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xC3, 0xCF, 0xE0, 0x13, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xBF, 0x1F, 0xFC, 0xFC, 0x3F, 0xE1, 0xF0, 0xFF, 0x00, 0x3F,
  0xDF, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF,
  0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x01,
  0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xF0, 0x3F,
  0x9F, 0xE0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x03, 0xF8, 0xFE, 0x0F,
  0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC,
  0x1F, 0xC7, 0xEF, 0x87, 0xF0, 0x7F, 0x1F, 0x3E, 0x3F, 0xC1, 0xFC, 0x7C,
  0xFC, 0xFE, 0x07, 0xF1, 0xF3, 0xF3, 0xF8, 0x0F, 0xEF, 0xCF, 0xCF, 0xE0,
  0x3F, 0xBF, 0x1F, 0x3F, 0x80, 0xFE, 0xF8, 0x7D, 0xFC, 0x03, 0xFB, 0xE1,
  0xF7, 0xF0, 0x07, 0xEF, 0x87, 0xFF, 0xC0, 0x1F, 0xBE, 0x1F, 0xFF, 0x00,
  0x7E, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD,
  0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x05,
  0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xA0, 0x07, 0xFC, 0x80, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 17, 13, 23, 3, -34 },
  { 69, 27, 34, 28, 1, -34 },
  { 184, 22, 39, 25, 2, -36 },
  { 292, 39, 34, 41, 1, -34 },
  { 458, 32, 34, 33, 1, -34 },
  { 594, 7, 13, 12, 3, -34 },
  { 606, 13, 41, 16, 2, -34 },
  { 673, 13, 41, 16, 1, -34 },
  { 740, 22, 22, 24, 1, -36 },
  { 801, 22, 23, 26, 2, -28 },
  { 865, 10, 12, 13, 1, -6 },
  { 880, 13, 7, 15, 1, -16 },
  { 892, 9, 9, 13, 2, -8 },
  { 903, 20, 34, 20, 0, -34 },
  { 988, 22, 34, 25, 2, -34 },
  { 1082, 17, 34, 25, 2, -34 },
  { 1155, 23, 34, 25, 1, -34 },
  { 1253, 22, 34, 25, 2, -34 },
  { 1347, 24, 34, 25, 1, -34 },
  { 1449, 21, 34, 25, 2, -34 },
  { 1539, 22, 34, 25, 2, -34 },
  { 1633, 23, 34, 25, 1, -34 },
  { 1731, 23, 34, 25, 1, -34 },
  { 1829, 23, 34, 25, 1, -34 },
  { 1927, 9, 27, 13, 2, -26 },
  { 1958, 10, 32, 13, 1, -26 },
  { 1998, 22, 24, 26, 2, -29 },
  { 2064, 22, 15, 26, 2, -24 },
  { 2106, 22, 24, 26, 2, -29 },
  { 2172, 20, 35, 21, 0, -34 },
  { 2260, 36, 38, 40, 2, -34 },
  { 2431, 31, 34, 31, 0, -34 },
  { 2563, 24, 34, 29, 3, -34 },
  { 2665, 24, 34, 28, 2, -34 },
  { 2767, 26, 34, 32, 3, -34 },
  { 2878, 18, 34, 24, 4, -34 },
  { 2955, 18, 34, 24, 4, -34 },
  { 3032, 27, 34, 32, 2, -34 },
  { 3147, 25, 34, 33, 4, -34 },
  { 3254, 16, 34, 18, 1, -34 },
  { 3322, 14, 44, 15, -3, -34 },
  { 3399, 25, 34, 29, 4, -34 },
  { 3506, 20, 34, 24, 3, -34 },
  { 3591, 34, 34, 42, 4, -34 },
  { 3736, 28, 34, 36, 4, -34 },
  { 3855, 30, 34, 34, 2, -34 },
  { 3983, 23, 34, 27, 3, -34 },
  { 4081, 30, 42, 34, 2, -34 },
  { 4239, 26, 34, 29, 3, -34 },
  { 4350, 21, 34, 24, 2, -34 },
  { 4440, 23, 34, 25, 1, -34 },
  { 4538, 26, 34, 32, 3, -34 },
  { 4649, 29, 34, 29, 0, -34 },
  { 4773, 43, 34, 43, 0, -34 },
  { 4956, 29, 34, 29, 0, -34 },
  { 5080, 28, 34, 28, 0, -34 },
  { 5199, 23, 34, 25, 1, -34 },
  { 5297, 11, 42, 15, 3, -34 },
  { 5355, 20, 34, 20, 0, -34 },
  { 5440, 11, 42, 15, 1, -34 },
  { 5498, 24, 22, 26, 1, -34 },
  { 5564, 21, 4, 21, 0, 4 },
  { 5575, 13, 8, 17, 2, -36 },
  { 5588, 22, 26, 26, 2, -26 },
  { 5660, 23, 36, 28, 3, -36 },
  { 5764, 20, 26, 23, 2, -26 },
  { 5829, 23, 36, 28, 2, -36 },
  { 5933, 22, 26, 26, 2, -26 },
  { 6005, 18, 36, 17, 1, -36 },
  { 6086, 23, 37, 28, 2, -26 },
  { 6193, 23, 36, 28, 3, -36 },
  { 6297, 8, 36, 14, 3, -36 },
  { 6333, 13, 47, 14, -2, -36 },
  { 6410, 25, 36, 28, 3, -36 },
  { 6523, 8, 36, 14, 3, -36 },
  { 6559, 37, 26, 43, 3, -26 },
  { 6680, 23, 26, 28, 3, -26 },
  { 6755, 23, 26, 27, 2, -26 },
  { 6830, 23, 37, 28, 3, -26 },
  { 6937, 23, 37, 28, 2, -26 },
  { 7044, 16, 26, 20, 3, -26 },
  { 7096, 18, 26, 22, 2, -26 },
  { 7155, 17, 31, 19, 1, -31 },
  { 7221, 22, 26, 28, 3, -26 },
  { 7293, 26, 26, 26, 0, -26 },
  { 7378, 38, 26, 38, 0, -26 },
  { 7502, 25, 26, 26, 0, -26 },
  { 7584, 26, 37, 26, 0, -26 },
  { 7705, 19, 26, 21, 1, -26 },
  { 7767, 16, 42, 18, 1, -34 },
  { 7851, 5, 47, 23, 9, -36 },
  { 7881, 16, 42, 18, 2, -34 },
  { 7965, 22, 9, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD47PT7B_H_
