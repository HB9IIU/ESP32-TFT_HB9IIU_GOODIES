#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x1B, 0x0D, 0x84, 0x8F, 0xF7,
  0xF9, 0xB3, 0xFD, 0xFE, 0x24, 0x16, 0x1B, 0x00, 0x11, 0xFB, 0xF6, 0x8F,
  0x0F, 0x07, 0x0F, 0xDD, 0xF8, 0x40, 0x80, 0x30, 0xC3, 0xC6, 0x36, 0x61,
  0x93, 0x0D, 0xB2, 0x3D, 0xF8, 0xDB, 0x60, 0xDB, 0x0C, 0xD8, 0x66, 0xC6,
  0x1C, 0x1C, 0x07, 0xC1, 0xD8, 0x3B, 0x03, 0xE0, 0x79, 0x9F, 0x73, 0x3C,
  0xE7, 0x8F, 0xF0, 0xFF, 0x80, 0xFF, 0x76, 0xEC, 0xCC, 0xCC, 0xCC, 0xC6,
  0x70, 0xE6, 0x33, 0x33, 0x33, 0x33, 0x36, 0xE0, 0x19, 0x37, 0xF8, 0xC3,
  0xCD, 0xC0, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x00, 0x6D, 0xE0, 0xFF,
  0xF0, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x1C, 0x61, 0x8C, 0x00, 0x79, 0xFB,
  0x36, 0x6C, 0xF9, 0xF3, 0xE6, 0xCD, 0xF9, 0xE0, 0x19, 0xDF, 0xB5, 0x8C,
  0x63, 0x18, 0xC6, 0x3C, 0xFE, 0x66, 0x06, 0x06, 0x0E, 0x1C, 0x38, 0x70,
  0xFF, 0xFF, 0x79, 0xFA, 0x30, 0x63, 0xCF, 0x07, 0x07, 0x8D, 0xFB, 0xE0,
  0x0E, 0x0E, 0x1E, 0x3E, 0x3E, 0x6E, 0x6E, 0xFF, 0xFF, 0x0E, 0x0E, 0xFF,
  0xFC, 0x30, 0xFB, 0xF0, 0xC3, 0x8F, 0xFF, 0x80, 0x1E, 0x3E, 0x70, 0x60,
  0x7E, 0x7E, 0xE7, 0x67, 0x67, 0x7E, 0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x18, 0x38, 0x70, 0x3C, 0x7E, 0x66, 0x66, 0x7E, 0x3C,
  0x7E, 0x67, 0xE7, 0x7E, 0x3C, 0x3C, 0x7E, 0x66, 0xE6, 0xE7, 0x7F, 0x7F,
  0x06, 0x06, 0x7C, 0x78, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x06, 0x3D,
  0xE6, 0x0F, 0x07, 0x83, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC1,
  0xE0, 0x73, 0xDE, 0x30, 0x00, 0x79, 0xF9, 0x38, 0x61, 0xC7, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x0F, 0x07, 0xF1, 0x83, 0x67, 0xBD, 0xB7, 0x26, 0xEC,
  0xDC, 0x9B, 0xDF, 0xD8, 0x01, 0xC6, 0x1F, 0xC0, 0x1E, 0x07, 0x81, 0xE0,
  0xF8, 0x37, 0x0C, 0xC7, 0x31, 0xFE, 0x7F, 0xB8, 0x6E, 0x1C, 0xF8, 0xFE,
  0xE6, 0xE6, 0xEE, 0xFC, 0xEE, 0xE7, 0xE7, 0xFE, 0xFC, 0x1E, 0xFF, 0x8F,
  0x0C, 0x18, 0x30, 0x70, 0xE2, 0xFC, 0xF8, 0xF8, 0xFE, 0xEF, 0xE7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE7, 0xFE, 0xFC, 0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38,
  0xE3, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0x8E, 0x00,
  0x1E, 0x7F, 0xF1, 0xE0, 0xC0, 0xCF, 0xCF, 0xE3, 0xE3, 0x7F, 0x3F, 0xE3,
  0xE3, 0xE3, 0xE3, 0xFF, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xCC,
  0x63, 0x18, 0xC6, 0x33, 0xFE, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x7F, 0x78, 0xE3, 0xE7, 0xEE, 0xEC, 0xFC, 0xF8, 0xFC, 0xEC, 0xEE, 0xE7,
  0xE7, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF8, 0xFD, 0x9F, 0xB6, 0xF6, 0xDE, 0x7B, 0xCE, 0x79, 0xCF,
  0x39, 0x80, 0xE1, 0xF8, 0xFC, 0x7F, 0x3D, 0x9E, 0xEF, 0x37, 0x9F, 0xC7,
  0xE3, 0xF0, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0xC7,
  0xE3, 0xBF, 0x8F, 0x80, 0xF9, 0xFF, 0xBF, 0x3E, 0x7F, 0xFF, 0x70, 0xE1,
  0xC3, 0x80, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0xC7, 0xE3,
  0xBF, 0x8F, 0x80, 0xE0, 0x70, 0x1C, 0xF8, 0xFE, 0xEE, 0xE6, 0xE6, 0xFE,
  0xFC, 0xEC, 0xEE, 0xE6, 0xE7, 0x7B, 0xFC, 0x70, 0xE1, 0xE3, 0xC3, 0x8F,
  0xFF, 0x80, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3E,
  0xE1, 0xF1, 0xD8, 0xEC, 0x67, 0x31, 0xB8, 0xD8, 0x6C, 0x3E, 0x0E, 0x07,
  0x00, 0xC3, 0x1F, 0x8C, 0x66, 0x71, 0x99, 0xE6, 0x67, 0xB9, 0xDE, 0xE7,
  0xDB, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x00, 0xE3, 0xB9, 0x9D,
  0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x7C, 0x77, 0x39, 0xB8, 0xE0, 0xE3, 0xB1,
  0x9D, 0xC6, 0xC3, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF,
  0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xFF, 0xFF, 0xFF, 0x6D,
  0xB6, 0xDB, 0x6E, 0xC1, 0x86, 0x18, 0x30, 0xC3, 0x86, 0x18, 0x30, 0xC0,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x3C, 0x66,
  0x66, 0xC3, 0xFF, 0xFC, 0xE3, 0xFC, 0x98, 0x37, 0xFC, 0xF9, 0xFF, 0xFB,
  0xC1, 0x83, 0x06, 0xEF, 0xF8, 0xF1, 0xE3, 0xE7, 0xFF, 0x70, 0x7F, 0xEC,
  0x30, 0xC3, 0x0F, 0xDF, 0x0E, 0x1C, 0x3B, 0xBF, 0xF9, 0xF1, 0xE3, 0xCF,
  0xFD, 0xD8, 0x7D, 0xDB, 0x3F, 0xFF, 0xF8, 0x3F, 0x3E, 0x3D, 0xD7, 0x3E,
  0xF9, 0xC7, 0x1C, 0x71, 0xC7, 0x00, 0x77, 0xFF, 0x3E, 0x3C, 0x79, 0xFF,
  0xBB, 0x0F, 0x1F, 0xF3, 0x80, 0xC1, 0x83, 0x06, 0xFF, 0xFC, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0x7C, 0xFF, 0xFF, 0x13, 0x30, 0x33, 0x33, 0x33, 0x33,
  0x3B, 0xF6, 0xC0, 0xC0, 0xC1, 0xCE, 0xCC, 0xDC, 0xF8, 0xFC, 0xCC, 0xCE,
  0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFF, 0xE6, 0x7C, 0x67, 0xC6, 0x7C,
  0x67, 0xC6, 0x7C, 0x67, 0xFF, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D,
  0xDF, 0x1E, 0x3C, 0x79, 0xFF, 0x3E, 0xDD, 0xFF, 0x1E, 0x3C, 0x7C, 0xFF,
  0xEE, 0xC1, 0x83, 0x06, 0x00, 0x77, 0xFF, 0x3E, 0x3C, 0x79, 0xFF, 0xBB,
  0x0E, 0x1C, 0x38, 0x70, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xFE, 0x71, 0xE7,
  0x8F, 0xFF, 0x30, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x7C, 0xF0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x79, 0xFF, 0xBB, 0xE7, 0x67, 0x66, 0x76, 0x3E, 0x3C, 0x3C,
  0x18, 0xE7, 0x36, 0xF7, 0x6F, 0x66, 0xF6, 0x6D, 0x63, 0x9E, 0x39, 0xC3,
  0x9C, 0xE7, 0x7E, 0x3C, 0x3C, 0x3C, 0x3E, 0x66, 0xE7, 0xE7, 0x67, 0x66,
  0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0x18, 0x38, 0x70, 0x60, 0x7D, 0xF1, 0xCE,
  0x31, 0xCF, 0xFF, 0x19, 0xCC, 0x63, 0x1B, 0x9E, 0x31, 0x8C, 0x73, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x31, 0xEF, 0x63, 0x19, 0xCE,
  0x00, 0x43, 0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 9, 0, -11 },
  { 20, 7, 12, 8, 1, -11 },
  { 31, 13, 11, 13, 0, -11 },
  { 49, 11, 11, 11, 0, -11 },
  { 65, 2, 4, 4, 1, -11 },
  { 66, 4, 13, 5, 1, -11 },
  { 73, 4, 13, 5, 0, -11 },
  { 80, 7, 6, 8, 0, -11 },
  { 86, 7, 7, 8, 1, -9 },
  { 93, 3, 4, 4, 0, -2 },
  { 95, 4, 2, 5, 0, -5 },
  { 96, 2, 2, 4, 1, -2 },
  { 97, 6, 11, 6, 0, -11 },
  { 106, 7, 11, 8, 1, -11 },
  { 116, 5, 11, 8, 1, -11 },
  { 123, 8, 11, 8, 0, -11 },
  { 134, 7, 11, 8, 1, -11 },
  { 144, 8, 11, 8, 0, -11 },
  { 155, 6, 11, 8, 1, -11 },
  { 164, 8, 11, 8, 0, -11 },
  { 175, 8, 11, 8, 0, -11 },
  { 186, 8, 11, 8, 0, -11 },
  { 197, 8, 11, 8, 0, -11 },
  { 208, 2, 8, 4, 1, -8 },
  { 210, 3, 10, 4, 0, -8 },
  { 214, 7, 7, 8, 1, -9 },
  { 221, 7, 5, 8, 1, -8 },
  { 226, 7, 7, 8, 1, -9 },
  { 233, 7, 11, 7, 0, -11 },
  { 243, 11, 12, 13, 1, -11 },
  { 260, 10, 11, 10, 0, -11 },
  { 274, 8, 11, 9, 1, -11 },
  { 285, 7, 11, 9, 1, -11 },
  { 295, 8, 11, 10, 1, -11 },
  { 306, 6, 11, 8, 1, -11 },
  { 315, 6, 11, 8, 1, -11 },
  { 324, 8, 11, 10, 1, -11 },
  { 335, 8, 11, 11, 1, -11 },
  { 346, 5, 11, 6, 0, -11 },
  { 353, 5, 14, 5, -1, -11 },
  { 362, 8, 11, 9, 1, -11 },
  { 373, 6, 11, 8, 1, -11 },
  { 382, 11, 11, 13, 1, -11 },
  { 398, 9, 11, 11, 1, -11 },
  { 411, 9, 11, 11, 1, -11 },
  { 424, 7, 11, 9, 1, -11 },
  { 434, 9, 14, 11, 1, -11 },
  { 450, 8, 11, 9, 1, -11 },
  { 461, 6, 11, 8, 1, -11 },
  { 470, 8, 11, 8, 0, -11 },
  { 481, 8, 11, 10, 1, -11 },
  { 492, 9, 11, 9, 0, -11 },
  { 505, 14, 11, 14, 0, -11 },
  { 525, 9, 11, 9, 0, -11 },
  { 538, 9, 11, 9, 0, -11 },
  { 551, 8, 11, 8, 0, -11 },
  { 562, 3, 13, 5, 1, -11 },
  { 567, 6, 11, 6, 0, -11 },
  { 576, 4, 13, 5, 0, -11 },
  { 583, 8, 7, 8, 0, -11 },
  { 590, 7, 2, 7, 0, 1 },
  { 592, 4, 2, 5, 1, -11 },
  { 593, 7, 8, 8, 1, -8 },
  { 600, 7, 11, 9, 1, -11 },
  { 610, 6, 8, 7, 1, -8 },
  { 616, 7, 11, 9, 1, -11 },
  { 626, 7, 8, 8, 1, -8 },
  { 633, 6, 11, 6, 0, -11 },
  { 642, 7, 12, 9, 1, -8 },
  { 653, 7, 11, 9, 1, -11 },
  { 663, 2, 12, 4, 1, -12 },
  { 666, 4, 16, 4, -1, -12 },
  { 674, 8, 11, 9, 1, -11 },
  { 685, 2, 11, 4, 1, -11 },
  { 688, 12, 8, 14, 1, -8 },
  { 700, 7, 8, 9, 1, -8 },
  { 707, 7, 8, 9, 1, -8 },
  { 714, 7, 12, 9, 1, -8 },
  { 725, 7, 12, 9, 1, -8 },
  { 736, 5, 8, 6, 1, -8 },
  { 741, 5, 8, 7, 1, -8 },
  { 746, 6, 10, 6, 0, -10 },
  { 754, 7, 8, 9, 1, -8 },
  { 761, 8, 8, 8, 0, -8 },
  { 769, 12, 8, 12, 0, -8 },
  { 781, 8, 8, 8, 0, -8 },
  { 789, 8, 12, 8, 0, -8 },
  { 801, 6, 8, 7, 0, -8 },
  { 807, 5, 13, 6, 0, -11 },
  { 816, 2, 14, 7, 3, -11 },
  { 820, 5, 13, 6, 1, -11 },
  { 829, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD15PT7B_H_
