#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0x8B, 0xBB, 0xB0, 0x3C, 0xA7, 0xDF, 0x2B, 0xF5, 0x94, 0x31,
  0xEE, 0x1C, 0x38, 0xBF, 0x8C, 0x20, 0x62, 0x7B, 0x35, 0x1F, 0xF6, 0xA8,
  0xD4, 0x4A, 0x67, 0x38, 0x68, 0x68, 0x38, 0x7E, 0xDE, 0xEC, 0x7F, 0xE0,
  0x2D, 0x2D, 0x92, 0x64, 0xCD, 0x92, 0x4B, 0x78, 0x37, 0xCC, 0xF5, 0x00,
  0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x78, 0xFC, 0xB0, 0x19, 0x8C, 0x46, 0x31,
  0x18, 0x71, 0xE4, 0xB3, 0xCF, 0x27, 0x9E, 0x3F, 0xB3, 0x33, 0x33, 0x7B,
  0xE0, 0x86, 0x31, 0x87, 0xFF, 0xF9, 0xE0, 0x9C, 0x78, 0x39, 0xBE, 0x18,
  0xE3, 0x9E, 0x5B, 0xF1, 0x86, 0xFF, 0x8F, 0xB1, 0xBF, 0x39, 0xE4, 0x3E,
  0xCF, 0x37, 0x9E, 0xFF, 0xF1, 0x86, 0x10, 0xC3, 0x18, 0x79, 0xE4, 0x9E,
  0x7B, 0x3C, 0xDE, 0x71, 0xEC, 0xB3, 0x7C, 0x21, 0x9C, 0xE0, 0xB0, 0x68,
  0x02, 0xB0, 0x04, 0x77, 0x38, 0x1C, 0x10, 0xFF, 0xF0, 0x3F, 0x83, 0x83,
  0x87, 0xE2, 0x00, 0xF7, 0xC6, 0x66, 0x01, 0x8C, 0x1E, 0x11, 0x97, 0xEA,
  0xDD, 0x6E, 0xBD, 0x6C, 0xC4, 0x1E, 0x00, 0x38, 0x70, 0xA3, 0x66, 0xCF,
  0xB1, 0xE3, 0xF7, 0xF7, 0xFF, 0xEF, 0x7E, 0x7F, 0xF1, 0x08, 0x63, 0xAF,
  0xF3, 0xEC, 0xF3, 0xCF, 0x3F, 0xBC, 0xFF, 0xCF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFC, 0xCC, 0x7F, 0xEC, 0x27, 0x9F, 0x3E, 0xDF, 0xCF, 0x3C, 0xFF, 0xFF,
  0x3C, 0xF3, 0xF6, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xCF,
  0x6F, 0x3C, 0xF3, 0x6D, 0xB3, 0xCC, 0xCC, 0xCC, 0xFF, 0xC7, 0xE7, 0xA7,
  0xA7, 0xBF, 0xBB, 0x9B, 0x9B, 0xC7, 0x9E, 0x6D, 0xB6, 0x79, 0xE3, 0x7B,
  0xFC, 0xE1, 0x87, 0x3F, 0xDE, 0xF7, 0xF7, 0xBF, 0x63, 0x18, 0x7B, 0xFC,
  0xE1, 0x87, 0x3F, 0xDE, 0x18, 0x30, 0xF3, 0xED, 0xB6, 0xF3, 0xCD, 0xB3,
  0x7B, 0xF0, 0xE3, 0x8F, 0x7F, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3D, 0xDE, 0xC7, 0x89, 0xB3, 0x66, 0x85, 0x0E, 0x1C,
  0xCC, 0xF3, 0x34, 0xCD, 0x7A, 0x7F, 0x9C, 0xE7, 0x38, 0xCC, 0xCE, 0xD9,
  0xE1, 0xC3, 0x8F, 0x1B, 0x63, 0xCD, 0xB6, 0x8E, 0x30, 0xC3, 0x0C, 0xFF,
  0xE1, 0x8C, 0x31, 0x8F, 0xFF, 0xEA, 0xAA, 0xB0, 0xC2, 0x18, 0xC2, 0x18,
  0xC3, 0xED, 0xB6, 0xDB, 0x7C, 0x30, 0xC7, 0x92, 0xCC, 0xF8, 0xF0, 0x79,
  0x27, 0xF3, 0xDD, 0xF0, 0x84, 0x2D, 0xB9, 0xCF, 0x76, 0x7B, 0x71, 0x86,
  0xBC, 0x0C, 0x37, 0xDB, 0xCF, 0x36, 0xDF, 0x79, 0x3F, 0xF0, 0x65, 0xE0,
  0x76, 0xF6, 0x66, 0x66, 0x7D, 0xBC, 0xF3, 0x6D, 0xF0, 0xDE, 0x70, 0x84,
  0x2F, 0xBD, 0xCE, 0x73, 0xCA, 0xAA, 0x30, 0x22, 0x22, 0x22, 0x2E, 0xC0,
  0x84, 0x27, 0x6A, 0x7A, 0x73, 0xFF, 0xBF, 0xDB, 0xD9, 0x99, 0x99, 0x99,
  0xBE, 0xF7, 0x39, 0xCC, 0x79, 0xBC, 0xF3, 0x6D, 0xE0, 0xB6, 0xE7, 0x3D,
  0xDA, 0x10, 0x80, 0x7D, 0xBC, 0xF3, 0x6D, 0xF0, 0xC3, 0x0C, 0xBE, 0xC8,
  0x88, 0x7E, 0x5C, 0x79, 0xF8, 0x6F, 0x66, 0x67, 0x70, 0x9C, 0xE7, 0x3D,
  0xFC, 0xCD, 0x27, 0x9E, 0x30, 0xC0, 0xDD, 0xEA, 0x95, 0x4E, 0xE7, 0x71,
  0xB0, 0xCD, 0xE3, 0x0C, 0x7B, 0x30, 0xCD, 0x27, 0x9E, 0x30, 0xC3, 0x38,
  0xC0, 0xF8, 0x8C, 0xC4, 0x7C, 0x36, 0x66, 0xEE, 0x66, 0x73, 0xFF, 0xC0,
  0xC6, 0x66, 0x37, 0x66, 0xEC, 0x66, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 8, 3, 1, -8 },
  { 3, 4, 3, 5, 1, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 9, 8, 10, 0, -8 },
  { 27, 8, 8, 8, 0, -8 },
  { 35, 1, 3, 3, 1, -8 },
  { 36, 3, 10, 4, 0, -8 },
  { 40, 3, 10, 4, 0, -8 },
  { 44, 5, 5, 6, 0, -8 },
  { 48, 6, 6, 6, 0, -7 },
  { 53, 3, 2, 3, 0, -1 },
  { 54, 3, 2, 3, 0, -4 },
  { 55, 2, 2, 3, 1, -2 },
  { 56, 5, 8, 5, 0, -8 },
  { 61, 6, 8, 6, 0, -8 },
  { 67, 4, 8, 6, 1, -8 },
  { 71, 6, 8, 6, 0, -8 },
  { 77, 6, 8, 6, 0, -8 },
  { 83, 6, 8, 6, 0, -8 },
  { 89, 4, 8, 6, 1, -8 },
  { 93, 6, 8, 6, 0, -8 },
  { 99, 6, 8, 6, 0, -8 },
  { 105, 6, 8, 6, 0, -8 },
  { 111, 6, 8, 6, 0, -8 },
  { 117, 2, 6, 3, 1, -6 },
  { 119, 3, 7, 3, 0, -6 },
  { 122, 6, 6, 6, 0, -7 },
  { 127, 6, 4, 6, 0, -6 },
  { 130, 6, 6, 6, 0, -7 },
  { 135, 5, 8, 5, 0, -8 },
  { 140, 9, 9, 9, 0, -8 },
  { 151, 7, 8, 7, 0, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 6, 1, -8 },
  { 168, 6, 8, 7, 1, -8 },
  { 174, 4, 8, 6, 1, -8 },
  { 178, 4, 8, 6, 1, -8 },
  { 182, 6, 8, 7, 1, -8 },
  { 188, 6, 8, 8, 1, -8 },
  { 194, 4, 8, 4, 0, -8 },
  { 198, 4, 10, 4, -1, -8 },
  { 203, 6, 8, 7, 1, -8 },
  { 209, 4, 8, 6, 1, -8 },
  { 213, 8, 8, 10, 1, -8 },
  { 221, 6, 8, 8, 1, -8 },
  { 227, 6, 8, 8, 1, -8 },
  { 233, 5, 8, 6, 1, -8 },
  { 238, 6, 10, 8, 1, -8 },
  { 246, 6, 8, 7, 1, -8 },
  { 252, 5, 8, 6, 0, -8 },
  { 257, 6, 8, 6, 0, -8 },
  { 263, 6, 8, 8, 1, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 10, 8, 10, 0, -8 },
  { 286, 7, 8, 7, 0, -8 },
  { 293, 6, 8, 6, 0, -8 },
  { 299, 6, 8, 6, 0, -8 },
  { 305, 2, 10, 4, 1, -8 },
  { 308, 5, 8, 5, 0, -8 },
  { 313, 3, 10, 4, 0, -8 },
  { 317, 6, 5, 6, 0, -8 },
  { 321, 5, 1, 5, 0, 1 },
  { 322, 4, 1, 4, 0, -8 },
  { 323, 6, 6, 6, 0, -6 },
  { 328, 5, 8, 7, 1, -8 },
  { 333, 5, 6, 5, 0, -6 },
  { 337, 6, 8, 7, 0, -8 },
  { 343, 6, 6, 6, 0, -6 },
  { 348, 4, 8, 4, 0, -8 },
  { 352, 6, 9, 7, 0, -6 },
  { 359, 5, 8, 7, 1, -8 },
  { 364, 2, 8, 3, 1, -8 },
  { 366, 4, 11, 3, -1, -8 },
  { 372, 5, 8, 6, 1, -8 },
  { 377, 1, 8, 3, 1, -8 },
  { 378, 8, 6, 10, 1, -6 },
  { 384, 5, 6, 7, 1, -6 },
  { 388, 6, 6, 6, 0, -6 },
  { 393, 5, 9, 7, 1, -6 },
  { 399, 6, 9, 7, 0, -6 },
  { 406, 4, 6, 5, 1, -6 },
  { 409, 5, 6, 5, 0, -6 },
  { 413, 4, 7, 4, 0, -7 },
  { 417, 5, 6, 7, 1, -6 },
  { 421, 6, 6, 6, 0, -6 },
  { 426, 9, 6, 9, 0, -6 },
  { 433, 6, 6, 6, 0, -6 },
  { 438, 6, 9, 6, 0, -6 },
  { 445, 5, 6, 5, 0, -6 },
  { 449, 4, 10, 4, 0, -8 },
  { 454, 1, 10, 5, 2, -8 },
  { 456, 4, 10, 4, 0, -8 },
  { 461, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD11PT7B_H_
