#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF0, 0x00, 0x00, 0x0E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x00,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0x81,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1,
  0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFC, 0xE3, 0x9F, 0x9C, 0x03, 0xE3,
  0x80, 0x7E, 0x70, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0E,
  0xFE, 0x01, 0xCF, 0xE0, 0x39, 0xFF, 0x07, 0x7E, 0xFE, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x20, 0x07, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x7F,
  0xF8, 0x0F, 0x80, 0x3F, 0x3E, 0x07, 0xC0, 0x0F, 0x8F, 0x81, 0xF0, 0x03,
  0xE3, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x1F, 0x00,
  0x0F, 0x87, 0xC7, 0xC0, 0x03, 0xE3, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0xF8,
  0xFC, 0x1F, 0x3E, 0x7C, 0x7F, 0x87, 0xFF, 0x9F, 0x3F, 0xF1, 0xFF, 0xCF,
  0x9F, 0xFE, 0x3F, 0xF3, 0xE7, 0xEF, 0x87, 0xF9, 0xF1, 0xF3, 0xF0, 0x70,
  0x7C, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x87, 0xC0,
  0x07, 0xC3, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0xF8, 0x3F, 0x1F,
  0x00, 0x3E, 0x07, 0xC7, 0xC0, 0x1F, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x7F,
  0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF,
  0x1F, 0xC7, 0xFF, 0xF1, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xF1, 0xFF, 0xF8,
  0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x9F, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x07, 0xE0, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xE3, 0xE3, 0x9F, 0xFB, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xC1,
  0xF8, 0xFC, 0x1F, 0x1F, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x3F, 0x9F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xF9,
  0xFC, 0xE3, 0xF8, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3E, 0x1F, 0xE3, 0x80, 0xFE, 0x10, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3C, 0x1F, 0xE1, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xE8, 0x00, 0xFE, 0xF0, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0xF7, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x7E, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F,
  0xEF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF9,
  0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F,
  0x8F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x07, 0xEF,
  0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF7,
  0xE0, 0x7E, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x1E, 0x3F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0x81, 0xFC, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x07, 0xF8, 0x7C,
  0xF8, 0x3F, 0xFC, 0xF9, 0xF0, 0xFF, 0xF8, 0xF3, 0xC3, 0xFF, 0xF1, 0xEF,
  0x8F, 0xC3, 0xE3, 0xFF, 0x1F, 0x07, 0xC7, 0xFE, 0x3E, 0x0F, 0x8F, 0xFC,
  0xF8, 0x1F, 0x1F, 0xF1, 0xF0, 0x3E, 0x3F, 0xE3, 0xE0, 0x78, 0x7F, 0xC7,
  0xC1, 0xF0, 0xF7, 0x8F, 0x83, 0xE1, 0xEF, 0x8F, 0x87, 0xE7, 0xDF, 0x1F,
  0xFF, 0xFF, 0x3E, 0x1F, 0xFF, 0xFE, 0x7C, 0x3F, 0xE7, 0xF8, 0x7C, 0x1F,
  0x87, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x04, 0x01, 0xFE, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0x07, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xBF, 0x83, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x3F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF,
  0xC3, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x83, 0x8F, 0xF0,
  0x04, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x02, 0x3F, 0xF1, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xC7, 0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF,
  0xC0, 0x7F, 0x3F, 0x83, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xF8, 0x0E, 0x1F, 0xE0, 0x04, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xE0,
  0x3F, 0x9F, 0xE0, 0x7F, 0x3F, 0xE0, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F, 0x00,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF7, 0xC0, 0xFF, 0xFF, 0xDF, 0x03, 0xEF, 0xFF, 0x7E, 0x0F, 0xBF, 0xFD,
  0xF8, 0x3E, 0xFF, 0xF3, 0xE1, 0xFB, 0xFF, 0xCF, 0x87, 0xCF, 0xFF, 0x3F,
  0x1F, 0x3F, 0xFC, 0x7C, 0xFC, 0xFF, 0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xEF,
  0x8F, 0xFF, 0x1F, 0xBE, 0x3F, 0xFC, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF,
  0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF, 0x7F,
  0x07, 0xFF, 0x9F, 0xC3, 0xFF, 0xCF, 0xE1, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1,
  0xFC, 0x7F, 0xF8, 0x7F, 0x3F, 0xFC, 0x3F, 0x9F, 0xFE, 0x0F, 0xEF, 0xFF,
  0x07, 0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xF1, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFF, 0x03, 0xFC, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xF1, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9,
  0xFF, 0x03, 0xFC, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF8, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xF0, 0xF3, 0xF8, 0x04,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xFC, 0x7F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0xF1, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x80,
  0xFE, 0x7F, 0x01, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC1, 0xFC, 0x3F, 0x03, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0xF0, 0x7E, 0x07, 0xE1,
  0xF7, 0xC3, 0xF8, 0x1F, 0x87, 0xDF, 0x8F, 0xE0, 0x7F, 0x1F, 0x3E, 0x3F,
  0x01, 0xFC, 0xFC, 0xF8, 0xFC, 0x03, 0xF3, 0xF3, 0xE3, 0xF0, 0x0F, 0xCF,
  0x8F, 0xDF, 0xC0, 0x3F, 0x3E, 0x3F, 0x7E, 0x00, 0xFC, 0xF8, 0x7D, 0xF8,
  0x01, 0xFF, 0xE1, 0xF7, 0xE0, 0x07, 0xFF, 0x07, 0xDF, 0x80, 0x1F, 0xFC,
  0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x83, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F,
  0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x00, 0xF9,
  0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xE0, 0xFE, 0x08, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x3F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F,
  0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0xBF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE1, 0xF0, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x0F, 0xCF, 0xF0,
  0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFB, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0x9F, 0xF0, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFE, 0xF3, 0xFC, 0x09, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0x3F, 0xC1, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xC7, 0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0x0F, 0xE3, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x1F, 0xBF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x19, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFC,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC3, 0xF1, 0xFF, 0x3F, 0x3F,
  0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x40,
  0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x7E, 0x1F, 0x9F, 0xF3, 0xF7, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x7E, 0x7E, 0xFF, 0xFE, 0x7E,
  0x3C, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFC, 0x7C, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xBF, 0x03, 0xF9, 0xF8, 0x3F, 0x8F, 0xC3, 0xFC, 0x7E, 0x1F, 0xC3,
  0xF1, 0xFC, 0x1F, 0x9F, 0xC0, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFD, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x1F,
  0xCF, 0xC0, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x03,
  0xE0, 0xF9, 0xFF, 0x8F, 0xF8, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x7E, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF9, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x7C,
  0x0F, 0x8F, 0xF0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFB,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xDF, 0xF0, 0xFC, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC3, 0xF1,
  0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFB, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0xF8, 0x3F, 0xE3, 0xFF,
  0x9F, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFC,
  0x1C, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x47, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xE7, 0xC7, 0xF8, 0xF8, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x7E, 0x7F, 0x03, 0xF8, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F,
  0x81, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xFC, 0x1F, 0xDF, 0x81, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFF, 0x07, 0xE7, 0xF0, 0xFF, 0x83, 0xF1, 0xF8, 0x7F,
  0xC1, 0xF8, 0xFC, 0x3F, 0xF1, 0xFC, 0x7E, 0x1E, 0xF8, 0xFC, 0x3F, 0x9F,
  0x7C, 0x7E, 0x0F, 0xCF, 0xBE, 0x3F, 0x07, 0xE7, 0xCF, 0xBF, 0x83, 0xF3,
  0xE7, 0xDF, 0x81, 0xF9, 0xE3, 0xEF, 0xC0, 0x7D, 0xF1, 0xF7, 0xE0, 0x3F,
  0xF8, 0xFB, 0xF0, 0x1F, 0xFC, 0x3D, 0xF0, 0x0F, 0xFE, 0x1E, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x3F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF9, 0xFC, 0x0F,
  0xEF, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x07,
  0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3,
  0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xF0,
  0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xA0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 16, 10, 20, 2, -29 },
  { 47, 23, 29, 25, 1, -29 },
  { 131, 19, 33, 22, 2, -31 },
  { 210, 34, 30, 36, 1, -30 },
  { 338, 28, 30, 29, 1, -30 },
  { 443, 7, 10, 11, 2, -29 },
  { 452, 11, 36, 14, 2, -30 },
  { 502, 11, 36, 14, 1, -30 },
  { 552, 19, 19, 21, 1, -31 },
  { 598, 19, 19, 22, 2, -24 },
  { 644, 8, 11, 12, 1, -5 },
  { 655, 11, 6, 13, 1, -14 },
  { 664, 7, 7, 11, 2, -7 },
  { 671, 17, 30, 17, 0, -30 },
  { 735, 20, 30, 22, 1, -30 },
  { 810, 15, 29, 22, 2, -29 },
  { 865, 20, 30, 22, 1, -30 },
  { 940, 20, 30, 22, 1, -30 },
  { 1015, 21, 29, 22, 1, -29 },
  { 1092, 18, 29, 22, 2, -29 },
  { 1158, 20, 30, 22, 1, -30 },
  { 1233, 20, 29, 22, 1, -29 },
  { 1306, 20, 30, 22, 1, -30 },
  { 1381, 20, 30, 22, 1, -30 },
  { 1456, 7, 23, 11, 2, -23 },
  { 1477, 8, 29, 12, 1, -23 },
  { 1506, 19, 21, 22, 2, -25 },
  { 1556, 19, 13, 22, 2, -21 },
  { 1587, 19, 21, 22, 2, -25 },
  { 1637, 18, 30, 18, 0, -30 },
  { 1705, 31, 33, 34, 2, -30 },
  { 1833, 27, 29, 27, 0, -29 },
  { 1931, 21, 29, 26, 3, -29 },
  { 2008, 21, 30, 24, 2, -30 },
  { 2087, 23, 29, 28, 3, -29 },
  { 2171, 16, 29, 21, 3, -29 },
  { 2229, 16, 29, 21, 3, -29 },
  { 2287, 23, 30, 28, 2, -30 },
  { 2374, 23, 29, 29, 3, -29 },
  { 2458, 13, 29, 16, 1, -29 },
  { 2506, 13, 38, 13, -3, -29 },
  { 2568, 23, 29, 26, 3, -29 },
  { 2652, 17, 29, 21, 3, -29 },
  { 2714, 30, 29, 37, 3, -29 },
  { 2823, 25, 29, 31, 3, -29 },
  { 2914, 26, 30, 30, 2, -30 },
  { 3012, 19, 29, 24, 3, -29 },
  { 3081, 26, 37, 30, 2, -30 },
  { 3202, 22, 29, 25, 3, -29 },
  { 3282, 18, 30, 21, 2, -30 },
  { 3350, 20, 29, 22, 1, -29 },
  { 3423, 22, 29, 28, 3, -29 },
  { 3503, 25, 29, 25, 0, -29 },
  { 3594, 38, 29, 38, 0, -29 },
  { 3732, 25, 29, 25, 0, -29 },
  { 3823, 24, 29, 24, 0, -29 },
  { 3910, 20, 29, 22, 1, -29 },
  { 3983, 10, 37, 13, 2, -30 },
  { 4030, 17, 30, 17, 0, -30 },
  { 4094, 10, 37, 13, 1, -30 },
  { 4141, 22, 19, 22, 0, -29 },
  { 4194, 19, 4, 19, 0, 3 },
  { 4204, 11, 6, 15, 2, -31 },
  { 4213, 20, 23, 23, 1, -23 },
  { 4271, 20, 31, 24, 3, -31 },
  { 4349, 17, 23, 20, 2, -23 },
  { 4398, 20, 31, 24, 2, -31 },
  { 4476, 19, 23, 23, 2, -23 },
  { 4531, 15, 31, 15, 1, -31 },
  { 4590, 20, 33, 24, 2, -23 },
  { 4673, 19, 31, 25, 3, -31 },
  { 4747, 8, 31, 12, 2, -31 },
  { 4778, 11, 41, 12, -2, -31 },
  { 4835, 21, 31, 24, 3, -31 },
  { 4917, 6, 31, 12, 3, -31 },
  { 4941, 32, 23, 37, 3, -23 },
  { 5033, 19, 23, 25, 3, -23 },
  { 5088, 20, 23, 24, 2, -23 },
  { 5146, 20, 33, 24, 3, -23 },
  { 5229, 20, 33, 24, 2, -23 },
  { 5312, 14, 23, 17, 3, -23 },
  { 5353, 16, 23, 19, 2, -23 },
  { 5399, 15, 27, 17, 1, -27 },
  { 5450, 19, 23, 25, 3, -23 },
  { 5505, 22, 23, 22, 0, -23 },
  { 5569, 33, 23, 34, 0, -23 },
  { 5664, 22, 23, 22, 0, -23 },
  { 5728, 22, 33, 22, 0, -23 },
  { 5819, 17, 23, 19, 1, -23 },
  { 5868, 14, 36, 16, 1, -29 },
  { 5931, 5, 40, 20, 8, -31 },
  { 5956, 14, 36, 16, 1, -29 },
  { 6019, 19, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD41PT7B_H_
