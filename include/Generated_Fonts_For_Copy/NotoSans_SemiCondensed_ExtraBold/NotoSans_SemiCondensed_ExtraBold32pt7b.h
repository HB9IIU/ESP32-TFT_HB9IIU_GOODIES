#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF,
  0x1E, 0xF1, 0xEF, 0x1E, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xC7, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0xF3, 0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x1E, 0x01, 0xC7, 0x00, 0xF1,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x3F, 0xC1, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xBE, 0x67, 0x7C, 0xC0, 0xF9,
  0x81, 0xFB, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xBF, 0x03, 0x7F, 0xC6, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x07, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F, 0x00, 0x78,
  0x1F, 0xE0, 0x3C, 0x07, 0xFC, 0x0F, 0x03, 0xCF, 0x07, 0x80, 0xF3, 0xC1,
  0xE0, 0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x3C, 0x03, 0xCF, 0x1E, 0x00, 0xF3,
  0xC7, 0x80, 0x3C, 0xF3, 0xCF, 0x8F, 0x3C, 0xF7, 0xF9, 0xFF, 0x79, 0xFE,
  0x7F, 0x9E, 0xF7, 0xC7, 0xCF, 0x3C, 0xF0, 0x03, 0xCF, 0x3C, 0x01, 0xE3,
  0xCF, 0x00, 0x78, 0xF3, 0xC0, 0x3C, 0x3C, 0xF0, 0x0F, 0x0F, 0x3C, 0x07,
  0x83, 0xCF, 0x01, 0xE0, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x7C, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x7E, 0x7F, 0xF1, 0xF1,
  0xFF, 0xE7, 0xCF, 0xCF, 0xFF, 0x3E, 0x1F, 0xF8, 0xF8, 0x3F, 0xE3, 0xF0,
  0xFF, 0x0F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0x0F, 0x87, 0x87,
  0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x04, 0x3C, 0x2F, 0x3B, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFF, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xE7, 0xC3,
  0xC7, 0x01, 0x0C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7D, 0xF7, 0xDE,
  0x7B, 0xEF, 0xBC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7, 0xCF,
  0x8F, 0x9F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x3E, 0xF8, 0xFD,
  0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x73, 0xE4, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE7,
  0xFF, 0xE7, 0xCF, 0xC6, 0x0F, 0xC8, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3, 0x8F, 0xC4,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFF,
  0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8,
  0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x77, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xFC, 0x1F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF8, 0x7D, 0xF1,
  0xFB, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF,
  0xE7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x3E, 0x3E, 0xFC, 0x7F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x8F, 0xDF, 0x9F, 0x1F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFB, 0xFF, 0xF7,
  0xFF, 0xE7, 0xFF, 0xC7, 0xEF, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x77, 0xFF, 0xFF,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x39, 0xF7, 0xDF,
  0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x7D, 0xF7, 0xBE,
  0xFB, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFC,
  0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x70, 0xFD, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x03, 0xE1, 0xF0, 0x00,
  0xF0, 0xF0, 0xFF, 0x3C, 0xF1, 0xFF, 0x9E, 0x78, 0xFF, 0xC7, 0x3C, 0xF0,
  0xE3, 0x9C, 0x78, 0xF1, 0xFE, 0x78, 0x78, 0xFF, 0x3C, 0x3C, 0x7F, 0x9E,
  0x1E, 0x3B, 0xCF, 0x0F, 0x1D, 0xE3, 0xC7, 0x9E, 0x71, 0xFF, 0xFE, 0x3C,
  0xFF, 0x7F, 0x1E, 0x3F, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x01, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E,
  0x00, 0xFB, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFF,
  0xFE, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F,
  0x1E, 0x7E, 0x02, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xDF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE7, 0xF8, 0x73, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBF, 0x07, 0xDF,
  0xC3, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0xAF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0xFC, 0x0F, 0xFF,
  0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xCF,
  0xC3, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xEF, 0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x3F,
  0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC0,
  0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xC1, 0xFF, 0xFB, 0xC3, 0xDF,
  0xFB, 0xC3, 0xDF, 0xF9, 0xE3, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xE7, 0x9F,
  0xF9, 0xF7, 0x9F, 0xF8, 0xFF, 0x9F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F,
  0xF8, 0x7F, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x3E, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFB,
  0xE1, 0xFF, 0xBF, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x9F, 0xF8, 0xF9, 0xFF,
  0x8F, 0xDF, 0xF8, 0x7D, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x1F,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x3F, 0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFC, 0xFE, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xDF, 0x83, 0xF3, 0xE0, 0xFC, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xE3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xEF, 0xC0, 0xFC, 0x0F, 0xF0, 0x7F,
  0xF3, 0xFF, 0xDF, 0xFF, 0x7E, 0x7B, 0xF0, 0x2F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC3,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xDF, 0x03, 0xF7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9,
  0xF0, 0x0F, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xDF, 0x03, 0xF0, 0x3E, 0xF8,
  0x1F, 0x83, 0xF7, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x7F,
  0x07, 0xC7, 0xC3, 0xFC, 0x3E, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xEF, 0x1F,
  0x0F, 0x8F, 0x78, 0xF8, 0x3E, 0x7B, 0xE7, 0xC1, 0xF7, 0xCF, 0x3C, 0x0F,
  0xBE, 0x7B, 0xE0, 0x7D, 0xE3, 0xDF, 0x01, 0xEF, 0x1E, 0xF8, 0x0F, 0x78,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x1F,
  0x81, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x1F, 0x83,
  0xF0, 0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x1E,
  0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC0, 0xF3,
  0xC0, 0x7B, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x1C, 0x07, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF1, 0x87, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xDE, 0x7E, 0x3C, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE,
  0x7E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF1, 0xF0, 0x03, 0xF0, 0x3F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7F, 0x39,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x27, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F,
  0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0x7C, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x8F, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1E, 0x7C,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x0F,
  0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3E, 0x03, 0xE0, 0x3F, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F,
  0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0x7C, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00,
  0x1F, 0x00, 0x1F, 0x40, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x7C, 0x7D, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xF9, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0x27, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFE, 0xFC,
  0x70, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x7F, 0xF0, 0x7E, 0xF8, 0x7E, 0x7C, 0x7E, 0x3E, 0x3E,
  0x1F, 0x3F, 0x0F, 0xBF, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xE7, 0xC1, 0xF3,
  0xE0, 0xFD, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x7C, 0x79, 0xFE,
  0x7F, 0x3F, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB, 0xFF, 0xE1,
  0xF8, 0xFF, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F,
  0xFC, 0x1F, 0x07, 0xC0, 0xF1, 0xF1, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E,
  0x7C, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x07, 0xF0, 0xF1, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E,
  0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8,
  0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x7F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0xFE,
  0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F,
  0xC1, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0x82, 0x7C, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xDF,
  0xFE, 0xFF, 0xE3, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xDE, 0x3F, 0x3C, 0xF8, 0x0F, 0xFE, 0x07,
  0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C,
  0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x3F, 0x07, 0xDF, 0x0F, 0xC1, 0xF7, 0xC3, 0xF0, 0xF9, 0xF0, 0xFE, 0x3E,
  0x7C, 0x7F, 0x8F, 0x8F, 0x1F, 0xE3, 0xE3, 0xE7, 0xF9, 0xF0, 0xF9, 0xCE,
  0x7C, 0x3E, 0xF3, 0xDF, 0x07, 0xBC, 0xF7, 0xC1, 0xEF, 0x3D, 0xE0, 0x7F,
  0xCF, 0x78, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F,
  0xBF, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xC1, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFB, 0xF0, 0xFC, 0xF8, 0x7C, 0x7E, 0x7E, 0x1F, 0x7E, 0x0F,
  0xC0, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xF8, 0x3C, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x03, 0xDF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8, 0x3F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xC3, 0xF0,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFE,
  0x1F, 0xC1, 0xF8, 0x7F, 0x1F, 0x83, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 12, 8, 16, 2, -23 },
  { 28, 18, 23, 19, 1, -23 },
  { 80, 15, 26, 17, 1, -24 },
  { 129, 26, 23, 28, 1, -23 },
  { 204, 22, 23, 23, 1, -23 },
  { 268, 5, 8, 8, 2, -23 },
  { 273, 9, 28, 11, 1, -23 },
  { 305, 9, 28, 11, 1, -23 },
  { 337, 15, 14, 16, 1, -24 },
  { 364, 15, 15, 17, 1, -19 },
  { 393, 6, 8, 9, 1, -4 },
  { 399, 8, 5, 10, 1, -11 },
  { 404, 5, 5, 9, 2, -5 },
  { 408, 13, 23, 14, 0, -23 },
  { 446, 15, 23, 17, 1, -23 },
  { 490, 11, 23, 17, 2, -23 },
  { 522, 15, 23, 17, 1, -23 },
  { 566, 15, 23, 17, 1, -23 },
  { 610, 16, 23, 17, 1, -23 },
  { 656, 14, 23, 17, 2, -23 },
  { 697, 15, 23, 17, 1, -23 },
  { 741, 15, 23, 17, 1, -23 },
  { 785, 15, 23, 17, 1, -23 },
  { 829, 15, 23, 17, 1, -23 },
  { 873, 5, 18, 9, 2, -18 },
  { 885, 6, 22, 9, 1, -18 },
  { 902, 15, 17, 17, 1, -20 },
  { 934, 15, 10, 17, 1, -16 },
  { 953, 15, 17, 17, 1, -20 },
  { 985, 14, 23, 14, 0, -23 },
  { 1026, 25, 26, 27, 1, -23 },
  { 1108, 21, 23, 21, 0, -23 },
  { 1169, 16, 23, 20, 2, -23 },
  { 1215, 16, 23, 19, 2, -23 },
  { 1261, 18, 23, 22, 2, -23 },
  { 1313, 13, 23, 16, 2, -23 },
  { 1351, 13, 23, 16, 2, -23 },
  { 1389, 17, 23, 22, 2, -23 },
  { 1438, 18, 23, 23, 2, -23 },
  { 1490, 10, 23, 12, 1, -23 },
  { 1519, 10, 30, 10, -2, -23 },
  { 1557, 18, 23, 20, 2, -23 },
  { 1609, 14, 23, 16, 2, -23 },
  { 1650, 24, 23, 29, 2, -23 },
  { 1719, 20, 23, 24, 2, -23 },
  { 1777, 20, 23, 23, 2, -23 },
  { 1835, 15, 23, 19, 2, -23 },
  { 1879, 20, 28, 23, 2, -23 },
  { 1949, 18, 23, 20, 2, -23 },
  { 2001, 14, 23, 17, 1, -23 },
  { 2042, 15, 23, 17, 1, -23 },
  { 2086, 18, 23, 22, 2, -23 },
  { 2138, 20, 23, 20, 0, -23 },
  { 2196, 29, 23, 29, 0, -23 },
  { 2280, 20, 23, 20, 0, -23 },
  { 2338, 19, 23, 19, 0, -23 },
  { 2393, 15, 23, 17, 1, -23 },
  { 2437, 8, 28, 10, 2, -23 },
  { 2465, 13, 23, 14, 0, -23 },
  { 2503, 7, 28, 10, 1, -23 },
  { 2528, 17, 15, 17, 0, -23 },
  { 2560, 15, 3, 14, 0, 2 },
  { 2566, 9, 6, 12, 1, -25 },
  { 2573, 15, 18, 18, 1, -18 },
  { 2607, 16, 24, 19, 2, -24 },
  { 2655, 14, 18, 16, 1, -18 },
  { 2687, 16, 24, 19, 1, -24 },
  { 2735, 16, 18, 18, 1, -18 },
  { 2771, 12, 24, 12, 1, -24 },
  { 2807, 16, 26, 19, 1, -18 },
  { 2859, 15, 24, 19, 2, -24 },
  { 2904, 5, 25, 9, 2, -25 },
  { 2920, 8, 33, 9, -1, -25 },
  { 2953, 17, 24, 19, 2, -24 },
  { 3004, 5, 24, 9, 2, -24 },
  { 3019, 25, 18, 29, 2, -18 },
  { 3076, 15, 18, 19, 2, -18 },
  { 3110, 16, 18, 19, 1, -18 },
  { 3146, 16, 26, 19, 2, -18 },
  { 3198, 16, 26, 19, 1, -18 },
  { 3250, 11, 18, 14, 2, -18 },
  { 3275, 13, 18, 15, 1, -18 },
  { 3305, 11, 21, 13, 1, -21 },
  { 3334, 15, 18, 19, 2, -18 },
  { 3368, 17, 18, 17, 0, -18 },
  { 3407, 26, 18, 26, 0, -18 },
  { 3466, 17, 18, 17, 0, -18 },
  { 3505, 17, 26, 17, 0, -18 },
  { 3561, 13, 18, 15, 1, -18 },
  { 3591, 10, 28, 13, 1, -23 },
  { 3626, 4, 31, 16, 6, -24 },
  { 3642, 11, 28, 13, 1, -23 },
  { 3681, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD32PT7B_H_
