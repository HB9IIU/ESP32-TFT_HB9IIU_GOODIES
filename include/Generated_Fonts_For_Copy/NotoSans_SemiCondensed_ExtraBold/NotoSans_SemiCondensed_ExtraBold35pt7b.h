#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF,
  0xBE, 0x78, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x81, 0xFF,
  0xF1, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xBC, 0xFD, 0xC2, 0x7C, 0xE0, 0x3F,
  0x70, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x77, 0xE0, 0x39, 0xF6, 0x1D, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x3E, 0x01, 0xFE, 0x01, 0xE0, 0x1F,
  0xF0, 0x1E, 0x01, 0xF7, 0xC0, 0xF0, 0x0F, 0x9E, 0x0F, 0x00, 0x78, 0xF0,
  0x78, 0x03, 0xC7, 0xC7, 0x80, 0x1E, 0x3E, 0x3C, 0x00, 0xF1, 0xF3, 0xC0,
  0x07, 0x8F, 0x1E, 0x00, 0x3E, 0x79, 0xE3, 0xF0, 0xF7, 0xCF, 0x3F, 0xC7,
  0xFE, 0xFB, 0xFF, 0x1F, 0xE7, 0x9E, 0x78, 0x7E, 0x7D, 0xF3, 0xE0, 0x03,
  0xCF, 0x9F, 0x00, 0x3E, 0x7C, 0xF8, 0x01, 0xE3, 0xE7, 0xC0, 0x1F, 0x1F,
  0x3E, 0x00, 0xF0, 0xF9, 0xF0, 0x0F, 0x83, 0xCF, 0x80, 0x78, 0x1F, 0xF8,
  0x07, 0xC0, 0xFF, 0xC0, 0x3C, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x7E, 0x1F,
  0xF0, 0x7E, 0x3F, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xFE, 0xFC, 0xFC,
  0x7F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFE, 0xFC, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x07, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x87, 0xC7, 0xC3, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x83, 0xC1, 0xF3, 0xCE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8,
  0x7E, 0x7C, 0x3C, 0x7C, 0x0C, 0x30, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF,
  0x9E, 0x7C, 0xF9, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xF7,
  0xE3, 0xF1, 0xF9, 0xF0, 0xFC, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0xC7, 0xE7, 0xF7, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0x79, 0xF3, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC1, 0xF8, 0x40,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xC7, 0xF1, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x7F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xD0, 0x07, 0xEF, 0x8F,
  0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xBF, 0x07, 0x9F, 0x87, 0xCF, 0xC3,
  0xC7, 0xE3, 0xE3, 0xF3, 0xE1, 0xF9, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xCF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xFF, 0xCF, 0x7F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xFC, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3,
  0xFE, 0x11, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xFE,
  0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0xC3, 0xE7, 0xF7, 0xF1,
  0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x1F, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF8, 0xFC,
  0x7E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D,
  0xF8, 0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xBE, 0x02, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC4, 0x1F, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x00, 0x23, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xFE, 0x10, 0xF9, 0xFB, 0xF7, 0xEF, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x3E, 0x7C, 0xF0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7E,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF7, 0xCF, 0xE4, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x0F, 0x83, 0xF0, 0xF1, 0xE1, 0xFF, 0x9E,
  0x7C, 0x7F, 0xF1, 0xEF, 0x1F, 0x9E, 0x3D, 0xE3, 0xC3, 0xC7, 0xBC, 0xF8,
  0x78, 0xF7, 0x9E, 0x0F, 0x1F, 0xE3, 0xC1, 0xE3, 0xFC, 0x78, 0x3C, 0x7F,
  0x8F, 0x0F, 0x8F, 0x79, 0xE1, 0xF3, 0xCF, 0x1E, 0x7E, 0x79, 0xE3, 0xFF,
  0xFE, 0x3C, 0x3F, 0x9F, 0xC7, 0xC3, 0xE1, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x7C,
  0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0x7C, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xFB, 0xE1, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x1F, 0xC0, 0x47, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x02, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0,
  0x7F, 0xBE, 0x07, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x7F, 0x7C, 0x1F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x00, 0x9F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x0F, 0xBF, 0x81, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xF3, 0xF8,
  0x70, 0x00, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x1F, 0xCF,
  0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x3F, 0x87, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F,
  0x7F, 0x03, 0xEF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xF7, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x07, 0xF7, 0xC0, 0x7E, 0xF8,
  0x0F, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0xF0, 0x7B, 0xFF, 0xBC, 0x1E, 0xFF, 0xEF, 0x8F,
  0xBF, 0xFB, 0xE3, 0xEF, 0xFE, 0x78, 0xF3, 0xFF, 0x9F, 0x3C, 0xFF, 0xE7,
  0xDF, 0x3F, 0xF9, 0xF7, 0x8F, 0xFE, 0x3D, 0xE3, 0xFF, 0x8F, 0xF8, 0xFF,
  0xE3, 0xFE, 0x3F, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F, 0xC3, 0xFF, 0x87, 0xF0,
  0xFF, 0xE1, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xC0, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xDF, 0x87, 0xFE, 0xFC,
  0x3F, 0xF3, 0xF1, 0xFF, 0x9F, 0x8F, 0xFC, 0x7E, 0x7F, 0xE3, 0xF3, 0xFF,
  0x0F, 0xDF, 0xF8, 0x7E, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xDF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF9, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xDF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F,
  0x1F, 0x07, 0xE3, 0xE1, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xF1, 0xF0, 0x7F, 0x3E, 0x07, 0xE7, 0xC0, 0xFE,
  0xF8, 0x0F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7E, 0x04, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E,
  0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7E,
  0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF8, 0x7C, 0x3F, 0x1F, 0xF8, 0xFC,
  0x3F, 0x1F, 0x78, 0xFC, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x1E, 0x78, 0xF8,
  0x1F, 0x3E, 0x7C, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBE, 0x3D, 0xF8,
  0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3F, 0xF0,
  0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF9, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F,
  0x8F, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFE, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x87,
  0xE0, 0x7E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x7C,
  0x0F, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xF7, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x00, 0x40, 0x0F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF0, 0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x07, 0xFF, 0x9F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFF, 0xFF, 0xBF, 0xF7, 0xDF, 0xF3, 0xE3, 0xF1, 0xF0, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x40, 0xFD, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xE3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7D, 0xFF, 0x3E, 0x7F, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xE1, 0x9F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0xBF,
  0x8F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x06, 0x1F, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1,
  0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xFC, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xF7, 0xC3, 0xF1, 0xE0, 0x00, 0xC0, 0x03, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x06, 0x3F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0x00,
  0x07, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8,
  0x7E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x7E, 0xFE, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFB, 0xE1, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0x00, 0x7E, 0xE0,
  0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x40, 0xFD, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xE0, 0x7B, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0,
  0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF9, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF,
  0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xDF, 0x83,
  0xF3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xE1, 0xF9, 0xF8, 0x3F, 0x7E,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xEF, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F,
  0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x04, 0x0F, 0x9F, 0xE3, 0xF8, 0xFB, 0xFF,
  0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xFC, 0x7E,
  0xFE, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0x00, 0x20, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xC0, 0x01, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0, 0xF9,
  0xF0, 0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C,
  0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xF9, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x30, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xBF, 0x8F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x07, 0xF7, 0xC7, 0xFB, 0xE7,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8,
  0x7E, 0xFE, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFB, 0xE1, 0xF9, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01,
  0x00, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0xFF, 0xFB, 0xF0, 0x4F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x93, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF9, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xF7, 0xC7,
  0xF1, 0xE0, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0xC1, 0xF7, 0xC1, 0xFC, 0x3F, 0x7C, 0x1F, 0xC3, 0xF7, 0xE3,
  0xFC, 0x3E, 0x3E, 0x3F, 0xC3, 0xE3, 0xE3, 0xDE, 0x7E, 0x3E, 0x3D, 0xE7,
  0xE3, 0xF7, 0xDE, 0x7C, 0x1F, 0x79, 0xE7, 0xC1, 0xF7, 0x9E, 0x7C, 0x1F,
  0x78, 0xFF, 0xC1, 0xF7, 0x8F, 0xF8, 0x0F, 0x78, 0xFF, 0x80, 0xF7, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xEF, 0xE1, 0xF8,
  0xFC, 0x7E, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F,
  0xC1, 0xFB, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x3F,
  0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x3F, 0x0F, 0xF0, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF0,
  0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF4, 0x01,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 10, 2, -25 },
  { 20, 13, 9, 17, 2, -25 },
  { 35, 20, 25, 21, 1, -25 },
  { 98, 17, 29, 19, 1, -27 },
  { 160, 29, 25, 31, 1, -25 },
  { 251, 24, 25, 25, 1, -25 },
  { 326, 5, 9, 9, 2, -25 },
  { 332, 10, 31, 12, 1, -25 },
  { 371, 9, 31, 12, 1, -25 },
  { 406, 16, 16, 18, 1, -27 },
  { 438, 17, 17, 19, 1, -21 },
  { 475, 7, 10, 10, 1, -5 },
  { 484, 9, 5, 11, 1, -12 },
  { 490, 6, 6, 10, 2, -6 },
  { 495, 15, 25, 15, 0, -25 },
  { 542, 17, 25, 19, 1, -25 },
  { 596, 12, 25, 19, 2, -25 },
  { 634, 17, 25, 19, 1, -25 },
  { 688, 17, 25, 19, 1, -25 },
  { 742, 17, 25, 19, 1, -25 },
  { 796, 15, 25, 19, 2, -25 },
  { 843, 17, 25, 19, 1, -25 },
  { 897, 17, 25, 19, 1, -25 },
  { 951, 17, 25, 19, 1, -25 },
  { 1005, 17, 25, 19, 1, -25 },
  { 1059, 6, 20, 10, 2, -20 },
  { 1074, 7, 25, 10, 1, -20 },
  { 1096, 17, 18, 19, 1, -22 },
  { 1135, 17, 11, 19, 1, -18 },
  { 1159, 17, 18, 19, 1, -22 },
  { 1198, 15, 25, 16, 0, -25 },
  { 1245, 27, 28, 29, 1, -25 },
  { 1340, 23, 25, 23, 0, -25 },
  { 1412, 17, 25, 22, 3, -25 },
  { 1466, 18, 25, 21, 2, -25 },
  { 1523, 19, 25, 24, 3, -25 },
  { 1583, 13, 25, 18, 3, -25 },
  { 1624, 13, 25, 18, 3, -25 },
  { 1665, 19, 25, 24, 2, -25 },
  { 1725, 19, 25, 25, 3, -25 },
  { 1785, 11, 25, 13, 1, -25 },
  { 1820, 10, 33, 11, -2, -25 },
  { 1862, 19, 25, 22, 3, -25 },
  { 1922, 14, 25, 18, 3, -25 },
  { 1966, 26, 25, 31, 3, -25 },
  { 2048, 21, 25, 26, 3, -25 },
  { 2114, 22, 25, 25, 2, -25 },
  { 2183, 16, 25, 20, 3, -25 },
  { 2233, 22, 31, 25, 2, -25 },
  { 2319, 19, 25, 22, 3, -25 },
  { 2379, 16, 25, 18, 1, -25 },
  { 2429, 17, 25, 19, 1, -25 },
  { 2483, 19, 25, 24, 3, -25 },
  { 2543, 22, 25, 22, 0, -25 },
  { 2612, 32, 25, 32, 0, -25 },
  { 2712, 22, 25, 22, 0, -25 },
  { 2781, 21, 25, 21, 0, -25 },
  { 2847, 17, 25, 19, 1, -25 },
  { 2901, 8, 31, 11, 2, -25 },
  { 2932, 15, 25, 15, 0, -25 },
  { 2979, 8, 31, 11, 1, -25 },
  { 3010, 19, 16, 19, 0, -25 },
  { 3048, 16, 3, 16, 0, 3 },
  { 3054, 10, 6, 13, 1, -27 },
  { 3062, 17, 20, 20, 1, -20 },
  { 3105, 17, 27, 21, 2, -27 },
  { 3163, 15, 20, 17, 1, -20 },
  { 3201, 17, 27, 21, 1, -27 },
  { 3259, 17, 20, 19, 1, -20 },
  { 3302, 13, 27, 13, 1, -27 },
  { 3346, 17, 28, 21, 1, -20 },
  { 3406, 17, 27, 21, 2, -27 },
  { 3464, 6, 27, 10, 2, -27 },
  { 3485, 10, 35, 10, -2, -27 },
  { 3529, 19, 27, 21, 2, -27 },
  { 3594, 6, 27, 10, 2, -27 },
  { 3615, 28, 20, 32, 2, -20 },
  { 3685, 17, 20, 21, 2, -20 },
  { 3728, 18, 20, 20, 1, -20 },
  { 3773, 17, 28, 21, 2, -20 },
  { 3833, 17, 28, 21, 1, -20 },
  { 3893, 12, 20, 15, 2, -20 },
  { 3923, 14, 20, 16, 1, -20 },
  { 3958, 12, 23, 14, 1, -23 },
  { 3993, 17, 19, 21, 2, -19 },
  { 4034, 19, 19, 19, 0, -19 },
  { 4080, 28, 19, 29, 0, -19 },
  { 4147, 19, 19, 19, 0, -19 },
  { 4193, 19, 27, 19, 0, -19 },
  { 4258, 14, 19, 16, 1, -19 },
  { 4292, 12, 31, 14, 1, -25 },
  { 4339, 4, 35, 17, 7, -27 },
  { 4357, 12, 31, 14, 1, -25 },
  { 4404, 17, 6, 19, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD35PT7B_H_
