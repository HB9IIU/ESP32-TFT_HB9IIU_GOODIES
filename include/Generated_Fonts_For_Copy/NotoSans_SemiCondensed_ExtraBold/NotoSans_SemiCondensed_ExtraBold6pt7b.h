#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLD6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xA0, 0x6F, 0xEA, 0x5F, 0x3E, 0xD7, 0x4E, 0xB0, 0x66, 0xBF,
  0x80, 0x6A, 0x40, 0xD5, 0x80, 0x5F, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x69, 0x40, 0xF6, 0xB0, 0xD5, 0xE5, 0x70, 0xEC, 0xF0, 0x6F, 0x90, 0xFC,
  0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39,
  0x80, 0xFC, 0x8F, 0x00, 0xE9, 0x20, 0x77, 0xF7, 0xE0, 0x66, 0xE9, 0xFE,
  0xF0, 0x72, 0x30, 0xE9, 0x9E, 0xFE, 0x70, 0xFE, 0x40, 0x7A, 0x97, 0x9F,
  0x99, 0xD7, 0xF8, 0xBA, 0xEB, 0x92, 0x70, 0xDE, 0xEF, 0x50, 0xDB, 0xB9,
  0x79, 0x97, 0xF7, 0x40, 0x79, 0x97, 0x10, 0xEA, 0xEB, 0xF8, 0xF0, 0xE9,
  0x20, 0x99, 0x96, 0xB6, 0x66, 0xAE, 0xE5, 0x96, 0xF6, 0x6B, 0xB6, 0x44,
  0xE9, 0x70, 0xEA, 0xC0, 0x89, 0x30, 0xD5, 0xC0, 0x54, 0xE0, 0xC0, 0xFF,
  0x80, 0x93, 0xDE, 0xF1, 0x80, 0x27, 0xDE, 0xFD, 0x80, 0x5D, 0x40, 0xF7,
  0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x88, 0xAE, 0xB0, 0xF8, 0xFD, 0x6A, 0xF6,
  0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xEB, 0x80, 0x69, 0xB7,
  0x80, 0xAD, 0x00, 0xAF, 0x94, 0xEA, 0x80, 0xAD, 0x60, 0xEB, 0x80, 0x59,
  0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 2, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 1, 3, 2, 0, -3 },
  { 46, 1, 4, 2, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 5, 4, 5, 0, -4 },
  { 57, 4, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 1, 5, 2, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 5, 4, 5, 0, -4 },
  { 82, 4, 4, 5, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 4, 5, 4, 0, -4 },
  { 91, 4, 4, 4, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 4, 4, 4, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 6, 4, 6, 0, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 4, 4, 4, 0, -4 },
  { 108, 3, 4, 3, 0, -4 },
  { 110, 2, 5, 2, 0, -4 },
  { 112, 3, 4, 3, 0, -4 },
  { 114, 2, 5, 2, 0, -4 },
  { 116, 3, 2, 3, 0, -4 },
  { 117, 3, 1, 3, 0, 0 },
  { 118, 2, 1, 2, 0, -5 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 3, 5, 4, 0, -5 },
  { 123, 3, 3, 3, 0, -3 },
  { 125, 3, 5, 4, 0, -5 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 2, 5, 2, 0, -5 },
  { 131, 3, 4, 4, 0, -3 },
  { 133, 3, 5, 4, 0, -5 },
  { 135, 1, 5, 2, 0, -5 },
  { 136, 1, 6, 2, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 1, 5, 2, 0, -5 },
  { 141, 5, 3, 5, 0, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -3 },
  { 149, 3, 4, 4, 0, -3 },
  { 151, 2, 3, 3, 0, -3 },
  { 152, 3, 3, 3, 0, -3 },
  { 154, 2, 4, 2, 0, -4 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 5, 3, 5, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 3, 4, 3, 0, -3 },
  { 165, 3, 3, 3, 0, -3 },
  { 167, 2, 5, 2, 0, -4 },
  { 169, 1, 6, 3, 1, -5 },
  { 170, 2, 5, 2, 0, -4 },
  { 172, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBold6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLD6PT7B_H_
