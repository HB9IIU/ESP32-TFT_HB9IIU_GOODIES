#ifndef _NOTOSANS_EXTRACONDENSED_THIN46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x17, 0xE0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x10, 0x03, 0x06, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04,
  0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x06, 0x04, 0x01, 0x83, 0x07,
  0xFF, 0xFC, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x08, 0x03, 0x02, 0x00, 0x80, 0x80, 0x20, 0x60, 0x08, 0x10,
  0x3F, 0xFF, 0xC0, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01,
  0x81, 0x00, 0x40, 0xC0, 0x10, 0x30, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x0F, 0xF8,
  0x19, 0x0C, 0x21, 0x00, 0x61, 0x00, 0x41, 0x00, 0x41, 0x00, 0xC1, 0x00,
  0xC1, 0x00, 0xC1, 0x00, 0x41, 0x00, 0x41, 0x00, 0x21, 0x00, 0x31, 0x00,
  0x1D, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0x60, 0x01, 0x18, 0x01, 0x0C,
  0x01, 0x06, 0x01, 0x02, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03,
  0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x81, 0x0C, 0x79, 0x38, 0x1F, 0xE0,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x3E, 0x00, 0x80, 0x88,
  0x06, 0x04, 0x10, 0x10, 0x10, 0x40, 0x40, 0x41, 0x83, 0x02, 0x02, 0x08,
  0x08, 0x08, 0x20, 0x20, 0x20, 0x80, 0x80, 0x84, 0x02, 0x02, 0x10, 0x08,
  0x08, 0x40, 0x20, 0x22, 0x00, 0x80, 0x88, 0x02, 0x02, 0x23, 0xCC, 0x09,
  0x11, 0x90, 0x64, 0xC2, 0x41, 0x12, 0x0D, 0x04, 0x88, 0x12, 0x22, 0x20,
  0x4F, 0x88, 0x81, 0x00, 0x46, 0x04, 0x01, 0x10, 0x10, 0x04, 0x40, 0x40,
  0x21, 0x01, 0x00, 0x84, 0x04, 0x02, 0x18, 0x10, 0x18, 0x60, 0x40, 0x40,
  0x81, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x30, 0x20, 0x30, 0x80, 0x80, 0x42,
  0x06, 0x00, 0xF0, 0x07, 0x80, 0x04, 0x20, 0x02, 0x08, 0x02, 0x04, 0x01,
  0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x0C, 0x10,
  0x02, 0x08, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x24, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x0C, 0x80, 0x0C, 0x60, 0x04, 0x10, 0x24, 0x04, 0x12,
  0x02, 0x09, 0x00, 0x8C, 0x80, 0x44, 0xC0, 0x12, 0x60, 0x0D, 0x10, 0x03,
  0x08, 0x00, 0x84, 0x00, 0xC2, 0x00, 0xD0, 0x80, 0x48, 0x60, 0xC2, 0x1F,
  0xC1, 0x80, 0xFF, 0xF0, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x0C, 0x46, 0x7B, 0x01, 0x80, 0x50, 0x09,
  0x02, 0x10, 0x83, 0x30, 0x20, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x32,
  0x22, 0x66, 0x44, 0xC8, 0x80, 0xFF, 0xC0, 0xFC, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0x61, 0x81, 0x03, 0x08, 0x04, 0x20, 0x19, 0x80,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xD0, 0x03, 0x40, 0x09, 0x00, 0x24,
  0x00, 0x98, 0x02, 0x20, 0x18, 0xC0, 0x41, 0x03, 0x06, 0x18, 0x0F, 0xC0,
  0x02, 0x1C, 0x69, 0x96, 0x38, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC1, 0x81, 0x84, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xFF, 0xFC, 0x3F, 0xC1, 0x81, 0x88, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x30, 0x18, 0x7F,
  0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x05, 0x80,
  0x02, 0xC0, 0x02, 0x60, 0x01, 0x30, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x86,
  0x00, 0x43, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x20, 0x60, 0x10, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x08, 0x06, 0x04, 0x03, 0x06, 0x01, 0x82, 0x00, 0xC3,
  0x00, 0x61, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x3F, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x08,
  0x07, 0xFE, 0x10, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x30, 0x18, 0x7F, 0xC0, 0x03, 0xF8,
  0x18, 0x20, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x1F, 0x0D, 0x83,
  0x3C, 0x04, 0xE0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x03, 0x60,
  0x08, 0x80, 0x23, 0x01, 0x04, 0x0C, 0x0F, 0xE0, 0x0C, 0x00, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x40, 0xC2,
  0x01, 0x90, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D,
  0x00, 0x26, 0x00, 0x88, 0x06, 0x30, 0x30, 0x61, 0x80, 0xCC, 0x00, 0xC0,
  0x07, 0x80, 0x61, 0x83, 0x03, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00,
  0x26, 0x01, 0x8C, 0x0C, 0x1F, 0xE0, 0x0F, 0xC0, 0xC1, 0x82, 0x03, 0x10,
  0x04, 0x40, 0x13, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x40, 0x1D,
  0x80, 0xF3, 0x06, 0xC7, 0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x7F, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x67, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x32, 0x26, 0x64, 0x4C,
  0x88, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x7E, 0x20, 0x40, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0x83, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x01,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40,
  0x08, 0x0C, 0x80, 0xFC, 0x0B, 0x03, 0x08, 0x14, 0x0C, 0x10, 0x28, 0x10,
  0x20, 0x50, 0x20, 0x40, 0xA0, 0xC0, 0x81, 0x41, 0x01, 0x02, 0x82, 0x02,
  0x07, 0x04, 0x04, 0x0E, 0x08, 0x18, 0x1C, 0x10, 0x30, 0x28, 0x20, 0x60,
  0x50, 0x40, 0xC0, 0xA0, 0xC1, 0x83, 0x40, 0x85, 0x04, 0x81, 0x0A, 0x09,
  0x01, 0xB3, 0x63, 0x01, 0x83, 0x82, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x16, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x30, 0x01, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x20, 0x40, 0x30, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x06, 0x06, 0x01,
  0x03, 0xFF, 0x81, 0x00, 0x40, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x88, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0D,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x80, 0xFF, 0x02, 0x07, 0x88, 0x03,
  0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0xC8, 0x06, 0x3F, 0xE0, 0x80,
  0xE2, 0x00, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0A, 0x00, 0x68,
  0x03, 0x20, 0x38, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0x03, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x01, 0x01, 0xFF, 0xFE,
  0x01, 0x07, 0x82, 0x01, 0x84, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x34, 0x00, 0x48, 0x01, 0x90, 0x02, 0x20, 0x18, 0x40, 0xE0, 0xFF,
  0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFE,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x70, 0x1C, 0x18, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0xFD, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x00, 0x88, 0x00, 0x11, 0x80, 0x02, 0x10, 0x00, 0x41, 0x00, 0x08, 0x18,
  0x03, 0x01, 0xFF, 0xC0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0xC6, 0xF8, 0x80, 0x1C, 0x00, 0xA0, 0x0D,
  0x00, 0x48, 0x04, 0x40, 0x62, 0x02, 0x10, 0x30, 0x81, 0x04, 0x10, 0x21,
  0x81, 0x08, 0x08, 0xC0, 0x44, 0x02, 0x40, 0x17, 0x00, 0xA8, 0x06, 0x60,
  0x31, 0x01, 0x0C, 0x08, 0x20, 0x41, 0x82, 0x04, 0x10, 0x30, 0x80, 0x84,
  0x06, 0x20, 0x11, 0x00, 0xC8, 0x02, 0x40, 0x1A, 0x00, 0x50, 0x03, 0x80,
  0x08, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xE0, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x80, 0x00, 0x5A, 0x00, 0x01, 0x6C, 0x00, 0x0D, 0x90, 0x00, 0x26,
  0x40, 0x00, 0x99, 0x80, 0x06, 0x62, 0x00, 0x11, 0x88, 0x00, 0x46, 0x20,
  0x01, 0x18, 0xC0, 0x08, 0x61, 0x00, 0x21, 0x84, 0x00, 0x86, 0x18, 0x06,
  0x18, 0x20, 0x10, 0x60, 0x80, 0x41, 0x83, 0x03, 0x06, 0x04, 0x08, 0x18,
  0x10, 0x20, 0x60, 0x41, 0x81, 0x80, 0x84, 0x06, 0x02, 0x10, 0x18, 0x08,
  0x40, 0x60, 0x33, 0x01, 0x80, 0x48, 0x06, 0x01, 0x20, 0x18, 0x07, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xA0, 0x03, 0xA0, 0x03, 0x90, 0x03, 0x90, 0x03, 0x98, 0x03,
  0x88, 0x03, 0x8C, 0x03, 0x84, 0x03, 0x84, 0x03, 0x82, 0x03, 0x82, 0x03,
  0x81, 0x03, 0x81, 0x03, 0x81, 0x83, 0x80, 0x83, 0x80, 0xC3, 0x80, 0x43,
  0x80, 0x43, 0x80, 0x23, 0x80, 0x23, 0x80, 0x13, 0x80, 0x13, 0x80, 0x1B,
  0x80, 0x0B, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x03, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x0C, 0x0C, 0x00, 0x81, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x4C,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x41, 0x00, 0x08, 0x30, 0x03, 0x02,
  0x00, 0xC0, 0x30, 0x30, 0x03, 0xFC, 0x00, 0xFE, 0x04, 0x3E, 0x20, 0x19,
  0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x64, 0x0E,
  0x3F, 0x81, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0x81, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00,
  0x4C, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x61, 0x00, 0x08, 0x30, 0x03,
  0x02, 0x00, 0xC0, 0x30, 0x30, 0x03, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0xFE, 0x02, 0x0F, 0x08, 0x06, 0x20, 0x0C, 0x80, 0x12,
  0x00, 0x48, 0x01, 0xA0, 0x06, 0x80, 0x1A, 0x00, 0x68, 0x01, 0xA0, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x18, 0x80, 0xC3, 0xFC, 0x08, 0x20,
  0x20, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x20, 0x20, 0x80, 0xC2, 0x01,
  0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48, 0x01, 0xA0, 0x02, 0x80,
  0x0C, 0x0F, 0xF4, 0x60, 0x22, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x20, 0x1C, 0xFF, 0xC0, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60,
  0x02, 0x30, 0x04, 0x18, 0x08, 0x0F, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0xD0,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x80, 0x08, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x03, 0x0C, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x06, 0x01,
  0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x0D, 0x00, 0x0C,
  0x00, 0x24, 0x00, 0x30, 0x00, 0x90, 0x00, 0xC0, 0x02, 0x40, 0x07, 0x00,
  0x19, 0x80, 0x14, 0x00, 0x42, 0x00, 0x58, 0x01, 0x08, 0x01, 0x20, 0x04,
  0x20, 0x04, 0x80, 0x30, 0x80, 0x32, 0x00, 0x83, 0x00, 0x88, 0x02, 0x04,
  0x02, 0x30, 0x08, 0x10, 0x08, 0x40, 0x20, 0x40, 0x21, 0x01, 0x81, 0x81,
  0x84, 0x04, 0x06, 0x04, 0x10, 0x10, 0x08, 0x10, 0x60, 0x40, 0x20, 0x40,
  0x83, 0x00, 0x81, 0x02, 0x0C, 0x03, 0x0C, 0x08, 0x20, 0x04, 0x20, 0x20,
  0x80, 0x10, 0x80, 0xC2, 0x00, 0x42, 0x01, 0x18, 0x01, 0x08, 0x04, 0x40,
  0x06, 0x60, 0x11, 0x00, 0x09, 0x00, 0x44, 0x00, 0x24, 0x01, 0x90, 0x00,
  0x90, 0x02, 0xC0, 0x03, 0x40, 0x0A, 0x00, 0x0F, 0x00, 0x28, 0x00, 0x18,
  0x00, 0xA0, 0x00, 0x60, 0x02, 0x80, 0x01, 0x80, 0x04, 0x00, 0x20, 0x06,
  0x40, 0x08, 0xC0, 0x10, 0x80, 0x61, 0x00, 0x81, 0x03, 0x02, 0x04, 0x06,
  0x08, 0x04, 0x30, 0x08, 0x40, 0x18, 0x80, 0x12, 0x00, 0x24, 0x00, 0x78,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0B, 0x00, 0x12, 0x00,
  0x64, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10, 0x08, 0x10, 0x30, 0x20, 0x40,
  0x40, 0x80, 0x43, 0x00, 0x84, 0x01, 0x98, 0x01, 0x20, 0x02, 0xC0, 0x06,
  0x80, 0x07, 0x00, 0x14, 0x00, 0xD0, 0x02, 0x60, 0x08, 0x80, 0x62, 0x01,
  0x0C, 0x04, 0x10, 0x10, 0x40, 0x81, 0x82, 0x02, 0x08, 0x08, 0x40, 0x31,
  0x00, 0x44, 0x01, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x7F, 0xF8,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x40,
  0x02, 0x60, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x81, 0x81, 0x80,
  0x0E, 0x03, 0xFC, 0x40, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x1F, 0x0E, 0x13, 0x01, 0x40, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x05, 0xC0, 0x56, 0x09,
  0x3F, 0x10, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x38, 0x23, 0xB8, 0x90,
  0x12, 0x80, 0x6A, 0x00, 0xB0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xA8, 0x02, 0xB0, 0x12,
  0x60, 0xC8, 0xFE, 0x00, 0x03, 0xC1, 0xEC, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x38, 0x43, 0xB9,
  0x10, 0x34, 0x80, 0x56, 0x00, 0xD0, 0x03, 0x40, 0x05, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x01, 0x40, 0x05, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x20,
  0x14, 0x40, 0x90, 0xFC, 0x40, 0x07, 0x00, 0x7E, 0x04, 0x08, 0x40, 0x26,
  0x01, 0x20, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0xFF,
  0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x03, 0x0F, 0xF0, 0x03, 0xE0,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x7F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x03,
  0x80, 0x3B, 0x91, 0x03, 0x48, 0x05, 0x60, 0x0D, 0x00, 0x34, 0x00, 0x50,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x03, 0x40, 0x0D,
  0x80, 0x52, 0x01, 0x44, 0x09, 0x0F, 0xC4, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0A, 0x00, 0x46, 0x06,
  0x0F, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0xE1, 0x1F, 0xC9, 0x02, 0x50,
  0x0A, 0x80, 0x58, 0x02, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0xF4,
  0x00, 0x15, 0x55, 0x55, 0x55, 0x55, 0x55, 0x40, 0x18, 0xC2, 0x00, 0x00,
  0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0x8D, 0xC0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x06, 0x80, 0x48, 0x08, 0x81, 0x88, 0x10,
  0x83, 0x08, 0x20, 0x84, 0x08, 0xC0, 0x8C, 0x09, 0x40, 0xB6, 0x0A, 0x20,
  0xC2, 0x0C, 0x10, 0x81, 0x08, 0x18, 0x80, 0x88, 0x08, 0x80, 0x48, 0x04,
  0x80, 0x68, 0x02, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0xC2, 0x77, 0x1D, 0xC9, 0x04, 0x41, 0xA8, 0x0A, 0x02, 0xA0, 0x28, 0x0B,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x03, 0x04, 0x77, 0x24, 0x0D,
  0x40, 0x2A, 0x01, 0x60, 0x0B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x03, 0x80, 0x3B, 0x81, 0x03, 0x08, 0x06, 0x60, 0x09, 0x00, 0x34, 0x00,
  0x50, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40,
  0x08, 0x80, 0x22, 0x01, 0x86, 0x0C, 0x0F, 0xE0, 0x03, 0x82, 0x3B, 0x89,
  0x83, 0x2C, 0x06, 0xA0, 0x0A, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xA0, 0x0A, 0x80, 0x2B, 0x01,
  0x26, 0x0C, 0x8F, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03,
  0x80, 0x3F, 0x91, 0x03, 0x48, 0x05, 0x20, 0x0D, 0x00, 0x34, 0x00, 0x50,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x03, 0x40, 0x0D,
  0x80, 0x53, 0x01, 0x46, 0x09, 0x0F, 0xC4, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x03, 0x47, 0xE4, 0x16, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x07, 0x07, 0xFD, 0x81, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x14, 0x06, 0xFF, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x1F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x54, 0x02, 0xA0, 0x25,
  0x83, 0x27, 0xF1, 0xC0, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x26, 0x01, 0x10,
  0x08, 0x80, 0xC4, 0x04, 0x20, 0x20, 0x81, 0x04, 0x18, 0x20, 0x81, 0x04,
  0x0C, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80, 0x64, 0x01, 0x20, 0x0B, 0x00,
  0x50, 0x02, 0x80, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x02, 0x80, 0x30, 0x05,
  0x00, 0x60, 0x1A, 0x01, 0xC0, 0x22, 0x02, 0xC0, 0x44, 0x04, 0x80, 0x88,
  0x09, 0x03, 0x10, 0x12, 0x04, 0x30, 0x64, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x10, 0xC1, 0x0C, 0x21, 0x01, 0x18, 0x62, 0x02, 0x20,
  0x44, 0x04, 0x40, 0x98, 0x08, 0x81, 0x20, 0x1B, 0x02, 0x40, 0x14, 0x06,
  0x80, 0x28, 0x05, 0x00, 0x50, 0x0E, 0x00, 0xA0, 0x18, 0x00, 0xC0, 0x30,
  0x01, 0x00, 0x60, 0xC0, 0x12, 0x01, 0x98, 0x08, 0x40, 0xC3, 0x04, 0x08,
  0x20, 0x62, 0x01, 0x10, 0x09, 0x00, 0x28, 0x01, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x80, 0x24, 0x01, 0x10, 0x18, 0x80, 0x86, 0x0C, 0x10, 0x40, 0xC6,
  0x02, 0x20, 0x1B, 0x00, 0x50, 0x03, 0x40, 0x05, 0x80, 0x32, 0x00, 0x88,
  0x02, 0x20, 0x08, 0xC0, 0x61, 0x01, 0x04, 0x04, 0x10, 0x10, 0x60, 0xC0,
  0x82, 0x02, 0x08, 0x08, 0x20, 0x31, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40,
  0x1B, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x02, 0x60, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0xFF, 0x00, 0x70, 0x1C, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x07, 0x80, 0xF0, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xF0,
  0x0E, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x07, 0x80, 0x3E, 0x01, 0x61, 0x81, 0x80, 0x7E, 0x00, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 33, 9, 3, -33 },
  { 14, 7, 12, 13, 3, -33 },
  { 25, 18, 33, 20, 1, -33 },
  { 100, 16, 38, 18, 1, -35 },
  { 176, 22, 33, 26, 2, -33 },
  { 267, 17, 33, 18, 1, -33 },
  { 338, 1, 12, 7, 3, -33 },
  { 340, 8, 40, 12, 2, -33 },
  { 380, 8, 40, 12, 2, -33 },
  { 420, 11, 12, 16, 2, -35 },
  { 437, 16, 21, 18, 1, -27 },
  { 479, 4, 11, 8, 2, -5 },
  { 485, 10, 1, 12, 1, -13 },
  { 487, 2, 3, 8, 3, -3 },
  { 488, 13, 33, 15, 1, -33 },
  { 542, 14, 33, 18, 2, -33 },
  { 600, 7, 33, 18, 4, -33 },
  { 629, 14, 33, 18, 2, -33 },
  { 687, 14, 33, 18, 2, -33 },
  { 745, 17, 33, 18, 1, -33 },
  { 816, 14, 33, 18, 2, -33 },
  { 874, 14, 34, 18, 2, -33 },
  { 934, 14, 33, 18, 2, -33 },
  { 992, 14, 33, 18, 2, -33 },
  { 1050, 14, 33, 18, 2, -33 },
  { 1108, 2, 24, 8, 3, -24 },
  { 1114, 4, 30, 8, 2, -24 },
  { 1129, 16, 19, 18, 1, -26 },
  { 1167, 16, 11, 18, 1, -22 },
  { 1189, 16, 19, 18, 1, -26 },
  { 1227, 10, 33, 12, 1, -33 },
  { 1269, 23, 37, 28, 2, -33 },
  { 1376, 17, 33, 17, 0, -33 },
  { 1447, 14, 33, 20, 4, -33 },
  { 1505, 16, 33, 19, 2, -33 },
  { 1571, 15, 33, 22, 4, -33 },
  { 1633, 11, 33, 18, 4, -33 },
  { 1679, 11, 33, 16, 4, -33 },
  { 1725, 19, 33, 24, 2, -33 },
  { 1804, 15, 33, 22, 4, -33 },
  { 1866, 6, 33, 10, 2, -33 },
  { 1891, 7, 41, 9, -2, -33 },
  { 1927, 13, 33, 17, 4, -33 },
  { 1981, 11, 33, 16, 4, -33 },
  { 2027, 22, 33, 30, 4, -33 },
  { 2118, 16, 33, 23, 4, -33 },
  { 2184, 19, 33, 24, 2, -33 },
  { 2263, 13, 33, 18, 4, -33 },
  { 2317, 19, 41, 24, 2, -33 },
  { 2415, 14, 33, 19, 4, -33 },
  { 2473, 14, 33, 18, 2, -33 },
  { 2531, 15, 33, 15, 0, -33 },
  { 2593, 16, 33, 22, 3, -33 },
  { 2659, 17, 33, 17, 0, -33 },
  { 2730, 30, 33, 30, 0, -33 },
  { 2854, 15, 33, 15, 0, -33 },
  { 2916, 14, 33, 14, 0, -33 },
  { 2974, 13, 33, 15, 1, -33 },
  { 3028, 8, 40, 14, 4, -33 },
  { 3068, 13, 33, 15, 1, -33 },
  { 3122, 8, 40, 14, 2, -33 },
  { 3162, 16, 16, 18, 1, -33 },
  { 3194, 18, 1, 18, 0, 4 },
  { 3197, 7, 7, 10, 2, -35 },
  { 3204, 12, 25, 17, 2, -25 },
  { 3242, 14, 35, 20, 3, -35 },
  { 3304, 11, 25, 14, 2, -25 },
  { 3339, 14, 35, 20, 2, -35 },
  { 3401, 13, 25, 17, 2, -25 },
  { 3442, 11, 35, 10, 0, -35 },
  { 3491, 14, 36, 19, 2, -25 },
  { 3554, 13, 35, 19, 3, -35 },
  { 3611, 2, 33, 8, 3, -33 },
  { 3620, 5, 44, 8, 0, -33 },
  { 3648, 12, 35, 15, 3, -35 },
  { 3701, 1, 35, 8, 3, -35 },
  { 3706, 22, 25, 28, 3, -25 },
  { 3775, 13, 25, 19, 3, -25 },
  { 3816, 14, 25, 19, 2, -25 },
  { 3860, 14, 36, 19, 3, -25 },
  { 3923, 14, 36, 19, 2, -25 },
  { 3986, 9, 25, 12, 3, -25 },
  { 4015, 11, 25, 14, 2, -25 },
  { 4050, 8, 30, 10, 1, -30 },
  { 4080, 13, 24, 19, 3, -24 },
  { 4119, 13, 24, 13, 0, -24 },
  { 4158, 23, 24, 24, 0, -24 },
  { 4227, 13, 24, 14, 1, -24 },
  { 4266, 14, 35, 15, 0, -24 },
  { 4328, 10, 24, 12, 1, -24 },
  { 4358, 12, 40, 16, 2, -33 },
  { 4418, 1, 46, 17, 8, -35 },
  { 4424, 11, 40, 16, 2, -33 },
  { 4479, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Thin46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN46PT7B_H_
