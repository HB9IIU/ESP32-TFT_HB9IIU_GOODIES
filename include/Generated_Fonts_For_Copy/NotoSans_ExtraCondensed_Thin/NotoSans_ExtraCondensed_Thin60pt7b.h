#ifndef _NOTOSANS_EXTRACONDENSED_THIN60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x02, 0xC0, 0xB0, 0x2C,
  0x0B, 0x02, 0x00, 0x40, 0x20, 0x01, 0x80, 0x40, 0x03, 0x00, 0x80, 0x06,
  0x01, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x40,
  0x30, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x02,
  0x00, 0x18, 0x04, 0x0F, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x00, 0x80, 0x60,
  0x01, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x02,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x08, 0x06, 0x07, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x20, 0x01, 0x80, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x08, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x40, 0x20,
  0x01, 0x80, 0x40, 0x03, 0x00, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x10, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0xE4, 0x7C, 0x38, 0x40, 0xC3,
  0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00,
  0xC0, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40,
  0x0C, 0x04, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x38, 0x40, 0x01, 0xC4,
  0x00, 0x07, 0x40, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x4E, 0x00, 0x04, 0x30, 0x00, 0x41, 0x80, 0x04, 0x0C, 0x00, 0x40, 0x60,
  0x04, 0x02, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x03,
  0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00, 0x40,
  0xC8, 0x04, 0x18, 0xF0, 0x47, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x0C,
  0x01, 0x8C, 0x00, 0x40, 0x18, 0x30, 0x02, 0x00, 0x80, 0x80, 0x30, 0x04,
  0x04, 0x01, 0x80, 0x60, 0x30, 0x08, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x04,
  0x06, 0x00, 0x80, 0x20, 0x20, 0x04, 0x01, 0x03, 0x00, 0x20, 0x08, 0x18,
  0x01, 0x00, 0x40, 0x80, 0x08, 0x02, 0x0C, 0x00, 0x40, 0x10, 0x60, 0x02,
  0x00, 0x82, 0x00, 0x10, 0x04, 0x30, 0x00, 0x80, 0x21, 0x80, 0x04, 0x01,
  0x08, 0x7C, 0x30, 0x18, 0xC6, 0x31, 0x80, 0xC6, 0x20, 0xCC, 0x06, 0x23,
  0x02, 0x20, 0x23, 0x10, 0x19, 0x83, 0x18, 0x80, 0xCC, 0x18, 0x84, 0x02,
  0x31, 0x8C, 0x60, 0x10, 0xF8, 0x63, 0x00, 0x80, 0x02, 0x18, 0x06, 0x00,
  0x30, 0xC0, 0x30, 0x01, 0x86, 0x01, 0x80, 0x08, 0x20, 0x0C, 0x00, 0xC1,
  0x00, 0x60, 0x06, 0x0C, 0x03, 0x00, 0x20, 0x60, 0x18, 0x01, 0x03, 0x00,
  0xC0, 0x18, 0x18, 0x04, 0x00, 0x80, 0xC0, 0x20, 0x04, 0x06, 0x01, 0x00,
  0x60, 0x10, 0x18, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x06, 0x04, 0x01, 0x80,
  0x10, 0x60, 0x08, 0x00, 0xC2, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x03, 0xE0, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x10, 0x10, 0x00,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x10, 0x03, 0x00, 0x80, 0x18, 0x04,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x18, 0x00, 0x80, 0xC0, 0x06,
  0x04, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x06, 0x30, 0x00, 0x13, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x33,
  0x00, 0x03, 0x08, 0x00, 0x30, 0x60, 0x03, 0x01, 0x00, 0x98, 0x0C, 0x04,
  0x80, 0x30, 0x6C, 0x00, 0x83, 0x60, 0x06, 0x1B, 0x00, 0x10, 0x90, 0x00,
  0xC4, 0x80, 0x02, 0x64, 0x00, 0x1A, 0x20, 0x00, 0x71, 0x80, 0x03, 0x8C,
  0x00, 0x1C, 0x20, 0x00, 0xA1, 0x80, 0x0D, 0x8C, 0x00, 0xC4, 0x30, 0x0C,
  0x30, 0xC0, 0xC0, 0x83, 0xFC, 0x06, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x70, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x10, 0x20, 0x78, 0x47, 0x0E, 0xB8, 0x07, 0x80, 0x07,
  0x00, 0x12, 0x00, 0x62, 0x01, 0x82, 0x02, 0x06, 0x08, 0x06, 0x30, 0x04,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0xC6,
  0x31, 0x18, 0xC6, 0x23, 0x18, 0x84, 0x60, 0xFF, 0xF0, 0xDF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0x87, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x0C,
  0x00, 0xC2, 0x00, 0x31, 0x80, 0x04, 0x60, 0x01, 0x90, 0x00, 0x64, 0x00,
  0x1B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02,
  0x40, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x04, 0x20, 0x01, 0x0C,
  0x00, 0xC3, 0x00, 0x20, 0x60, 0x18, 0x0C, 0x0C, 0x03, 0x87, 0x00, 0x3F,
  0x00, 0x00, 0x80, 0xC1, 0xA1, 0xD1, 0x89, 0x85, 0x83, 0x81, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x0F, 0xF8, 0x07, 0x83, 0xC1, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0x83, 0xC1, 0x80, 0x1C, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x80, 0x03, 0x1E, 0x01,
  0xC0, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x36, 0x00, 0x00,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x11, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80,
  0x60, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC2, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x40, 0x0F, 0xFF, 0x83,
  0xC0, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x80,
  0x0E, 0x38, 0x0E, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x00, 0xF0,
  0xC0, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xFE,
  0x0C, 0xF1, 0xC3, 0x60, 0x18, 0xD0, 0x03, 0x38, 0x00, 0x4E, 0x00, 0x1B,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x0D, 0x00, 0x02, 0x60, 0x00, 0x98, 0x00, 0x62, 0x00, 0x18,
  0xC0, 0x0C, 0x18, 0x02, 0x03, 0x03, 0x80, 0x7F, 0xC0, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFC, 0x01, 0xC1, 0xC0, 0x70, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x0C,
  0x40, 0x01, 0x98, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x0D,
  0x80, 0x01, 0x30, 0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x84, 0x00, 0x60,
  0xC0, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x70, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x07, 0x70, 0x01, 0xC3, 0x00, 0x60, 0x30, 0x18, 0x03, 0x06,
  0x00, 0x30, 0xC0, 0x03, 0x30, 0x00, 0x64, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x31, 0x80, 0x06, 0x18,
  0x01, 0x81, 0xC0, 0xE0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x07, 0xF8, 0x03,
  0x83, 0x01, 0x80, 0x60, 0x40, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00,
  0x09, 0x80, 0x02, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xC8, 0x00, 0x53, 0x00,
  0x14, 0x60, 0x09, 0x0C, 0x0C, 0x41, 0xFE, 0x10, 0x04, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x08, 0x1C, 0x03, 0xFE, 0x00, 0x18, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x19, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x46, 0x31, 0x88, 0xC6, 0x21,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x3F, 0xC7, 0x07, 0x20, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06, 0x30, 0x01, 0xE0, 0x18, 0x80,
  0x1F, 0xE0, 0x26, 0x00, 0xC1, 0x80, 0x98, 0x06, 0x06, 0x03, 0x60, 0x10,
  0x18, 0x0D, 0x00, 0xC0, 0x60, 0x34, 0x02, 0x01, 0x00, 0xD0, 0x18, 0x04,
  0x03, 0xC0, 0x60, 0x10, 0x0F, 0x01, 0x80, 0x40, 0x1C, 0x06, 0x01, 0x00,
  0x70, 0x18, 0x04, 0x01, 0xC0, 0x40, 0x10, 0x07, 0x01, 0x00, 0xC0, 0x3C,
  0x04, 0x03, 0x00, 0xF0, 0x10, 0x0C, 0x03, 0xC0, 0x40, 0x30, 0x0F, 0x01,
  0x80, 0xC0, 0x3C, 0x06, 0x03, 0x00, 0x90, 0x18, 0x1C, 0x06, 0x40, 0x20,
  0x58, 0x19, 0x00, 0xC3, 0x20, 0xC6, 0x01, 0x98, 0xE6, 0x18, 0x03, 0xC1,
  0xF0, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x20, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x03,
  0x40, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62,
  0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x80, 0x80,
  0x03, 0x01, 0x00, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x10, 0x04, 0x00,
  0x60, 0x08, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x40, 0x1F, 0xFF, 0x80, 0x30, 0x01, 0x80, 0x40, 0x03, 0x01, 0x80,
  0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x30, 0x00,
  0x10, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0D,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x18, 0xFF, 0xE0, 0x3F, 0xFF, 0x08, 0x00,
  0xE2, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00,
  0xE2, 0x00, 0xF0, 0xFF, 0xF0, 0x20, 0x0F, 0x08, 0x00, 0x62, 0x00, 0x0C,
  0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x0C,
  0x80, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1E, 0x07,
  0x03, 0x80, 0x10, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x10, 0x0E, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x80, 0x1C, 0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x18,
  0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00,
  0xC8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00,
  0x60, 0x80, 0x1C, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF,
  0xD0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F,
  0xFF, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x00,
  0xC0, 0x60, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80,
  0x70, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0xFF, 0x8E, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x3F, 0xE0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x1A, 0x0C, 0xFE, 0x04,
  0x00, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x18, 0x80, 0x06,
  0x20, 0x03, 0x08, 0x00, 0x82, 0x00, 0x60, 0x80, 0x30, 0x20, 0x0C, 0x08,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x18, 0x02, 0x0C,
  0x00, 0x82, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x02, 0x30, 0x00, 0x9E, 0x00,
  0x25, 0x80, 0x0B, 0x30, 0x03, 0x8C, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08,
  0x0C, 0x02, 0x03, 0x00, 0x80, 0x60, 0x20, 0x18, 0x08, 0x03, 0x02, 0x00,
  0xC0, 0x80, 0x18, 0x20, 0x06, 0x08, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x06,
  0x20, 0x01, 0x88, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x68,
  0x00, 0x0C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00,
  0x2E, 0xC0, 0x00, 0x01, 0xBB, 0x00, 0x00, 0x06, 0xE4, 0x00, 0x00, 0x13,
  0x98, 0x00, 0x00, 0x4E, 0x60, 0x00, 0x03, 0x38, 0x80, 0x00, 0x0C, 0xE2,
  0x00, 0x00, 0x23, 0x8C, 0x00, 0x01, 0x8E, 0x30, 0x00, 0x06, 0x38, 0x40,
  0x00, 0x10, 0xE1, 0x80, 0x00, 0xC3, 0x86, 0x00, 0x03, 0x0E, 0x08, 0x00,
  0x08, 0x38, 0x30, 0x00, 0x60, 0xE0, 0xC0, 0x01, 0x83, 0x81, 0x00, 0x06,
  0x0E, 0x04, 0x00, 0x10, 0x38, 0x18, 0x00, 0xC0, 0xE0, 0x60, 0x03, 0x03,
  0x80, 0x80, 0x08, 0x0E, 0x03, 0x00, 0x60, 0x38, 0x0C, 0x01, 0x80, 0xE0,
  0x10, 0x04, 0x03, 0x80, 0x60, 0x30, 0x0E, 0x01, 0x80, 0xC0, 0x38, 0x02,
  0x03, 0x00, 0xE0, 0x0C, 0x08, 0x03, 0x80, 0x30, 0x60, 0x0E, 0x00, 0xC1,
  0x80, 0x38, 0x01, 0x04, 0x00, 0xE0, 0x06, 0x30, 0x03, 0x80, 0x18, 0xC0,
  0x0E, 0x00, 0x22, 0x00, 0x38, 0x00, 0xD8, 0x00, 0xE0, 0x03, 0x60, 0x03,
  0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3A, 0x00,
  0x01, 0xD8, 0x00, 0x0E, 0x40, 0x00, 0x73, 0x00, 0x03, 0x88, 0x00, 0x1C,
  0x60, 0x00, 0xE1, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x00,
  0x0E, 0x0C, 0x00, 0x70, 0x20, 0x03, 0x81, 0x80, 0x1C, 0x04, 0x00, 0xE0,
  0x30, 0x07, 0x01, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x80,
  0x70, 0x06, 0x03, 0x80, 0x10, 0x1C, 0x00, 0xC0, 0xE0, 0x02, 0x07, 0x00,
  0x18, 0x38, 0x00, 0xC1, 0xC0, 0x02, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x43,
  0x80, 0x03, 0x1C, 0x00, 0x08, 0xE0, 0x00, 0x67, 0x00, 0x01, 0x38, 0x00,
  0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x03, 0xC1, 0xE0, 0x07,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x10,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x20, 0x0F, 0x10,
  0x01, 0xC8, 0x00, 0x64, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x48,
  0x00, 0x64, 0x00, 0x62, 0x00, 0xE1, 0xFF, 0xC0, 0xFE, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0xFF, 0x80, 0x3F, 0xFC, 0x08, 0x01, 0xC2, 0x00,
  0x38, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x04, 0x80, 0x01,
  0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68,
  0x00, 0x1A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00,
  0x18, 0x80, 0x0C, 0x20, 0x0E, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x80, 0xC0,
  0x20, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0x80, 0x20, 0x20, 0x0C, 0x08,
  0x01, 0x02, 0x00, 0x60, 0x80, 0x18, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00,
  0x18, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x04, 0x80, 0x01,
  0xA0, 0x00, 0x28, 0x00, 0x0C, 0x07, 0xFF, 0x03, 0x80, 0xE3, 0x80, 0x08,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x80,
  0x06, 0x38, 0x07, 0x07, 0xFF, 0x80, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x18,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x10,
  0x08, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x40, 0x02, 0x01,
  0x00, 0x08, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00,
  0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x02,
  0x10, 0x00, 0x08, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20,
  0x00, 0x05, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x80, 0x00, 0x60, 0x00,
  0x09, 0x00, 0x00, 0xE0, 0x00, 0x33, 0x00, 0x01, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0x80, 0x00, 0xCC, 0x00, 0x0D, 0x00, 0x01, 0x08, 0x00, 0x1A, 0x00,
  0x06, 0x18, 0x00, 0x36, 0x00, 0x0C, 0x30, 0x00, 0x6C, 0x00, 0x18, 0x60,
  0x00, 0x98, 0x00, 0x20, 0xC0, 0x03, 0x10, 0x00, 0x40, 0x80, 0x06, 0x20,
  0x01, 0x81, 0x80, 0x0C, 0x60, 0x03, 0x03, 0x00, 0x18, 0xC0, 0x06, 0x06,
  0x00, 0x21, 0x80, 0x08, 0x04, 0x00, 0x43, 0x00, 0x30, 0x08, 0x01, 0x82,
  0x00, 0x60, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x18, 0x02, 0x00, 0x40, 0x10, 0x30, 0x0C, 0x00, 0xC0, 0x60,
  0x20, 0x18, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x06, 0x02, 0x01, 0x80, 0x80, 0x04, 0x04, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x02, 0x06, 0x00, 0x18, 0x30, 0x04, 0x0C, 0x00, 0x30, 0x60, 0x0C, 0x10,
  0x00, 0x20, 0x80, 0x18, 0x60, 0x00, 0x41, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x42, 0x00, 0x03, 0x18, 0x00, 0xC4,
  0x00, 0x02, 0x20, 0x01, 0x98, 0x00, 0x06, 0x40, 0x03, 0x30, 0x00, 0x0D,
  0x80, 0x02, 0x60, 0x00, 0x1B, 0x00, 0x04, 0x80, 0x00, 0x36, 0x00, 0x0D,
  0x00, 0x00, 0x28, 0x00, 0x1E, 0x00, 0x00, 0x50, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC8,
  0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x10, 0x01, 0x86, 0x00, 0x41, 0x80,
  0x30, 0x20, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x40, 0x18, 0x30,
  0x02, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x04, 0x40, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x60,
  0x06, 0x08, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x30, 0x10, 0x08, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x20, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00,
  0x19, 0x80, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x0C, 0xC0, 0x00,
  0x78, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0x40, 0x01,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x01, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x04, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x01, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0x41, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x11, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x60, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x20, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01,
  0x98, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x07, 0xF0, 0x3E, 0x3C, 0x10, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0x03, 0xE3, 0x0E, 0x03, 0x18, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x05, 0x40, 0x05, 0x60, 0x0D, 0x20, 0x09,
  0x38, 0x31, 0x1F, 0xE1, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0xFE, 0x06, 0x38, 0xF0, 0xCC, 0x07, 0x1B, 0x00,
  0x63, 0x40, 0x06, 0x70, 0x00, 0x4E, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00,
  0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x01,
  0xB8, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0x9E, 0x00, 0x33, 0x40, 0x0C,
  0x64, 0x01, 0x8C, 0xE0, 0xE1, 0x8F, 0xF8, 0x00, 0x10, 0x00, 0x01, 0xFE,
  0x0F, 0x18, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x81, 0x83, 0xFF, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0x04, 0x38, 0x71,
  0x18, 0x06, 0x4C, 0x00, 0xD3, 0x00, 0x15, 0x80, 0x05, 0x60, 0x00, 0xD0,
  0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01, 0x48, 0x00, 0x53, 0x00,
  0x34, 0x60, 0x19, 0x1C, 0x0C, 0x41, 0xFE, 0x10, 0x08, 0x00, 0x03, 0xF0,
  0x07, 0x1C, 0x06, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x23, 0x00, 0x19, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x08, 0x38, 0x1C, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x1F,
  0xC1, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x01, 0xFF, 0x1F, 0xF8, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x03, 0xF8, 0x43, 0xCF, 0x11, 0x80, 0x64, 0xC0, 0x0D, 0x30, 0x01, 0x58,
  0x00, 0x76, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x76, 0x00,
  0x14, 0x80, 0x05, 0x30, 0x02, 0x46, 0x01, 0x90, 0xC0, 0xC4, 0x1F, 0xE1,
  0x00, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x31, 0x00, 0x18, 0x70, 0x1C, 0x0F, 0xFE, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC3, 0xF8, 0xC7, 0x1C, 0xCC, 0x0E, 0xD8, 0x06, 0xD0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xA0, 0x00, 0x00, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x0E,
  0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C,
  0xF0, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x23,
  0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xC3,
  0x01, 0x86, 0x03, 0x18, 0x06, 0x38, 0x0C, 0xF0, 0x1B, 0x20, 0x34, 0x60,
  0x78, 0x40, 0xE0, 0xC1, 0x81, 0x83, 0x01, 0x06, 0x03, 0x0C, 0x02, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x08, 0xC0, 0x19, 0x80, 0x13, 0x00, 0x36, 0x00,
  0x6C, 0x00, 0x58, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x87, 0xF0, 0x1F, 0x88, 0xE3, 0x87, 0x1C,
  0x98, 0x08, 0x40, 0x69, 0x00, 0xC8, 0x02, 0xF0, 0x05, 0x80, 0x3E, 0x00,
  0x50, 0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0,
  0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20,
  0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C,
  0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02,
  0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01,
  0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00,
  0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0x83, 0xF8, 0x87,
  0x1C, 0x8C, 0x06, 0x98, 0x06, 0x90, 0x03, 0xA0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x03, 0xF8, 0x03, 0x8F, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x26,
  0x00, 0x18, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01, 0xC0, 0xC0, 0xE0, 0x1F,
  0xE0, 0x00, 0xC0, 0x00, 0x83, 0xF8, 0x10, 0xE3, 0xC2, 0x30, 0x1C, 0x4C,
  0x01, 0x89, 0x00, 0x19, 0x60, 0x01, 0x28, 0x00, 0x35, 0x00, 0x06, 0xE0,
  0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00,
  0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x02, 0x68, 0x00, 0xCD, 0x80,
  0x31, 0x98, 0x0E, 0x33, 0x83, 0x86, 0x1F, 0xC0, 0xC0, 0x40, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x43, 0xCF, 0x11, 0xC0,
  0x64, 0x60, 0x0D, 0x30, 0x01, 0x48, 0x00, 0x56, 0x00, 0x0D, 0x00, 0x03,
  0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x40, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x14, 0x80, 0x05, 0x30, 0x02, 0x46,
  0x01, 0x90, 0xC1, 0xC4, 0x1F, 0xE1, 0x01, 0xC0, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x83, 0xF0, 0xEF, 0x30, 0x6C, 0x0D, 0x01, 0xA0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x0F, 0xF8,
  0x3C, 0x7C, 0xC0, 0x13, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xD0, 0x03, 0x38, 0x0E, 0x1F, 0xF0, 0x07, 0x00,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xFF, 0xFF,
  0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x18, 0x41, 0xF8, 0x0C, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x05, 0x40, 0x05, 0x60, 0x0D, 0x70, 0x19, 0x38, 0x31, 0x1F, 0xE1, 0x03,
  0x80, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x11,
  0x00, 0x18, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x18, 0x03, 0x04, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x20, 0x20, 0x30, 0x10, 0x18, 0x0C,
  0x08, 0x06, 0x04, 0x01, 0x06, 0x00, 0x83, 0x00, 0x61, 0x00, 0x30, 0x80,
  0x08, 0xC0, 0x04, 0x60, 0x03, 0x20, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x2C,
  0x00, 0x16, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0A, 0x00, 0x24,
  0x00, 0x50, 0x01, 0x20, 0x02, 0xC0, 0x19, 0x00, 0x36, 0x00, 0xCC, 0x01,
  0xB0, 0x06, 0x60, 0x08, 0x80, 0x21, 0x00, 0x44, 0x01, 0x08, 0x06, 0x30,
  0x18, 0x60, 0x31, 0x80, 0xC3, 0x01, 0x84, 0x04, 0x08, 0x08, 0x20, 0x20,
  0x40, 0x41, 0x01, 0x02, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xC1,
  0x81, 0x04, 0x02, 0x08, 0x08, 0x20, 0x10, 0x40, 0x63, 0x00, 0xC6, 0x03,
  0x18, 0x06, 0x30, 0x18, 0x80, 0x11, 0x00, 0x44, 0x00, 0x88, 0x02, 0x20,
  0x06, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x80, 0x05,
  0x00, 0x14, 0x00, 0x28, 0x00, 0xA0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x80, 0x40, 0x01, 0xB0, 0x01, 0x88, 0x00, 0xC6,
  0x00, 0xC1, 0x00, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x18, 0x10, 0x0C, 0x18,
  0x02, 0x08, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0xD8, 0x00, 0x64, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x30, 0x60, 0x18, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x04, 0x01, 0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x0D, 0x80,
  0x03, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x11,
  0x00, 0x18, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x08, 0x03, 0x04, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x08, 0x02, 0x0C, 0x01, 0x06, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x11, 0x80,
  0x08, 0xC0, 0x06, 0x60, 0x03, 0x20, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x09, 0x80,
  0x07, 0xC0, 0x01, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x80, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x01, 0xE0, 0xE0,
  0x38, 0x03, 0xCE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 43, 12, 4, -43 },
  { 18, 10, 16, 18, 4, -43 },
  { 38, 23, 43, 25, 1, -43 },
  { 162, 20, 49, 24, 2, -46 },
  { 285, 29, 44, 34, 3, -43 },
  { 445, 21, 44, 23, 2, -43 },
  { 561, 2, 16, 10, 4, -43 },
  { 565, 10, 52, 16, 3, -43 },
  { 630, 11, 52, 16, 2, -43 },
  { 702, 15, 16, 20, 3, -46 },
  { 732, 20, 28, 24, 2, -35 },
  { 802, 5, 14, 11, 2, -6 },
  { 811, 12, 1, 16, 2, -17 },
  { 813, 3, 4, 11, 4, -4 },
  { 815, 18, 43, 20, 1, -43 },
  { 912, 18, 43, 24, 3, -43 },
  { 1009, 9, 43, 24, 5, -43 },
  { 1058, 19, 43, 24, 2, -43 },
  { 1161, 19, 44, 24, 2, -43 },
  { 1266, 22, 43, 24, 1, -43 },
  { 1385, 18, 44, 24, 3, -43 },
  { 1484, 18, 44, 24, 3, -43 },
  { 1583, 18, 43, 24, 3, -43 },
  { 1680, 19, 44, 24, 2, -43 },
  { 1785, 18, 44, 24, 2, -43 },
  { 1884, 3, 32, 11, 4, -32 },
  { 1896, 5, 40, 11, 2, -32 },
  { 1921, 20, 24, 24, 2, -33 },
  { 1981, 20, 14, 24, 2, -28 },
  { 2016, 20, 24, 24, 2, -33 },
  { 2076, 13, 43, 16, 1, -43 },
  { 2146, 30, 49, 36, 3, -43 },
  { 2330, 23, 43, 23, 0, -43 },
  { 2454, 18, 43, 26, 5, -43 },
  { 2551, 20, 44, 25, 3, -43 },
  { 2661, 20, 43, 28, 5, -43 },
  { 2769, 15, 43, 23, 5, -43 },
  { 2850, 15, 43, 21, 5, -43 },
  { 2931, 25, 44, 31, 3, -43 },
  { 3069, 19, 43, 29, 5, -43 },
  { 3172, 9, 43, 13, 2, -43 },
  { 3221, 10, 54, 11, -3, -43 },
  { 3289, 18, 43, 23, 5, -43 },
  { 3386, 14, 43, 20, 5, -43 },
  { 3462, 30, 43, 39, 5, -43 },
  { 3624, 21, 43, 30, 5, -43 },
  { 3737, 24, 44, 31, 3, -43 },
  { 3869, 17, 43, 24, 5, -43 },
  { 3961, 24, 53, 31, 3, -43 },
  { 4120, 18, 43, 24, 5, -43 },
  { 4217, 18, 44, 23, 3, -43 },
  { 4316, 20, 43, 20, 0, -43 },
  { 4424, 21, 44, 29, 4, -43 },
  { 4540, 22, 43, 22, 0, -43 },
  { 4659, 39, 43, 39, 0, -43 },
  { 4869, 18, 43, 20, 1, -43 },
  { 4966, 19, 43, 19, 0, -43 },
  { 5069, 16, 43, 19, 2, -43 },
  { 5155, 11, 52, 18, 5, -43 },
  { 5227, 18, 43, 20, 1, -43 },
  { 5324, 11, 52, 18, 2, -43 },
  { 5396, 22, 21, 24, 1, -43 },
  { 5454, 24, 2, 24, 0, 5 },
  { 5460, 9, 10, 14, 2, -46 },
  { 5472, 16, 33, 22, 2, -32 },
  { 5538, 19, 47, 25, 4, -46 },
  { 5650, 15, 33, 19, 3, -32 },
  { 5712, 18, 47, 25, 3, -46 },
  { 5818, 17, 33, 23, 3, -32 },
  { 5889, 13, 46, 13, 1, -46 },
  { 5964, 18, 47, 25, 3, -32 },
  { 6070, 16, 46, 24, 4, -46 },
  { 6162, 3, 43, 11, 4, -43 },
  { 6179, 7, 58, 11, 0, -43 },
  { 6230, 15, 46, 19, 4, -46 },
  { 6317, 2, 46, 10, 4, -46 },
  { 6329, 28, 32, 36, 4, -32 },
  { 6441, 16, 32, 24, 4, -32 },
  { 6505, 18, 33, 24, 3, -32 },
  { 6580, 19, 46, 25, 4, -32 },
  { 6690, 18, 46, 25, 3, -32 },
  { 6794, 11, 32, 16, 4, -32 },
  { 6838, 15, 33, 19, 2, -32 },
  { 6900, 11, 40, 13, 1, -39 },
  { 6955, 16, 33, 24, 4, -32 },
  { 7021, 17, 32, 18, 0, -32 },
  { 7089, 29, 32, 31, 1, -32 },
  { 7205, 17, 32, 19, 1, -32 },
  { 7273, 17, 47, 19, 1, -32 },
  { 7373, 12, 32, 15, 2, -32 },
  { 7421, 15, 52, 21, 3, -43 },
  { 7519, 1, 61, 23, 11, -46 },
  { 7527, 15, 52, 21, 3, -43 },
  { 7625, 20, 5, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Thin60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN60PT7B_H_
