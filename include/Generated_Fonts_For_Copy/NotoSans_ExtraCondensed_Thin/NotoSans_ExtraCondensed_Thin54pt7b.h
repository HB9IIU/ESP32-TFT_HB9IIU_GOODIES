#ifndef _NOTOSANS_EXTRACONDENSED_THIN54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x2F, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x60, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x06,
  0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x06,
  0x02, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x60,
  0x02, 0x03, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x60,
  0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0x80, 0x40, 0x04, 0x06, 0x07,
  0xFF, 0xFF, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x06, 0x02,
  0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x60, 0x02,
  0x03, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x1C, 0x9F,
  0x0C, 0x20, 0xC6, 0x08, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x08,
  0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x08, 0x03, 0x02,
  0x00, 0x40, 0x80, 0x18, 0x20, 0x03, 0x88, 0x00, 0x32, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x02, 0x60, 0x00, 0x8E, 0x00, 0x20, 0xC0,
  0x08, 0x10, 0x02, 0x06, 0x00, 0x80, 0x80, 0x20, 0x30, 0x08, 0x0C, 0x02,
  0x03, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x18, 0x02, 0x04, 0x00, 0x83,
  0x30, 0x23, 0x87, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x10, 0x04, 0x60, 0x04, 0x02, 0x08,
  0x03, 0x00, 0x83, 0x00, 0x80, 0x60, 0x40, 0x20, 0x10, 0x10, 0x18, 0x04,
  0x06, 0x04, 0x01, 0x01, 0x81, 0x00, 0x40, 0x60, 0xC0, 0x10, 0x18, 0x20,
  0x0C, 0x02, 0x08, 0x03, 0x00, 0x86, 0x00, 0xC0, 0x21, 0x00, 0x30, 0x08,
  0x40, 0x04, 0x06, 0x30, 0x01, 0x01, 0x8C, 0x30, 0x40, 0x62, 0x1B, 0x10,
  0x19, 0x88, 0x64, 0x04, 0x66, 0x09, 0x81, 0x11, 0x03, 0x20, 0xCC, 0x40,
  0xCC, 0x23, 0x30, 0x11, 0x98, 0x8C, 0x04, 0x3C, 0x22, 0x01, 0x00, 0x18,
  0x80, 0x40, 0x04, 0x20, 0x10, 0x01, 0x08, 0x04, 0x00, 0xC2, 0x01, 0x00,
  0x20, 0x80, 0x40, 0x08, 0x20, 0x10, 0x06, 0x08, 0x04, 0x01, 0x03, 0x01,
  0x00, 0x40, 0xC0, 0x40, 0x30, 0x30, 0x10, 0x08, 0x04, 0x0C, 0x02, 0x01,
  0x02, 0x01, 0x80, 0x60, 0x80, 0x40, 0x0C, 0x60, 0x30, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0x8C, 0x00, 0x20, 0x80, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x20,
  0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40,
  0x40, 0x08, 0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00, 0x22,
  0x00, 0x04, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x01, 0x98,
  0x00, 0x61, 0x00, 0x08, 0x30, 0x03, 0x02, 0x02, 0x40, 0x60, 0xD8, 0x04,
  0x1A, 0x00, 0x42, 0x40, 0x08, 0x48, 0x00, 0x89, 0x00, 0x1B, 0x20, 0x01,
  0x44, 0x00, 0x38, 0x80, 0x02, 0x18, 0x00, 0xE3, 0x00, 0x14, 0x20, 0x06,
  0x46, 0x01, 0x88, 0x60, 0x60, 0x87, 0xF8, 0x18, 0x10, 0x00, 0xFF, 0xFC,
  0x01, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80,
  0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x03,
  0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01, 0x81, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x81, 0x05, 0xC4, 0x61, 0xDE,
  0x00, 0xC0, 0x03, 0x80, 0x12, 0x00, 0x84, 0x06, 0x08, 0x30, 0x10, 0x80,
  0x40, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x11, 0x33, 0x32, 0x26, 0x64,
  0xC8, 0xFF, 0xF0, 0xBF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x0C, 0x70, 0x18, 0x18, 0x30, 0x08, 0x20, 0x0C, 0x60, 0x04, 0x60, 0x04,
  0x40, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06,
  0x40, 0x06, 0x40, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x18, 0x18,
  0x0C, 0x30, 0x07, 0xE0, 0x00, 0x80, 0xC1, 0xE1, 0xB1, 0x99, 0x8D, 0x87,
  0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x0F, 0xE0, 0x1E, 0x1C, 0x18, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xE0, 0x1E, 0x3C, 0x18, 0x03, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC8, 0x00, 0xC7, 0x00, 0xC1, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0x60, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x04,
  0x60, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x10, 0x60, 0x03,
  0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x06, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x20, 0x06, 0x06, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x9F, 0xC0,
  0xFC, 0xF0, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x80, 0x18, 0xC0, 0x70, 0x7F, 0xC0, 0x00, 0xF8, 0x03, 0xDC,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x8F, 0xF0, 0x98, 0x18, 0xB0, 0x0C, 0xA0, 0x04,
  0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18,
  0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0xF0,
  0x07, 0x9C, 0x06, 0x01, 0x86, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x98, 0x00, 0x4C, 0x00, 0x22,
  0x00, 0x31, 0x80, 0x10, 0x60, 0x18, 0x18, 0x18, 0x06, 0x38, 0x01, 0xB0,
  0x00, 0x70, 0x00, 0x6C, 0x00, 0x63, 0x00, 0xC0, 0x60, 0xC0, 0x18, 0x40,
  0x04, 0x60, 0x03, 0x20, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00,
  0x4C, 0x00, 0x63, 0x00, 0x60, 0xE0, 0x60, 0x3F, 0xE0, 0x01, 0x00, 0x07,
  0xE0, 0x0C, 0x38, 0x18, 0x08, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40,
  0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40,
  0x03, 0x60, 0x03, 0x20, 0x05, 0x30, 0x0D, 0x1C, 0x39, 0x07, 0xE1, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x40, 0x60, 0x3F, 0xC0, 0x0C, 0x00, 0xBF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x2F, 0xC0, 0x31, 0x8E, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x42,
  0x31, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0x0F, 0x3C, 0x80, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x08, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03,
  0x30, 0x03, 0x80, 0x66, 0x01, 0xFC, 0x04, 0x80, 0x60, 0x80, 0x90, 0x08,
  0x10, 0x16, 0x03, 0x02, 0x03, 0xC0, 0x40, 0x40, 0x78, 0x18, 0x08, 0x0F,
  0x03, 0x01, 0x01, 0xE0, 0x40, 0x20, 0x38, 0x08, 0x0C, 0x07, 0x01, 0x01,
  0x80, 0xE0, 0x20, 0x30, 0x1C, 0x04, 0x06, 0x03, 0x80, 0x80, 0xC0, 0x70,
  0x10, 0x18, 0x0E, 0x02, 0x03, 0x01, 0x60, 0x40, 0x60, 0x2C, 0x0C, 0x1C,
  0x0D, 0x81, 0x82, 0x81, 0x30, 0x18, 0xD8, 0x62, 0x01, 0xB1, 0xF8, 0x40,
  0x1C, 0x1E, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x0D, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x00, 0x00, 0x98, 0x00, 0x18, 0x80,
  0x01, 0x88, 0x00, 0x10, 0x80, 0x01, 0x0C, 0x00, 0x10, 0x40, 0x03, 0x04,
  0x00, 0x20, 0x40, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x02, 0x00, 0x60,
  0x20, 0x04, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x00, 0xC0, 0x10, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x18, 0x01, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81,
  0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x06,
  0x20, 0x00, 0x66, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0x80, 0x7F, 0xFC, 0x30, 0x07,
  0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0,
  0x01, 0x60, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x1B,
  0x00, 0x09, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x0C, 0x3F, 0xF8, 0x18, 0x0F,
  0x0C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00,
  0xE6, 0x03, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x78, 0xF0, 0x70, 0x04,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x0F, 0xF8, 0x00, 0x20, 0xFF,
  0x00, 0x1F, 0xFE, 0x03, 0x00, 0xE0, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x06, 0x30, 0x00, 0x46, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00,
  0x02, 0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00,
  0x0B, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00,
  0x26, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03,
  0x0C, 0x01, 0xC1, 0x81, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xB0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x83, 0xC0, 0x30, 0x01, 0xC1, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x30, 0x00, 0x04, 0x60, 0x00, 0x10,
  0x80, 0x00, 0x43, 0x00, 0x01, 0x07, 0x00, 0x04, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x04, 0xFF, 0x7E, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02, 0x86, 0xFC, 0xC0,
  0x03, 0x60, 0x01, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0xC3,
  0x00, 0x41, 0x80, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x30, 0x30, 0x18, 0x10,
  0x0C, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66,
  0x00, 0x37, 0x00, 0x1A, 0xC0, 0x0F, 0x20, 0x07, 0x18, 0x03, 0x04, 0x01,
  0x83, 0x00, 0xC0, 0x80, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x02,
  0x06, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x06, 0x30,
  0x01, 0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x5F, 0x00, 0x00, 0x0B, 0xE0, 0x00, 0x03, 0x74, 0x00,
  0x00, 0x4E, 0x80, 0x00, 0x09, 0xD8, 0x00, 0x03, 0x39, 0x00, 0x00, 0x67,
  0x20, 0x00, 0x08, 0xE6, 0x00, 0x01, 0x1C, 0x40, 0x00, 0x63, 0x88, 0x00,
  0x08, 0x71, 0x80, 0x01, 0x0E, 0x30, 0x00, 0x61, 0xC2, 0x00, 0x08, 0x38,
  0x40, 0x01, 0x07, 0x0C, 0x00, 0x60, 0xE0, 0x80, 0x0C, 0x1C, 0x10, 0x01,
  0x03, 0x83, 0x00, 0x60, 0x70, 0x20, 0x0C, 0x0E, 0x04, 0x01, 0x01, 0xC0,
  0xC0, 0x20, 0x38, 0x18, 0x0C, 0x07, 0x01, 0x01, 0x00, 0xE0, 0x30, 0x20,
  0x1C, 0x06, 0x0C, 0x03, 0x80, 0x41, 0x80, 0x70, 0x08, 0x20, 0x0E, 0x01,
  0x8C, 0x01, 0xC0, 0x11, 0x80, 0x38, 0x02, 0x20, 0x07, 0x00, 0x6C, 0x00,
  0xE0, 0x0D, 0x80, 0x1C, 0x00, 0xA0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x08, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xA0, 0x00, 0x76, 0x00, 0x0E, 0x40, 0x01, 0xC8, 0x00, 0x39,
  0x80, 0x07, 0x10, 0x00, 0xE3, 0x00, 0x1C, 0x20, 0x03, 0x86, 0x00, 0x70,
  0x40, 0x0E, 0x0C, 0x01, 0xC0, 0x80, 0x38, 0x10, 0x07, 0x03, 0x00, 0xE0,
  0x20, 0x1C, 0x06, 0x03, 0x80, 0x40, 0x70, 0x0C, 0x0E, 0x00, 0x81, 0xC0,
  0x10, 0x38, 0x01, 0x07, 0x00, 0x20, 0xE0, 0x06, 0x1C, 0x00, 0x43, 0x80,
  0x0C, 0x70, 0x00, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0x38, 0x00, 0x27, 0x00,
  0x06, 0xE0, 0x00, 0x5C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x01,
  0xFC, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0x18, 0x02, 0x00, 0x30, 0x18, 0x00,
  0x60, 0xC0, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x11,
  0x00, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x00, 0x06, 0x06,
  0x00, 0x10, 0x0C, 0x00, 0xC0, 0x1C, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x08,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0,
  0x04, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xFF, 0xE0, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x1C,
  0x00, 0x60, 0x18, 0x02, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0x82,
  0x00, 0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x11, 0x00, 0x00, 0x64, 0x00,
  0x01, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x04, 0x20,
  0x00, 0x30, 0xC0, 0x00, 0xC1, 0x00, 0x06, 0x06, 0x00, 0x10, 0x0C, 0x00,
  0xC0, 0x1C, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0xFC, 0x00, 0x7F, 0xF0, 0x30,
  0x0E, 0x18, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x33, 0x00, 0x09, 0x80, 0x04,
  0xC0, 0x02, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x13, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x06, 0x18,
  0x06, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x04, 0x0C, 0x03, 0x06, 0x00, 0x83, 0x00,
  0x61, 0x80, 0x10, 0xC0, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x98, 0x00, 0x4C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x04, 0x03, 0xFC, 0x07, 0x07, 0x86, 0x00,
  0x46, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE7, 0x00, 0xE1, 0xFF, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xD0, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x30, 0x03, 0x07, 0x01,
  0x80, 0x7F, 0xC0, 0x01, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x24, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x00, 0x08, 0x10,
  0x00, 0x81, 0x00, 0x18, 0x18, 0x01, 0x01, 0x80, 0x10, 0x08, 0x01, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x04, 0x02, 0x00, 0x40, 0x60,
  0x04, 0x06, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x0C,
  0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x19,
  0x00, 0x01, 0x90, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x0B, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x09, 0x00, 0x03, 0x80, 0x01, 0x20, 0x00, 0x70, 0x00,
  0x66, 0x00, 0x0A, 0x00, 0x0C, 0xC0, 0x01, 0x40, 0x01, 0x88, 0x00, 0x68,
  0x00, 0x21, 0x00, 0x0D, 0x00, 0x04, 0x20, 0x01, 0xB0, 0x01, 0x86, 0x00,
  0x26, 0x00, 0x30, 0xC0, 0x04, 0x40, 0x04, 0x08, 0x01, 0x88, 0x00, 0x81,
  0x00, 0x31, 0x00, 0x10, 0x30, 0x06, 0x30, 0x06, 0x06, 0x00, 0x86, 0x00,
  0xC0, 0xC0, 0x10, 0x40, 0x10, 0x08, 0x06, 0x08, 0x02, 0x01, 0x00, 0xC1,
  0x00, 0xC0, 0x30, 0x18, 0x30, 0x18, 0x06, 0x02, 0x06, 0x02, 0x00, 0x40,
  0x40, 0x40, 0x40, 0x08, 0x08, 0x08, 0x08, 0x01, 0x03, 0x01, 0x03, 0x00,
  0x30, 0x60, 0x30, 0x60, 0x06, 0x08, 0x06, 0x08, 0x00, 0x41, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x08, 0x60, 0x01, 0x8C, 0x01, 0x0C, 0x00, 0x31, 0x80,
  0x31, 0x80, 0x06, 0x20, 0x06, 0x20, 0x00, 0x44, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x09, 0x80, 0x01, 0xB0, 0x01, 0x30, 0x00, 0x36, 0x00, 0x34, 0x00,
  0x02, 0x80, 0x06, 0x80, 0x00, 0x50, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x60, 0x03, 0x20, 0x03, 0x20, 0x02, 0x30, 0x06, 0x10, 0x04, 0x18, 0x04,
  0x18, 0x0C, 0x08, 0x08, 0x0C, 0x18, 0x04, 0x10, 0x04, 0x10, 0x06, 0x30,
  0x02, 0x20, 0x02, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20,
  0x04, 0x30, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x08,
  0x10, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x48, 0x00,
  0x26, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x60, 0x0C, 0x10, 0x04, 0x08,
  0x02, 0x06, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80, 0x60, 0xC0, 0x10, 0x40,
  0x08, 0x20, 0x06, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x6C, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC3, 0x00, 0x10,
  0x60, 0x06, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x08, 0x04, 0x01, 0x81, 0x80,
  0x10, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06, 0x60, 0x00, 0x48, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x07, 0xC0, 0xFB, 0xC2, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x07, 0xF0, 0xF0, 0x46, 0x01, 0x20, 0x05, 0x80, 0x14, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00,
  0x56, 0x01, 0x4C, 0x19, 0x1F, 0xC4, 0x18, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83, 0xE0, 0x8F, 0x78,
  0x98, 0x0C, 0xB0, 0x04, 0xA0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xA0, 0x06, 0xA0, 0x04,
  0x90, 0x0C, 0x9C, 0x18, 0x8F, 0xF0, 0x00, 0x80, 0x03, 0xF0, 0x79, 0xC6,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x38, 0x10, 0xFF, 0x80, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x3E,
  0x08, 0x39, 0xC4, 0x30, 0x32, 0x30, 0x0D, 0x30, 0x02, 0x90, 0x01, 0xC8,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x32, 0x00, 0x29, 0x80, 0x14, 0x60, 0x12, 0x18, 0x39, 0x07, 0xF0,
  0x80, 0xE0, 0x00, 0x07, 0xC0, 0x39, 0xE0, 0xC0, 0x61, 0x80, 0x46, 0x00,
  0xC8, 0x00, 0x90, 0x01, 0x60, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x10, 0xE0, 0x60, 0xFF, 0x80, 0x10, 0x00,
  0x03, 0xF0, 0x61, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xF8, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x00, 0x03, 0xF0, 0x07, 0x9C, 0x46, 0x03, 0x22, 0x00, 0xD3, 0x00,
  0x29, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x1A, 0x00,
  0x0D, 0x80, 0x06, 0x40, 0x05, 0x20, 0x02, 0x98, 0x03, 0x46, 0x01, 0x21,
  0x83, 0x10, 0x7F, 0x08, 0x06, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x80, 0x18, 0x7C, 0x38, 0x07, 0xF0, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x83, 0xE2, 0x39, 0xC9, 0x81, 0xAC, 0x02,
  0xA0, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x70, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x6B, 0x38, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x1A, 0x00, 0x90, 0x0C, 0x80,
  0xC4, 0x04, 0x20, 0x61, 0x02, 0x08, 0x30, 0x43, 0x02, 0x10, 0x11, 0x80,
  0x8C, 0x04, 0xB0, 0x2C, 0x81, 0x46, 0x0C, 0x10, 0x60, 0x82, 0x06, 0x10,
  0x10, 0x80, 0xC4, 0x02, 0x20, 0x19, 0x00, 0xC8, 0x02, 0x40, 0x1A, 0x00,
  0x50, 0x03, 0x80, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x7C, 0x4E, 0x30, 0xE7, 0x24, 0x0C, 0xC0, 0xD4, 0x02, 0x40, 0x2A, 0x01,
  0x40, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x30, 0x03, 0x80, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x07, 0xE2, 0x39, 0xC9, 0x81, 0xAC, 0x02,
  0xA0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x03, 0xF0, 0x07, 0x9C,
  0x06, 0x03, 0x02, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x09, 0x80, 0x04, 0xC0,
  0x03, 0x40, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x40, 0x02, 0x20,
  0x03, 0x18, 0x01, 0x06, 0x01, 0x81, 0x81, 0x80, 0x7F, 0x80, 0x04, 0x00,
  0x03, 0xE0, 0x8F, 0x78, 0x98, 0x0C, 0xB0, 0x04, 0xA0, 0x06, 0xA0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xA0, 0x06, 0xB0, 0x04, 0x90, 0x0C, 0x9C, 0x18, 0x87, 0xF0, 0x80, 0x80,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0x9C, 0x43, 0x03, 0x23, 0x00, 0xD3, 0x00, 0x29, 0x00,
  0x0C, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x80,
  0x06, 0x40, 0x05, 0x30, 0x02, 0x98, 0x03, 0x46, 0x01, 0x21, 0x83, 0x10,
  0x7F, 0x08, 0x04, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x07, 0xE3, 0xE9, 0x82, 0x40, 0xA0,
  0x28, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xE1, 0xE7, 0xCC, 0x02,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xA0, 0x0D, 0x80, 0xC7, 0xFC, 0x02, 0x00, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x03, 0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x06, 0x00, 0xF8, 0x08, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x05, 0xC0,
  0x15, 0x80, 0xD7, 0x06, 0x4F, 0xF1, 0x04, 0x00, 0xC0, 0x03, 0x40, 0x02,
  0x40, 0x06, 0x60, 0x06, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x30, 0x0C,
  0x30, 0x08, 0x10, 0x08, 0x10, 0x18, 0x10, 0x18, 0x18, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x00,
  0xC0, 0x0B, 0x00, 0x78, 0x02, 0x40, 0x1A, 0x00, 0x90, 0x04, 0x80, 0x64,
  0x01, 0x20, 0x19, 0x80, 0xC8, 0x04, 0x20, 0x33, 0x01, 0x08, 0x08, 0x40,
  0x42, 0x02, 0x10, 0x30, 0xC0, 0x84, 0x08, 0x30, 0x61, 0x82, 0x04, 0x18,
  0x60, 0x81, 0x04, 0x08, 0x60, 0x41, 0x02, 0x18, 0x18, 0x40, 0x84, 0x02,
  0x30, 0x31, 0x00, 0x8C, 0x0C, 0x40, 0x22, 0x01, 0x30, 0x0C, 0x80, 0x4C,
  0x03, 0x60, 0x12, 0x00, 0x58, 0x06, 0x80, 0x14, 0x01, 0xA0, 0x05, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0xC0,
  0x06, 0xC0, 0x18, 0x80, 0x21, 0x80, 0xC1, 0x01, 0x83, 0x02, 0x02, 0x0C,
  0x06, 0x10, 0x04, 0x60, 0x08, 0x80, 0x1B, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x20, 0x00, 0xE0, 0x01, 0x40, 0x06, 0xC0, 0x08, 0x80, 0x31, 0x80, 0x41,
  0x01, 0x83, 0x02, 0x02, 0x0C, 0x06, 0x18, 0x0C, 0x20, 0x08, 0xC0, 0x19,
  0x00, 0x16, 0x00, 0x30, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10, 0x08,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x30,
  0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xB8, 0x00,
  0xE0, 0x00, 0xFF, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x07, 0xC0, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x1F, 0x00, 0xF8, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x03, 0xE0, 0x10, 0x00, 0x3F, 0x00, 0x70, 0x70, 0x18,
  0x07, 0x1A, 0x00, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 39, 10, 4, -39 },
  { 16, 8, 14, 16, 4, -39 },
  { 30, 21, 39, 23, 1, -39 },
  { 133, 18, 44, 21, 2, -41 },
  { 232, 26, 39, 31, 2, -39 },
  { 359, 19, 40, 21, 2, -39 },
  { 454, 1, 14, 9, 4, -39 },
  { 456, 9, 48, 14, 3, -39 },
  { 510, 9, 48, 14, 2, -39 },
  { 564, 14, 14, 18, 2, -41 },
  { 589, 18, 24, 22, 2, -31 },
  { 643, 4, 12, 10, 2, -5 },
  { 649, 12, 1, 14, 1, -15 },
  { 651, 2, 4, 10, 4, -4 },
  { 652, 16, 39, 18, 1, -39 },
  { 730, 16, 39, 21, 3, -39 },
  { 808, 9, 39, 21, 4, -39 },
  { 852, 17, 39, 21, 2, -39 },
  { 935, 17, 40, 21, 2, -39 },
  { 1020, 20, 39, 21, 1, -39 },
  { 1118, 16, 39, 21, 3, -39 },
  { 1196, 16, 40, 21, 3, -39 },
  { 1276, 16, 39, 21, 2, -39 },
  { 1354, 17, 40, 21, 2, -39 },
  { 1439, 16, 40, 21, 2, -39 },
  { 1519, 2, 29, 10, 4, -29 },
  { 1527, 5, 36, 10, 2, -29 },
  { 1550, 18, 22, 22, 2, -30 },
  { 1600, 18, 13, 22, 2, -26 },
  { 1630, 18, 22, 22, 2, -30 },
  { 1680, 12, 39, 14, 1, -39 },
  { 1739, 27, 44, 33, 3, -39 },
  { 1888, 20, 39, 20, 0, -39 },
  { 1986, 17, 39, 23, 4, -39 },
  { 2069, 18, 40, 22, 3, -39 },
  { 2159, 19, 39, 25, 4, -39 },
  { 2252, 14, 39, 21, 4, -39 },
  { 2321, 14, 39, 19, 4, -39 },
  { 2390, 22, 40, 28, 3, -39 },
  { 2500, 18, 39, 26, 4, -39 },
  { 2588, 8, 39, 12, 2, -39 },
  { 2627, 8, 48, 10, -2, -39 },
  { 2675, 17, 39, 20, 4, -39 },
  { 2758, 13, 39, 18, 4, -39 },
  { 2822, 27, 39, 35, 4, -39 },
  { 2954, 19, 39, 27, 4, -39 },
  { 3047, 22, 40, 28, 3, -39 },
  { 3157, 16, 39, 21, 4, -39 },
  { 3235, 22, 48, 28, 3, -39 },
  { 3367, 17, 39, 22, 4, -39 },
  { 3450, 17, 40, 21, 2, -39 },
  { 3535, 18, 39, 18, 0, -39 },
  { 3623, 18, 40, 26, 4, -39 },
  { 3713, 20, 39, 20, 0, -39 },
  { 3811, 35, 39, 35, 0, -39 },
  { 3982, 16, 39, 18, 1, -39 },
  { 4060, 17, 39, 17, 0, -39 },
  { 4143, 14, 39, 17, 2, -39 },
  { 4212, 10, 48, 17, 5, -39 },
  { 4272, 16, 39, 18, 1, -39 },
  { 4350, 10, 48, 17, 2, -39 },
  { 4410, 19, 19, 21, 1, -39 },
  { 4456, 21, 1, 21, 0, 5 },
  { 4459, 8, 8, 12, 2, -41 },
  { 4467, 14, 30, 20, 2, -29 },
  { 4520, 16, 42, 23, 4, -41 },
  { 4604, 13, 30, 17, 3, -29 },
  { 4653, 17, 42, 23, 2, -41 },
  { 4743, 15, 30, 21, 3, -29 },
  { 4800, 12, 41, 11, 1, -41 },
  { 4862, 17, 42, 23, 2, -29 },
  { 4952, 14, 41, 22, 4, -41 },
  { 5024, 2, 39, 10, 4, -39 },
  { 5034, 6, 52, 10, 0, -39 },
  { 5073, 13, 41, 18, 4, -41 },
  { 5140, 1, 41, 9, 4, -41 },
  { 5146, 25, 29, 33, 4, -29 },
  { 5237, 14, 29, 22, 4, -29 },
  { 5288, 17, 30, 22, 2, -29 },
  { 5352, 16, 42, 23, 4, -29 },
  { 5436, 17, 42, 23, 2, -29 },
  { 5526, 10, 29, 14, 4, -29 },
  { 5563, 13, 30, 17, 2, -29 },
  { 5612, 10, 36, 11, 1, -35 },
  { 5657, 14, 29, 22, 4, -28 },
  { 5708, 16, 28, 16, 0, -28 },
  { 5764, 26, 28, 28, 1, -28 },
  { 5855, 15, 28, 17, 1, -28 },
  { 5908, 16, 41, 17, 1, -28 },
  { 5990, 11, 28, 14, 2, -28 },
  { 6029, 13, 48, 19, 3, -39 },
  { 6107, 2, 54, 20, 9, -41 },
  { 6121, 13, 48, 19, 3, -39 },
  { 6199, 18, 4, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Thin54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN54PT7B_H_
