#ifndef _NOTOSANS_EXTRACONDENSED_THIN63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin63pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x00, 0x00, 0x1B, 0xFE, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00, 0x10, 0x04, 0x00,
  0x08, 0x06, 0x00, 0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x10, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x10, 0x00, 0x20, 0x08, 0x07, 0xFF, 0xFF, 0xF0,
  0x08, 0x02, 0x00, 0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x10, 0x00, 0x20, 0x08,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x04, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0x31, 0xF0, 0x61, 0x81, 0x86, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x39, 0x80, 0x00,
  0xEC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xCE,
  0x00, 0x06, 0x38, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x19, 0x80, 0xC3, 0x8F, 0x86, 0x78, 0x1F, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x03,
  0x0C, 0x00, 0x60, 0x08, 0x10, 0x01, 0x00, 0x60, 0x60, 0x0C, 0x01, 0x01,
  0x80, 0x30, 0x04, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x00, 0xC0, 0x40, 0x0C, 0x03, 0x03, 0x00, 0x20, 0x0C, 0x0C,
  0x00, 0x80, 0x30, 0x20, 0x02, 0x00, 0xC1, 0x80, 0x08, 0x03, 0x06, 0x00,
  0x20, 0x0C, 0x10, 0x00, 0x80, 0x30, 0xC0, 0x02, 0x00, 0xC3, 0x00, 0x0C,
  0x03, 0x08, 0x18, 0x30, 0x0C, 0x21, 0xF8, 0xC0, 0x31, 0x8C, 0x33, 0x00,
  0x84, 0x20, 0x44, 0x02, 0x11, 0x81, 0x90, 0x18, 0xC6, 0x02, 0x60, 0x62,
  0x10, 0x08, 0x81, 0x08, 0x40, 0x33, 0x0C, 0x63, 0x00, 0xC7, 0xE1, 0x8C,
  0x03, 0x06, 0x04, 0x30, 0x0C, 0x00, 0x30, 0xC0, 0x10, 0x00, 0xC3, 0x00,
  0x40, 0x02, 0x0C, 0x01, 0x00, 0x18, 0x30, 0x04, 0x00, 0x60, 0xC0, 0x10,
  0x01, 0x03, 0x00, 0x40, 0x0C, 0x0C, 0x01, 0x00, 0x30, 0x30, 0x0C, 0x00,
  0x80, 0xC0, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x03, 0x00, 0x40,
  0x10, 0x08, 0x03, 0x00, 0x60, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x02,
  0x04, 0x01, 0x80, 0x0C, 0x30, 0x06, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x08, 0x06,
  0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x40, 0x00, 0x61, 0x80,
  0x03, 0x02, 0x00, 0x08, 0x0C, 0x02, 0x60, 0x18, 0x09, 0x80, 0x20, 0x24,
  0x00, 0xC1, 0xB0, 0x01, 0x06, 0xC0, 0x06, 0x13, 0x00, 0x08, 0x4C, 0x00,
  0x33, 0x30, 0x00, 0x4C, 0xC0, 0x01, 0xA3, 0x00, 0x03, 0x8C, 0x00, 0x04,
  0x30, 0x00, 0x38, 0x40, 0x01, 0xA1, 0x80, 0x06, 0xC2, 0x00, 0x31, 0x0C,
  0x01, 0x86, 0x1C, 0x1C, 0x08, 0x3F, 0xE0, 0x30, 0x08, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x10, 0x20, 0x78, 0x43, 0x8E, 0x9C, 0x07, 0xC0, 0x03, 0x00, 0x0B,
  0x00, 0x23, 0x00, 0xC2, 0x03, 0x02, 0x0C, 0x06, 0x10, 0x06, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0x86, 0x18,
  0x43, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01,
  0x80, 0x30, 0x30, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0x8C,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x0C, 0x80, 0x00, 0xB0,
  0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x48, 0x00, 0x09, 0x00,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x88, 0x00, 0x21, 0x80,
  0x0C, 0x30, 0x01, 0x83, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x03, 0x00, 0x71,
  0xC0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1B, 0x0C, 0xC6, 0x37,
  0x0F, 0x83, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x80, 0x03, 0xFF, 0x01, 0xE0, 0x70, 0x70, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x3C, 0x0F, 0x07, 0x00,
  0x38, 0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC4, 0x00, 0x38, 0x78, 0x0F, 0x03, 0xFF, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00,
  0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x04, 0x03, 0x00, 0x18, 0x06, 0x00, 0x20,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x08, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x0F, 0x80, 0x3F, 0xFE, 0x0F, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x62, 0x00, 0x18, 0x78, 0x0E, 0x07, 0xFF, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x3C, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x0F, 0xF0, 0x67, 0x87,
  0x0C, 0xC0, 0x31, 0xA0, 0x03, 0x3C, 0x00, 0x27, 0x00, 0x06, 0xE0, 0x00,
  0xD8, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01,
  0xA0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x31, 0x00, 0x06,
  0x30, 0x00, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x07, 0x03, 0x00, 0x7F, 0xC0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x07, 0x07, 0x00, 0xC0, 0x18,
  0x18, 0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00,
  0x26, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0x30, 0x60, 0x01, 0x9C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1D, 0xC0, 0x03, 0x06, 0x00, 0xE0, 0x30, 0x1C, 0x01, 0x81, 0x80, 0x0C,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x23, 0x00, 0x06, 0x30,
  0x00, 0xC1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x01, 0xFE, 0x01, 0xC1, 0xC0, 0xE0, 0x18, 0x30, 0x03, 0x18,
  0x00, 0x46, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x34, 0x00, 0x0D, 0x80, 0x05, 0x60, 0x03, 0x4C, 0x01, 0x91, 0x80,
  0xC4, 0x3F, 0xE1, 0x01, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x40, 0x70, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0x5F, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x10,
  0x63, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x61, 0x86, 0x18,
  0x63, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x0E, 0x07, 0x20, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x30, 0x03, 0xFC, 0x06, 0x20, 0x07,
  0x1C, 0x06, 0x60, 0x0C, 0x0C, 0x06, 0x60, 0x0C, 0x0C, 0x02, 0x60, 0x18,
  0x0C, 0x02, 0x60, 0x10, 0x0C, 0x03, 0x60, 0x30, 0x0C, 0x03, 0x40, 0x30,
  0x0C, 0x03, 0x40, 0x30, 0x0C, 0x03, 0x40, 0x20, 0x0C, 0x03, 0xC0, 0x20,
  0x08, 0x03, 0xC0, 0x60, 0x08, 0x03, 0xC0, 0x60, 0x08, 0x03, 0xC0, 0x60,
  0x08, 0x03, 0xC0, 0x60, 0x18, 0x03, 0xC0, 0x60, 0x18, 0x03, 0xC0, 0x60,
  0x18, 0x02, 0x40, 0x20, 0x18, 0x02, 0x40, 0x20, 0x18, 0x06, 0x40, 0x30,
  0x38, 0x06, 0x60, 0x30, 0x3C, 0x04, 0x60, 0x10, 0x24, 0x0C, 0x60, 0x18,
  0x66, 0x18, 0x60, 0x0F, 0xC3, 0xF8, 0x20, 0x07, 0x81, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x02, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x64, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x83, 0x00, 0x01, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x01, 0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x30,
  0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xC0, 0x07,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x04, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x7C, 0x0F, 0xFF, 0x80,
  0xC0, 0x1E, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x18, 0xC0, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xC0, 0x0E, 0x03, 0xC0, 0x60, 0x02, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01, 0x00,
  0xF0, 0x1C, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x30, 0x03, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x33,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x03,
  0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0x80, 0x78, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0x81,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x58, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10,
  0x30, 0x00, 0x04, 0x07, 0x00, 0x01, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x6F, 0xF1, 0xF8, 0xC0, 0x00, 0xD8, 0x00, 0x13, 0x00, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x60, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x81,
  0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0xBC, 0x00, 0x36, 0xC0, 0x07, 0x98,
  0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x5B, 0x00, 0x00, 0x01, 0xB6,
  0x00, 0x00, 0x03, 0x74, 0x00, 0x00, 0x04, 0xEC, 0x00, 0x00, 0x19, 0xD8,
  0x00, 0x00, 0x33, 0x90, 0x00, 0x00, 0x67, 0x30, 0x00, 0x01, 0x8E, 0x60,
  0x00, 0x03, 0x1C, 0xC0, 0x00, 0x06, 0x38, 0x80, 0x00, 0x08, 0x71, 0x80,
  0x00, 0x30, 0xE3, 0x00, 0x00, 0x61, 0xC2, 0x00, 0x00, 0x83, 0x86, 0x00,
  0x03, 0x07, 0x0C, 0x00, 0x06, 0x0E, 0x08, 0x00, 0x08, 0x1C, 0x18, 0x00,
  0x30, 0x38, 0x30, 0x00, 0x60, 0x70, 0x60, 0x00, 0xC0, 0xE0, 0x40, 0x01,
  0x01, 0xC0, 0xC0, 0x06, 0x03, 0x81, 0x80, 0x0C, 0x07, 0x01, 0x00, 0x10,
  0x0E, 0x03, 0x00, 0x60, 0x1C, 0x06, 0x00, 0xC0, 0x38, 0x04, 0x01, 0x00,
  0x70, 0x0C, 0x06, 0x00, 0xE0, 0x18, 0x0C, 0x01, 0xC0, 0x30, 0x18, 0x03,
  0x80, 0x30, 0x60, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0xC1, 0x80, 0x1C,
  0x00, 0x82, 0x00, 0x38, 0x01, 0x8C, 0x00, 0x70, 0x03, 0x18, 0x00, 0xE0,
  0x02, 0x20, 0x01, 0xC0, 0x06, 0xC0, 0x03, 0x80, 0x0D, 0x80, 0x07, 0x00,
  0x0B, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x20, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x40, 0x00, 0x3D, 0x80, 0x00, 0xF2, 0x00, 0x03, 0xCC, 0x00, 0x0F,
  0x30, 0x00, 0x3C, 0x40, 0x00, 0xF1, 0x80, 0x03, 0xC2, 0x00, 0x0F, 0x0C,
  0x00, 0x3C, 0x10, 0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0F, 0x03, 0x00,
  0x3C, 0x0C, 0x00, 0xF0, 0x10, 0x03, 0xC0, 0x60, 0x0F, 0x00, 0x80, 0x3C,
  0x03, 0x00, 0xF0, 0x04, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x60, 0x3C, 0x00,
  0xC0, 0xF0, 0x03, 0x03, 0xC0, 0x04, 0x0F, 0x00, 0x18, 0x3C, 0x00, 0x20,
  0xF0, 0x00, 0xC3, 0xC0, 0x01, 0x0F, 0x00, 0x06, 0x3C, 0x00, 0x18, 0xF0,
  0x00, 0x33, 0xC0, 0x00, 0xCF, 0x00, 0x01, 0x3C, 0x00, 0x06, 0xF0, 0x00,
  0x0B, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x0F,
  0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0xE3, 0x00, 0x70, 0xFF, 0xF0, 0x3F, 0xE0, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1C, 0x0F, 0x00, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x10, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x02, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x08, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0x00, 0x78, 0x60, 0x03, 0x8C, 0x00, 0x31,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x1C, 0x30, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x18,
  0x18, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x18, 0x01, 0x83, 0x00, 0x10, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x38, 0x00, 0xFF, 0xF0, 0x38, 0x07, 0x0C, 0x00, 0x23, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x40, 0x03, 0x8F, 0x01, 0xE0, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0B, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x30, 0x1C, 0x07, 0x00, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80,
  0x00, 0x81, 0x00, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x10, 0x08, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x02,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x02, 0x00, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x40, 0x00, 0x08, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x1C,
  0x00, 0x02, 0x60, 0x00, 0x34, 0x00, 0x06, 0x20, 0x00, 0x34, 0x00, 0x06,
  0x30, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00,
  0x26, 0x00, 0x04, 0x10, 0x00, 0x66, 0x00, 0x0C, 0x10, 0x00, 0x62, 0x00,
  0x0C, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x18,
  0x00, 0x43, 0x00, 0x08, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x0C, 0x00, 0xC1,
  0x00, 0x18, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x00, 0xC1, 0x80, 0x10,
  0x0C, 0x00, 0x81, 0x80, 0x30, 0x04, 0x01, 0x81, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x80, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x01, 0x80, 0xC0,
  0x20, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x03,
  0x03, 0x00, 0x40, 0x60, 0x03, 0x03, 0x00, 0x60, 0x40, 0x03, 0x03, 0x00,
  0x60, 0x40, 0x01, 0x02, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x60, 0xC0,
  0x01, 0x86, 0x00, 0x20, 0xC0, 0x01, 0x86, 0x00, 0x30, 0x80, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x00, 0x84, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x31,
  0x80, 0x00, 0xCC, 0x00, 0x11, 0x00, 0x00, 0xCC, 0x00, 0x11, 0x00, 0x00,
  0x4C, 0x00, 0x1B, 0x00, 0x00, 0x48, 0x00, 0x1B, 0x00, 0x00, 0x68, 0x00,
  0x1B, 0x00, 0x00, 0x78, 0x00, 0x0A, 0x00, 0x00, 0x78, 0x00, 0x0A, 0x00,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x64, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03,
  0x02, 0x00, 0x60, 0x60, 0x08, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x18,
  0x03, 0x03, 0x00, 0x20, 0x40, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x40,
  0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x32, 0x00,
  0x06, 0x60, 0x00, 0x8C, 0x00, 0x30, 0x80, 0x06, 0x18, 0x01, 0x83, 0x00,
  0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x0C, 0x01, 0x81,
  0x80, 0x10, 0x20, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x3C,
  0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x01,
  0x18, 0x00, 0x19, 0x80, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x01, 0xF0, 0x07, 0xFE,
  0x06, 0x03, 0x82, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0x03, 0xF9, 0x87, 0x80, 0xC7, 0x00,
  0x66, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x74, 0x00, 0x3B, 0x00, 0x1D,
  0x80, 0x16, 0x60, 0x1B, 0x18, 0x19, 0x87, 0xF8, 0xC0, 0x70, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xF8,
  0x0C, 0x3F, 0xE0, 0xC6, 0x03, 0x0C, 0xC0, 0x18, 0xD8, 0x00, 0xCD, 0x00,
  0x0C, 0xF0, 0x00, 0x4E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00,
  0x2E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xF0, 0x00, 0xCD, 0x00,
  0x0C, 0xD8, 0x01, 0x8C, 0xC0, 0x38, 0xC7, 0x07, 0x0C, 0x3F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1C, 0x08, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x02, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x7C, 0x08, 0x3F, 0xE1, 0x0E, 0x06,
  0x23, 0x00, 0x64, 0xC0, 0x06, 0x98, 0x00, 0x52, 0x00, 0x0E, 0xC0, 0x00,
  0xD8, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D,
  0x80, 0x02, 0x98, 0x00, 0x53, 0x00, 0x12, 0x30, 0x06, 0x43, 0x83, 0x88,
  0x3F, 0xE1, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xE0, 0xE0,
  0x60, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x19, 0x80, 0x02, 0x60,
  0x00, 0x90, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x02, 0x0F, 0x03, 0x80, 0xFF, 0x80, 0x07, 0x00,
  0x01, 0xFC, 0x0E, 0x20, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x3F, 0xF8, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x84, 0x38, 0x18, 0x8C, 0x01, 0x93, 0x00, 0x1A,
  0x60, 0x01, 0x58, 0x00, 0x3B, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x68,
  0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x56, 0x00, 0x0A, 0x60, 0x03, 0x4C,
  0x00, 0x48, 0xC0, 0x19, 0x0E, 0x0E, 0x20, 0xFF, 0x04, 0x03, 0x80, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x18, 0x01, 0xC3, 0xE1, 0xF0, 0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x03, 0xC1, 0x87, 0xF8, 0xC6, 0x06, 0x66, 0x01, 0xB6,
  0x00, 0xDA, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x5F, 0xF4, 0x00, 0x00, 0x00, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x04, 0x1C, 0x38,
  0x70, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18,
  0x35, 0xCF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC7,
  0x00, 0xCD, 0x00, 0xC9, 0x80, 0xD8, 0x80, 0xD0, 0xC0, 0xE0, 0xC0, 0xE0,
  0x60, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x07, 0x83, 0x1F, 0xE0, 0x7F, 0x8C, 0xC0,
  0xC3, 0x03, 0x36, 0x01, 0x98, 0x06, 0xD0, 0x06, 0x40, 0x1B, 0x40, 0x0B,
  0x00, 0x2E, 0x00, 0x28, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xF0, 0x61, 0xFE, 0x31, 0x81, 0x99, 0x80, 0x6D, 0x80, 0x1E, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x30, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18,
  0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x68,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x84,
  0x00, 0x60, 0xC0, 0x18, 0x0E, 0x07, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x0C, 0x3F, 0xE0, 0xC6, 0x07, 0x0C, 0xC0, 0x18, 0xD8, 0x00,
  0xCD, 0x00, 0x0C, 0xF0, 0x00, 0x4E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x02, 0xE0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0xE0, 0x00, 0x2E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x04, 0xD0, 0x00,
  0xCD, 0x00, 0x0C, 0xD8, 0x01, 0x8C, 0xC0, 0x30, 0xC7, 0x07, 0x0C, 0x3F,
  0xC0, 0xC0, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x84, 0x38, 0x18, 0x8C, 0x01,
  0x91, 0x80, 0x1A, 0x60, 0x01, 0x48, 0x00, 0x2B, 0x00, 0x03, 0x60, 0x00,
  0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x56, 0x00, 0x0A,
  0x60, 0x03, 0x4E, 0x00, 0x48, 0xE0, 0x19, 0x0E, 0x0E, 0x20, 0xFF, 0x84,
  0x03, 0x80, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0xEC, 0x3F, 0xC6, 0x1C, 0xC0, 0xC8, 0x0D, 0x80, 0xD0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x18, 0x06, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x0C, 0xF0, 0x38, 0x3F, 0xF0, 0x03,
  0x00, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0xFF, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x61, 0x07, 0xE0, 0x38, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0xE8, 0x00, 0x56, 0x00,
  0x2B, 0x00, 0x24, 0xC0, 0x32, 0x70, 0x71, 0x0F, 0xF0, 0x80, 0xC0, 0x00,
  0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x02, 0x60, 0x01, 0x88,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x04, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x08, 0x18, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x30, 0x10,
  0x0C, 0x0C, 0x01, 0x03, 0x00, 0x40, 0xC0, 0x18, 0x20, 0x06, 0x08, 0x01,
  0x86, 0x00, 0x21, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x13,
  0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0B, 0x00,
  0x0E, 0x00, 0x36, 0x00, 0x14, 0x00, 0x64, 0x00, 0x68, 0x00, 0xC8, 0x00,
  0xD0, 0x01, 0x18, 0x01, 0xB0, 0x02, 0x30, 0x02, 0x60, 0x0C, 0x20, 0x04,
  0x40, 0x18, 0x40, 0x18, 0x80, 0x30, 0xC0, 0x31, 0x80, 0x41, 0x80, 0x63,
  0x01, 0x83, 0x00, 0x86, 0x03, 0x02, 0x03, 0x04, 0x06, 0x06, 0x06, 0x08,
  0x08, 0x0C, 0x0C, 0x18, 0x10, 0x18, 0x10, 0x30, 0x60, 0x10, 0x20, 0x60,
  0xC0, 0x20, 0xC0, 0x41, 0x80, 0x61, 0x80, 0x82, 0x00, 0xC3, 0x01, 0x84,
  0x01, 0x84, 0x03, 0x18, 0x01, 0x18, 0x06, 0x30, 0x03, 0x30, 0x04, 0x40,
  0x06, 0x60, 0x0C, 0x80, 0x0C, 0xC0, 0x1B, 0x00, 0x09, 0x00, 0x36, 0x00,
  0x16, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x50, 0x00, 0x78, 0x00, 0xA0, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x02, 0x00, 0x60,
  0x01, 0x98, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x06, 0x06, 0x01,
  0x80, 0xC0, 0x40, 0x30, 0x30, 0x04, 0x08, 0x01, 0x86, 0x00, 0x21, 0x80,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x30, 0x20, 0x0C, 0x0C, 0x02, 0x01, 0x01, 0x80, 0x60,
  0x40, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x02, 0x20,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x08, 0x08, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x20, 0x02,
  0x18, 0x00, 0x86, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x01, 0x30, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x06, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0B, 0x80, 0x03,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x7F,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x3C, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 45, 12, 5, -45 },
  { 18, 10, 16, 18, 4, -45 },
  { 38, 25, 45, 27, 1, -45 },
  { 179, 21, 52, 25, 2, -48 },
  { 316, 30, 47, 36, 3, -46 },
  { 493, 22, 47, 24, 2, -46 },
  { 623, 2, 16, 10, 4, -45 },
  { 627, 11, 55, 17, 3, -45 },
  { 703, 10, 55, 17, 3, -45 },
  { 772, 15, 16, 21, 3, -48 },
  { 802, 21, 29, 25, 2, -37 },
  { 879, 6, 14, 11, 2, -6 },
  { 890, 13, 2, 17, 2, -18 },
  { 894, 3, 4, 11, 4, -4 },
  { 896, 18, 45, 21, 2, -45 },
  { 998, 19, 46, 25, 3, -46 },
  { 1108, 10, 45, 25, 5, -45 },
  { 1165, 19, 46, 25, 3, -46 },
  { 1275, 20, 47, 25, 2, -46 },
  { 1393, 23, 45, 25, 1, -45 },
  { 1523, 19, 46, 25, 3, -45 },
  { 1633, 19, 46, 25, 3, -45 },
  { 1743, 19, 45, 25, 3, -45 },
  { 1850, 20, 47, 25, 2, -46 },
  { 1968, 18, 47, 25, 3, -46 },
  { 2074, 3, 34, 11, 4, -34 },
  { 2087, 6, 42, 11, 2, -34 },
  { 2119, 21, 26, 25, 2, -35 },
  { 2188, 21, 15, 25, 2, -30 },
  { 2228, 21, 26, 25, 2, -35 },
  { 2297, 14, 46, 17, 1, -46 },
  { 2378, 32, 51, 38, 3, -45 },
  { 2582, 24, 45, 24, 0, -45 },
  { 2717, 20, 45, 27, 5, -45 },
  { 2830, 22, 47, 26, 3, -46 },
  { 2960, 21, 45, 30, 5, -45 },
  { 3079, 16, 45, 24, 5, -45 },
  { 3169, 16, 45, 22, 5, -45 },
  { 3259, 26, 47, 33, 3, -46 },
  { 3412, 21, 45, 31, 5, -45 },
  { 3531, 9, 45, 14, 2, -45 },
  { 3582, 10, 56, 12, -3, -45 },
  { 3652, 19, 45, 24, 5, -45 },
  { 3759, 15, 45, 21, 5, -45 },
  { 3844, 31, 45, 41, 5, -45 },
  { 4019, 22, 45, 32, 5, -45 },
  { 4143, 26, 47, 32, 3, -46 },
  { 4296, 18, 45, 25, 5, -45 },
  { 4398, 26, 57, 32, 3, -46 },
  { 4584, 19, 45, 25, 5, -45 },
  { 4691, 19, 47, 25, 3, -46 },
  { 4803, 21, 45, 21, 0, -45 },
  { 4922, 21, 46, 31, 5, -45 },
  { 5043, 23, 45, 23, 0, -45 },
  { 5173, 40, 45, 41, 0, -45 },
  { 5398, 19, 45, 21, 1, -45 },
  { 5505, 20, 45, 20, 0, -45 },
  { 5618, 17, 45, 20, 2, -45 },
  { 5714, 12, 55, 19, 5, -45 },
  { 5797, 17, 45, 21, 2, -45 },
  { 5893, 12, 55, 19, 2, -45 },
  { 5976, 23, 22, 25, 1, -45 },
  { 6040, 25, 1, 25, 0, 6 },
  { 6044, 9, 10, 14, 3, -48 },
  { 6056, 17, 35, 23, 2, -34 },
  { 6131, 20, 49, 27, 4, -48 },
  { 6254, 15, 35, 20, 3, -34 },
  { 6320, 19, 49, 27, 3, -48 },
  { 6437, 18, 35, 24, 3, -34 },
  { 6516, 14, 48, 13, 1, -48 },
  { 6600, 19, 49, 27, 3, -34 },
  { 6717, 17, 48, 26, 4, -48 },
  { 6819, 3, 46, 11, 4, -46 },
  { 6837, 7, 61, 11, 0, -46 },
  { 6891, 16, 48, 20, 4, -48 },
  { 6987, 2, 48, 11, 4, -48 },
  { 6999, 30, 34, 38, 4, -34 },
  { 7127, 17, 34, 26, 4, -34 },
  { 7200, 19, 35, 25, 3, -34 },
  { 7284, 20, 49, 27, 4, -34 },
  { 7407, 19, 49, 27, 3, -34 },
  { 7524, 12, 34, 17, 4, -34 },
  { 7575, 16, 35, 20, 2, -34 },
  { 7645, 11, 42, 13, 1, -41 },
  { 7703, 17, 34, 26, 4, -33 },
  { 7776, 18, 33, 18, 0, -33 },
  { 7851, 31, 33, 32, 1, -33 },
  { 7979, 18, 33, 20, 1, -33 },
  { 8054, 18, 48, 20, 1, -33 },
  { 8162, 13, 33, 16, 2, -33 },
  { 8216, 16, 55, 22, 3, -45 },
  { 8326, 2, 63, 24, 11, -48 },
  { 8342, 15, 55, 22, 3, -45 },
  { 8446, 21, 5, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Thin63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN63PT7B_H_
